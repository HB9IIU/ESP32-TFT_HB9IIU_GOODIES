#ifndef _NOTOSANS_CONDENSED_THIN66PT7B_H_
#define _NOTOSANS_CONDENSED_THIN66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin66pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB0, 0x00, 0x00, 0x7F, 0xF8, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x34, 0x06, 0x80, 0xD0, 0x0A, 0x01, 0x40, 0x28, 0x05, 0x00, 0xA0, 0x14,
  0x02, 0x80, 0x50, 0x0A, 0x01, 0x40, 0x20, 0x00, 0x08, 0x01, 0x80, 0x00,
  0x60, 0x06, 0x00, 0x01, 0x80, 0x10, 0x00, 0x06, 0x00, 0x40, 0x00, 0x18,
  0x01, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x00, 0x30, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x80, 0x00, 0x30, 0x02, 0x00, 0x00, 0x80, 0x18, 0x03,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x06, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x06, 0x00, 0x40, 0x00, 0x18, 0x01, 0x00, 0x00, 0x40,
  0x04, 0x00, 0x01, 0x00, 0x30, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x30, 0x03,
  0x00, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x80,
  0x00, 0x30, 0x02, 0x00, 0x00, 0x80, 0x18, 0x00, 0x02, 0x00, 0x60, 0x0F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x18, 0x00, 0x06,
  0x00, 0x40, 0x00, 0x18, 0x01, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x01, 0x00,
  0x30, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x03, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x80, 0x18, 0x00, 0x02, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x60, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xE6, 0x3F, 0x07, 0x0C, 0x0E,
  0x18, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xC0, 0x06,
  0x01, 0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x20, 0x0C, 0x00, 0x60,
  0x18, 0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x01,
  0x80, 0x07, 0x03, 0x00, 0x07, 0x06, 0x00, 0x07, 0x0C, 0x00, 0x07, 0x98,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0x3C, 0x00, 0x06, 0x1C, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x0C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x08, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xE0, 0x03,
  0x01, 0x98, 0x06, 0x0E, 0x3E, 0x0C, 0x78, 0x1F, 0xFF, 0xC0, 0x01, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0x00, 0x18, 0x30, 0x00, 0x30, 0x03, 0x01, 0x80, 0x06, 0x00, 0x30, 0x18,
  0x00, 0x60, 0x06, 0x00, 0x80, 0x04, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x0C, 0x01, 0x80, 0x04, 0x00, 0x40, 0x18,
  0x00, 0xC0, 0x04, 0x01, 0x00, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x06,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x20, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x0C,
  0x00, 0x60, 0x40, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0xC0,
  0x00, 0xC0, 0x06, 0x08, 0x00, 0x0C, 0x00, 0x41, 0x83, 0xE0, 0x40, 0x04,
  0x10, 0x7F, 0x84, 0x00, 0xC3, 0x0C, 0x18, 0x60, 0x0C, 0x30, 0x80, 0xC6,
  0x00, 0xC2, 0x18, 0x04, 0x60, 0x08, 0x61, 0x00, 0x63, 0x01, 0x86, 0x30,
  0x06, 0x30, 0x18, 0xC3, 0x00, 0x21, 0x83, 0x0C, 0x30, 0x02, 0x0F, 0xE0,
  0x82, 0x00, 0x30, 0x38, 0x18, 0x20, 0x03, 0x00, 0x01, 0x82, 0x00, 0x30,
  0x00, 0x30, 0x20, 0x03, 0x00, 0x03, 0x02, 0x00, 0x30, 0x00, 0x20, 0x20,
  0x03, 0x00, 0x06, 0x02, 0x00, 0x30, 0x00, 0x60, 0x20, 0x03, 0x00, 0x0C,
  0x02, 0x00, 0x30, 0x00, 0xC0, 0x20, 0x03, 0x00, 0x08, 0x02, 0x00, 0x30,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x18, 0x03, 0x00, 0x20, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x60, 0x02, 0x00, 0x18, 0x06, 0x00, 0x60,
  0x01, 0x80, 0xC0, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x00, 0xE1, 0x80,
  0x0C, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x04,
  0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x04,
  0x00, 0x08, 0x00, 0x40, 0x00, 0x80, 0x04, 0x00, 0x08, 0x00, 0x40, 0x00,
  0x80, 0x04, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x0C, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x60, 0x08, 0x00, 0x06, 0x01, 0x80, 0x00, 0x30, 0x30, 0x00,
  0x03, 0x03, 0x00, 0x00, 0x18, 0x60, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x30, 0x00,
  0x00, 0xE1, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x06, 0x30,
  0x06, 0x00, 0x66, 0x00, 0x60, 0x06, 0x60, 0x03, 0x00, 0x4C, 0x00, 0x18,
  0x04, 0xC0, 0x00, 0x80, 0xCC, 0x00, 0x0C, 0x0C, 0xC0, 0x00, 0x60, 0x88,
  0x00, 0x02, 0x18, 0x80, 0x00, 0x31, 0x88, 0x00, 0x01, 0xB0, 0xC0, 0x00,
  0x0F, 0x0C, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x00, 0xF0,
  0x60, 0x00, 0x1B, 0x06, 0x00, 0x03, 0x18, 0x30, 0x00, 0x60, 0xC1, 0x80,
  0x0C, 0x0C, 0x0E, 0x03, 0x80, 0x60, 0x7F, 0xF0, 0x03, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0x55, 0x55, 0x55, 0x40, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x70, 0xC0, 0x0C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03,
  0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x80, 0x20, 0x1F, 0x02, 0x07, 0x1C,
  0x23, 0xC0, 0x7A, 0xE0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xD8, 0x00,
  0x18, 0x80, 0x03, 0x04, 0x00, 0x20, 0x60, 0x06, 0x03, 0x00, 0xC0, 0x10,
  0x18, 0x01, 0x80, 0x80, 0x08, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x18, 0xC6, 0x73, 0x18, 0xC6, 0x63, 0x18, 0x8C, 0x62,
  0x10, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x03, 0xFF, 0x00, 0x0E, 0x07, 0x00, 0x30, 0x07, 0x00, 0xC0,
  0x06, 0x01, 0x80, 0x06, 0x06, 0x00, 0x04, 0x0C, 0x00, 0x0C, 0x30, 0x00,
  0x18, 0x60, 0x00, 0x10, 0xC0, 0x00, 0x31, 0x00, 0x00, 0x66, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x98, 0x00, 0x01, 0x30, 0x00, 0x03, 0x60, 0x00, 0x06,
  0x80, 0x00, 0x0D, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x68, 0x00,
  0x00, 0xD0, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x13, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC4, 0x00, 0x01,
  0x8C, 0x00, 0x03, 0x18, 0x00, 0x04, 0x10, 0x00, 0x18, 0x30, 0x00, 0x30,
  0x60, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x60, 0x06, 0x00, 0xE0, 0x18, 0x00,
  0xF0, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x60, 0x1C, 0x06, 0x81, 0x90, 0xE2,
  0x38, 0x4E, 0x0B, 0x01, 0xC0, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x78,
  0x00, 0x0F, 0xFE, 0x00, 0x78, 0x0F, 0x03, 0x80, 0x07, 0x02, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x0F,
  0x03, 0x80, 0x07, 0x0C, 0x00, 0x03, 0x10, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x18, 0x00, 0x1C, 0x3E, 0x00, 0xF0, 0x1F, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x06, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x0C, 0x18, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x18, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x18,
  0x00, 0x06, 0x01, 0x80, 0x00, 0x40, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01,
  0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x18, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x18, 0x01,
  0x80, 0x01, 0x80, 0x18, 0x00, 0x18, 0x03, 0x00, 0x01, 0x80, 0x30, 0x00,
  0x18, 0x06, 0x00, 0x01, 0x80, 0x60, 0x00, 0x18, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC3, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x11, 0xFF, 0x00, 0x7F, 0xFF, 0x83, 0x80, 0x07, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x20, 0x00, 0x38, 0xC0,
  0x01, 0xC3, 0xE0, 0x3C, 0x03, 0xFF, 0xC0, 0x00, 0x68, 0x00, 0x00, 0x07,
  0x80, 0x01, 0xFF, 0xC0, 0x0E, 0x01, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x1F, 0x00, 0xC3, 0xFF, 0x83, 0x1C, 0x07, 0x08, 0xC0,
  0x06, 0x26, 0x00, 0x0C, 0xB0, 0x00, 0x12, 0x80, 0x00, 0x6E, 0x00, 0x01,
  0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x34, 0x00, 0x00, 0xD8, 0x00, 0x03,
  0x60, 0x00, 0x08, 0x80, 0x00, 0x63, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x30, 0x03, 0x80, 0x70, 0x1C, 0x00, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x00, 0x1C,
  0x07, 0x80, 0x60, 0x03, 0x81, 0x80, 0x03, 0x86, 0x00, 0x03, 0x0C, 0x00,
  0x03, 0x10, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x19, 0x80, 0x00,
  0x33, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x8C, 0x00, 0x03,
  0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x38, 0x00, 0x60, 0x30, 0x01, 0x80,
  0x38, 0x06, 0x00, 0x38, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xC7, 0x00, 0x07, 0x03, 0x00, 0x18, 0x03, 0x80, 0xE0,
  0x03, 0x81, 0x80, 0x03, 0x86, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00,
  0x02, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x31, 0x80, 0x00, 0xE3,
  0x80, 0x01, 0x83, 0x80, 0x0E, 0x03, 0xC0, 0x78, 0x01, 0xFF, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFE, 0x00, 0x3C, 0x0E, 0x00, 0xE0,
  0x06, 0x01, 0x80, 0x06, 0x06, 0x00, 0x06, 0x08, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x60, 0x00, 0x18, 0x80, 0x00, 0x13, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x01, 0x60, 0x00, 0x02,
  0xC0, 0x00, 0x05, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xE8, 0x00, 0x01, 0xD8, 0x00, 0x03, 0xB0, 0x00, 0x0F, 0x30,
  0x00, 0x36, 0x60, 0x00, 0x4C, 0x60, 0x03, 0x98, 0x70, 0x0E, 0x20, 0x7F,
  0xF0, 0x40, 0x1F, 0x80, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x08, 0x07, 0x80, 0x1F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x39, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x67, 0x31, 0x8C, 0x66,
  0x31, 0x88, 0xC6, 0x21, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F,
  0xF0, 0xE0, 0x3C, 0x80, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x30, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x60, 0x00, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x03, 0xE0, 0x01, 0x0C, 0x00, 0x1F, 0xF8, 0x03, 0x18, 0x00,
  0x70, 0x30, 0x06, 0x30, 0x01, 0x80, 0x60, 0x0C, 0x40, 0x06, 0x00, 0xC0,
  0x09, 0x80, 0x18, 0x01, 0x80, 0x1B, 0x00, 0x30, 0x03, 0x00, 0x36, 0x00,
  0xC0, 0x06, 0x00, 0x6C, 0x01, 0x80, 0x0C, 0x00, 0xD8, 0x03, 0x00, 0x18,
  0x01, 0xA0, 0x04, 0x00, 0x30, 0x03, 0x40, 0x18, 0x00, 0x60, 0x06, 0x80,
  0x30, 0x00, 0xC0, 0x0F, 0x00, 0x60, 0x01, 0x80, 0x1E, 0x00, 0xC0, 0x02,
  0x00, 0x3C, 0x01, 0x80, 0x04, 0x00, 0x68, 0x03, 0x00, 0x18, 0x00, 0xD0,
  0x06, 0x00, 0x30, 0x01, 0x20, 0x0C, 0x00, 0x60, 0x06, 0x40, 0x08, 0x00,
  0xC0, 0x0C, 0xC0, 0x18, 0x03, 0xC0, 0x19, 0x80, 0x30, 0x07, 0x80, 0x63,
  0x00, 0x60, 0x09, 0x00, 0xC6, 0x00, 0x60, 0x33, 0x03, 0x0C, 0x00, 0x61,
  0xC7, 0x0E, 0x0C, 0x00, 0x7F, 0x07, 0xF8, 0x18, 0x00, 0x30, 0x01, 0x80,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x20,
  0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0x40, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x04,
  0x40, 0x00, 0x00, 0x23, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0x82, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x02, 0x02, 0x00, 0x00, 0x10, 0x18, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x40, 0x10, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x08, 0x00, 0x80, 0x00, 0xC0, 0x06, 0x00,
  0x06, 0x00, 0x30, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0x00, 0x01, 0x80, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x30,
  0x0C, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x02, 0x00, 0x00, 0x20, 0x30,
  0x00, 0x01, 0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x00, 0x00, 0x01,
  0x18, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x60,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x82, 0x00, 0x03, 0x84, 0x00, 0x03, 0x88, 0x00, 0x03, 0x90, 0x00, 0x03,
  0x20, 0x00, 0x02, 0x40, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x1A,
  0x00, 0x00, 0x34, 0x00, 0x00, 0x68, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xA0,
  0x00, 0x03, 0x40, 0x00, 0x04, 0x80, 0x00, 0x19, 0x00, 0x00, 0x32, 0x00,
  0x00, 0xC4, 0x00, 0x03, 0x08, 0x00, 0x1C, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x40, 0x01, 0xE0, 0x80, 0x00, 0x71, 0x00, 0x00, 0x72, 0x00, 0x00,
  0x64, 0x00, 0x00, 0x68, 0x00, 0x00, 0xD0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x06, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x32, 0x00, 0x00, 0xE4, 0x00,
  0x03, 0x88, 0x00, 0x1E, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x02,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x20, 0x07, 0x80, 0x78, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x08, 0x00, 0x3C,
  0x02, 0x00, 0x03, 0xC0, 0x80, 0x00, 0x38, 0x20, 0x00, 0x06, 0x08, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x20, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x06, 0x80, 0x00, 0x00, 0xA0, 0x00,
  0x00, 0x28, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xA0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x12, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x03, 0x20, 0x00, 0x01, 0x88, 0x00, 0x00, 0x62, 0x00, 0x00,
  0x30, 0x80, 0x00, 0x1C, 0x20, 0x00, 0x06, 0x08, 0x00, 0x07, 0x02, 0x00,
  0x03, 0x80, 0x80, 0x03, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF4, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0xFF, 0xFF, 0xD0, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x38, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x08, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x30, 0x60, 0x00,
  0x00, 0xC0, 0xC0, 0x00, 0x03, 0x01, 0x80, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x70, 0x07, 0xC0, 0x0F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x06, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x0F, 0xFC, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x60, 0x0C, 0xC3, 0xCF, 0xF0, 0x08, 0x00, 0x80, 0x00, 0x1D, 0x00, 0x00,
  0x32, 0x00, 0x00, 0xC4, 0x00, 0x03, 0x08, 0x00, 0x0E, 0x10, 0x00, 0x18,
  0x20, 0x00, 0x60, 0x40, 0x01, 0xC0, 0x80, 0x03, 0x01, 0x00, 0x0C, 0x02,
  0x00, 0x30, 0x04, 0x00, 0xE0, 0x08, 0x01, 0x80, 0x10, 0x06, 0x00, 0x20,
  0x1C, 0x00, 0x40, 0x30, 0x00, 0x80, 0xC0, 0x01, 0x03, 0x00, 0x02, 0x0E,
  0x00, 0x04, 0x18, 0x00, 0x08, 0x70, 0x00, 0x11, 0xE0, 0x00, 0x23, 0x60,
  0x00, 0x4C, 0xC0, 0x00, 0xB0, 0xC0, 0x01, 0x41, 0x80, 0x03, 0x81, 0x80,
  0x06, 0x01, 0x80, 0x08, 0x03, 0x00, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x06, 0x00, 0x80, 0x0C, 0x01, 0x00, 0x0C, 0x02, 0x00, 0x0C, 0x04,
  0x00, 0x18, 0x08, 0x00, 0x18, 0x10, 0x00, 0x30, 0x20, 0x00, 0x30, 0x40,
  0x00, 0x60, 0x80, 0x00, 0x61, 0x00, 0x00, 0x42, 0x00, 0x00, 0xC4, 0x00,
  0x00, 0xC8, 0x00, 0x01, 0x90, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x80, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xD0, 0x00,
  0x00, 0x00, 0xFB, 0x00, 0x00, 0x00, 0x1F, 0x60, 0x00, 0x00, 0x02, 0xE4,
  0x00, 0x00, 0x00, 0xDC, 0xC0, 0x00, 0x00, 0x1B, 0x98, 0x00, 0x00, 0x06,
  0x71, 0x00, 0x00, 0x00, 0xCE, 0x30, 0x00, 0x00, 0x19, 0xC6, 0x00, 0x00,
  0x06, 0x38, 0x40, 0x00, 0x00, 0xC7, 0x0C, 0x00, 0x00, 0x18, 0xE1, 0x80,
  0x00, 0x06, 0x1C, 0x10, 0x00, 0x00, 0xC3, 0x83, 0x00, 0x00, 0x18, 0x70,
  0x60, 0x00, 0x06, 0x0E, 0x04, 0x00, 0x00, 0xC1, 0xC0, 0xC0, 0x00, 0x18,
  0x38, 0x18, 0x00, 0x06, 0x07, 0x01, 0x80, 0x00, 0xC0, 0xE0, 0x30, 0x00,
  0x18, 0x1C, 0x06, 0x00, 0x06, 0x03, 0x80, 0x60, 0x00, 0xC0, 0x70, 0x0C,
  0x00, 0x18, 0x0E, 0x01, 0x80, 0x06, 0x01, 0xC0, 0x18, 0x00, 0xC0, 0x38,
  0x03, 0x00, 0x18, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x06, 0x00, 0xC0,
  0x1C, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x18, 0x06, 0x00, 0x70, 0x01, 0x80,
  0xC0, 0x0E, 0x00, 0x30, 0x18, 0x01, 0xC0, 0x06, 0x06, 0x00, 0x38, 0x00,
  0x60, 0xC0, 0x07, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0x01, 0x86, 0x00, 0x1C,
  0x00, 0x18, 0xC0, 0x03, 0x80, 0x03, 0x18, 0x00, 0x70, 0x00, 0x66, 0x00,
  0x0E, 0x00, 0x06, 0xC0, 0x01, 0xC0, 0x00, 0xD8, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x18, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x60, 0x00, 0x03, 0x10, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x61, 0x80, 0x00, 0x30, 0x40, 0x00,
  0x18, 0x30, 0x00, 0x0C, 0x08, 0x00, 0x06, 0x06, 0x00, 0x03, 0x01, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0x20, 0x00, 0x60, 0x18, 0x00, 0x30, 0x06,
  0x00, 0x18, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03,
  0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x18,
  0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x00, 0xC6, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x60, 0x00,
  0x01, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x06, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x70, 0x00, 0x18, 0x01, 0xC0, 0x00,
  0x18, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x30, 0x18, 0x00, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x63, 0x00, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x01, 0x90, 0x00, 0x00, 0x03,
  0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0x60, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0C, 0x80, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00,
  0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x01,
  0x80, 0x30, 0x00, 0x06, 0x00, 0x70, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x20, 0x01, 0xE1, 0x00, 0x03, 0x88, 0x00,
  0x06, 0x40, 0x00, 0x3A, 0x00, 0x00, 0xD0, 0x00, 0x06, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xA0,
  0x00, 0x0D, 0x00, 0x00, 0x68, 0x00, 0x03, 0x40, 0x00, 0x32, 0x00, 0x03,
  0x10, 0x00, 0x38, 0x80, 0x0F, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0x80, 0x78, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x70, 0x00, 0x18, 0x01,
  0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00, 0x38, 0x18,
  0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x8C, 0x00, 0x00, 0x01, 0x90, 0x00,
  0x00, 0x03, 0x60, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x00, 0x0D, 0x80, 0x00,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x0C,
  0x80, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0x84, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0xC0, 0x30,
  0x00, 0x01, 0x80, 0x30, 0x00, 0x06, 0x00, 0x70, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x02, 0x00,
  0x0E, 0x04, 0x00, 0x06, 0x08, 0x00, 0x06, 0x10, 0x00, 0x06, 0x20, 0x00,
  0x0C, 0x40, 0x00, 0x08, 0x80, 0x00, 0x19, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x64, 0x00, 0x00, 0xC8, 0x00, 0x01, 0x90, 0x00, 0x03, 0x20, 0x00, 0x06,
  0x40, 0x00, 0x0C, 0x80, 0x00, 0x19, 0x00, 0x00, 0x22, 0x00, 0x00, 0xC4,
  0x00, 0x01, 0x88, 0x00, 0x06, 0x10, 0x00, 0x18, 0x20, 0x00, 0x60, 0x40,
  0x03, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x02, 0x00, 0xC0, 0x04, 0x00,
  0xC0, 0x08, 0x01, 0x80, 0x10, 0x01, 0x80, 0x20, 0x03, 0x00, 0x40, 0x03,
  0x00, 0x80, 0x06, 0x01, 0x00, 0x06, 0x02, 0x00, 0x0C, 0x04, 0x00, 0x0C,
  0x08, 0x00, 0x18, 0x10, 0x00, 0x18, 0x20, 0x00, 0x30, 0x40, 0x00, 0x30,
  0x80, 0x00, 0x61, 0x00, 0x00, 0x62, 0x00, 0x00, 0xC4, 0x00, 0x00, 0xC8,
  0x00, 0x01, 0x90, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x00,
  0x03, 0xFF, 0xE0, 0x1E, 0x00, 0xF0, 0x60, 0x00, 0x41, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x10, 0x00, 0x1C, 0x3E, 0x01, 0xF0,
  0x1F, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0xD0, 0x00, 0x00,
  0x36, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x30, 0x70, 0x00, 0x18, 0x0E, 0x00, 0x1C, 0x01,
  0xF0, 0x1E, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x26, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x62, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x08, 0x18, 0x00, 0x01, 0x81,
  0x80, 0x00, 0x18, 0x18, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x0C, 0x00,
  0x03, 0x00, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x02, 0x00, 0x60, 0x00, 0x60,
  0x06, 0x00, 0x06, 0x00, 0x60, 0x00, 0x60, 0x02, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x18,
  0x00, 0x18, 0x01, 0x80, 0x01, 0x80, 0x18, 0x00, 0x08, 0x01, 0x00, 0x00,
  0xC0, 0x30, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x02,
  0x00, 0x00, 0x60, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0x20, 0x40, 0x00,
  0x02, 0x0C, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x10,
  0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x19, 0x80, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x09, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x26, 0x00, 0x00, 0x50, 0x00, 0x03, 0x30, 0x00,
  0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x36, 0x00, 0x00, 0xC4, 0x00, 0x01,
  0xB0, 0x00, 0x04, 0x30, 0x00, 0x09, 0x80, 0x00, 0x61, 0x80, 0x00, 0xC4,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x18, 0x20, 0x00, 0x31, 0x80,
  0x00, 0xC1, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x0C, 0x00, 0x08, 0x60, 0x00,
  0x60, 0x60, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x18,
  0x08, 0x00, 0x30, 0x60, 0x01, 0x80, 0x60, 0x01, 0x83, 0x00, 0x0C, 0x03,
  0x00, 0x18, 0x08, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x40,
  0x06, 0x03, 0x00, 0x10, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x02, 0x00, 0xC0,
  0x18, 0x02, 0x00, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x06,
  0x01, 0x80, 0x06, 0x01, 0x00, 0x10, 0x0C, 0x00, 0x30, 0x18, 0x00, 0xC0,
  0x60, 0x00, 0x80, 0xC0, 0x06, 0x06, 0x00, 0x06, 0x06, 0x00, 0x30, 0x30,
  0x00, 0x30, 0x20, 0x01, 0x81, 0x80, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x04, 0x18, 0x00, 0x30, 0x40, 0x00, 0x30, 0xC0, 0x01, 0x86, 0x00, 0x01,
  0x86, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20, 0x00, 0x21, 0x80, 0x00, 0x23,
  0x00, 0x01, 0x88, 0x00, 0x01, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x0C, 0xC0,
  0x00, 0x66, 0x00, 0x00, 0x64, 0x00, 0x03, 0x30, 0x00, 0x03, 0x60, 0x00,
  0x09, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x8C, 0x00,
  0x01, 0x86, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x06, 0x00,
  0x06, 0x06, 0x00, 0x01, 0x03, 0x00, 0x00, 0xC1, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x18, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x06, 0x20, 0x00, 0x06,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x01,
  0x80, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0x08, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x04, 0x00, 0x01, 0x86, 0x00, 0x00,
  0x43, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x06, 0xC0, 0x00,
  0x03, 0xA0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x60, 0x40, 0x00, 0x30, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x04, 0x00, 0x80, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0x80,
  0x01, 0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x10, 0x00, 0x02, 0x18, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x18, 0xFF,
  0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x08, 0x60, 0x00, 0x06, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x00, 0xC0, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0x30,
  0x0C, 0x00, 0x0C, 0x06, 0x00, 0x01, 0x81, 0x80, 0x00, 0x60, 0xC0, 0x00,
  0x0C, 0x30, 0x00, 0x03, 0x18, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x1B, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x18, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xFE,
  0x03, 0xE0, 0xE0, 0xE0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x7F,
  0x01, 0xFF, 0xE0, 0xF0, 0x04, 0x70, 0x00, 0x9C, 0x00, 0x17, 0x00, 0x02,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0x70, 0x00, 0x6B,
  0x00, 0x09, 0x70, 0x03, 0x27, 0x01, 0xC4, 0x3F, 0xE0, 0x80, 0xE0, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x04, 0x00, 0x60, 0xFF, 0x80, 0xC7, 0x83,
  0xC1, 0x9C, 0x01, 0xC3, 0x30, 0x00, 0xC6, 0xC0, 0x01, 0x8F, 0x00, 0x01,
  0x9E, 0x00, 0x03, 0x38, 0x00, 0x03, 0x70, 0x00, 0x06, 0xC0, 0x00, 0x0D,
  0x80, 0x00, 0x0B, 0x00, 0x00, 0x16, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0xC0, 0x00,
  0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0xCF, 0x00, 0x01, 0x9A, 0x00, 0x06,
  0x36, 0x00, 0x1C, 0x66, 0x00, 0x70, 0xC7, 0x03, 0xC1, 0x87, 0xFE, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x3E, 0x1C, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x0C,
  0x07, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x7F, 0x83, 0x03, 0xC3, 0xC6, 0x0C, 0x00, 0xCC, 0x30, 0x00, 0xD8,
  0xC0, 0x00, 0xB1, 0x80, 0x01, 0xE6, 0x00, 0x01, 0x4C, 0x00, 0x03, 0xB0,
  0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1A, 0x00,
  0x00, 0x34, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xD0, 0x00, 0x01, 0xB0, 0x00, 0x03,
  0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x39, 0x80, 0x00, 0x53,
  0x00, 0x01, 0xA3, 0x00, 0x02, 0x47, 0x00, 0x0C, 0x87, 0x00, 0x31, 0x07,
  0x81, 0xC2, 0x03, 0xFF, 0x04, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0x1E, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0x60, 0x00,
  0xC3, 0x00, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x09, 0x80, 0x00, 0x26,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x18, 0x0E, 0x01, 0xE0, 0x1F, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0x80, 0xE0, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF,
  0x82, 0x07, 0x87, 0x84, 0x18, 0x01, 0x88, 0x60, 0x01, 0xB1, 0x80, 0x01,
  0xE2, 0x00, 0x01, 0xCC, 0x00, 0x03, 0x98, 0x00, 0x07, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xD0, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00,
  0x0D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x73, 0x00, 0x00, 0xE6, 0x00, 0x03,
  0xC6, 0x00, 0x0D, 0x8C, 0x00, 0x1B, 0x0E, 0x00, 0x66, 0x0E, 0x03, 0x8C,
  0x07, 0xFC, 0x18, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0E, 0x10, 0x00, 0x38, 0x38, 0x01, 0xE0, 0x3F, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x1F, 0xF0, 0xC7, 0x87, 0x8C, 0xE0, 0x0C, 0xCC, 0x00,
  0x6D, 0x80, 0x06, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xDF, 0xFC, 0x00, 0x00, 0x01, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0x03, 0x01, 0xC1, 0xE0, 0x70, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x33, 0xF1, 0xF0,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x06, 0xC0, 0x01, 0x98, 0x00, 0x63, 0x00, 0x18, 0x60, 0x03, 0x0C,
  0x00, 0xC1, 0x80, 0x30, 0x30, 0x06, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18,
  0x08, 0x03, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x31,
  0xE0, 0x06, 0x64, 0x00, 0xC8, 0xC0, 0x1B, 0x08, 0x03, 0xC1, 0x80, 0x70,
  0x18, 0x0E, 0x03, 0x01, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0x60, 0xC0,
  0x0C, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80,
  0x03, 0x30, 0x00, 0x66, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x0C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x83, 0xFC, 0x01, 0xFE, 0x10, 0xE1, 0xC0, 0xF0, 0xE2, 0x30, 0x0C, 0x38,
  0x06, 0x4C, 0x00, 0xC4, 0x00, 0x6D, 0x00, 0x09, 0x80, 0x0D, 0xE0, 0x01,
  0xA0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0x60, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x01,
  0xE0, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x07, 0x80, 0x00, 0xC0,
  0x00, 0xF0, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x01, 0xE0,
  0x00, 0x30, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0x60,
  0x00, 0x78, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x00,
  0x30, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x07, 0x80, 0x00, 0xC0, 0x00, 0xF0,
  0x00, 0x18, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00,
  0x78, 0x00, 0x0C, 0x00, 0x0F, 0x00, 0x01, 0x80, 0x01, 0x80, 0x81, 0xFF,
  0x08, 0x78, 0x38, 0x8E, 0x00, 0xC8, 0xC0, 0x06, 0x98, 0x00, 0x6B, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x10, 0x01, 0xFF, 0x80, 0x03, 0xC3, 0xC0, 0x06, 0x00, 0x70, 0x0C,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x20,
  0x00, 0x04, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x40,
  0x00, 0x06, 0x40, 0x00, 0x02, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x02, 0x40,
  0x00, 0x02, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x20,
  0x00, 0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x30, 0x0E, 0x00, 0x70, 0x07, 0x81, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x81, 0xFF, 0x01, 0x07, 0x87, 0x82, 0x18, 0x03, 0x84, 0x60,
  0x01, 0x89, 0x80, 0x03, 0x12, 0x00, 0x03, 0x2C, 0x00, 0x06, 0x50, 0x00,
  0x06, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x2C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x02, 0xC0,
  0x00, 0x05, 0x80, 0x00, 0x1B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x4F, 0x00,
  0x01, 0x9E, 0x00, 0x03, 0x36, 0x00, 0x0C, 0x6E, 0x00, 0x38, 0xCE, 0x00,
  0xE1, 0x8F, 0x07, 0x83, 0x07, 0xFC, 0x06, 0x01, 0xC0, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x02, 0x07, 0x87, 0x84, 0x18, 0x01, 0x88, 0x60,
  0x01, 0x91, 0x80, 0x01, 0x63, 0x00, 0x03, 0xCC, 0x00, 0x03, 0x98, 0x00,
  0x07, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1A, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40,
  0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x3B, 0x00, 0x00, 0x73, 0x00,
  0x00, 0xE6, 0x00, 0x03, 0xC6, 0x00, 0x0D, 0x8E, 0x00, 0x13, 0x0E, 0x00,
  0xE6, 0x0F, 0x03, 0x8C, 0x07, 0xFC, 0x18, 0x03, 0xC0, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x81, 0xFF, 0x1E, 0x6C, 0xE0, 0x33, 0x00, 0xD8, 0x03, 0x40,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0x81, 0xE0, 0xFC, 0x70, 0x01, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x34, 0x00, 0x06, 0xC0, 0x01, 0x9F, 0x01,
  0xE0, 0xFF, 0xF8, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x1C, 0x10, 0x3F, 0xC0, 0x18, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x5C,
  0x00, 0x0D, 0x60, 0x00, 0x96, 0x00, 0x19, 0x30, 0x03, 0x11, 0xC0, 0xE1,
  0x0F, 0xFC, 0x10, 0x1C, 0x00, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x26, 0x00,
  0x01, 0x98, 0x00, 0x06, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x43, 0x00, 0x03,
  0x0C, 0x00, 0x0C, 0x10, 0x00, 0x20, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06,
  0x00, 0x18, 0x08, 0x00, 0x40, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x00,
  0x20, 0x06, 0x01, 0x80, 0x18, 0x06, 0x00, 0x60, 0x18, 0x00, 0x80, 0x40,
  0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x10, 0x20, 0x00, 0x41, 0x80, 0x01,
  0x86, 0x00, 0x06, 0x18, 0x00, 0x08, 0x40, 0x00, 0x33, 0x00, 0x00, 0xCC,
  0x00, 0x03, 0x20, 0x00, 0x04, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xA0, 0x00, 0x78, 0x00, 0x36,
  0x00, 0x0F, 0x00, 0x04, 0xC0, 0x01, 0x60, 0x00, 0x98, 0x00, 0x64, 0x00,
  0x31, 0x00, 0x0C, 0xC0, 0x06, 0x30, 0x01, 0x98, 0x00, 0xC6, 0x00, 0x23,
  0x00, 0x10, 0xC0, 0x0C, 0x20, 0x06, 0x08, 0x01, 0x86, 0x00, 0xC1, 0x00,
  0x30, 0xC0, 0x18, 0x30, 0x04, 0x18, 0x02, 0x06, 0x01, 0x81, 0x00, 0xC0,
  0x40, 0x30, 0x30, 0x18, 0x08, 0x06, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0,
  0x40, 0x30, 0x30, 0x08, 0x08, 0x06, 0x06, 0x01, 0x83, 0x00, 0x40, 0xC0,
  0x30, 0x60, 0x0C, 0x10, 0x06, 0x08, 0x01, 0x86, 0x00, 0x41, 0x00, 0x30,
  0xC0, 0x0C, 0x60, 0x02, 0x18, 0x01, 0x8C, 0x00, 0x62, 0x00, 0x31, 0x80,
  0x0C, 0xC0, 0x02, 0x20, 0x01, 0x98, 0x00, 0x6C, 0x00, 0x13, 0x00, 0x0D,
  0x80, 0x03, 0x40, 0x01, 0xB0, 0x00, 0x78, 0x00, 0x14, 0x00, 0x0F, 0x00,
  0x02, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x43, 0x00, 0x03,
  0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x60, 0x06, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x61,
  0x80, 0x00, 0x86, 0x00, 0x03, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1A, 0x00, 0x00,
  0xCC, 0x00, 0x02, 0x10, 0x00, 0x18, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x03,
  0x00, 0x18, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0,
  0x60, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x31, 0x80,
  0x00, 0x6E, 0x00, 0x01, 0xC0, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x08, 0x80,
  0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0x82, 0x00, 0x03, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x10, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0x60, 0x01, 0x00, 0x40, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x60, 0x02, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x0C, 0x02, 0x00,
  0x08, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x20, 0x00, 0x60, 0xC0, 0x00,
  0x61, 0x80, 0x00, 0xC3, 0x00, 0x01, 0x84, 0x00, 0x01, 0x18, 0x00, 0x03,
  0x30, 0x00, 0x06, 0x40, 0x00, 0x05, 0x80, 0x00, 0x0B, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x1F, 0xC0, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00,
  0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x7F,
  0xF0, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x0F, 0x0E, 0x80, 0x03, 0xFC,
};

const GFXglyph NotoSans_Condensed_Thin66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 3, 47, 13, 5, -47 },
  { 19, 11, 17, 20, 4, -47 },
  { 43, 30, 47, 32, 1, -47 },
  { 220, 23, 54, 30, 3, -50 },
  { 376, 36, 49, 42, 3, -48 },
  { 597, 28, 49, 32, 3, -48 },
  { 769, 2, 17, 11, 4, -47 },
  { 774, 12, 57, 17, 3, -47 },
  { 860, 11, 57, 17, 3, -47 },
  { 939, 20, 20, 27, 3, -50 },
  { 989, 25, 30, 30, 2, -38 },
  { 1083, 5, 16, 12, 3, -7 },
  { 1093, 15, 2, 19, 2, -19 },
  { 1097, 3, 4, 13, 5, -4 },
  { 1099, 19, 47, 22, 1, -47 },
  { 1211, 23, 48, 30, 3, -48 },
  { 1349, 11, 47, 30, 6, -47 },
  { 1414, 23, 48, 30, 3, -48 },
  { 1552, 23, 49, 30, 3, -48 },
  { 1693, 28, 47, 30, 1, -47 },
  { 1858, 22, 48, 30, 4, -47 },
  { 1990, 22, 49, 30, 4, -48 },
  { 2125, 23, 47, 30, 3, -47 },
  { 2261, 23, 49, 30, 3, -48 },
  { 2402, 23, 49, 30, 3, -48 },
  { 2543, 3, 35, 13, 5, -35 },
  { 2557, 5, 44, 13, 3, -35 },
  { 2585, 25, 27, 30, 2, -37 },
  { 2670, 25, 16, 30, 2, -31 },
  { 2720, 25, 27, 30, 2, -37 },
  { 2805, 16, 48, 20, 2, -48 },
  { 2901, 39, 53, 45, 3, -47 },
  { 3160, 29, 47, 29, 0, -47 },
  { 3331, 23, 47, 32, 6, -47 },
  { 3467, 26, 49, 31, 4, -48 },
  { 3627, 26, 47, 36, 6, -47 },
  { 3780, 19, 47, 29, 6, -47 },
  { 3892, 19, 47, 26, 6, -47 },
  { 4004, 30, 49, 38, 4, -48 },
  { 4188, 25, 47, 36, 6, -47 },
  { 4335, 10, 47, 16, 3, -47 },
  { 4394, 12, 59, 13, -4, -47 },
  { 4483, 23, 47, 29, 6, -47 },
  { 4619, 18, 47, 26, 6, -47 },
  { 4725, 35, 47, 47, 6, -47 },
  { 4931, 25, 47, 37, 6, -47 },
  { 5078, 31, 49, 39, 4, -48 },
  { 5268, 21, 47, 30, 6, -47 },
  { 5392, 31, 59, 39, 4, -48 },
  { 5621, 23, 47, 30, 6, -47 },
  { 5757, 23, 49, 29, 3, -48 },
  { 5898, 25, 47, 26, 0, -47 },
  { 6045, 26, 48, 37, 5, -47 },
  { 6201, 28, 47, 28, 0, -47 },
  { 6366, 45, 47, 47, 1, -47 },
  { 6631, 25, 47, 25, 0, -47 },
  { 6778, 25, 47, 25, 0, -47 },
  { 6925, 23, 47, 26, 2, -47 },
  { 7061, 12, 57, 20, 6, -47 },
  { 7147, 19, 47, 22, 1, -47 },
  { 7259, 13, 57, 20, 2, -47 },
  { 7352, 26, 24, 30, 2, -47 },
  { 7430, 26, 2, 26, 0, 6 },
  { 7437, 10, 10, 15, 3, -50 },
  { 7450, 19, 36, 27, 3, -35 },
  { 7536, 23, 51, 31, 5, -50 },
  { 7683, 19, 36, 24, 3, -35 },
  { 7769, 23, 51, 31, 3, -50 },
  { 7916, 22, 36, 28, 3, -35 },
  { 8015, 17, 50, 15, 1, -50 },
  { 8122, 23, 51, 31, 3, -35 },
  { 8269, 20, 50, 30, 5, -50 },
  { 8394, 3, 48, 12, 5, -48 },
  { 8412, 9, 64, 12, -1, -48 },
  { 8484, 19, 50, 24, 5, -50 },
  { 8603, 2, 50, 12, 5, -50 },
  { 8616, 35, 35, 45, 5, -35 },
  { 8770, 20, 35, 30, 5, -35 },
  { 8858, 24, 36, 30, 3, -35 },
  { 8966, 23, 50, 31, 5, -35 },
  { 9110, 23, 50, 31, 3, -35 },
  { 9254, 14, 35, 20, 5, -35 },
  { 9316, 19, 36, 24, 2, -35 },
  { 9402, 14, 44, 16, 1, -43 },
  { 9479, 20, 36, 30, 5, -35 },
  { 9569, 22, 35, 22, 0, -35 },
  { 9666, 35, 35, 37, 1, -35 },
  { 9820, 22, 35, 24, 1, -35 },
  { 9917, 23, 51, 23, 0, -35 },
  { 10064, 17, 35, 21, 2, -35 },
  { 10139, 17, 57, 23, 3, -47 },
  { 10261, 2, 66, 28, 13, -50 },
  { 10278, 17, 57, 23, 3, -47 },
  { 10400, 24, 5, 30, 3, -26 },
};

const GFXfont NotoSans_Condensed_Thin66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin66pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_CONDENSED_THIN66PT7B_H_
