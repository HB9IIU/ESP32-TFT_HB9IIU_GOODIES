#ifndef _NOTOSANS_CONDENSED_THIN57PT7B_H_
#define _NOTOSANS_CONDENSED_THIN57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin57pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xD8, 0x00, 0x00, 0xBF, 0xE0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x00, 0x20,
  0x08, 0x00, 0x08, 0x02, 0x00, 0x02, 0x00, 0x80, 0x01, 0x80, 0x60, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x00, 0x01, 0x00, 0x40,
  0x00, 0x40, 0x10, 0x00, 0x10, 0x04, 0x00, 0x04, 0x01, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xF0, 0x08, 0x02, 0x00, 0x02,
  0x00, 0x80, 0x00, 0x80, 0x20, 0x00, 0x20, 0x08, 0x00, 0x18, 0x02, 0x00,
  0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x40, 0x18, 0x00, 0x10, 0x04,
  0x00, 0x04, 0x01, 0x00, 0x01, 0x00, 0x40, 0x00, 0xC0, 0x10, 0x0F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x00, 0x80, 0x20, 0x00,
  0x20, 0x08, 0x00, 0x08, 0x02, 0x00, 0x02, 0x00, 0x80, 0x01, 0x80, 0x60,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x04, 0x01, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x40, 0x10, 0x00, 0x10, 0x04, 0x00, 0x0C, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFE, 0x00, 0xF6,
  0x7E, 0x0C, 0x30, 0x20, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x02,
  0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x30,
  0x01, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x06,
  0x18, 0x00, 0x18, 0xC0, 0x00, 0x76, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x67, 0x00, 0x03, 0x0C, 0x00, 0x18, 0x30, 0x00,
  0xC0, 0xC0, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01, 0x80, 0x40, 0x0C, 0x02,
  0x00, 0x60, 0x18, 0x03, 0x00, 0x80, 0x18, 0x04, 0x00, 0xC0, 0x60, 0x06,
  0x03, 0x00, 0x30, 0x32, 0x01, 0x83, 0x1C, 0x0C, 0x30, 0x7F, 0xFF, 0x00,
  0x3F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0x80, 0x03, 0x00, 0x61, 0x80, 0x06, 0x00, 0x81, 0x00, 0x08,
  0x03, 0x03, 0x00, 0x30, 0x04, 0x02, 0x00, 0x40, 0x18, 0x06, 0x01, 0x80,
  0x30, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x04, 0x00, 0x80, 0x10, 0x18, 0x01,
  0x00, 0x20, 0x20, 0x02, 0x00, 0x40, 0xC0, 0x04, 0x00, 0x81, 0x80, 0x08,
  0x01, 0x02, 0x00, 0x10, 0x02, 0x0C, 0x00, 0x20, 0x04, 0x10, 0x00, 0x40,
  0x08, 0x60, 0x00, 0x80, 0x10, 0xC3, 0xE1, 0x80, 0x61, 0x0C, 0x63, 0x00,
  0xC6, 0x30, 0x62, 0x01, 0x08, 0x40, 0x44, 0x02, 0x31, 0x80, 0xCC, 0x0C,
  0x62, 0x01, 0x88, 0x10, 0x84, 0x01, 0x18, 0x63, 0x08, 0x02, 0x1F, 0x84,
  0x30, 0x04, 0x00, 0x08, 0x60, 0x08, 0x00, 0x30, 0xC0, 0x18, 0x00, 0x41,
  0x80, 0x30, 0x01, 0x83, 0x00, 0x60, 0x02, 0x06, 0x00, 0xC0, 0x04, 0x0C,
  0x01, 0x80, 0x18, 0x18, 0x02, 0x00, 0x20, 0x30, 0x04, 0x00, 0xC0, 0x60,
  0x08, 0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0xC0, 0x10, 0x03, 0x01, 0x00, 0x60, 0x02, 0x06, 0x00, 0xC0, 0x02, 0x18,
  0x03, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0x87, 0x00, 0x01, 0x80, 0x80, 0x00, 0x80, 0x60, 0x00, 0xC0, 0x10, 0x00,
  0x40, 0x08, 0x00, 0x20, 0x04, 0x00, 0x10, 0x03, 0x00, 0x08, 0x01, 0x80,
  0x04, 0x00, 0x80, 0x03, 0x00, 0x40, 0x01, 0x80, 0x20, 0x00, 0x40, 0x30,
  0x00, 0x30, 0x10, 0x00, 0x08, 0x18, 0x00, 0x06, 0x18, 0x00, 0x01, 0x18,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x71, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x20, 0x30, 0x06, 0x30,
  0x0C, 0x03, 0x30, 0x02, 0x01, 0x18, 0x01, 0x80, 0x88, 0x00, 0x60, 0x44,
  0x00, 0x10, 0x66, 0x00, 0x0C, 0x23, 0x00, 0x03, 0x11, 0x80, 0x00, 0x98,
  0xC0, 0x00, 0x68, 0x20, 0x00, 0x1C, 0x10, 0x00, 0x0C, 0x0C, 0x00, 0x07,
  0x06, 0x00, 0x06, 0xC1, 0x80, 0x06, 0x20, 0x60, 0x06, 0x18, 0x18, 0x0E,
  0x06, 0x07, 0xFC, 0x01, 0x80, 0x20, 0x00, 0x00, 0xFF, 0xFE, 0xAA, 0xA8,
  0x00, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x04,
  0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x18, 0x02,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x10, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x06, 0x00,
  0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06,
  0x01, 0x00, 0xC0, 0x60, 0x30, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x08, 0x04, 0x04, 0x07, 0x82, 0x1E, 0x39, 0x38, 0x03,
  0xE0, 0x00, 0xE0, 0x00, 0x50, 0x00, 0x44, 0x00, 0x41, 0x00, 0x60, 0xC0,
  0x60, 0x20, 0x60, 0x0C, 0x10, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x18, 0xC6, 0x23, 0x18, 0xC4,
  0x23, 0x18, 0x8C, 0x00, 0xFF, 0xF0, 0x5F, 0xF0, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x70, 0xE0, 0x0C, 0x03, 0x01, 0x80, 0x10, 0x10, 0x01,
  0x83, 0x00, 0x08, 0x20, 0x00, 0xC6, 0x00, 0x04, 0x60, 0x00, 0x44, 0x00,
  0x06, 0x40, 0x00, 0x64, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0,
  0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0x80, 0x00, 0x28,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x2C, 0x00, 0x02,
  0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00,
  0x24, 0x00, 0x06, 0x40, 0x00, 0x64, 0x00, 0x06, 0x60, 0x00, 0x46, 0x00,
  0x04, 0x20, 0x00, 0xC3, 0x00, 0x08, 0x10, 0x01, 0x81, 0x80, 0x10, 0x0C,
  0x03, 0x00, 0x70, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0xC0, 0x70, 0x34, 0x19,
  0x0C, 0x4E, 0x17, 0x07, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x07,
  0xF8, 0x07, 0x83, 0x81, 0x80, 0x1C, 0x20, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFC, 0x01, 0xE0, 0xF0, 0x70, 0x01, 0x8E, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x10, 0x00, 0x01, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x80, 0x01, 0x8F, 0x00, 0x70, 0x3F, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x40, 0x00, 0x06, 0x40, 0x00, 0x04, 0x40, 0x00, 0x0C, 0x40, 0x00, 0x08,
  0x40, 0x00, 0x18, 0x40, 0x00, 0x10, 0x40, 0x00, 0x30, 0x40, 0x00, 0x60,
  0x40, 0x00, 0x60, 0x40, 0x00, 0xC0, 0x40, 0x00, 0x80, 0x40, 0x01, 0x80,
  0x40, 0x01, 0x00, 0x40, 0x03, 0x00, 0x40, 0x06, 0x00, 0x40, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0x40, 0x08, 0x00, 0x40, 0x18, 0x00, 0x40, 0x10, 0x00,
  0x40, 0x30, 0x00, 0x40, 0x20, 0x00, 0x40, 0x60, 0x00, 0x40, 0xC0, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x40, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0xFF, 0x80, 0x7C, 0x0E,
  0x04, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x80, 0x03, 0x0F, 0x00, 0xE0, 0x3F, 0xF8, 0x00, 0x18, 0x00, 0x00, 0x7F,
  0x80, 0x1E, 0x0C, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04,
  0x00, 0x00, 0xC1, 0xF8, 0x0C, 0x7F, 0xE0, 0xCC, 0x03, 0x8D, 0x80, 0x08,
  0xF0, 0x00, 0xCE, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00,
  0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x40, 0x00, 0x34, 0x00, 0x03, 0x40, 0x00, 0x26, 0x00, 0x02, 0x60,
  0x00, 0x62, 0x00, 0x06, 0x30, 0x00, 0x41, 0x80, 0x0C, 0x18, 0x01, 0x80,
  0xE0, 0x30, 0x03, 0xFE, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0xF0, 0xF0, 0x18, 0x03, 0x83, 0x00, 0x08, 0x20, 0x00, 0xC6, 0x00, 0x04,
  0x40, 0x00, 0x64, 0x00, 0x06, 0x40, 0x00, 0x64, 0x00, 0x06, 0x40, 0x00,
  0x66, 0x00, 0x06, 0x60, 0x00, 0x42, 0x00, 0x0C, 0x30, 0x01, 0x81, 0x80,
  0x30, 0x0C, 0x06, 0x00, 0x70, 0xC0, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x03,
  0xB8, 0x00, 0x60, 0xC0, 0x1C, 0x03, 0x03, 0x00, 0x18, 0x30, 0x00, 0xC6,
  0x00, 0x04, 0xC0, 0x00, 0x6C, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x2C, 0x00, 0x06, 0x40, 0x00, 0x66, 0x00, 0x0C, 0x30, 0x01, 0x81, 0xC0,
  0x70, 0x07, 0xFC, 0x00, 0x04, 0x00, 0x07, 0xF8, 0x01, 0xC3, 0x80, 0x60,
  0x18, 0x18, 0x01, 0x86, 0x00, 0x18, 0x80, 0x01, 0x30, 0x00, 0x36, 0x00,
  0x06, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xA0, 0x00, 0x56, 0x00, 0x0A, 0x40, 0x02, 0x4C, 0x00,
  0xC8, 0xE0, 0x73, 0x07, 0xF8, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x07, 0x02, 0x01, 0xC0, 0x7F, 0xE0, 0x01, 0xC0, 0x00, 0xFF, 0xA0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x7F, 0xC0, 0x39, 0xCE,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0xC6, 0x23, 0x18, 0xC4, 0x63, 0x10, 0x8C, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xE1, 0xE0, 0xE1, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x18, 0x00, 0x00, 0x20, 0x18, 0x00, 0x00, 0x18, 0x08, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x03, 0x04, 0x00, 0x00, 0x00, 0x86, 0x00, 0x00,
  0x00, 0x62, 0x00, 0x1F, 0xC0, 0x33, 0x00, 0x38, 0x70, 0x09, 0x80, 0x30,
  0x18, 0x06, 0xC0, 0x10, 0x0C, 0x03, 0x40, 0x18, 0x06, 0x01, 0xA0, 0x18,
  0x03, 0x00, 0xF0, 0x0C, 0x01, 0x80, 0x38, 0x04, 0x00, 0xC0, 0x1C, 0x02,
  0x00, 0x60, 0x0E, 0x03, 0x00, 0x30, 0x07, 0x01, 0x80, 0x18, 0x03, 0x80,
  0xC0, 0x08, 0x01, 0xC0, 0x60, 0x04, 0x00, 0xE0, 0x30, 0x02, 0x00, 0xF0,
  0x18, 0x01, 0x00, 0x78, 0x0C, 0x01, 0x80, 0x3C, 0x02, 0x00, 0xC0, 0x16,
  0x01, 0x00, 0x70, 0x0B, 0x00, 0xC0, 0x68, 0x0C, 0x80, 0x60, 0x24, 0x0C,
  0x40, 0x18, 0x33, 0x0E, 0x30, 0x07, 0xF0, 0xFE, 0x18, 0x00, 0xC0, 0x18,
  0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x20, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x05, 0x00, 0x00, 0x02, 0x80, 0x00, 0x03,
  0x60, 0x00, 0x01, 0x10, 0x00, 0x00, 0x88, 0x00, 0x00, 0x46, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x20, 0x80, 0x00, 0x10, 0x40, 0x00, 0x18, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x04, 0x04, 0x00, 0x02, 0x03, 0x00, 0x03, 0x01, 0x80,
  0x01, 0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x0C,
  0x00, 0x20, 0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x07, 0xFF, 0xF0, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x00,
  0x01, 0x00, 0x80, 0x00, 0x80, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x20,
  0x00, 0x08, 0x30, 0x00, 0x06, 0x18, 0x00, 0x03, 0x08, 0x00, 0x00, 0x84,
  0x00, 0x00, 0x46, 0x00, 0x00, 0x33, 0x00, 0x00, 0x19, 0x00, 0x00, 0x05,
  0x80, 0x00, 0x02, 0xC0, 0x00, 0x01, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x80, 0x07, 0x08, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x06, 0x80, 0x00,
  0x68, 0x00, 0x06, 0x80, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00,
  0x02, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x80,
  0x01, 0x88, 0x00, 0x38, 0x80, 0x0E, 0x0F, 0xFF, 0x80, 0x80, 0x1E, 0x08,
  0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x06, 0x80, 0x00, 0x28, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x28, 0x00,
  0x06, 0x80, 0x00, 0x48, 0x00, 0x0C, 0x80, 0x03, 0x88, 0x03, 0xE0, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x01, 0xE0, 0x7C, 0x07, 0x00, 0x10, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x06, 0x00, 0x3F, 0xF8,
  0x00, 0x0E, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x08, 0x00, 0xF0, 0x20,
  0x00, 0x60, 0x80, 0x00, 0xC2, 0x00, 0x01, 0x88, 0x00, 0x03, 0x20, 0x00,
  0x0C, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x68, 0x00, 0x00, 0xA0, 0x00, 0x02,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x28, 0x00, 0x00, 0xA0, 0x00, 0x06, 0x80, 0x00, 0x12, 0x00, 0x00,
  0xC8, 0x00, 0x02, 0x20, 0x00, 0x18, 0x80, 0x00, 0xC2, 0x00, 0x06, 0x08,
  0x00, 0x70, 0x20, 0x3F, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04,
  0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00,
  0x1F, 0xFF, 0xE8, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x07, 0xFF, 0xFA, 0x00,
  0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1E, 0x03, 0xE0, 0x0C,
  0x00, 0x1C, 0x0E, 0x00, 0x01, 0x06, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x30, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x50, 0x00, 0x00, 0x14, 0x00, 0x00, 0x05, 0x00, 0x00, 0x01, 0x60,
  0x00, 0x00, 0x58, 0x00, 0x00, 0x12, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x01,
  0x30, 0x00, 0x00, 0x44, 0x00, 0x00, 0x11, 0x80, 0x00, 0x04, 0x30, 0x00,
  0x01, 0x06, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x10, 0x18, 0x00, 0x04, 0x03,
  0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0xFF, 0x7C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x03, 0x3F, 0xCF, 0xC0, 0x80,
  0x00, 0x68, 0x00, 0x0C, 0x80, 0x00, 0xC8, 0x00, 0x18, 0x80, 0x03, 0x08,
  0x00, 0x20, 0x80, 0x06, 0x08, 0x00, 0xC0, 0x80, 0x18, 0x08, 0x01, 0x80,
  0x80, 0x30, 0x08, 0x06, 0x00, 0x80, 0xC0, 0x08, 0x0C, 0x00, 0x81, 0x80,
  0x08, 0x30, 0x00, 0x83, 0x00, 0x08, 0x60, 0x00, 0x8E, 0x00, 0x09, 0xB0,
  0x00, 0x9B, 0x00, 0x0B, 0x18, 0x00, 0xE1, 0x80, 0x0C, 0x0C, 0x00, 0xC0,
  0x40, 0x08, 0x06, 0x00, 0x80, 0x30, 0x08, 0x03, 0x00, 0x80, 0x18, 0x08,
  0x01, 0x80, 0x80, 0x0C, 0x08, 0x00, 0x40, 0x80, 0x06, 0x08, 0x00, 0x20,
  0x80, 0x03, 0x08, 0x00, 0x18, 0x80, 0x01, 0x88, 0x00, 0x0C, 0x80, 0x00,
  0x48, 0x00, 0x06, 0x80, 0x00, 0x30, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xE8, 0x00, 0x00, 0x07, 0xB0, 0x00, 0x00, 0x16, 0xC0,
  0x00, 0x00, 0xD9, 0x00, 0x00, 0x03, 0x66, 0x00, 0x00, 0x09, 0x98, 0x00,
  0x00, 0x66, 0x20, 0x00, 0x01, 0x98, 0xC0, 0x00, 0x04, 0x63, 0x00, 0x00,
  0x31, 0x84, 0x00, 0x00, 0xC6, 0x18, 0x00, 0x02, 0x18, 0x60, 0x00, 0x18,
  0x60, 0x80, 0x00, 0x61, 0x83, 0x00, 0x01, 0x06, 0x0C, 0x00, 0x0C, 0x18,
  0x10, 0x00, 0x30, 0x60, 0x60, 0x00, 0x81, 0x81, 0x80, 0x06, 0x06, 0x02,
  0x00, 0x18, 0x18, 0x0C, 0x00, 0x40, 0x60, 0x30, 0x03, 0x01, 0x80, 0x40,
  0x0C, 0x06, 0x01, 0x80, 0x20, 0x18, 0x06, 0x01, 0x80, 0x60, 0x08, 0x06,
  0x01, 0x80, 0x30, 0x10, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x01, 0x03, 0x00,
  0x60, 0x06, 0x08, 0x01, 0x80, 0x18, 0x60, 0x06, 0x00, 0x21, 0x80, 0x18,
  0x00, 0xC4, 0x00, 0x60, 0x03, 0x30, 0x01, 0x80, 0x04, 0xC0, 0x06, 0x00,
  0x1A, 0x00, 0x18, 0x00, 0x78, 0x00, 0x60, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x04, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x62, 0x00, 0x01,
  0x8C, 0x00, 0x06, 0x10, 0x00, 0x18, 0x60, 0x00, 0x60, 0x80, 0x01, 0x83,
  0x00, 0x06, 0x04, 0x00, 0x18, 0x18, 0x00, 0x60, 0x20, 0x01, 0x80, 0xC0,
  0x06, 0x01, 0x00, 0x18, 0x06, 0x00, 0x60, 0x08, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x40, 0x18, 0x01, 0x80, 0x60, 0x02, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x10, 0x18, 0x00, 0x60, 0x60, 0x00, 0x81, 0x80, 0x03, 0x06, 0x00, 0x04,
  0x18, 0x00, 0x18, 0x60, 0x00, 0x21, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x18,
  0x00, 0x06, 0x60, 0x00, 0x09, 0x80, 0x00, 0x36, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x7F, 0xC0, 0x00, 0x3C,
  0x0E, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60,
  0x30, 0x00, 0x06, 0x06, 0x00, 0x00, 0x41, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x84, 0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x24,
  0x00, 0x00, 0x04, 0x80, 0x00, 0x00, 0x90, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0D, 0x00,
  0x00, 0x01, 0xA0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x31, 0x00, 0x00, 0x06, 0x30, 0x00, 0x00, 0x86, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20,
  0x0C, 0x00, 0x0C, 0x00, 0xC0, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x08, 0x00, 0xE2,
  0x00, 0x0C, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x28, 0x00, 0x1A,
  0x00, 0x0C, 0x80, 0x07, 0x20, 0x07, 0x0F, 0xFF, 0x83, 0xF8, 0x00, 0x80,
  0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x30, 0x00, 0x06, 0x06, 0x00,
  0x00, 0x41, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x84, 0x00, 0x00, 0x19,
  0x80, 0x00, 0x03, 0x30, 0x00, 0x00, 0x24, 0x00, 0x00, 0x04, 0x80, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x34, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00, 0x98, 0x00, 0x00, 0x31, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x86, 0x00, 0x00, 0x30, 0x60, 0x00, 0x06,
  0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x20, 0x0C, 0x00, 0x0C, 0x00, 0xC0,
  0x07, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x80, 0x0E, 0x08, 0x00, 0x30, 0x80, 0x01, 0x88, 0x00, 0x08, 0x80, 0x00,
  0xC8, 0x00, 0x0C, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0x48, 0x00,
  0x04, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80,
  0x00, 0x88, 0x00, 0x18, 0x80, 0x01, 0x08, 0x00, 0x60, 0x80, 0x0C, 0x0F,
  0xFF, 0x80, 0xFF, 0xC0, 0x08, 0x06, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00,
  0x80, 0x10, 0x08, 0x01, 0x80, 0x80, 0x08, 0x08, 0x00, 0xC0, 0x80, 0x04,
  0x08, 0x00, 0x60, 0x80, 0x02, 0x08, 0x00, 0x30, 0x80, 0x01, 0x08, 0x00,
  0x18, 0x80, 0x00, 0x88, 0x00, 0x0C, 0x80, 0x00, 0x48, 0x00, 0x06, 0x80,
  0x00, 0x30, 0x03, 0xFF, 0x01, 0xE0, 0x78, 0x60, 0x01, 0x18, 0x00, 0x06,
  0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x20, 0x00, 0xC7, 0x00,
  0x70, 0x7F, 0xFC, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x28, 0x00,
  0x00, 0x50, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x06, 0xC0, 0x00,
  0x09, 0x80, 0x00, 0x11, 0x00, 0x00, 0x63, 0x00, 0x00, 0x83, 0x00, 0x03,
  0x03, 0x00, 0x0C, 0x03, 0x80, 0x70, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x02,
  0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x20, 0x00, 0x06, 0x20, 0x00, 0x04,
  0x30, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x10, 0x00, 0x08, 0x18, 0x00, 0x08,
  0x18, 0x00, 0x18, 0x08, 0x00, 0x18, 0x08, 0x00, 0x10, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x04, 0x00, 0x20, 0x04, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x60, 0x02, 0x00, 0x40, 0x03, 0x00, 0x40, 0x03, 0x00, 0xC0,
  0x01, 0x00, 0xC0, 0x01, 0x00, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80,
  0x00, 0x81, 0x00, 0x00, 0x81, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x62, 0x00, 0x00, 0x66, 0x00, 0x00, 0x24, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0x80, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00,
  0x0F, 0x00, 0x00, 0xC0, 0x00, 0x16, 0x00, 0x01, 0xC0, 0x00, 0x24, 0x00,
  0x03, 0x80, 0x00, 0xC8, 0x00, 0x0D, 0x00, 0x01, 0x98, 0x00, 0x1A, 0x00,
  0x03, 0x30, 0x00, 0x26, 0x00, 0x04, 0x20, 0x00, 0x4C, 0x00, 0x18, 0x40,
  0x01, 0x98, 0x00, 0x30, 0xC0, 0x03, 0x10, 0x00, 0x61, 0x80, 0x06, 0x20,
  0x00, 0x81, 0x00, 0x08, 0x60, 0x03, 0x02, 0x00, 0x10, 0xC0, 0x06, 0x06,
  0x00, 0x60, 0x80, 0x0C, 0x0C, 0x00, 0xC1, 0x00, 0x10, 0x18, 0x01, 0x83,
  0x00, 0x20, 0x10, 0x02, 0x06, 0x00, 0xC0, 0x30, 0x04, 0x0C, 0x01, 0x80,
  0x60, 0x18, 0x08, 0x02, 0x00, 0xC0, 0x30, 0x10, 0x04, 0x00, 0x80, 0x40,
  0x30, 0x18, 0x01, 0x00, 0x80, 0x60, 0x30, 0x03, 0x03, 0x00, 0x40, 0x40,
  0x06, 0x06, 0x00, 0x80, 0x80, 0x04, 0x0C, 0x01, 0x83, 0x00, 0x08, 0x10,
  0x03, 0x06, 0x00, 0x18, 0x20, 0x06, 0x0C, 0x00, 0x30, 0xC0, 0x04, 0x10,
  0x00, 0x61, 0x80, 0x08, 0x60, 0x00, 0x42, 0x00, 0x18, 0xC0, 0x00, 0xC4,
  0x00, 0x31, 0x80, 0x01, 0x98, 0x00, 0x22, 0x00, 0x03, 0x30, 0x00, 0x44,
  0x00, 0x02, 0x60, 0x00, 0xD8, 0x00, 0x04, 0x80, 0x01, 0xB0, 0x00, 0x0D,
  0x00, 0x03, 0x40, 0x00, 0x1E, 0x00, 0x02, 0x80, 0x00, 0x1C, 0x00, 0x05,
  0x00, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x20,
  0x00, 0x08, 0xC0, 0x00, 0x61, 0x00, 0x01, 0x06, 0x00, 0x0C, 0x08, 0x00,
  0x20, 0x30, 0x01, 0x80, 0xC0, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80,
  0x08, 0x06, 0x00, 0x30, 0x18, 0x00, 0x40, 0xC0, 0x01, 0x83, 0x00, 0x02,
  0x08, 0x00, 0x0C, 0x60, 0x00, 0x11, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xA0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x80, 0x00, 0x13, 0x00, 0x00, 0xC4, 0x00, 0x02, 0x18, 0x00, 0x18,
  0x20, 0x00, 0x40, 0xC0, 0x03, 0x03, 0x00, 0x08, 0x06, 0x00, 0x60, 0x18,
  0x01, 0x80, 0x20, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x01, 0x80, 0x06, 0x06,
  0x00, 0x08, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC2, 0x00, 0x01, 0x18, 0x00,
  0x06, 0xC0, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xD0, 0x00, 0x04,
  0xC0, 0x00, 0x62, 0x00, 0x03, 0x18, 0x00, 0x10, 0xC0, 0x01, 0x82, 0x00,
  0x08, 0x18, 0x00, 0xC0, 0x40, 0x06, 0x03, 0x00, 0x20, 0x18, 0x03, 0x00,
  0x40, 0x10, 0x03, 0x01, 0x80, 0x08, 0x0C, 0x00, 0x60, 0x40, 0x03, 0x06,
  0x00, 0x08, 0x20, 0x00, 0x63, 0x00, 0x01, 0x18, 0x00, 0x0C, 0x80, 0x00,
  0x6C, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x1F, 0xFC, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x04,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x08,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x10,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x7F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0x20, 0x00, 0x06, 0x60, 0x00, 0x08, 0x40, 0x00, 0x30, 0xC0,
  0x00, 0x40, 0x80, 0x01, 0x81, 0x80, 0x02, 0x01, 0x00, 0x0C, 0x03, 0x00,
  0x10, 0x02, 0x00, 0x60, 0x06, 0x00, 0x80, 0x04, 0x03, 0x00, 0x0C, 0x04,
  0x00, 0x18, 0x18, 0x00, 0x18, 0x20, 0x00, 0x30, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0,
  0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x00, 0xE0,
  0x07, 0xFE, 0x0F, 0x01, 0x82, 0x00, 0x60, 0x00, 0x10, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x01, 0xFE, 0x07, 0xC1, 0x0E, 0x00, 0x8C, 0x00,
  0x4C, 0x00, 0x2C, 0x00, 0x14, 0x00, 0x0A, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xD0, 0x00, 0xAC, 0x00, 0x52, 0x00, 0x49,
  0xC0, 0xC4, 0x3F, 0xC2, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x70, 0x0C, 0x3F, 0xE0, 0xC6, 0x03, 0x0C, 0x80, 0x18, 0xD8, 0x00,
  0xCF, 0x00, 0x04, 0xE0, 0x00, 0x6E, 0x00, 0x02, 0xE0, 0x00, 0x2C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2E, 0x00, 0x02,
  0xE0, 0x00, 0x6E, 0x00, 0x06, 0xF0, 0x00, 0xCD, 0x00, 0x0C, 0xC8, 0x01,
  0x8C, 0xE0, 0x70, 0xC3, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x30, 0x03, 0xFF,
  0x07, 0x01, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x01, 0x03, 0xFF, 0x00, 0x20,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x60, 0x30, 0x7F, 0xC3, 0x0E,
  0x07, 0x31, 0x80, 0x13, 0x30, 0x00, 0xB3, 0x00, 0x0F, 0x60, 0x00, 0x76,
  0x00, 0x07, 0x40, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x34, 0x00, 0x07, 0x40, 0x00, 0x76, 0x00, 0x07, 0x20,
  0x00, 0xB3, 0x00, 0x1B, 0x18, 0x01, 0x30, 0xE0, 0x63, 0x07, 0xFC, 0x30,
  0x04, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0x00, 0xE0, 0x60, 0x60, 0x0C, 0x30,
  0x01, 0x8C, 0x00, 0x66, 0x00, 0x09, 0x80, 0x03, 0x40, 0x00, 0x50, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x43, 0x80, 0x70, 0x3F, 0xF0,
  0x00, 0x80, 0x00, 0x20, 0x07, 0xF0, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x0F, 0xFE, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xC4,
  0x38, 0x1C, 0x8C, 0x00, 0xD3, 0x00, 0x0A, 0x40, 0x01, 0xD8, 0x00, 0x1B,
  0x00, 0x03, 0x40, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x6C, 0x00, 0x1C, 0x80, 0x02, 0x98,
  0x00, 0xD1, 0x80, 0x32, 0x18, 0x0C, 0x41, 0xFF, 0x08, 0x02, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC8, 0x00, 0x31, 0xC0,
  0x1C, 0x1F, 0xFF, 0x00, 0x1E, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x60, 0x30,
  0xFF, 0x0C, 0xE0, 0x73, 0x20, 0x0C, 0xD8, 0x01, 0xBC, 0x00, 0x2E, 0x00,
  0x0B, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0C, 0xFF, 0xA0, 0x00, 0x00, 0x24,
  0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x07,
  0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x0C, 0xF8, 0xF0, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x1B,
  0x00, 0x19, 0x80, 0x18, 0xC0, 0x18, 0x60, 0x08, 0x30, 0x0C, 0x18, 0x0C,
  0x0C, 0x04, 0x06, 0x06, 0x03, 0x06, 0x01, 0x82, 0x00, 0xC3, 0x00, 0x63,
  0x80, 0x33, 0x40, 0x19, 0x30, 0x0D, 0x88, 0x07, 0x86, 0x03, 0x81, 0x01,
  0x80, 0xC0, 0xC0, 0x20, 0x60, 0x18, 0x30, 0x04, 0x18, 0x03, 0x0C, 0x00,
  0x86, 0x00, 0x63, 0x00, 0x11, 0x80, 0x0C, 0xC0, 0x02, 0x60, 0x01, 0xB0,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xC0, 0x01, 0x81, 0x0F, 0xF0, 0x3F, 0xC3, 0x30, 0x30, 0xE0,
  0xE6, 0xC0, 0x33, 0x00, 0xCD, 0x00, 0x24, 0x00, 0xDC, 0x00, 0x78, 0x00,
  0xB8, 0x00, 0xE0, 0x01, 0x70, 0x00, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x07,
  0x80, 0x02, 0x00, 0x0F, 0x00, 0x04, 0x00, 0x1E, 0x00, 0x08, 0x00, 0x3C,
  0x00, 0x10, 0x00, 0x78, 0x00, 0x20, 0x00, 0xF0, 0x00, 0x40, 0x01, 0xE0,
  0x00, 0x80, 0x03, 0xC0, 0x01, 0x00, 0x07, 0x80, 0x02, 0x00, 0x0F, 0x00,
  0x04, 0x00, 0x1E, 0x00, 0x08, 0x00, 0x3C, 0x00, 0x10, 0x00, 0x78, 0x00,
  0x20, 0x00, 0xF0, 0x00, 0x40, 0x01, 0xE0, 0x00, 0x80, 0x03, 0xC0, 0x01,
  0x00, 0x07, 0x80, 0x02, 0x00, 0x0F, 0x00, 0x04, 0x00, 0x1E, 0x00, 0x08,
  0x00, 0x3C, 0x00, 0x10, 0x00, 0x78, 0x00, 0x20, 0x00, 0xF0, 0x00, 0x40,
  0x01, 0x80, 0x00, 0x70, 0x30, 0xFF, 0x0C, 0xE0, 0x73, 0x20, 0x0C, 0xD0,
  0x01, 0xBC, 0x00, 0x2E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0C,
  0x00, 0x60, 0x00, 0x7F, 0xE0, 0x0E, 0x07, 0x01, 0x80, 0x18, 0x30, 0x00,
  0xC2, 0x00, 0x0C, 0x60, 0x00, 0x66, 0x00, 0x06, 0x40, 0x00, 0x2C, 0x00,
  0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x24, 0x00, 0x02,
  0x60, 0x00, 0x66, 0x00, 0x06, 0x30, 0x00, 0xC3, 0x00, 0x0C, 0x18, 0x01,
  0x80, 0xE0, 0x70, 0x07, 0xFE, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0C, 0x3F,
  0xE0, 0xC6, 0x03, 0x0C, 0xC0, 0x18, 0xD8, 0x00, 0xCD, 0x00, 0x04, 0xF0,
  0x00, 0x6E, 0x00, 0x02, 0xE0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2E, 0x00, 0x02, 0xE0, 0x00, 0x6E, 0x00,
  0x04, 0xD0, 0x00, 0xCD, 0x80, 0x08, 0xCC, 0x01, 0x8C, 0x60, 0x70, 0xC3,
  0xFC, 0x0C, 0x02, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0x84, 0x38, 0x1C, 0x8C, 0x00, 0x93, 0x00, 0x0A, 0x60, 0x01,
  0xD8, 0x00, 0x1B, 0x00, 0x03, 0x40, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1A, 0x00, 0x03, 0x40, 0x00, 0x6C, 0x00, 0x1C,
  0x80, 0x02, 0x98, 0x00, 0xD1, 0x80, 0x32, 0x1C, 0x0C, 0x41, 0xFF, 0x08,
  0x02, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10,
  0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x4C, 0x3F, 0xC6, 0x1C,
  0x80, 0xD8, 0x0D, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x0F, 0xFE, 0x18, 0x07,
  0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x02, 0x80, 0x06, 0xE0, 0x1C, 0x3F, 0xF0, 0x03, 0x00, 0x08, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x0F, 0xFF, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0xC0, 0x07, 0xF0, 0x0C, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x40, 0x01, 0xD0, 0x00, 0xF6, 0x00, 0x2C, 0xC0, 0x13, 0x38, 0x1C,
  0xC3, 0xFC, 0x30, 0x30, 0x00, 0xC0, 0x00, 0x68, 0x00, 0x09, 0x00, 0x01,
  0x30, 0x00, 0x62, 0x00, 0x0C, 0x40, 0x01, 0x0C, 0x00, 0x61, 0x80, 0x0C,
  0x10, 0x01, 0x02, 0x00, 0x20, 0x60, 0x0C, 0x0C, 0x01, 0x80, 0x80, 0x20,
  0x18, 0x0C, 0x03, 0x01, 0x80, 0x20, 0x20, 0x04, 0x04, 0x00, 0xC1, 0x80,
  0x18, 0x30, 0x01, 0x04, 0x00, 0x21, 0x80, 0x06, 0x30, 0x00, 0x44, 0x00,
  0x08, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00,
  0x0E, 0x00, 0x00, 0x80, 0x00, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xD0, 0x00, 0xA0, 0x03, 0x40, 0x06, 0x80, 0x09,
  0x80, 0x1A, 0x00, 0x26, 0x00, 0x4C, 0x00, 0x88, 0x01, 0x10, 0x06, 0x20,
  0x0C, 0x40, 0x10, 0x80, 0x31, 0x00, 0x43, 0x00, 0x86, 0x01, 0x0C, 0x02,
  0x08, 0x0C, 0x10, 0x18, 0x20, 0x30, 0x40, 0x60, 0x80, 0x81, 0x81, 0x03,
  0x02, 0x06, 0x04, 0x0C, 0x18, 0x08, 0x30, 0x10, 0x60, 0x20, 0xC0, 0x41,
  0x00, 0xC2, 0x01, 0x84, 0x03, 0x08, 0x06, 0x30, 0x04, 0x60, 0x08, 0xC0,
  0x11, 0x80, 0x22, 0x00, 0x64, 0x00, 0xC8, 0x01, 0x90, 0x03, 0x20, 0x02,
  0xC0, 0x05, 0x80, 0x0B, 0x00, 0x16, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00,
  0xCC, 0x00, 0x10, 0xC0, 0x06, 0x08, 0x00, 0x81, 0x80, 0x30, 0x10, 0x0C,
  0x03, 0x01, 0x80, 0x20, 0x60, 0x06, 0x0C, 0x00, 0x43, 0x00, 0x0C, 0x60,
  0x00, 0x98, 0x00, 0x1A, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x01, 0xA0, 0x00, 0x26, 0x00, 0x0C, 0x40, 0x01, 0x0C, 0x00, 0x60, 0x80,
  0x08, 0x18, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x03, 0x02, 0x00, 0x60,
  0xC0, 0x06, 0x30, 0x00, 0x46, 0x00, 0x0D, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0x36, 0x00, 0x02, 0x20, 0x00, 0x62, 0x00, 0x06, 0x30, 0x00, 0x41, 0x00,
  0x0C, 0x10, 0x00, 0xC1, 0x80, 0x08, 0x18, 0x00, 0x80, 0x80, 0x18, 0x08,
  0x01, 0x00, 0xC0, 0x10, 0x04, 0x03, 0x00, 0x40, 0x30, 0x06, 0x02, 0x00,
  0x60, 0x20, 0x02, 0x06, 0x00, 0x20, 0x40, 0x03, 0x04, 0x00, 0x10, 0xC0,
  0x01, 0x0C, 0x00, 0x18, 0x80, 0x01, 0x98, 0x00, 0x09, 0x80, 0x00, 0x90,
  0x00, 0x0D, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0xFC, 0x00, 0x07, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x0C, 0x03, 0xF0, 0x1C, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0xF8,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xF8, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x03, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7C, 0x00, 0xF0, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x03, 0x80,
  0x7C, 0x03, 0xC0, 0x00, 0x06, 0x00, 0x01, 0xFE, 0x00, 0x58, 0x1C, 0x03,
  0x80, 0x38, 0x78, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_Condensed_Thin57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 41, 12, 4, -41 },
  { 17, 9, 15, 17, 4, -41 },
  { 34, 26, 41, 28, 1, -41 },
  { 168, 21, 46, 25, 2, -43 },
  { 289, 31, 42, 36, 3, -41 },
  { 452, 25, 42, 27, 2, -41 },
  { 584, 2, 15, 9, 4, -41 },
  { 588, 10, 50, 15, 3, -41 },
  { 651, 10, 50, 15, 2, -41 },
  { 714, 17, 17, 23, 3, -43 },
  { 751, 22, 26, 26, 2, -33 },
  { 823, 5, 13, 10, 2, -6 },
  { 832, 12, 1, 16, 2, -16 },
  { 834, 3, 4, 11, 4, -4 },
  { 836, 17, 41, 19, 1, -41 },
  { 924, 20, 41, 25, 3, -41 },
  { 1027, 10, 41, 25, 5, -41 },
  { 1079, 19, 41, 25, 3, -41 },
  { 1177, 20, 42, 25, 2, -41 },
  { 1282, 24, 41, 25, 1, -41 },
  { 1405, 20, 42, 25, 3, -41 },
  { 1510, 20, 42, 25, 3, -41 },
  { 1615, 19, 41, 25, 3, -41 },
  { 1713, 20, 42, 25, 3, -41 },
  { 1818, 19, 42, 25, 3, -41 },
  { 1918, 3, 30, 11, 4, -30 },
  { 1930, 5, 37, 11, 2, -30 },
  { 1954, 21, 24, 26, 2, -32 },
  { 2017, 22, 14, 26, 2, -27 },
  { 2056, 21, 24, 26, 2, -32 },
  { 2119, 15, 41, 18, 1, -41 },
  { 2196, 33, 46, 39, 3, -41 },
  { 2386, 25, 41, 25, 0, -41 },
  { 2515, 20, 41, 28, 5, -41 },
  { 2618, 23, 42, 27, 3, -41 },
  { 2739, 22, 41, 31, 5, -41 },
  { 2852, 17, 41, 25, 5, -41 },
  { 2940, 17, 41, 22, 5, -41 },
  { 3028, 26, 42, 33, 3, -41 },
  { 3165, 22, 41, 31, 5, -41 },
  { 3278, 8, 41, 14, 3, -41 },
  { 3319, 10, 51, 11, -3, -41 },
  { 3383, 20, 41, 25, 5, -41 },
  { 3486, 16, 41, 22, 5, -41 },
  { 3568, 30, 41, 40, 5, -41 },
  { 3722, 22, 41, 32, 5, -41 },
  { 3835, 27, 42, 33, 3, -41 },
  { 3977, 18, 41, 26, 5, -41 },
  { 4070, 27, 51, 33, 3, -41 },
  { 4243, 20, 41, 26, 5, -41 },
  { 4346, 19, 42, 25, 3, -41 },
  { 4446, 22, 41, 22, 0, -41 },
  { 4559, 23, 42, 32, 4, -41 },
  { 4680, 24, 41, 24, 0, -41 },
  { 4803, 39, 41, 41, 1, -41 },
  { 5003, 22, 41, 22, 0, -41 },
  { 5116, 21, 41, 21, 0, -41 },
  { 5224, 19, 41, 23, 2, -41 },
  { 5322, 11, 50, 18, 5, -41 },
  { 5391, 17, 41, 19, 1, -41 },
  { 5479, 11, 50, 18, 2, -41 },
  { 5548, 23, 21, 25, 1, -41 },
  { 5609, 22, 2, 22, 0, 5 },
  { 5615, 9, 9, 13, 2, -44 },
  { 5626, 17, 32, 23, 2, -31 },
  { 5694, 20, 44, 27, 4, -43 },
  { 5804, 16, 32, 21, 3, -31 },
  { 5868, 20, 44, 27, 3, -43 },
  { 5978, 18, 32, 24, 3, -31 },
  { 6050, 14, 44, 13, 1, -44 },
  { 6127, 19, 45, 27, 3, -31 },
  { 6234, 18, 43, 26, 4, -43 },
  { 6331, 3, 41, 11, 4, -41 },
  { 6347, 8, 55, 11, -1, -41 },
  { 6402, 17, 43, 21, 4, -43 },
  { 6494, 2, 43, 10, 4, -43 },
  { 6505, 31, 31, 39, 4, -31 },
  { 6626, 18, 31, 26, 4, -31 },
  { 6696, 20, 32, 26, 3, -31 },
  { 6776, 20, 44, 27, 4, -31 },
  { 6886, 19, 44, 27, 3, -31 },
  { 6991, 12, 31, 17, 4, -31 },
  { 7038, 16, 32, 20, 2, -31 },
  { 7102, 12, 38, 14, 1, -37 },
  { 7159, 18, 31, 26, 4, -30 },
  { 7229, 19, 30, 19, 0, -30 },
  { 7301, 30, 30, 32, 1, -30 },
  { 7414, 19, 30, 21, 1, -30 },
  { 7486, 20, 44, 20, 0, -30 },
  { 7596, 14, 30, 18, 2, -30 },
  { 7649, 14, 50, 20, 3, -41 },
  { 7737, 2, 57, 24, 11, -43 },
  { 7752, 14, 50, 20, 3, -41 },
  { 7840, 21, 5, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_Thin57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin57pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_CONDENSED_THIN57PT7B_H_
