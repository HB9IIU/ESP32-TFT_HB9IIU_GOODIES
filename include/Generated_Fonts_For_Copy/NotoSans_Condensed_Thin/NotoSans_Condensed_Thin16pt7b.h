#ifndef _NOTOSANS_CONDENSED_THIN16PT7B_H_
#define _NOTOSANS_CONDENSED_THIN16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x14, 0x24, 0x24, 0x7F, 0x24, 0x24, 0x24,
  0xFE, 0x28, 0x48, 0x48, 0x27, 0xE9, 0x4A, 0x30, 0xC5, 0x29, 0x4B, 0xE2,
  0x00, 0x42, 0xA4, 0xA4, 0x94, 0x98, 0xAF, 0xAD, 0x55, 0x15, 0x25, 0x25,
  0x27, 0x20, 0xA2, 0x44, 0x85, 0x04, 0x18, 0x4A, 0x95, 0x1A, 0x27, 0xB0,
  0xF0, 0x6A, 0x49, 0x24, 0x92, 0x24, 0x40, 0x95, 0x55, 0x55, 0xA0, 0x25,
  0xD8, 0xA9, 0x00, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x00, 0xF0, 0xF0, 0x80,
  0x08, 0x44, 0x22, 0x10, 0x88, 0x42, 0x20, 0x74, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x62, 0xE0, 0x74, 0x92, 0x49, 0x24, 0x80, 0x74, 0x42, 0x10, 0x84,
  0x42, 0x22, 0x21, 0xF0, 0x74, 0x42, 0x10, 0x89, 0xC1, 0x08, 0x43, 0xE0,
  0x08, 0x28, 0x51, 0x22, 0x48, 0x91, 0x7F, 0x04, 0x08, 0x10, 0xFC, 0x21,
  0x0F, 0x04, 0x21, 0x08, 0x7C, 0x3A, 0x21, 0x08, 0x7A, 0x31, 0x8C, 0x62,
  0xF0, 0xF8, 0x42, 0x21, 0x08, 0x84, 0x22, 0x10, 0x74, 0x63, 0x18, 0xB9,
  0x51, 0x8C, 0x62, 0xF0, 0x74, 0x63, 0x18, 0xC6, 0x2F, 0x08, 0x43, 0xE0,
  0xC0, 0x80, 0xC1, 0xE0, 0x0C, 0xCC, 0x20, 0x60, 0x60, 0x40, 0xFC, 0x00,
  0x3F, 0x81, 0x81, 0x83, 0x31, 0x08, 0x00, 0x69, 0x11, 0x11, 0x24, 0x40,
  0x04, 0x3F, 0x20, 0xA0, 0x33, 0xDA, 0x2D, 0x26, 0x93, 0x49, 0x9F, 0xC0,
  0x10, 0x0C, 0x01, 0xC0, 0x10, 0x50, 0xA1, 0x42, 0x88, 0x9F, 0x22, 0x83,
  0x06, 0x08, 0xFE, 0x18, 0x61, 0xFA, 0x28, 0x61, 0x86, 0x1F, 0x80, 0x3D,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x0F, 0xF9, 0x0A, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x85, 0x0B, 0xE0, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x84,
  0x3E, 0xFC, 0x21, 0x08, 0x7E, 0x10, 0x84, 0x20, 0x1C, 0xC5, 0x04, 0x08,
  0x10, 0x23, 0xC1, 0x83, 0x05, 0x09, 0xF0, 0x86, 0x18, 0x61, 0xFE, 0x18,
  0x61, 0x86, 0x18, 0x40, 0xEA, 0xAA, 0xAC, 0x24, 0x92, 0x49, 0x24, 0x93,
  0x80, 0x8E, 0x29, 0x28, 0xC2, 0x89, 0x24, 0x8A, 0x28, 0x40, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x3E, 0x80, 0xE0, 0xF0, 0x74, 0x3A, 0x2D, 0x16,
  0x4B, 0x29, 0x94, 0xC4, 0x62, 0x20, 0x83, 0x86, 0x8D, 0x19, 0x32, 0x62,
  0xC5, 0x87, 0x0E, 0x08, 0x30, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x05, 0x09, 0xE0, 0xFA, 0x18, 0x61, 0x8B, 0xE8, 0x20, 0x82, 0x08, 0x00,
  0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x05, 0x09, 0xA0, 0x80,
  0x81, 0x00, 0xFA, 0x18, 0x61, 0x8B, 0xC9, 0x24, 0x8A, 0x28, 0x40, 0x7C,
  0x21, 0x08, 0x20, 0xC1, 0x08, 0x43, 0xE0, 0xFC, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x00, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x09, 0xF0, 0x83, 0x05, 0x12, 0x24, 0x49, 0x0A, 0x14, 0x28, 0x60, 0x40,
  0x84, 0x30, 0x85, 0x18, 0xA5, 0x14, 0xA4, 0x94, 0x8A, 0x51, 0x8A, 0x31,
  0x86, 0x10, 0x42, 0x00, 0xC5, 0x22, 0x8C, 0x10, 0x43, 0x12, 0x49, 0x18,
  0x40, 0x86, 0x24, 0x92, 0x30, 0xC2, 0x08, 0x20, 0x82, 0x00, 0x7C, 0x20,
  0x84, 0x10, 0x42, 0x08, 0x41, 0x0F, 0xC0, 0xF2, 0x49, 0x24, 0x92, 0x49,
  0xC0, 0x82, 0x10, 0x82, 0x10, 0x42, 0x10, 0x42, 0xE4, 0x92, 0x49, 0x24,
  0x93, 0xC0, 0x10, 0x50, 0x92, 0x24, 0x30, 0x40, 0xFC, 0x90, 0x69, 0x11,
  0x79, 0x99, 0xF0, 0x82, 0x08, 0x2C, 0xCA, 0x18, 0x61, 0x86, 0x18, 0x7E,
  0x3C, 0x88, 0x88, 0x88, 0x70, 0x08, 0x42, 0xF8, 0xC6, 0x31, 0x8C, 0x62,
  0xF0, 0x74, 0x63, 0x1F, 0xC2, 0x10, 0x78, 0x34, 0x4E, 0x44, 0x44, 0x44,
  0x44, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x78, 0x42, 0x1F, 0x00, 0x84, 0x21,
  0x6C, 0xC6, 0x31, 0x8C, 0x63, 0x10, 0x8F, 0xF0, 0x40, 0x55, 0x55, 0x56,
  0x84, 0x21, 0x19, 0x52, 0x9C, 0xA4, 0xA5, 0x10, 0xFF, 0xF0, 0x33, 0x66,
  0x62, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0x80, 0x36, 0x63, 0x18,
  0xC6, 0x31, 0x88, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x78, 0x33, 0x28, 0x61,
  0x86, 0x18, 0x61, 0xFA, 0x08, 0x20, 0x80, 0x74, 0x63, 0x18, 0xC6, 0x31,
  0x78, 0x42, 0x10, 0x80, 0x3C, 0x88, 0x88, 0x88, 0x80, 0x78, 0x88, 0x43,
  0x11, 0xF0, 0x44, 0xF4, 0x44, 0x44, 0x44, 0x70, 0x8C, 0x63, 0x18, 0xC6,
  0x2F, 0x8C, 0x52, 0xA5, 0x28, 0x84, 0x88, 0xC4, 0x55, 0x4A, 0xA5, 0x52,
  0x90, 0x88, 0x44, 0xCA, 0x4C, 0x43, 0x29, 0x31, 0x8A, 0x52, 0x95, 0x18,
  0x84, 0x21, 0x09, 0x80, 0xF2, 0x24, 0x48, 0x8F, 0x74, 0x44, 0x44, 0x84,
  0x44, 0x44, 0x43, 0xFF, 0xFF, 0xC4, 0x44, 0x42, 0x12, 0x44, 0x44, 0x48,
  0xFC,
};

const GFXglyph NotoSans_Condensed_Thin16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 8, 11, 8, 0, -11 },
  { 16, 5, 13, 7, 1, -12 },
  { 25, 8, 12, 10, 1, -12 },
  { 37, 7, 12, 8, 1, -12 },
  { 48, 1, 4, 3, 1, -11 },
  { 49, 3, 14, 4, 1, -11 },
  { 55, 2, 14, 4, 1, -11 },
  { 59, 5, 5, 6, 1, -12 },
  { 63, 6, 7, 7, 1, -9 },
  { 69, 1, 4, 3, 1, -2 },
  { 70, 4, 1, 5, 0, -5 },
  { 71, 1, 1, 3, 1, -1 },
  { 72, 5, 11, 5, 0, -11 },
  { 79, 5, 12, 7, 1, -12 },
  { 87, 3, 11, 7, 1, -11 },
  { 92, 5, 12, 7, 1, -12 },
  { 100, 5, 12, 7, 1, -12 },
  { 108, 7, 11, 7, 0, -11 },
  { 118, 5, 11, 7, 1, -11 },
  { 125, 5, 12, 7, 1, -12 },
  { 133, 5, 11, 7, 1, -11 },
  { 140, 5, 12, 7, 1, -12 },
  { 148, 5, 12, 7, 1, -12 },
  { 156, 1, 9, 3, 1, -9 },
  { 158, 1, 11, 3, 1, -9 },
  { 160, 6, 7, 7, 1, -9 },
  { 166, 6, 4, 7, 1, -8 },
  { 169, 6, 7, 7, 1, -9 },
  { 175, 4, 12, 5, 0, -12 },
  { 181, 9, 13, 11, 1, -11 },
  { 196, 7, 11, 7, 0, -11 },
  { 206, 6, 11, 8, 1, -11 },
  { 215, 6, 12, 8, 1, -12 },
  { 224, 7, 11, 9, 1, -11 },
  { 234, 5, 11, 7, 1, -11 },
  { 241, 5, 11, 6, 1, -11 },
  { 248, 7, 12, 9, 1, -12 },
  { 259, 6, 11, 9, 1, -11 },
  { 268, 2, 11, 4, 1, -11 },
  { 271, 3, 14, 3, -1, -11 },
  { 277, 6, 11, 7, 1, -11 },
  { 286, 5, 11, 6, 1, -11 },
  { 293, 9, 11, 11, 1, -11 },
  { 306, 7, 11, 9, 1, -11 },
  { 316, 7, 12, 9, 1, -12 },
  { 327, 6, 11, 7, 1, -11 },
  { 336, 7, 15, 9, 1, -12 },
  { 350, 6, 11, 7, 1, -11 },
  { 359, 5, 12, 7, 1, -12 },
  { 367, 6, 11, 6, 0, -11 },
  { 376, 7, 11, 9, 1, -11 },
  { 386, 7, 11, 7, 0, -11 },
  { 396, 11, 11, 11, 0, -11 },
  { 412, 6, 11, 6, 0, -11 },
  { 421, 6, 11, 6, 0, -11 },
  { 430, 6, 11, 6, 0, -11 },
  { 439, 3, 14, 5, 1, -11 },
  { 445, 5, 11, 5, 0, -11 },
  { 452, 3, 14, 5, 1, -11 },
  { 458, 7, 6, 7, 0, -11 },
  { 464, 6, 1, 6, 0, 1 },
  { 465, 2, 2, 4, 1, -12 },
  { 466, 4, 9, 7, 1, -9 },
  { 471, 6, 12, 8, 1, -12 },
  { 480, 4, 9, 6, 1, -9 },
  { 485, 5, 12, 8, 1, -12 },
  { 493, 5, 9, 7, 1, -9 },
  { 499, 4, 12, 4, 0, -12 },
  { 505, 5, 13, 8, 1, -9 },
  { 514, 5, 12, 7, 1, -12 },
  { 522, 1, 12, 3, 1, -12 },
  { 524, 2, 16, 3, 0, -12 },
  { 528, 5, 12, 6, 1, -12 },
  { 536, 1, 12, 3, 1, -12 },
  { 538, 9, 9, 11, 1, -9 },
  { 549, 5, 9, 7, 1, -9 },
  { 555, 5, 9, 7, 1, -9 },
  { 561, 6, 13, 8, 1, -9 },
  { 571, 5, 13, 8, 1, -9 },
  { 580, 4, 9, 5, 1, -9 },
  { 585, 4, 9, 6, 1, -9 },
  { 590, 4, 11, 4, 0, -11 },
  { 596, 5, 8, 7, 1, -8 },
  { 601, 5, 8, 5, 0, -8 },
  { 606, 9, 8, 9, 0, -8 },
  { 615, 5, 8, 6, 0, -8 },
  { 620, 5, 12, 6, 0, -8 },
  { 628, 4, 8, 5, 1, -8 },
  { 632, 4, 14, 5, 1, -11 },
  { 639, 1, 16, 7, 3, -12 },
  { 641, 4, 14, 5, 1, -11 },
  { 648, 6, 1, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_Thin16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_THIN16PT7B_H_
