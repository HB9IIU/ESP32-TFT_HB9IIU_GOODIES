#ifndef _NOTOSANS_CONDENSED_THIN63PT7B_H_
#define _NOTOSANS_CONDENSED_THIN63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin63pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x64, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24,
  0x92, 0x48, 0x00, 0x00, 0x1B, 0xFE, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xB0, 0x12, 0x02, 0x00, 0x18, 0x03, 0x00, 0x00, 0x80, 0x10, 0x00,
  0x04, 0x00, 0x80, 0x00, 0x20, 0x04, 0x00, 0x03, 0x00, 0x20, 0x00, 0x18,
  0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x30, 0x06,
  0x00, 0x01, 0x00, 0x20, 0x00, 0x08, 0x01, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x06, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C,
  0x01, 0x80, 0x00, 0x40, 0x0C, 0x00, 0x02, 0x00, 0x40, 0x00, 0x10, 0x02,
  0x00, 0x01, 0x80, 0x10, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00,
  0x03, 0x00, 0x60, 0x00, 0x10, 0x03, 0x00, 0x00, 0x80, 0x10, 0x00, 0x04,
  0x00, 0x80, 0x00, 0x60, 0x04, 0x00, 0x03, 0x00, 0x60, 0x00, 0x18, 0x03,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x00, 0x20, 0x06, 0x00,
  0x01, 0x00, 0x20, 0x00, 0x08, 0x01, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x30, 0x00, 0x08, 0x01,
  0x80, 0x00, 0x40, 0x08, 0x00, 0x02, 0x00, 0x40, 0x00, 0x30, 0x02, 0x00,
  0x01, 0x80, 0x30, 0x00, 0x0C, 0x01, 0x80, 0x00, 0x60, 0x0C, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x03,
  0xFF, 0x80, 0x3C, 0x8F, 0xC1, 0x82, 0x07, 0x0C, 0x08, 0x00, 0x60, 0x20,
  0x03, 0x00, 0x80, 0x0C, 0x02, 0x00, 0x30, 0x08, 0x00, 0x80, 0x20, 0x02,
  0x00, 0x80, 0x08, 0x02, 0x00, 0x20, 0x08, 0x00, 0xC0, 0x20, 0x03, 0x00,
  0x80, 0x0C, 0x02, 0x00, 0x18, 0x08, 0x00, 0x30, 0x20, 0x00, 0x60, 0x80,
  0x00, 0xE2, 0x00, 0x01, 0xE8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x09, 0xE0, 0x00, 0x21, 0xC0, 0x00, 0x81, 0x80, 0x02,
  0x03, 0x00, 0x08, 0x06, 0x00, 0x20, 0x18, 0x00, 0x80, 0x30, 0x02, 0x00,
  0xC0, 0x08, 0x03, 0x00, 0x20, 0x0C, 0x00, 0x80, 0x30, 0x02, 0x00, 0xC0,
  0x08, 0x02, 0x00, 0x20, 0x18, 0x00, 0x80, 0x60, 0x02, 0x03, 0x20, 0x08,
  0x18, 0xF0, 0x21, 0xC1, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x18, 0x01, 0x86, 0x00, 0x04, 0x00,
  0xC0, 0xC0, 0x03, 0x00, 0x20, 0x10, 0x00, 0x80, 0x18, 0x06, 0x00, 0x60,
  0x06, 0x01, 0x80, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x60, 0x03, 0x00, 0x30,
  0x18, 0x00, 0xC0, 0x0C, 0x04, 0x00, 0x30, 0x03, 0x03, 0x00, 0x0C, 0x00,
  0xC0, 0x80, 0x03, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x0C, 0x18, 0x00, 0x30,
  0x03, 0x04, 0x00, 0x0C, 0x00, 0xC3, 0x03, 0x03, 0x00, 0x30, 0xC3, 0xF8,
  0x40, 0x08, 0x61, 0x87, 0x10, 0x02, 0x18, 0xC0, 0xC6, 0x01, 0x84, 0x30,
  0x19, 0x80, 0x63, 0x08, 0x06, 0x20, 0x10, 0xC6, 0x00, 0x8C, 0x0C, 0x61,
  0x80, 0x31, 0x86, 0x18, 0x40, 0x0C, 0x3F, 0x04, 0x10, 0x03, 0x03, 0x03,
  0x04, 0x00, 0xC0, 0x00, 0xC1, 0x00, 0x30, 0x00, 0x20, 0xC0, 0x0C, 0x00,
  0x18, 0x30, 0x03, 0x00, 0x04, 0x0C, 0x00, 0xC0, 0x03, 0x03, 0x00, 0x30,
  0x00, 0xC0, 0xC0, 0x0C, 0x00, 0x20, 0x10, 0x03, 0x00, 0x18, 0x04, 0x00,
  0xC0, 0x04, 0x01, 0x00, 0x30, 0x03, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x80, 0x18, 0x00, 0x80, 0x60, 0x04, 0x00,
  0x30, 0x18, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0xC0, 0x01, 0x86, 0x00, 0x60,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0C, 0x18, 0x00, 0x03, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00,
  0x18, 0x03, 0x00, 0x02, 0x00, 0x20, 0x00, 0x40, 0x04, 0x00, 0x18, 0x00,
  0x80, 0x03, 0x00, 0x10, 0x00, 0x20, 0x02, 0x00, 0x04, 0x00, 0x40, 0x00,
  0x80, 0x08, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x60, 0x00, 0x20, 0x18,
  0x00, 0x06, 0x03, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x0C, 0x30, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x03, 0x00, 0x00, 0xC0,
  0x60, 0x02, 0x10, 0x06, 0x00, 0x46, 0x00, 0x60, 0x08, 0x80, 0x04, 0x03,
  0x30, 0x00, 0xC0, 0x66, 0x00, 0x0C, 0x08, 0x80, 0x00, 0x81, 0x10, 0x00,
  0x18, 0x62, 0x00, 0x01, 0x8C, 0x40, 0x00, 0x13, 0x08, 0x00, 0x03, 0x61,
  0x00, 0x00, 0x38, 0x30, 0x00, 0x03, 0x06, 0x00, 0x00, 0xE0, 0x40, 0x00,
  0x36, 0x0C, 0x00, 0x0C, 0x60, 0xC0, 0x03, 0x8C, 0x1C, 0x00, 0xE0, 0xC1,
  0xC0, 0x70, 0x0C, 0x0F, 0xFC, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x55, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00,
  0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0xE0, 0x04, 0x00, 0xC0, 0x0C, 0x00,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18,
  0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40,
  0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x20, 0x0C, 0x03, 0x00, 0x40, 0x38, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x20, 0x10, 0x0F, 0x82, 0x07, 0x1C, 0x47, 0x80, 0x7B, 0x80, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x19, 0x00, 0x02, 0x30, 0x00, 0x83, 0x00, 0x30, 0x20,
  0x0C, 0x02, 0x03, 0x00, 0x60, 0x40, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x08,
  0x31, 0x86, 0x18, 0x61, 0x8C, 0x30, 0xC2, 0x18, 0x61, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x67, 0xF7, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0xFC, 0x00, 0x30, 0x38,
  0x01, 0x80, 0x30, 0x0C, 0x00, 0xC0, 0x60, 0x01, 0x81, 0x80, 0x02, 0x0C,
  0x00, 0x0C, 0x30, 0x00, 0x30, 0x80, 0x00, 0x46, 0x00, 0x01, 0x98, 0x00,
  0x06, 0x60, 0x00, 0x19, 0x80, 0x00, 0x24, 0x00, 0x00, 0x90, 0x00, 0x02,
  0x40, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x02, 0x40, 0x00, 0x09, 0x80,
  0x00, 0x26, 0x00, 0x01, 0x98, 0x00, 0x06, 0x20, 0x00, 0x18, 0xC0, 0x00,
  0x43, 0x00, 0x03, 0x04, 0x00, 0x0C, 0x18, 0x00, 0x20, 0x60, 0x01, 0x80,
  0xC0, 0x0C, 0x01, 0x80, 0x60, 0x03, 0x87, 0x80, 0x07, 0xF8, 0x00, 0x00,
  0x30, 0x0F, 0x01, 0xF0, 0x3B, 0x06, 0x30, 0xC3, 0x38, 0x37, 0x03, 0xE0,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x1F, 0xF8,
  0x01, 0xE0, 0x78, 0x1C, 0x00, 0x70, 0x40, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x60, 0x00, 0x7F, 0xF0, 0x0F, 0x01, 0xE0, 0xE0, 0x03,
  0x8C, 0x00, 0x06, 0x40, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x19, 0x00, 0x03, 0x8F, 0x80, 0x78,
  0x1F, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0B, 0x00, 0x00,
  0x03, 0x60, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0x30,
  0x00, 0x00, 0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x04, 0x18, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x20, 0x60, 0x00, 0x0C, 0x0C, 0x00, 0x03, 0x01, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x06, 0x00, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x18, 0x00, 0x10, 0x03, 0x00, 0x06, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x60, 0x00,
  0xC0, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x03, 0x00, 0x40, 0x00, 0x60, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x08, 0x00, 0x00, 0x40, 0x00,
  0x02, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x30, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x20, 0x00, 0xE1, 0xE0, 0x1C, 0x07, 0xFF, 0xC0,
  0x00, 0xA0, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xC0, 0xC0, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x01, 0x80, 0x40, 0x04, 0x1F, 0xF0, 0x10, 0xE0, 0x70, 0x4E, 0x00,
  0x61, 0x20, 0x00, 0xCD, 0x00, 0x01, 0x3C, 0x00, 0x06, 0xE0, 0x00, 0x1B,
  0x80, 0x00, 0x2E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x00,
  0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x80, 0x00,
  0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x20, 0x00, 0x0C, 0xC0, 0x00, 0x23,
  0x00, 0x01, 0x84, 0x00, 0x06, 0x18, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xE0,
  0x06, 0x01, 0xC0, 0x70, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x40, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFC, 0x00, 0x70, 0x3C, 0x03, 0x00,
  0x38, 0x18, 0x00, 0x60, 0xC0, 0x00, 0xC2, 0x00, 0x01, 0x18, 0x00, 0x06,
  0x60, 0x00, 0x19, 0x80, 0x00, 0x66, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60,
  0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x01, 0x0C, 0x00, 0x0C, 0x18, 0x00,
  0x60, 0x70, 0x01, 0x80, 0xE0, 0x1C, 0x00, 0xC0, 0xE0, 0x01, 0xCE, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x73, 0x80, 0x07, 0x03, 0x00, 0x38,
  0x07, 0x01, 0x80, 0x0E, 0x0C, 0x00, 0x1C, 0x30, 0x00, 0x31, 0x80, 0x00,
  0x64, 0x00, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x03,
  0x06, 0x00, 0x18, 0x0F, 0x01, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x70, 0x07, 0x00, 0x60, 0x30,
  0x00, 0xC0, 0xC0, 0x01, 0x86, 0x00, 0x02, 0x18, 0x00, 0x0C, 0x40, 0x00,
  0x33, 0x00, 0x00, 0x4C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B,
  0x00, 0x00, 0x68, 0x00, 0x00, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0B, 0x00,
  0x00, 0x2C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1D, 0x00, 0x00,
  0x66, 0x00, 0x03, 0x98, 0x00, 0x0A, 0x30, 0x00, 0x48, 0x60, 0x03, 0x20,
  0xE0, 0x38, 0x81, 0xFF, 0x82, 0x00, 0xF0, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x10, 0x00, 0x00, 0x40, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x20, 0x1C, 0x00, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x27, 0xF7,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x67, 0xF7, 0x08, 0x71, 0xC7, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x1C, 0x61, 0x86, 0x18, 0x63, 0x0C, 0x30, 0x86, 0x18, 0x43, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0x80, 0x1F, 0xF8, 0x3C, 0x07, 0x08, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x30, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x60, 0x00,
  0x00, 0x06, 0x02, 0x00, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x00, 0xC1,
  0x80, 0x00, 0x00, 0x02, 0x18, 0x00, 0x3F, 0xC0, 0x18, 0xC0, 0x07, 0x8F,
  0x00, 0xC6, 0x00, 0x70, 0x18, 0x02, 0x60, 0x06, 0x00, 0xC0, 0x13, 0x00,
  0x30, 0x06, 0x00, 0xD8, 0x03, 0x00, 0x30, 0x06, 0xC0, 0x18, 0x01, 0x00,
  0x34, 0x01, 0x80, 0x08, 0x01, 0xA0, 0x0C, 0x00, 0x40, 0x0F, 0x00, 0x60,
  0x02, 0x00, 0x78, 0x02, 0x00, 0x10, 0x03, 0xC0, 0x10, 0x00, 0x80, 0x1E,
  0x00, 0x80, 0x0C, 0x00, 0xF0, 0x04, 0x00, 0x60, 0x07, 0x80, 0x20, 0x03,
  0x00, 0x3C, 0x01, 0x00, 0x18, 0x01, 0xE0, 0x08, 0x00, 0xC0, 0x0F, 0x00,
  0x40, 0x06, 0x00, 0x48, 0x03, 0x00, 0x70, 0x06, 0x40, 0x18, 0x03, 0x80,
  0x33, 0x00, 0xC0, 0x16, 0x01, 0x18, 0x03, 0x01, 0xB0, 0x18, 0xC0, 0x0C,
  0x18, 0xC1, 0x86, 0x00, 0x7F, 0x83, 0xF8, 0x10, 0x00, 0xF8, 0x0F, 0x80,
  0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xB0, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x11, 0x80,
  0x00, 0x01, 0x08, 0x00, 0x00, 0x30, 0x80, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x20, 0xC0, 0x00, 0x02, 0x04, 0x00, 0x00, 0x60, 0x40, 0x00, 0x06, 0x06,
  0x00, 0x00, 0x40, 0x60, 0x00, 0x0C, 0x02, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x08, 0x03, 0x00, 0x00, 0x80, 0x30, 0x00, 0x18, 0x01, 0x00, 0x01, 0x80,
  0x18, 0x00, 0x10, 0x01, 0x80, 0x03, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x60,
  0x00, 0x60, 0x04, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x03,
  0x00, 0xC0, 0x00, 0x30, 0x08, 0x00, 0x03, 0x01, 0x80, 0x00, 0x10, 0x18,
  0x00, 0x01, 0x81, 0x00, 0x00, 0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x00,
  0x08, 0x30, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x06, 0x40, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x30, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0x00, 0x07, 0x86, 0x00,
  0x03, 0x8C, 0x00, 0x03, 0x18, 0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00,
  0x04, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x36, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x02, 0x60, 0x00, 0x0C,
  0xC0, 0x00, 0x19, 0x80, 0x00, 0x63, 0x00, 0x01, 0x86, 0x00, 0x0E, 0x0C,
  0x01, 0xF8, 0x1F, 0xFF, 0xC0, 0x30, 0x00, 0xF0, 0x60, 0x00, 0x30, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x33, 0x00, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x58, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x58, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x39,
  0x80, 0x00, 0xE3, 0x00, 0x03, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0xF0, 0x0F, 0x01, 0xC0, 0x01,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x01,
  0x00, 0xF0, 0x07, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xC0, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x30, 0x00, 0xF0, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x31, 0x80, 0x00, 0x18, 0xC0, 0x00,
  0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x16, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x02, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0xD8, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80,
  0x00, 0x30, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x70, 0x30, 0x00, 0xF0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xB0, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07,
  0xFF, 0xFE, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x01, 0x03, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0x40, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0,
  0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x0C, 0x60, 0x00,
  0x00, 0x63, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00,
  0xC0, 0xE0, 0x00, 0x06, 0x03, 0x80, 0x00, 0x70, 0x07, 0x80, 0x1F, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0x84,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x0F,
  0xF8, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x80,
  0x30, 0x0C, 0x03, 0xBF, 0xE3, 0xF0, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x6C,
  0x00, 0x03, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xE3, 0x00, 0x03, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x18, 0x0C, 0x00, 0xC0,
  0x30, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x0C, 0x06, 0x00, 0x30,
  0x38, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xC0,
  0x00, 0xC7, 0x00, 0x03, 0x36, 0x00, 0x0D, 0x8C, 0x00, 0x36, 0x30, 0x00,
  0xF0, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0xC0, 0x30, 0x01, 0x80, 0xC0, 0x06,
  0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0x60, 0xC0, 0x00, 0x83,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x30, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0xCC, 0x00, 0x01, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0C, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0D, 0xD0, 0x00, 0x00,
  0x03, 0x76, 0x00, 0x00, 0x00, 0xDD, 0x80, 0x00, 0x00, 0x67, 0x20, 0x00,
  0x00, 0x19, 0xCC, 0x00, 0x00, 0x06, 0x73, 0x00, 0x00, 0x03, 0x1C, 0x40,
  0x00, 0x00, 0xC7, 0x18, 0x00, 0x00, 0x31, 0xC6, 0x00, 0x00, 0x18, 0x70,
  0x80, 0x00, 0x06, 0x1C, 0x30, 0x00, 0x01, 0x87, 0x0C, 0x00, 0x00, 0xC1,
  0xC1, 0x00, 0x00, 0x30, 0x70, 0x60, 0x00, 0x0C, 0x1C, 0x18, 0x00, 0x06,
  0x07, 0x02, 0x00, 0x01, 0x81, 0xC0, 0xC0, 0x00, 0x60, 0x70, 0x30, 0x00,
  0x30, 0x1C, 0x04, 0x00, 0x0C, 0x07, 0x01, 0x80, 0x03, 0x01, 0xC0, 0x60,
  0x01, 0x80, 0x70, 0x08, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x18, 0x07, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x10, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x60, 0x07, 0x00, 0x20, 0x18, 0x01, 0xC0, 0x0C, 0x06, 0x00,
  0x70, 0x03, 0x03, 0x00, 0x1C, 0x00, 0x40, 0xC0, 0x07, 0x00, 0x18, 0x30,
  0x01, 0xC0, 0x06, 0x18, 0x00, 0x70, 0x00, 0x86, 0x00, 0x1C, 0x00, 0x31,
  0x80, 0x07, 0x00, 0x0C, 0xC0, 0x01, 0xC0, 0x01, 0x30, 0x00, 0x70, 0x00,
  0x6C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x1E, 0xC0, 0x00, 0x0F, 0x20,
  0x00, 0x07, 0x98, 0x00, 0x03, 0xC4, 0x00, 0x01, 0xE3, 0x00, 0x00, 0xF0,
  0x80, 0x00, 0x78, 0x60, 0x00, 0x3C, 0x18, 0x00, 0x1E, 0x0C, 0x00, 0x0F,
  0x03, 0x00, 0x07, 0x81, 0x80, 0x03, 0xC0, 0x60, 0x01, 0xE0, 0x30, 0x00,
  0xF0, 0x0C, 0x00, 0x78, 0x06, 0x00, 0x3C, 0x01, 0x80, 0x1E, 0x00, 0xC0,
  0x0F, 0x00, 0x30, 0x07, 0x80, 0x18, 0x03, 0xC0, 0x06, 0x01, 0xE0, 0x03,
  0x00, 0xF0, 0x00, 0xC0, 0x78, 0x00, 0x60, 0x3C, 0x00, 0x18, 0x1E, 0x00,
  0x0C, 0x0F, 0x00, 0x03, 0x07, 0x80, 0x01, 0x83, 0xC0, 0x00, 0x61, 0xE0,
  0x00, 0x30, 0xF0, 0x00, 0x0C, 0x78, 0x00, 0x06, 0x3C, 0x00, 0x01, 0x9E,
  0x00, 0x00, 0x4F, 0x00, 0x00, 0x37, 0x80, 0x00, 0x0B, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x78, 0x0F, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x00, 0xC0, 0x60,
  0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00,
  0x03, 0x18, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03,
  0x20, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x12, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x00, 0x62,
  0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0x83, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x01, 0x80, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x30, 0x01, 0xE1,
  0x80, 0x01, 0x8C, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x00, 0xD8, 0x00,
  0x06, 0xC0, 0x00, 0x16, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x16, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x4C, 0x00, 0x06, 0x60,
  0x00, 0x63, 0x00, 0x07, 0x18, 0x00, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x30, 0x06, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0x08, 0xC0, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x03, 0x20, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0x58, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x12, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x0C, 0xC0, 0x00,
  0x00, 0x62, 0x00, 0x00, 0x02, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x0C, 0x01,
  0x80, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x0C,
  0x00, 0x38, 0x30, 0x00, 0x30, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xCC, 0x00,
  0x03, 0x30, 0x00, 0x04, 0xC0, 0x00, 0x13, 0x00, 0x00, 0x6C, 0x00, 0x01,
  0xB0, 0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6C, 0x00, 0x01, 0xB0,
  0x00, 0x04, 0xC0, 0x00, 0x13, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x30, 0x00,
  0x18, 0xC0, 0x00, 0xC3, 0x00, 0x06, 0x0C, 0x00, 0x70, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0xC0,
  0x0C, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0xC0, 0x03,
  0x03, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x30, 0xC0, 0x00, 0xC3,
  0x00, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x0F, 0xFF, 0x80, 0x70, 0x07, 0x87, 0x00, 0x04, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x20, 0x00, 0x70, 0xF8,
  0x07, 0x81, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x34, 0x00, 0x00, 0x13, 0x00, 0x00, 0x19, 0x80, 0x00,
  0x0C, 0x40, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x0C, 0x00, 0x06, 0x03, 0x00,
  0x06, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x09, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x0C, 0x40, 0x00, 0x01, 0x08, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x0C, 0x30, 0x00, 0x01, 0x02, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C,
  0x0C, 0x00, 0x01, 0x81, 0x80, 0x00, 0x20, 0x10, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x20, 0x04, 0x00, 0x04, 0x00, 0x80, 0x01, 0x80,
  0x18, 0x00, 0x30, 0x03, 0x00, 0x04, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x80, 0x01, 0x00, 0x30, 0x00,
  0x30, 0x06, 0x00, 0x06, 0x00, 0x80, 0x00, 0x40, 0x30, 0x00, 0x08, 0x06,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x10, 0x00, 0x02, 0x06, 0x00, 0x00,
  0x60, 0xC0, 0x00, 0x0C, 0x10, 0x00, 0x01, 0x82, 0x00, 0x00, 0x10, 0xC0,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x62, 0x00, 0x00, 0x04, 0xC0, 0x00, 0x00,
  0x98, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0x40, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xA0,
  0x00, 0x07, 0x00, 0x00, 0x26, 0x00, 0x00, 0xA0, 0x00, 0x0C, 0xC0, 0x00,
  0x34, 0x00, 0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x31, 0x00, 0x00, 0xD8,
  0x00, 0x04, 0x20, 0x00, 0x13, 0x00, 0x01, 0x86, 0x00, 0x06, 0x20, 0x00,
  0x30, 0xC0, 0x00, 0xC6, 0x00, 0x06, 0x18, 0x00, 0x18, 0xC0, 0x00, 0x81,
  0x00, 0x03, 0x18, 0x00, 0x30, 0x30, 0x00, 0x43, 0x00, 0x06, 0x06, 0x00,
  0x18, 0x20, 0x00, 0xC0, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x08, 0x00, 0x60,
  0xC0, 0x02, 0x01, 0x80, 0x08, 0x18, 0x00, 0xC0, 0x30, 0x03, 0x01, 0x00,
  0x18, 0x06, 0x00, 0x60, 0x30, 0x03, 0x00, 0x40, 0x0C, 0x06, 0x00, 0x40,
  0x08, 0x01, 0x80, 0xC0, 0x18, 0x01, 0x80, 0x20, 0x18, 0x03, 0x00, 0x30,
  0x0C, 0x01, 0x00, 0x60, 0x06, 0x01, 0x80, 0x30, 0x08, 0x00, 0x40, 0x30,
  0x06, 0x03, 0x00, 0x0C, 0x04, 0x00, 0xC0, 0x60, 0x01, 0x80, 0x80, 0x08,
  0x0C, 0x00, 0x30, 0x30, 0x01, 0x81, 0x00, 0x02, 0x06, 0x00, 0x30, 0x60,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x0C, 0x10, 0x00, 0xC1, 0x80, 0x01,
  0x86, 0x00, 0x08, 0x20, 0x00, 0x10, 0xC0, 0x01, 0x84, 0x00, 0x03, 0x18,
  0x00, 0x31, 0x80, 0x00, 0x62, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x40, 0x00,
  0x46, 0x00, 0x01, 0x98, 0x00, 0x08, 0x80, 0x00, 0x13, 0x00, 0x01, 0xB0,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x00, 0x68, 0x00, 0x06, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x50, 0x00, 0x00, 0xE0, 0x00, 0x0A, 0x00, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x07,
  0x10, 0x00, 0x06, 0x18, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x0C, 0x00, 0x08,
  0x0C, 0x00, 0x18, 0x06, 0x00, 0x18, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x01, 0x00, 0x60, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0,
  0x00, 0xC0, 0x80, 0x00, 0xC1, 0x80, 0x00, 0x61, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x32, 0x00, 0x00, 0x36, 0x00, 0x00, 0x16, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x22, 0x00, 0x00, 0x63, 0x00, 0x00, 0x63, 0x00, 0x00, 0xC1, 0x80,
  0x00, 0xC1, 0x80, 0x01, 0x80, 0x80, 0x01, 0x80, 0xC0, 0x03, 0x00, 0x40,
  0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x08, 0x30, 0x00, 0x0C,
  0x30, 0x00, 0x0C, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x06, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x13, 0x00, 0x00, 0x63,
  0x00, 0x00, 0xC6, 0x00, 0x01, 0x04, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x10, 0x00, 0x60, 0x30, 0x00, 0x80, 0x20, 0x03, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x18, 0x00, 0x80, 0x30, 0x01, 0x80, 0x40, 0x01, 0x01,
  0x80, 0x03, 0x03, 0x00, 0x06, 0x0C, 0x00, 0x04, 0x18, 0x00, 0x0C, 0x20,
  0x00, 0x08, 0xC0, 0x00, 0x19, 0x80, 0x00, 0x36, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x40, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x08, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x02,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x05, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x18,
  0x00, 0x03, 0x04, 0x00, 0x01, 0x83, 0x00, 0x01, 0x80, 0x80, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0x10, 0x00, 0x60, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x06, 0x0C, 0x00, 0x03, 0x06, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0x40, 0x01, 0xF0,
  0x03, 0xFF, 0x83, 0x80, 0x70, 0x80, 0x06, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x04, 0x00, 0x7F, 0x03, 0xFF,
  0x43, 0xC0, 0x11, 0x80, 0x04, 0xC0, 0x01, 0x60, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0xC0, 0x01, 0x70, 0x00, 0x54, 0x00, 0x25, 0x80, 0x19, 0x38, 0x1C,
  0x47, 0xFE, 0x10, 0x18, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x0F, 0xC0, 0x20, 0xFF,
  0xC0, 0x8E, 0x01, 0x82, 0x70, 0x03, 0x09, 0x80, 0x06, 0x2C, 0x00, 0x0C,
  0xA0, 0x00, 0x32, 0x80, 0x00, 0x4C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0,
  0x00, 0x1B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0, 0x00, 0x02, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xA0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00,
  0x00, 0x6C, 0x00, 0x01, 0xB0, 0x00, 0x06, 0xC0, 0x00, 0x13, 0x80, 0x00,
  0xCA, 0x00, 0x03, 0x2C, 0x00, 0x18, 0x98, 0x00, 0xE2, 0x30, 0x07, 0x08,
  0x70, 0x78, 0x20, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x3F, 0x00, 0x7F,
  0xF0, 0x38, 0x04, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0xC0, 0x7F,
  0xF0, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x07, 0xC0, 0xC0, 0xFF, 0xC3, 0x07,
  0x01, 0x8C, 0x30, 0x03, 0x31, 0x80, 0x06, 0xC4, 0x00, 0x0F, 0x30, 0x00,
  0x1C, 0x80, 0x00, 0x76, 0x00, 0x01, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0D, 0x00, 0x00, 0x34,
  0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x73, 0x00,
  0x03, 0xCC, 0x00, 0x0B, 0x18, 0x00, 0x64, 0x30, 0x03, 0x10, 0x70, 0x38,
  0x40, 0xFF, 0xC1, 0x00, 0x30, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x01,
  0xC0, 0xE0, 0x18, 0x01, 0x81, 0x80, 0x04, 0x0C, 0x00, 0x30, 0xC0, 0x00,
  0x84, 0x00, 0x06, 0x60, 0x00, 0x33, 0x00, 0x00, 0x98, 0x00, 0x04, 0x80,
  0x00, 0x34, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x06, 0x07, 0x80, 0xF0, 0x0F, 0xFE, 0x00,
  0x0F, 0x00, 0x00, 0xFE, 0x01, 0xC7, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0xFF, 0xF0, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x04, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x30, 0x70, 0x1C, 0xC3, 0x00,
  0x1B, 0x18, 0x00, 0x2C, 0xC0, 0x00, 0xF3, 0x00, 0x01, 0xC8, 0x00, 0x07,
  0x60, 0x00, 0x0D, 0x80, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xD0, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x80,
  0x00, 0x76, 0x00, 0x01, 0xC8, 0x00, 0x07, 0x30, 0x00, 0x3C, 0xC0, 0x00,
  0xB1, 0x80, 0x06, 0xC3, 0x00, 0x33, 0x07, 0x03, 0x8C, 0x0F, 0xF8, 0x30,
  0x03, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01,
  0x80, 0x00, 0x04, 0x00, 0x00, 0x31, 0x00, 0x01, 0x87, 0x00, 0x1C, 0x0F,
  0xC7, 0xE0, 0x07, 0xFE, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x3E, 0x04, 0x1F, 0xF0, 0x8E, 0x03, 0x93, 0x80, 0x32,
  0x60, 0x03, 0x58, 0x00, 0x2A, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x46,
  0xFE, 0x40, 0x00, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x02, 0x03,
  0x81, 0xE0, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x02, 0x03, 0x01, 0x93, 0x8F, 0x80, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x0A, 0x00, 0x0C, 0x80, 0x02, 0x20, 0x01, 0x88,
  0x00, 0xC2, 0x00, 0x20, 0x80, 0x18, 0x20, 0x0C, 0x08, 0x06, 0x02, 0x01,
  0x80, 0x80, 0xC0, 0x20, 0x60, 0x08, 0x10, 0x02, 0x0C, 0x00, 0x87, 0x00,
  0x23, 0x40, 0x08, 0xD8, 0x02, 0x62, 0x00, 0xB0, 0xC0, 0x28, 0x10, 0x0E,
  0x06, 0x03, 0x00, 0x80, 0x80, 0x30, 0x20, 0x04, 0x08, 0x01, 0x82, 0x00,
  0x20, 0x80, 0x0C, 0x20, 0x01, 0x08, 0x00, 0x62, 0x00, 0x08, 0x80, 0x03,
  0x20, 0x00, 0x48, 0x00, 0x1A, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xF0, 0x01, 0xF0, 0x43, 0xFE, 0x03, 0xFE, 0x23, 0x01, 0x83,
  0x03, 0x93, 0x00, 0x63, 0x00, 0x6B, 0x00, 0x33, 0x00, 0x35, 0x00, 0x0D,
  0x00, 0x0E, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00,
  0x02, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0,
  0x00, 0x40, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18,
  0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00,
  0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00,
  0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0xF8,
  0x10, 0x7F, 0xE2, 0x38, 0x0E, 0x4E, 0x00, 0xE9, 0x00, 0x0D, 0x60, 0x00,
  0xA8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x7C, 0x00, 0x0F, 0xFE,
  0x00, 0x70, 0x1C, 0x03, 0x00, 0x18, 0x18, 0x00, 0x30, 0xC0, 0x00, 0xC3,
  0x00, 0x01, 0x88, 0x00, 0x06, 0x60, 0x00, 0x09, 0x80, 0x00, 0x34, 0x00,
  0x00, 0xD0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xD0, 0x00,
  0x03, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0x88, 0x00, 0x06,
  0x30, 0x00, 0x18, 0x40, 0x00, 0xC1, 0x80, 0x07, 0x03, 0x00, 0x38, 0x07,
  0x01, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x02, 0x0F,
  0xFC, 0x08, 0x70, 0x38, 0x23, 0x00, 0x30, 0x98, 0x00, 0x62, 0xC0, 0x00,
  0xCB, 0x00, 0x03, 0x28, 0x00, 0x04, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0x6C,
  0x00, 0x01, 0xB0, 0x00, 0x02, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xB0,
  0x00, 0x06, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x6E, 0x00, 0x01, 0x28, 0x00,
  0x0C, 0xB0, 0x00, 0x32, 0xC0, 0x01, 0x89, 0x80, 0x0E, 0x23, 0x00, 0x70,
  0x87, 0x03, 0x82, 0x0F, 0xF8, 0x08, 0x06, 0x00, 0x20, 0x00, 0x00, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x0F, 0xFC, 0x30, 0x70, 0x1C, 0xC3, 0x00, 0x33, 0x18, 0x00,
  0x6C, 0x40, 0x00, 0xF3, 0x00, 0x01, 0xC8, 0x00, 0x07, 0x60, 0x00, 0x1D,
  0x80, 0x00, 0x34, 0x00, 0x00, 0xD0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x40, 0x00, 0x0D, 0x80, 0x00, 0x76, 0x00,
  0x01, 0xD8, 0x00, 0x07, 0x30, 0x00, 0x3C, 0xC0, 0x00, 0xB1, 0x80, 0x06,
  0xC3, 0x00, 0x33, 0x07, 0x03, 0x8C, 0x0F, 0xF8, 0x30, 0x03, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0xF4, 0x1F, 0xE3, 0x83, 0x18, 0x09, 0x80, 0x58, 0x02,
  0x80, 0x14, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x00, 0x01, 0xF8,
  0x03, 0xFF, 0xE1, 0xC0, 0x1C, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x10, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x1B, 0x00, 0x0C, 0xF8, 0x0E,
  0x0F, 0xFF, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0xFF, 0xF8, 0x40, 0x02, 0x00, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC1, 0x03, 0xF8,
  0x07, 0x00, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1F, 0x00, 0x02, 0xE0, 0x00, 0x5C, 0x00, 0x12, 0xC0,
  0x06, 0x5C, 0x01, 0x89, 0xC0, 0xE1, 0x1F, 0xF8, 0x20, 0x30, 0x00, 0xC0,
  0x00, 0x1A, 0x00, 0x00, 0x98, 0x00, 0x0C, 0xC0, 0x00, 0x62, 0x00, 0x03,
  0x18, 0x00, 0x10, 0xC0, 0x01, 0x86, 0x00, 0x0C, 0x10, 0x00, 0x40, 0xC0,
  0x06, 0x06, 0x00, 0x30, 0x10, 0x01, 0x80, 0x80, 0x08, 0x06, 0x00, 0xC0,
  0x30, 0x06, 0x00, 0x80, 0x20, 0x06, 0x03, 0x00, 0x30, 0x18, 0x00, 0x80,
  0xC0, 0x04, 0x04, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x04, 0x10, 0x00,
  0x31, 0x80, 0x01, 0x8C, 0x00, 0x0C, 0x60, 0x00, 0x22, 0x00, 0x01, 0xB0,
  0x00, 0x0D, 0x80, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x2C, 0x00,
  0x0E, 0x00, 0x09, 0x00, 0x07, 0x80, 0x06, 0x60, 0x01, 0xA0, 0x01, 0x98,
  0x00, 0x48, 0x00, 0x46, 0x00, 0x13, 0x00, 0x10, 0x80, 0x0C, 0xC0, 0x0C,
  0x30, 0x03, 0x30, 0x03, 0x0C, 0x00, 0x84, 0x00, 0xC3, 0x00, 0x21, 0x80,
  0x20, 0x40, 0x18, 0x60, 0x18, 0x10, 0x06, 0x18, 0x06, 0x06, 0x01, 0x02,
  0x01, 0x81, 0x80, 0x40, 0xC0, 0x40, 0x20, 0x30, 0x30, 0x10, 0x08, 0x0C,
  0x0C, 0x0C, 0x03, 0x02, 0x01, 0x03, 0x00, 0xC0, 0x80, 0x40, 0x80, 0x10,
  0x60, 0x18, 0x20, 0x04, 0x18, 0x06, 0x18, 0x01, 0x84, 0x00, 0x86, 0x00,
  0x63, 0x00, 0x21, 0x00, 0x08, 0xC0, 0x0C, 0x40, 0x02, 0x30, 0x03, 0x30,
  0x00, 0xC8, 0x00, 0x4C, 0x00, 0x36, 0x00, 0x13, 0x00, 0x0D, 0x80, 0x06,
  0x80, 0x01, 0x60, 0x01, 0xA0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x31, 0x80, 0x03, 0x0C, 0x00, 0x18, 0x30, 0x01, 0x81, 0x80, 0x0C,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x60, 0x06, 0x03, 0x00, 0x18,
  0x30, 0x00, 0x41, 0x00, 0x03, 0x18, 0x00, 0x08, 0x80, 0x00, 0x6C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x02, 0x80, 0x00, 0x36,
  0x00, 0x03, 0x10, 0x00, 0x18, 0xC0, 0x01, 0x83, 0x00, 0x0C, 0x18, 0x00,
  0xC0, 0x60, 0x06, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x30, 0x01,
  0x81, 0x80, 0x0C, 0x18, 0x00, 0x30, 0x80, 0x01, 0x8C, 0x00, 0x06, 0xC0,
  0x00, 0x38, 0x60, 0x00, 0x0C, 0x80, 0x00, 0x62, 0x00, 0x01, 0x8C, 0x00,
  0x06, 0x30, 0x00, 0x10, 0x40, 0x00, 0xC1, 0x80, 0x03, 0x06, 0x00, 0x08,
  0x08, 0x00, 0x60, 0x20, 0x01, 0x80, 0xC0, 0x06, 0x03, 0x00, 0x10, 0x04,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x00, 0x80, 0x60, 0x02, 0x01,
  0x80, 0x0C, 0x04, 0x00, 0x30, 0x10, 0x00, 0x40, 0xC0, 0x01, 0x83, 0x00,
  0x06, 0x08, 0x00, 0x08, 0x60, 0x00, 0x31, 0x80, 0x00, 0xC4, 0x00, 0x03,
  0x30, 0x00, 0x04, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x68, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x60, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x7F,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xF0, 0x01, 0x60, 0x3C, 0x03, 0xC0, 0x0F, 0x0E, 0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_Condensed_Thin63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 45, 13, 5, -45 },
  { 18, 11, 16, 19, 4, -45 },
  { 40, 29, 45, 31, 1, -45 },
  { 204, 22, 52, 28, 3, -48 },
  { 347, 34, 47, 40, 3, -46 },
  { 547, 27, 47, 30, 3, -46 },
  { 706, 2, 16, 10, 4, -45 },
  { 710, 11, 55, 16, 3, -45 },
  { 786, 11, 55, 16, 2, -45 },
  { 862, 19, 19, 25, 3, -48 },
  { 908, 24, 29, 28, 2, -37 },
  { 995, 6, 15, 11, 2, -7 },
  { 1007, 14, 2, 18, 2, -18 },
  { 1011, 4, 4, 12, 4, -4 },
  { 1013, 19, 45, 21, 1, -45 },
  { 1120, 22, 46, 28, 3, -46 },
  { 1247, 12, 45, 28, 5, -45 },
  { 1315, 22, 46, 28, 3, -46 },
  { 1442, 21, 47, 28, 3, -46 },
  { 1566, 27, 45, 28, 1, -45 },
  { 1718, 21, 46, 28, 4, -45 },
  { 1839, 22, 46, 28, 3, -45 },
  { 1966, 22, 45, 28, 3, -45 },
  { 2090, 22, 47, 28, 3, -46 },
  { 2220, 22, 47, 28, 3, -46 },
  { 2350, 4, 34, 12, 4, -34 },
  { 2367, 6, 42, 12, 2, -34 },
  { 2399, 24, 27, 28, 2, -36 },
  { 2480, 24, 15, 28, 2, -30 },
  { 2525, 24, 27, 28, 2, -36 },
  { 2606, 17, 46, 19, 1, -46 },
  { 2704, 37, 51, 43, 3, -45 },
  { 2940, 28, 45, 28, 0, -45 },
  { 3098, 23, 45, 31, 5, -45 },
  { 3228, 24, 47, 30, 4, -46 },
  { 3369, 25, 45, 34, 5, -45 },
  { 3510, 19, 45, 27, 5, -45 },
  { 3617, 19, 45, 25, 5, -45 },
  { 3724, 29, 47, 37, 4, -46 },
  { 3895, 24, 45, 35, 5, -45 },
  { 4030, 9, 45, 15, 3, -45 },
  { 4081, 11, 56, 13, -4, -45 },
  { 4158, 22, 45, 27, 5, -45 },
  { 4282, 18, 45, 25, 5, -45 },
  { 4384, 34, 45, 45, 5, -45 },
  { 4576, 25, 45, 35, 5, -45 },
  { 4717, 29, 47, 37, 4, -46 },
  { 4888, 21, 45, 28, 5, -45 },
  { 5007, 29, 57, 37, 4, -46 },
  { 5214, 22, 45, 29, 5, -45 },
  { 5338, 22, 47, 27, 3, -46 },
  { 5468, 24, 45, 24, 0, -45 },
  { 5603, 25, 46, 35, 5, -45 },
  { 5747, 27, 45, 27, 0, -45 },
  { 5899, 43, 45, 45, 1, -45 },
  { 6141, 24, 45, 24, 0, -45 },
  { 6276, 23, 45, 23, 0, -45 },
  { 6406, 22, 45, 25, 2, -45 },
  { 6530, 12, 55, 19, 5, -45 },
  { 6613, 18, 45, 21, 1, -45 },
  { 6715, 12, 55, 19, 2, -45 },
  { 6798, 25, 23, 28, 2, -45 },
  { 6870, 25, 1, 25, 0, 6 },
  { 6874, 9, 10, 15, 3, -48 },
  { 6886, 18, 35, 26, 3, -34 },
  { 6965, 22, 49, 30, 5, -48 },
  { 7100, 18, 35, 23, 3, -34 },
  { 7179, 22, 49, 30, 3, -48 },
  { 7314, 21, 35, 27, 3, -34 },
  { 7406, 16, 48, 14, 1, -48 },
  { 7502, 22, 49, 30, 3, -34 },
  { 7637, 19, 48, 29, 5, -48 },
  { 7751, 4, 46, 12, 4, -46 },
  { 7774, 9, 61, 12, -1, -46 },
  { 7843, 18, 48, 23, 5, -48 },
  { 7951, 1, 48, 11, 5, -48 },
  { 7957, 33, 34, 43, 5, -34 },
  { 8098, 19, 34, 29, 5, -34 },
  { 8179, 22, 35, 29, 3, -34 },
  { 8276, 22, 49, 30, 5, -34 },
  { 8411, 22, 49, 30, 3, -34 },
  { 8546, 13, 34, 19, 5, -34 },
  { 8602, 18, 35, 22, 2, -34 },
  { 8681, 13, 42, 15, 1, -41 },
  { 8750, 19, 34, 29, 5, -33 },
  { 8831, 21, 33, 21, 0, -33 },
  { 8918, 34, 33, 36, 1, -33 },
  { 9059, 21, 33, 23, 1, -33 },
  { 9146, 22, 48, 22, 0, -33 },
  { 9278, 16, 33, 20, 2, -33 },
  { 9344, 16, 55, 22, 3, -45 },
  { 9454, 1, 63, 27, 13, -48 },
  { 9462, 16, 55, 22, 3, -45 },
  { 9572, 24, 5, 28, 2, -25 },
};

const GFXfont NotoSans_Condensed_Thin63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin63pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_CONDENSED_THIN63PT7B_H_
