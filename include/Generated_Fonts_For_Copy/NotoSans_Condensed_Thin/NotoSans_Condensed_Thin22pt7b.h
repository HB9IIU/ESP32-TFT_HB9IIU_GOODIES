#ifndef _NOTOSANS_CONDENSED_THIN22PT7B_H_
#define _NOTOSANS_CONDENSED_THIN22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF1, 0x99, 0x99, 0x99, 0x08, 0x82, 0x20, 0x88, 0x24, 0x11,
  0x1F, 0xF1, 0x10, 0x44, 0x11, 0x04, 0x4F, 0xFC, 0x88, 0x22, 0x08, 0x82,
  0x20, 0x88, 0x10, 0x3C, 0x52, 0x90, 0x90, 0x90, 0x90, 0x50, 0x30, 0x1C,
  0x12, 0x11, 0x11, 0x11, 0x11, 0x96, 0x78, 0x10, 0x70, 0x48, 0x88, 0x88,
  0x88, 0x90, 0x89, 0x08, 0x90, 0x8A, 0x68, 0xA9, 0x8D, 0x17, 0x51, 0x05,
  0x10, 0x91, 0x09, 0x11, 0x11, 0x11, 0x11, 0x0E, 0x38, 0x22, 0x11, 0x08,
  0x84, 0x41, 0x20, 0xA0, 0x60, 0x50, 0x44, 0x61, 0x30, 0x98, 0x34, 0x0A,
  0x0A, 0xF9, 0xFC, 0x12, 0x24, 0x48, 0x88, 0x88, 0x88, 0x88, 0x84, 0x42,
  0x30, 0x84, 0x42, 0x22, 0x11, 0x11, 0x11, 0x12, 0x22, 0x44, 0x80, 0x10,
  0x22, 0x4B, 0xE3, 0x05, 0x11, 0x00, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF,
  0x10, 0x10, 0x10, 0x10, 0x5A, 0x80, 0xF8, 0x80, 0x02, 0x04, 0x10, 0x20,
  0x81, 0x02, 0x08, 0x10, 0x20, 0x81, 0x02, 0x08, 0x10, 0x40, 0x3C, 0x42,
  0x42, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x42,
  0x42, 0x3C, 0x13, 0x59, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x7C, 0x82,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x40,
  0x40, 0xFF, 0x7C, 0x82, 0x02, 0x02, 0x02, 0x02, 0x06, 0x38, 0x04, 0x02,
  0x01, 0x01, 0x01, 0x02, 0x02, 0xFC, 0x02, 0x00, 0x80, 0x50, 0x14, 0x09,
  0x02, 0x41, 0x10, 0x84, 0x21, 0x10, 0x44, 0x13, 0xFF, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x7E, 0x40, 0x40, 0x40, 0x40, 0x80, 0x90, 0x6C, 0x02, 0x01,
  0x01, 0x01, 0x01, 0x02, 0x02, 0xFC, 0x1E, 0x20, 0x40, 0x40, 0x80, 0x80,
  0x9C, 0xE2, 0x81, 0x81, 0x81, 0x81, 0x81, 0x41, 0x42, 0x3C, 0xFF, 0x01,
  0x02, 0x02, 0x02, 0x04, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x10, 0x20,
  0x20, 0x20, 0x3C, 0x42, 0x82, 0x81, 0x81, 0x42, 0x24, 0x18, 0x24, 0x42,
  0x81, 0x81, 0x81, 0x81, 0x82, 0x7C, 0x3C, 0x42, 0x82, 0x82, 0x81, 0x81,
  0x81, 0x81, 0x43, 0x3D, 0x01, 0x02, 0x02, 0x02, 0x04, 0xF8, 0xC0, 0x10,
  0x50, 0x00, 0x05, 0xA8, 0x03, 0x0C, 0x30, 0xC0, 0xC0, 0x30, 0x08, 0x06,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x30, 0x0C, 0x03, 0x03, 0x0C,
  0x10, 0x60, 0x80, 0xF8, 0x10, 0x41, 0x04, 0x10, 0x42, 0x10, 0x82, 0x08,
  0x00, 0x00, 0x08, 0x07, 0x80, 0xC3, 0x08, 0x04, 0x80, 0x24, 0x00, 0xA3,
  0xC6, 0x22, 0x31, 0x11, 0x88, 0x8C, 0x44, 0x62, 0x23, 0x11, 0x18, 0x99,
  0x43, 0x31, 0x00, 0x08, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x08, 0x03, 0x00,
  0xC0, 0x50, 0x12, 0x04, 0x82, 0x20, 0x88, 0x21, 0x0F, 0xC4, 0x11, 0x02,
  0x40, 0x90, 0x28, 0x0A, 0x01, 0xFC, 0x82, 0x82, 0x81, 0x81, 0x82, 0x82,
  0xFC, 0x86, 0x82, 0x81, 0x81, 0x81, 0x81, 0x82, 0xFC, 0x0F, 0x98, 0x10,
  0x08, 0x04, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x04, 0x02,
  0x00, 0x80, 0x3F, 0xF8, 0x42, 0x20, 0x90, 0x28, 0x14, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x28, 0x14, 0x0A, 0x09, 0xF8, 0xFE, 0x08, 0x20,
  0x82, 0x08, 0x3F, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0xFE, 0x08, 0x20,
  0x82, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x0F, 0x84, 0x12,
  0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x83, 0xE0, 0x18, 0x06, 0x01,
  0x40, 0x50, 0x12, 0x04, 0x7F, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xE9, 0x24, 0x92,
  0x49, 0x24, 0x97, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x2C, 0x82, 0x82, 0x84, 0x88, 0x90, 0x90, 0xA0, 0xE0, 0xA0, 0x90, 0x88,
  0x88, 0x84, 0x84, 0x82, 0x83, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x3F, 0x80, 0x18, 0x03, 0x80, 0x3C, 0x03, 0xC0,
  0x5A, 0x05, 0xA0, 0x5A, 0x09, 0x90, 0x99, 0x09, 0x91, 0x18, 0x91, 0x89,
  0x18, 0xA1, 0x86, 0x18, 0x41, 0x80, 0xC0, 0x70, 0x38, 0x1A, 0x0D, 0x06,
  0x43, 0x21, 0x88, 0xC4, 0x61, 0x30, 0x98, 0x2C, 0x16, 0x07, 0x01, 0x1F,
  0x04, 0x11, 0x01, 0x20, 0x28, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x24, 0x04, 0x80, 0x88, 0x20, 0xF8, 0xF9, 0x0A, 0x0C,
  0x18, 0x30, 0x60, 0xC2, 0xF9, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x1F,
  0x04, 0x11, 0x01, 0x20, 0x28, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x24, 0x04, 0x80, 0x88, 0x20, 0xE8, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0xF8, 0x84, 0x82, 0x82, 0x82, 0x82, 0x82, 0x84, 0xF8,
  0x90, 0x88, 0x88, 0x84, 0x84, 0x82, 0x83, 0x3E, 0x40, 0x80, 0x80, 0x80,
  0x80, 0x40, 0x30, 0x0C, 0x02, 0x01, 0x01, 0x01, 0x01, 0x02, 0xFC, 0xFF,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x7E, 0x80, 0xC0, 0x60, 0x28, 0x14,
  0x12, 0x09, 0x04, 0x42, 0x22, 0x11, 0x04, 0x82, 0x81, 0x40, 0xA0, 0x20,
  0x10, 0x81, 0x03, 0x02, 0x05, 0x06, 0x0A, 0x0C, 0x14, 0x28, 0x28, 0x50,
  0x88, 0x91, 0x11, 0x22, 0x22, 0x44, 0x48, 0x90, 0x90, 0xA0, 0xA1, 0x41,
  0x42, 0x83, 0x06, 0x02, 0x04, 0x04, 0x08, 0x41, 0x41, 0x42, 0x22, 0x24,
  0x14, 0x14, 0x08, 0x08, 0x14, 0x14, 0x22, 0x22, 0x42, 0x41, 0x81, 0x81,
  0x81, 0x41, 0x42, 0x42, 0x24, 0x24, 0x14, 0x18, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0xFE, 0x04, 0x10, 0x20, 0x41, 0x02, 0x08, 0x10, 0x40,
  0x82, 0x04, 0x10, 0x20, 0x7F, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x88, 0x88, 0xF0, 0x80, 0x81, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10, 0x10,
  0x20, 0x40, 0x40, 0x81, 0x01, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0xF0, 0x08, 0x18, 0x24, 0x24, 0x42, 0x42, 0x81, 0x81, 0xFF,
  0x80, 0x88, 0x90, 0x78, 0x10, 0x41, 0x04, 0x76, 0x61, 0x86, 0x18, 0x5F,
  0x81, 0x02, 0x04, 0x08, 0x17, 0x31, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0xFC, 0x1D, 0x84, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x0F,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x43, 0x3D, 0x3C, 0x85, 0x0C, 0x18, 0x3F, 0xE0, 0x40,
  0x81, 0x01, 0x01, 0xF0, 0x1C, 0x82, 0x08, 0x23, 0xE2, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x02, 0x7C, 0x82, 0x08,
  0x20, 0x82, 0xEC, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84, 0xCF,
  0xFF, 0x64, 0x02, 0x49, 0x24, 0x92, 0x49, 0x24, 0xAC, 0x82, 0x08, 0x20,
  0x82, 0x18, 0xA4, 0x92, 0x8E, 0x28, 0x92, 0x48, 0xA2, 0x84, 0xFF, 0xFF,
  0x80, 0xB1, 0xD9, 0x46, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61, 0x0C, 0x21,
  0x84, 0x30, 0x86, 0x10, 0xC2, 0x10, 0xBB, 0x18, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x3C, 0x42, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x42, 0x3C, 0xB9, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0F, 0xE8, 0x10, 0x20, 0x40, 0x80, 0x3D, 0x43, 0x41, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0x01, 0xBC,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x7E, 0x08, 0x20, 0x81, 0x81, 0x81, 0x04,
  0x10, 0x7E, 0x42, 0x3E, 0x84, 0x21, 0x08, 0x42, 0x10, 0x82, 0x1C, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x5F, 0x83, 0x06, 0x0A, 0x14,
  0x48, 0x89, 0x14, 0x28, 0x50, 0x40, 0x80, 0x82, 0x18, 0x21, 0x46, 0x14,
  0x51, 0x45, 0x24, 0x52, 0x29, 0x22, 0x8A, 0x28, 0xC2, 0x8C, 0x30, 0x41,
  0x04, 0x41, 0x42, 0x24, 0x24, 0x18, 0x18, 0x18, 0x18, 0x24, 0x24, 0x42,
  0xC3, 0x81, 0x82, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24, 0x28, 0x18, 0x18,
  0x10, 0x10, 0x10, 0x10, 0x20, 0xE0, 0xF8, 0x42, 0x21, 0x10, 0x88, 0x44,
  0x21, 0xF0, 0x0C, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x23, 0x04, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x81, 0xC0, 0xFF, 0xFF, 0xFC, 0xC0, 0x82, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x71, 0x04, 0x10, 0x41, 0x04, 0x10, 0x8E, 0x00, 0x71,
  0x8F,
};

const GFXglyph NotoSans_Condensed_Thin22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 16, 4, 2, -16 },
  { 3, 4, 6, 7, 1, -16 },
  { 6, 10, 16, 11, 0, -16 },
  { 26, 8, 18, 10, 1, -17 },
  { 44, 12, 16, 14, 1, -16 },
  { 68, 9, 16, 11, 1, -16 },
  { 86, 1, 6, 4, 1, -16 },
  { 87, 4, 19, 6, 1, -16 },
  { 97, 4, 19, 6, 1, -16 },
  { 107, 7, 7, 9, 1, -17 },
  { 114, 8, 10, 10, 1, -13 },
  { 124, 2, 5, 4, 1, -2 },
  { 126, 5, 1, 6, 1, -6 },
  { 127, 1, 1, 4, 2, -1 },
  { 128, 7, 16, 7, 0, -16 },
  { 142, 8, 16, 10, 1, -16 },
  { 158, 4, 16, 10, 2, -16 },
  { 166, 8, 16, 10, 1, -16 },
  { 182, 8, 16, 10, 1, -16 },
  { 198, 10, 16, 10, 0, -16 },
  { 218, 8, 16, 10, 1, -16 },
  { 234, 8, 16, 10, 1, -16 },
  { 250, 8, 16, 10, 1, -16 },
  { 266, 8, 16, 10, 1, -16 },
  { 282, 8, 16, 10, 1, -16 },
  { 298, 1, 12, 4, 2, -12 },
  { 300, 2, 15, 4, 1, -12 },
  { 304, 8, 9, 10, 1, -12 },
  { 313, 8, 5, 10, 1, -10 },
  { 318, 8, 9, 10, 1, -12 },
  { 327, 6, 16, 7, 0, -16 },
  { 339, 13, 18, 15, 1, -16 },
  { 369, 10, 16, 10, 0, -16 },
  { 389, 8, 16, 11, 2, -16 },
  { 405, 9, 16, 10, 1, -16 },
  { 423, 9, 16, 12, 2, -16 },
  { 441, 6, 16, 10, 2, -16 },
  { 453, 6, 16, 9, 2, -16 },
  { 465, 10, 16, 13, 1, -16 },
  { 485, 8, 16, 12, 2, -16 },
  { 501, 3, 16, 5, 1, -16 },
  { 507, 4, 20, 4, -1, -16 },
  { 517, 8, 16, 10, 2, -16 },
  { 533, 6, 16, 9, 2, -16 },
  { 545, 12, 16, 16, 2, -16 },
  { 569, 9, 16, 12, 2, -16 },
  { 587, 11, 16, 13, 1, -16 },
  { 609, 7, 16, 10, 2, -16 },
  { 623, 11, 20, 13, 1, -16 },
  { 651, 8, 16, 10, 2, -16 },
  { 667, 8, 16, 10, 1, -16 },
  { 683, 8, 16, 9, 0, -16 },
  { 699, 8, 16, 12, 2, -16 },
  { 715, 9, 16, 9, 0, -16 },
  { 733, 15, 16, 16, 0, -16 },
  { 763, 8, 16, 8, 0, -16 },
  { 779, 8, 16, 8, 0, -16 },
  { 795, 7, 16, 9, 1, -16 },
  { 809, 4, 19, 7, 2, -16 },
  { 819, 7, 16, 7, 0, -16 },
  { 833, 4, 19, 7, 1, -16 },
  { 843, 8, 8, 10, 1, -16 },
  { 851, 9, 1, 9, 0, 2 },
  { 853, 3, 4, 5, 1, -17 },
  { 855, 6, 12, 9, 1, -12 },
  { 864, 7, 17, 10, 2, -17 },
  { 879, 6, 12, 8, 1, -12 },
  { 888, 8, 17, 10, 1, -17 },
  { 905, 7, 12, 9, 1, -12 },
  { 916, 6, 17, 5, 0, -17 },
  { 929, 8, 17, 10, 1, -12 },
  { 946, 6, 17, 10, 2, -17 },
  { 959, 1, 16, 4, 2, -16 },
  { 961, 3, 21, 4, 0, -16 },
  { 969, 6, 17, 8, 2, -17 },
  { 982, 1, 17, 4, 1, -17 },
  { 985, 11, 12, 15, 2, -12 },
  { 1002, 6, 12, 10, 2, -12 },
  { 1011, 8, 12, 10, 1, -12 },
  { 1023, 7, 17, 10, 2, -12 },
  { 1038, 8, 17, 10, 1, -12 },
  { 1055, 4, 12, 7, 2, -12 },
  { 1061, 6, 12, 8, 1, -12 },
  { 1070, 5, 14, 5, 0, -14 },
  { 1079, 6, 12, 10, 2, -12 },
  { 1088, 7, 12, 7, 0, -12 },
  { 1099, 12, 12, 12, 0, -12 },
  { 1117, 8, 12, 8, 0, -12 },
  { 1129, 8, 17, 8, 0, -12 },
  { 1146, 5, 12, 7, 1, -12 },
  { 1154, 6, 19, 8, 1, -16 },
  { 1169, 1, 22, 9, 4, -17 },
  { 1172, 6, 19, 8, 1, -16 },
  { 1187, 8, 2, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_Thin22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_THIN22PT7B_H_
