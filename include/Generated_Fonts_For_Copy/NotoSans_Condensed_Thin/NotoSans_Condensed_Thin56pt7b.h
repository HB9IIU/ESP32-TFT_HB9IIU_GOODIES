#ifndef _NOTOSANS_CONDENSED_THIN56PT7B_H_
#define _NOTOSANS_CONDENSED_THIN56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin56pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x24, 0x92, 0x49, 0x24,
  0x80, 0x00, 0x01, 0xFF, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x04, 0x00, 0x20, 0x18, 0x00,
  0x10, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x02, 0x00, 0x06, 0x01, 0x00,
  0x02, 0x00, 0x80, 0x01, 0x00, 0x40, 0x00, 0x80, 0x20, 0x00, 0x40, 0x30,
  0x00, 0x60, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x04, 0x03, 0xFF, 0xFF,
  0xF8, 0x04, 0x01, 0x00, 0x02, 0x00, 0x80, 0x01, 0x00, 0x40, 0x01, 0x80,
  0x60, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x18, 0x00, 0x20, 0x08, 0x00, 0x10,
  0x04, 0x00, 0x08, 0x02, 0x00, 0x04, 0x01, 0x00, 0x06, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x01, 0x80, 0x60, 0x3F, 0xFF, 0xFF, 0xC0, 0x40, 0x10, 0x00,
  0x20, 0x08, 0x00, 0x10, 0x04, 0x00, 0x08, 0x06, 0x00, 0x0C, 0x03, 0x00,
  0x06, 0x01, 0x80, 0x03, 0x00, 0x80, 0x01, 0x00, 0x40, 0x00, 0x80, 0x20,
  0x00, 0x40, 0x10, 0x00, 0x20, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x07,
  0xFF, 0x00, 0xE6, 0x3C, 0x18, 0x60, 0x43, 0x06, 0x00, 0x60, 0x60, 0x04,
  0x06, 0x00, 0x40, 0x60, 0x0C, 0x06, 0x00, 0xC0, 0x60, 0x0C, 0x06, 0x00,
  0xC0, 0x60, 0x04, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x30, 0x60,
  0x01, 0x86, 0x00, 0x0E, 0x60, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x6E, 0x00, 0x06, 0x38, 0x00, 0x61, 0xC0, 0x06, 0x06, 0x00,
  0x60, 0x60, 0x06, 0x03, 0x00, 0x60, 0x30, 0x06, 0x01, 0x00, 0x60, 0x10,
  0x06, 0x01, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x20, 0x06, 0x06,
  0x00, 0x60, 0xCE, 0x06, 0x18, 0x7F, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x08, 0x03, 0x0C, 0x00, 0x60, 0x18, 0x10, 0x01, 0x80, 0x40,
  0x60, 0x04, 0x01, 0x00, 0x80, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x30, 0x0C,
  0x06, 0x00, 0x80, 0x30, 0x18, 0x02, 0x00, 0xC0, 0x40, 0x08, 0x03, 0x03,
  0x00, 0x20, 0x04, 0x08, 0x00, 0x80, 0x10, 0x60, 0x02, 0x00, 0x41, 0x80,
  0x08, 0x03, 0x04, 0x00, 0x20, 0x0C, 0x30, 0x00, 0x80, 0x30, 0x81, 0x02,
  0x00, 0xC2, 0x1F, 0x8C, 0x03, 0x18, 0xC3, 0x30, 0x08, 0x46, 0x04, 0x40,
  0x23, 0x10, 0x19, 0x01, 0x88, 0x40, 0x26, 0x04, 0x23, 0x00, 0x8C, 0x31,
  0x8C, 0x03, 0x1F, 0x84, 0x20, 0x0C, 0x18, 0x30, 0x80, 0x30, 0x00, 0x82,
  0x00, 0xC0, 0x02, 0x08, 0x03, 0x00, 0x18, 0x20, 0x04, 0x00, 0x40, 0x80,
  0x10, 0x03, 0x02, 0x00, 0xC0, 0x08, 0x08, 0x03, 0x00, 0x20, 0x20, 0x0C,
  0x01, 0x80, 0x80, 0x30, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x00,
  0x80, 0x10, 0x08, 0x02, 0x00, 0x60, 0x60, 0x18, 0x01, 0x81, 0x00, 0x40,
  0x03, 0x0C, 0x03, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x20,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0x06, 0x00, 0x04, 0x02, 0x00, 0x0C, 0x03,
  0x00, 0x08, 0x03, 0x00, 0x08, 0x01, 0x00, 0x08, 0x01, 0x00, 0x08, 0x01,
  0x00, 0x08, 0x01, 0x00, 0x08, 0x01, 0x00, 0x08, 0x03, 0x00, 0x0C, 0x03,
  0x00, 0x04, 0x02, 0x00, 0x06, 0x06, 0x00, 0x02, 0x0C, 0x00, 0x03, 0x08,
  0x00, 0x01, 0x30, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x40,
  0x00, 0x06, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x18, 0x10, 0x00, 0x30, 0x18,
  0x02, 0x20, 0x0C, 0x02, 0x60, 0x04, 0x06, 0x40, 0x06, 0x06, 0x40, 0x03,
  0x04, 0xC0, 0x01, 0x04, 0xC0, 0x00, 0x8C, 0xC0, 0x00, 0xC8, 0xC0, 0x00,
  0x78, 0xC0, 0x00, 0x30, 0x40, 0x00, 0x30, 0x40, 0x00, 0x78, 0x60, 0x00,
  0x48, 0x30, 0x00, 0xCC, 0x30, 0x03, 0x86, 0x1C, 0x06, 0x02, 0x07, 0xFC,
  0x03, 0x00, 0x60, 0x00, 0xFF, 0xFC, 0x01, 0x80, 0x80, 0xC0, 0xC0, 0x40,
  0x60, 0x20, 0x30, 0x10, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80,
  0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x0C, 0x06, 0x01,
  0x00, 0xC0, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x02,
  0x01, 0x80, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x06, 0x00, 0x80,
  0x20, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x03, 0x02, 0x04, 0xE1, 0x1F, 0x0E, 0xB8, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x48, 0x00, 0x62, 0x00, 0x20, 0x80, 0x20, 0x60,
  0x20, 0x18, 0x30, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x18, 0xC4, 0x23, 0x18, 0xC4, 0x63, 0x10, 0x8C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x00, 0x40, 0x00, 0x7F, 0x80, 0x38, 0x38, 0x04, 0x01, 0x81, 0x80, 0x10,
  0x60, 0x03, 0x0C, 0x00, 0x21, 0x00, 0x06, 0x60, 0x00, 0xCC, 0x00, 0x09,
  0x00, 0x01, 0x20, 0x00, 0x2C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xD0,
  0x00, 0x12, 0x00, 0x02, 0x60, 0x00, 0x4C, 0x00, 0x18, 0x80, 0x02, 0x18,
  0x00, 0x41, 0x00, 0x18, 0x30, 0x06, 0x03, 0x00, 0x80, 0x30, 0x70, 0x03,
  0xF8, 0x00, 0x00, 0xC0, 0x70, 0x3C, 0x3B, 0x18, 0xCC, 0x36, 0x0F, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x01, 0xFF, 0x00, 0xE0, 0x38, 0x70,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00,
  0x06, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0xFF, 0xC0, 0x3C,
  0x07, 0x07, 0x00, 0x18, 0xC0, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x07, 0x80, 0x07, 0xF8, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00,
  0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x40, 0x00, 0x0C, 0x80, 0x01, 0x8F, 0x00, 0x70, 0x3F, 0xFC,
  0x00, 0x08, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x30, 0x00,
  0x04, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x21, 0x80, 0x00, 0xC3, 0x00, 0x01,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x20, 0x30, 0x00, 0xC0,
  0x60, 0x01, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x08, 0x03, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x06, 0x00, 0x30, 0x08, 0x00, 0x60,
  0x30, 0x00, 0xC0, 0x40, 0x01, 0x81, 0x80, 0x03, 0x02, 0x00, 0x06, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x3F, 0xFF,
  0x86, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x43, 0xE0, 0x0F, 0xFF, 0x81, 0x80, 0x1C, 0x00, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x19, 0x00, 0x0E, 0x38, 0x07, 0x81, 0xFF, 0xC0, 0x01, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x38, 0x10, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x04, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x06,
  0x00, 0x00, 0xC3, 0xFC, 0x19, 0xC0, 0xE3, 0x60, 0x06, 0x68, 0x00, 0x4E,
  0x00, 0x0D, 0xC0, 0x00, 0xB0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x50,
  0x00, 0x0A, 0x00, 0x01, 0x60, 0x00, 0x6C, 0x00, 0x0C, 0x80, 0x01, 0x18,
  0x00, 0x61, 0x00, 0x08, 0x30, 0x03, 0x03, 0x81, 0xC0, 0x3F, 0xE0, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x20,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x03, 0xFE, 0x00, 0x60, 0x38, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x30,
  0x00, 0x62, 0x00, 0x02, 0x20, 0x00, 0x22, 0x00, 0x02, 0x20, 0x00, 0x22,
  0x00, 0x02, 0x20, 0x00, 0x23, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x0C,
  0x0C, 0x00, 0x80, 0x60, 0x38, 0x03, 0x06, 0x00, 0x1D, 0xC0, 0x00, 0x70,
  0x00, 0x0F, 0x80, 0x03, 0x8E, 0x00, 0x60, 0x30, 0x0C, 0x01, 0x81, 0x80,
  0x0C, 0x30, 0x00, 0x66, 0x00, 0x02, 0x60, 0x00, 0x34, 0x00, 0x01, 0x40,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x40, 0x00, 0x14,
  0x00, 0x03, 0x60, 0x00, 0x32, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x0C,
  0x0E, 0x03, 0x80, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x3F,
  0xC0, 0x0E, 0x06, 0x01, 0x80, 0x30, 0x10, 0x01, 0x83, 0x00, 0x0C, 0x20,
  0x00, 0x46, 0x00, 0x04, 0x60, 0x00, 0x64, 0x00, 0x06, 0x40, 0x00, 0x24,
  0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x34, 0x00, 0x03,
  0x40, 0x00, 0x34, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x07, 0x20, 0x00,
  0x73, 0x00, 0x0B, 0x18, 0x01, 0xB0, 0xC0, 0x73, 0x07, 0xFC, 0x30, 0x0E,
  0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x02, 0x01, 0x80,
  0x3F, 0xF0, 0x00, 0x70, 0x00, 0x5F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x11, 0xCE, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0xC6, 0x23, 0x18,
  0xC4, 0x63, 0x10, 0x8C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x7F, 0xC3, 0x80, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x80, 0x01, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40, 0x00,
  0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x10, 0x00, 0x00, 0x60, 0x18, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x04, 0x08, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x01,
  0x86, 0x00, 0x0C, 0x00, 0x42, 0x00, 0x3F, 0xE0, 0x33, 0x00, 0x70, 0x20,
  0x19, 0x80, 0x30, 0x10, 0x0C, 0x80, 0x30, 0x08, 0x02, 0x40, 0x30, 0x04,
  0x01, 0x60, 0x18, 0x02, 0x00, 0xB0, 0x08, 0x01, 0x00, 0x58, 0x0C, 0x00,
  0x80, 0x3C, 0x06, 0x00, 0x40, 0x1E, 0x03, 0x00, 0x20, 0x0F, 0x01, 0x80,
  0x10, 0x07, 0x00, 0xC0, 0x18, 0x02, 0x80, 0x60, 0x0C, 0x01, 0x60, 0x30,
  0x06, 0x00, 0xB0, 0x18, 0x03, 0x00, 0x58, 0x0C, 0x01, 0x80, 0x6C, 0x06,
  0x01, 0xC0, 0x36, 0x01, 0x00, 0xA0, 0x11, 0x00, 0xC0, 0xD8, 0x18, 0x80,
  0x30, 0x44, 0x18, 0x40, 0x0F, 0xC3, 0xF8, 0x30, 0x03, 0xC0, 0x78, 0x18,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x80,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x14, 0x00, 0x00, 0x34, 0x00, 0x00, 0x26, 0x00,
  0x00, 0x26, 0x00, 0x00, 0x22, 0x00, 0x00, 0x62, 0x00, 0x00, 0x43, 0x00,
  0x00, 0x41, 0x00, 0x00, 0xC1, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x81, 0x80,
  0x00, 0x80, 0x80, 0x01, 0x80, 0x80, 0x01, 0x00, 0xC0, 0x01, 0x00, 0xC0,
  0x03, 0x00, 0x40, 0x03, 0x00, 0x40, 0x02, 0x00, 0x60, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x20, 0x04, 0x00, 0x30, 0x07, 0xFF, 0xF0, 0x0C, 0x00, 0x10,
  0x0C, 0x00, 0x10, 0x08, 0x00, 0x18, 0x08, 0x00, 0x18, 0x18, 0x00, 0x08,
  0x18, 0x00, 0x0C, 0x10, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x30, 0x00, 0x04,
  0x20, 0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x02, 0x60, 0x00, 0x02,
  0x40, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x08,
  0x07, 0xE0, 0x80, 0x03, 0x08, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x04,
  0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00, 0x68, 0x00, 0x06, 0x80, 0x00,
  0x68, 0x00, 0x06, 0x80, 0x00, 0x48, 0x00, 0x04, 0x80, 0x00, 0xC8, 0x00,
  0x08, 0x80, 0x01, 0x88, 0x00, 0x70, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x80,
  0x07, 0x08, 0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x06, 0x80, 0x00, 0x68,
  0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x02, 0x80, 0x00, 0x28, 0x00, 0x06, 0x80, 0x00,
  0x68, 0x00, 0x0C, 0x80, 0x01, 0x88, 0x00, 0x30, 0x80, 0x3E, 0x0F, 0xFF,
  0x80, 0x00, 0x02, 0x00, 0x00, 0xFF, 0xE0, 0x0E, 0x01, 0xC0, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x10,
  0x00, 0x00, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x7F, 0xF8, 0x00, 0x08, 0x00, 0xFF, 0xE0, 0x02,
  0x03, 0xF0, 0x08, 0x00, 0x70, 0x20, 0x00, 0x60, 0x80, 0x00, 0xC2, 0x00,
  0x01, 0x88, 0x00, 0x02, 0x20, 0x00, 0x0C, 0x80, 0x00, 0x12, 0x00, 0x00,
  0x68, 0x00, 0x01, 0xA0, 0x00, 0x02, 0x80, 0x00, 0x0A, 0x00, 0x00, 0x28,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xA0,
  0x00, 0x02, 0x80, 0x00, 0x1A, 0x00, 0x00, 0x68, 0x00, 0x01, 0x20, 0x00,
  0x0C, 0x80, 0x00, 0x32, 0x00, 0x01, 0x88, 0x00, 0x04, 0x20, 0x00, 0x30,
  0x80, 0x03, 0x82, 0x00, 0x1C, 0x08, 0x0F, 0xC0, 0x3F, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x00,
  0x7C, 0x06, 0x00, 0x02, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x34, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x03, 0x40, 0x00,
  0x00, 0xD8, 0x00, 0x00, 0x36, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x03, 0x30,
  0x00, 0x00, 0xC4, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x03,
  0x06, 0x00, 0x00, 0xC1, 0xC0, 0x00, 0x30, 0x38, 0x00, 0x0C, 0x03, 0x80,
  0x0F, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x0C, 0xFE, 0x1E, 0x00,
  0x80, 0x00, 0x70, 0x00, 0x1A, 0x00, 0x06, 0x40, 0x01, 0x88, 0x00, 0x31,
  0x00, 0x0C, 0x20, 0x03, 0x04, 0x00, 0x40, 0x80, 0x18, 0x10, 0x06, 0x02,
  0x01, 0x80, 0x40, 0x30, 0x08, 0x0C, 0x01, 0x03, 0x00, 0x20, 0xC0, 0x04,
  0x18, 0x00, 0x86, 0x00, 0x11, 0xC0, 0x02, 0x38, 0x00, 0x4D, 0x80, 0x0B,
  0x10, 0x01, 0x43, 0x00, 0x30, 0x20, 0x06, 0x06, 0x00, 0x80, 0x40, 0x10,
  0x0C, 0x02, 0x00, 0xC0, 0x40, 0x08, 0x08, 0x01, 0x81, 0x00, 0x10, 0x20,
  0x03, 0x04, 0x00, 0x20, 0x80, 0x06, 0x10, 0x00, 0x62, 0x00, 0x0C, 0x40,
  0x00, 0xC8, 0x00, 0x09, 0x00, 0x01, 0xA0, 0x00, 0x14, 0x00, 0x03, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xE8, 0x00, 0x00, 0x0F, 0xA0, 0x00,
  0x00, 0x3E, 0xC0, 0x00, 0x00, 0xB9, 0x00, 0x00, 0x06, 0xE6, 0x00, 0x00,
  0x1B, 0x98, 0x00, 0x00, 0x4E, 0x20, 0x00, 0x03, 0x38, 0xC0, 0x00, 0x0C,
  0xE3, 0x00, 0x00, 0x23, 0x84, 0x00, 0x01, 0x8E, 0x18, 0x00, 0x06, 0x38,
  0x60, 0x00, 0x10, 0xE0, 0x80, 0x00, 0xC3, 0x83, 0x00, 0x03, 0x0E, 0x0C,
  0x00, 0x08, 0x38, 0x10, 0x00, 0x60, 0xE0, 0x60, 0x01, 0x83, 0x81, 0x80,
  0x04, 0x0E, 0x02, 0x00, 0x30, 0x38, 0x0C, 0x00, 0xC0, 0xE0, 0x30, 0x02,
  0x03, 0x80, 0x40, 0x18, 0x0E, 0x01, 0x80, 0x60, 0x38, 0x06, 0x01, 0x00,
  0xE0, 0x08, 0x0C, 0x03, 0x80, 0x30, 0x30, 0x0E, 0x00, 0xC0, 0x80, 0x38,
  0x01, 0x06, 0x00, 0xE0, 0x06, 0x18, 0x03, 0x80, 0x18, 0x40, 0x0E, 0x00,
  0x23, 0x00, 0x38, 0x00, 0xCC, 0x00, 0xE0, 0x03, 0x20, 0x03, 0x80, 0x05,
  0x80, 0x0E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xE8, 0x00, 0x03,
  0xB0, 0x00, 0x0E, 0x40, 0x00, 0x39, 0x80, 0x00, 0xE2, 0x00, 0x03, 0x8C,
  0x00, 0x0E, 0x10, 0x00, 0x38, 0x60, 0x00, 0xE0, 0x80, 0x03, 0x83, 0x00,
  0x0E, 0x04, 0x00, 0x38, 0x18, 0x00, 0xE0, 0x20, 0x03, 0x80, 0xC0, 0x0E,
  0x01, 0x00, 0x38, 0x06, 0x00, 0xE0, 0x08, 0x03, 0x80, 0x30, 0x0E, 0x00,
  0x40, 0x38, 0x01, 0x80, 0xE0, 0x02, 0x03, 0x80, 0x0C, 0x0E, 0x00, 0x10,
  0x38, 0x00, 0x60, 0xE0, 0x00, 0x83, 0x80, 0x03, 0x0E, 0x00, 0x04, 0x38,
  0x00, 0x18, 0xE0, 0x00, 0x23, 0x80, 0x00, 0xCE, 0x00, 0x01, 0x38, 0x00,
  0x06, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0x01,
  0xC0, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x08, 0x30, 0x00, 0x01, 0x84, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0x44, 0x00, 0x00, 0x0C, 0x80,
  0x00, 0x01, 0x90, 0x00, 0x00, 0x16, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00,
  0x58, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x2C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x16, 0x00, 0x00, 0x02,
  0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x09, 0x00, 0x00, 0x01, 0x20, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x21,
  0x00, 0x00, 0x04, 0x20, 0x00, 0x01, 0x86, 0x00, 0x00, 0x30, 0x40, 0x00,
  0x04, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x01,
  0xC0, 0x06, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0xFF, 0xE0, 0x20, 0x7F, 0x08, 0x00, 0xE2, 0x00, 0x0C, 0x80, 0x01,
  0xA0, 0x00, 0x68, 0x00, 0x0A, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x02, 0x80, 0x01, 0xA0, 0x00, 0x68, 0x00, 0x32, 0x00, 0x18, 0x80, 0x0E,
  0x3F, 0xFE, 0x0F, 0xFC, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08,
  0x00, 0x02, 0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00,
  0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x80, 0x00,
  0x20, 0x00, 0x08, 0x00, 0x02, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x18, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC0, 0x80, 0x00, 0x18, 0x30, 0x00,
  0x01, 0x84, 0x00, 0x00, 0x31, 0x80, 0x00, 0x02, 0x30, 0x00, 0x00, 0x64,
  0x00, 0x00, 0x0C, 0x80, 0x00, 0x01, 0x90, 0x00, 0x00, 0x16, 0x00, 0x00,
  0x02, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x0B, 0x00, 0x00, 0x01, 0x60,
  0x00, 0x00, 0x2C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x16, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x58, 0x00, 0x00, 0x09, 0x00,
  0x00, 0x01, 0x20, 0x00, 0x00, 0x24, 0x00, 0x00, 0x0C, 0xC0, 0x00, 0x01,
  0x98, 0x00, 0x00, 0x31, 0x00, 0x00, 0x04, 0x20, 0x00, 0x01, 0x86, 0x00,
  0x00, 0x30, 0x40, 0x00, 0x04, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x60,
  0x0C, 0x00, 0x18, 0x01, 0xC0, 0x06, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x10, 0x00,
  0xFF, 0xE0, 0x10, 0x3F, 0x82, 0x00, 0x38, 0x40, 0x01, 0x88, 0x00, 0x19,
  0x00, 0x03, 0x20, 0x00, 0x24, 0x00, 0x06, 0x80, 0x00, 0xD0, 0x00, 0x1A,
  0x00, 0x03, 0x40, 0x00, 0x68, 0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x24,
  0x00, 0x04, 0x80, 0x01, 0x90, 0x00, 0x62, 0x00, 0x08, 0x40, 0x06, 0x08,
  0x0F, 0x81, 0xFF, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x30, 0x10,
  0x06, 0x02, 0x00, 0x60, 0x40, 0x0C, 0x08, 0x00, 0xC1, 0x00, 0x18, 0x20,
  0x01, 0x84, 0x00, 0x30, 0x80, 0x03, 0x10, 0x00, 0x62, 0x00, 0x06, 0x40,
  0x00, 0xC8, 0x00, 0x0D, 0x00, 0x01, 0xA0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x20, 0x00, 0xFF, 0xF0, 0x38, 0x07, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x20, 0x00, 0xC7, 0x00, 0x70, 0x7F, 0xF8,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00,
  0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xD0, 0x00, 0x01, 0x20, 0x00, 0x02, 0x40, 0x00, 0x04, 0xC0,
  0x00, 0x18, 0x80, 0x00, 0x21, 0x80, 0x00, 0xC1, 0x80, 0x03, 0x03, 0x80,
  0x0E, 0x01, 0xC0, 0x70, 0x01, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x02, 0x40, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x04, 0x20, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x08, 0x10, 0x00, 0x08, 0x10, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x10, 0x08, 0x00, 0x10, 0x08, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x04, 0x00,
  0x20, 0x04, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x02, 0x00,
  0x40, 0x02, 0x00, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x80, 0x01, 0x00,
  0x80, 0x01, 0x01, 0x80, 0x01, 0x81, 0x00, 0x00, 0x81, 0x00, 0x00, 0x83,
  0x00, 0x00, 0xC3, 0x00, 0x00, 0xC2, 0x00, 0x00, 0x42, 0x00, 0x00, 0x46,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x64, 0x00, 0x00, 0x2C, 0x00, 0x00, 0x2C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00,
  0xD0, 0x00, 0x1C, 0x00, 0x02, 0x40, 0x00, 0x78, 0x00, 0x09, 0x80, 0x01,
  0x60, 0x00, 0x66, 0x00, 0x05, 0x80, 0x01, 0x98, 0x00, 0x12, 0x00, 0x06,
  0x20, 0x00, 0xC8, 0x00, 0x10, 0x80, 0x03, 0x30, 0x00, 0xC3, 0x00, 0x08,
  0xC0, 0x03, 0x0C, 0x00, 0x21, 0x00, 0x0C, 0x10, 0x01, 0x84, 0x00, 0x20,
  0x40, 0x06, 0x18, 0x00, 0x81, 0x80, 0x18, 0x60, 0x06, 0x06, 0x00, 0x40,
  0x80, 0x18, 0x08, 0x01, 0x02, 0x00, 0x40, 0x20, 0x0C, 0x08, 0x01, 0x00,
  0xC0, 0x30, 0x30, 0x0C, 0x03, 0x00, 0x80, 0xC0, 0x30, 0x0C, 0x02, 0x01,
  0x00, 0x80, 0x10, 0x18, 0x04, 0x02, 0x00, 0x40, 0x60, 0x18, 0x18, 0x01,
  0x81, 0x80, 0x60, 0x60, 0x06, 0x04, 0x01, 0x81, 0x00, 0x08, 0x10, 0x02,
  0x04, 0x00, 0x20, 0xC0, 0x08, 0x30, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x03,
  0x08, 0x00, 0xC3, 0x00, 0x04, 0x20, 0x01, 0x08, 0x00, 0x11, 0x80, 0x04,
  0x20, 0x00, 0x66, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x66, 0x00, 0x06,
  0x40, 0x01, 0x90, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0x2C, 0x00, 0x0B,
  0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x19, 0x80,
  0x00, 0x84, 0x00, 0x0C, 0x30, 0x00, 0x40, 0x80, 0x06, 0x06, 0x00, 0x20,
  0x10, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x18, 0x0C, 0x00, 0xC0,
  0xC0, 0x02, 0x06, 0x00, 0x18, 0x20, 0x00, 0x43, 0x00, 0x03, 0x10, 0x00,
  0x09, 0x80, 0x00, 0x68, 0x00, 0x03, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x34, 0x00, 0x01, 0x30, 0x00, 0x19, 0x80, 0x00,
  0x84, 0x00, 0x0C, 0x30, 0x00, 0x40, 0x80, 0x06, 0x06, 0x00, 0x20, 0x10,
  0x03, 0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x10, 0x0C, 0x00, 0xC0, 0xC0,
  0x02, 0x06, 0x00, 0x18, 0x60, 0x00, 0x43, 0x00, 0x03, 0x10, 0x00, 0x19,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1A, 0x00, 0x00, 0x98, 0x00,
  0x0C, 0xC0, 0x00, 0x42, 0x00, 0x06, 0x18, 0x00, 0x30, 0x40, 0x01, 0x02,
  0x00, 0x18, 0x18, 0x00, 0xC0, 0x40, 0x04, 0x03, 0x00, 0x60, 0x08, 0x02,
  0x00, 0x40, 0x30, 0x03, 0x01, 0x80, 0x08, 0x08, 0x00, 0x60, 0xC0, 0x01,
  0x04, 0x00, 0x08, 0x60, 0x00, 0x63, 0x00, 0x01, 0x10, 0x00, 0x0D, 0x80,
  0x00, 0x28, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00,
  0x04, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0x40,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00,
  0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03,
  0x00, 0x00, 0x40, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x06, 0x00, 0x00, 0x80,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00,
  0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03,
  0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20,
  0x00, 0x30, 0x00, 0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x40, 0x00, 0x60, 0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x18, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x04, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0x00, 0x03, 0x00, 0x01, 0xFF,
  0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x20,
  0x00, 0x06, 0x60, 0x00, 0x18, 0x40, 0x00, 0x20, 0xC0, 0x00, 0xC0, 0x80,
  0x01, 0x01, 0x80, 0x06, 0x01, 0x00, 0x08, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x40, 0x06, 0x01, 0x80, 0x0C, 0x02, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x10,
  0x00, 0x18, 0x60, 0x00, 0x30, 0x80, 0x00, 0x33, 0x00, 0x00, 0x6C, 0x00,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x03, 0xF8, 0x1F, 0x8E, 0x04,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0xFC, 0x0F, 0xF6, 0x1C, 0x03, 0x18, 0x01, 0x98, 0x00, 0xD8, 0x00, 0x68,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xA0, 0x01, 0x58, 0x01, 0xA4, 0x01, 0x93, 0x81, 0x88, 0xFF, 0x84, 0x04,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x1F, 0xC0,
  0xC7, 0x8E, 0x0C, 0xC0, 0x30, 0xD8, 0x01, 0x8D, 0x00, 0x0C, 0xE0, 0x00,
  0x4E, 0x00, 0x06, 0xE0, 0x00, 0x6C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00,
  0x02, 0xC0, 0x00, 0x2C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x02, 0xC0, 0x00, 0x2C,
  0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x04,
  0xF0, 0x00, 0xCD, 0x00, 0x18, 0xD8, 0x03, 0x0C, 0xE0, 0x70, 0xC7, 0xFC,
  0x00, 0x04, 0x00, 0x01, 0xFE, 0x07, 0xC7, 0x0E, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E,
  0x01, 0x03, 0xFF, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x07, 0xF0, 0x41, 0xC7, 0x88, 0xE0, 0x19, 0x18, 0x01, 0x26, 0x00, 0x14,
  0x80, 0x02, 0xB0, 0x00, 0x34, 0x00, 0x06, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x34, 0x00, 0x06, 0xC0, 0x01, 0xD8,
  0x00, 0x29, 0x80, 0x0D, 0x18, 0x03, 0x21, 0x80, 0xC4, 0x1F, 0xF0, 0x80,
  0x20, 0x00, 0x03, 0xF8, 0x01, 0xCF, 0x01, 0xC0, 0x60, 0x60, 0x0C, 0x30,
  0x01, 0x08, 0x00, 0x66, 0x00, 0x09, 0x00, 0x02, 0x40, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x80, 0x00, 0x20, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x02, 0x0E, 0x03, 0x80, 0xFF, 0xC0, 0x02, 0x00,
  0x00, 0xF8, 0x0F, 0xF0, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x7F,
  0x0F, 0xFC, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x00, 0x03, 0xF8, 0x21, 0xF3, 0xC4, 0x70, 0x0C, 0x88,
  0x00, 0xD3, 0x00, 0x0A, 0xC0, 0x01, 0xD8, 0x00, 0x1A, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1A, 0x00,
  0x03, 0x60, 0x00, 0xA4, 0x00, 0x14, 0xC0, 0x04, 0x8C, 0x01, 0x90, 0xC0,
  0x62, 0x0F, 0xF8, 0x40, 0x10, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00,
  0x30, 0x00, 0x0C, 0x40, 0x03, 0x8E, 0x01, 0xC0, 0x7F, 0xF0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x7E, 0x0C, 0x79, 0xE3, 0x30,
  0x1C, 0xD8, 0x03, 0x34, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x02, 0xE0, 0x00,
  0xB0, 0x00, 0x2C, 0x00, 0x0B, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0C, 0xFF, 0x00, 0x00, 0x01, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49,
  0x24, 0x92, 0x49, 0x24, 0x92, 0x07, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0xF8, 0x20, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x08, 0xC0, 0x10, 0xC0,
  0x30, 0xC0, 0x60, 0xC0, 0x40, 0xC0, 0xC0, 0xC1, 0x80, 0xC1, 0x00, 0xC3,
  0x00, 0xC6, 0x00, 0xCF, 0x00, 0xC9, 0x00, 0xD9, 0x80, 0xF0, 0x80, 0xE0,
  0xC0, 0xC0, 0x40, 0xC0, 0x60, 0xC0, 0x20, 0xC0, 0x30, 0xC0, 0x10, 0xC0,
  0x18, 0xC0, 0x08, 0xC0, 0x0C, 0xC0, 0x04, 0xC0, 0x06, 0xC0, 0x02, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x83, 0xF0, 0x0F, 0xC2, 0x3C, 0x60, 0xE3, 0xC9, 0x80, 0xC6, 0x03, 0x24,
  0x01, 0x90, 0x06, 0xF0, 0x02, 0x80, 0x0B, 0x80, 0x0A, 0x00, 0x3E, 0x00,
  0x38, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x00,
  0x07, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0xC0, 0x03, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x00, 0x07, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x70, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x00,
  0x07, 0x00, 0x0C, 0x00, 0x10, 0x81, 0xF8, 0x21, 0xC3, 0x88, 0xC0, 0x32,
  0x60, 0x04, 0xF0, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x0B, 0x00, 0x02, 0xC0,
  0x00, 0xB0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x30, 0x03, 0xF8, 0x00, 0x71, 0xE0, 0x1C, 0x03, 0x01, 0x00, 0x18, 0x30,
  0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x44, 0x00, 0x06, 0xC0, 0x00, 0x6C,
  0x00, 0x02, 0xC0, 0x00, 0x28, 0x00, 0x02, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x28, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0x40, 0x00, 0x64, 0x00,
  0x06, 0x60, 0x00, 0x42, 0x00, 0x0C, 0x30, 0x00, 0x81, 0x80, 0x18, 0x0E,
  0x07, 0x00, 0x7F, 0xC0, 0x00, 0xC0, 0x00, 0x81, 0xFC, 0x08, 0x78, 0xE0,
  0x8C, 0x03, 0x09, 0x80, 0x18, 0x90, 0x00, 0xCB, 0x00, 0x04, 0xA0, 0x00,
  0x6E, 0x00, 0x06, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x2C, 0x00,
  0x02, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x2C, 0x00, 0x02, 0xC0, 0x00, 0x2C,
  0x00, 0x02, 0xC0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00, 0x4F, 0x00, 0x0C,
  0xD8, 0x01, 0x8D, 0x80, 0x30, 0xCE, 0x07, 0x0C, 0x3F, 0xC0, 0xC0, 0xC0,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x20, 0xE3, 0xC4,
  0x70, 0x0C, 0x8C, 0x00, 0x93, 0x00, 0x0A, 0xC0, 0x01, 0x58, 0x00, 0x1A,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1A, 0x00, 0x03, 0x60, 0x00, 0xAC, 0x00, 0x14, 0xC0, 0x04, 0x8C,
  0x01, 0x90, 0xC0, 0xE2, 0x0F, 0xF0, 0x40, 0x10, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x83, 0xEC, 0x77, 0xCC, 0x0D, 0x80, 0xD0, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x07,
  0xF8, 0x1E, 0x3E, 0x30, 0x02, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x06, 0x80, 0x06, 0xE0, 0x1C, 0x3F, 0xF0, 0x03,
  0x00, 0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0xFF, 0xFF, 0xF1, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x00, 0x80, 0x08, 0x00, 0xC0, 0x07, 0xE0, 0x08, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xA0, 0x01, 0x58, 0x01, 0xA6, 0x01, 0x93, 0x81, 0x88,
  0xFF, 0x84, 0x04, 0x00, 0xC0, 0x00, 0x68, 0x00, 0x09, 0x00, 0x03, 0x30,
  0x00, 0x66, 0x00, 0x08, 0x40, 0x01, 0x08, 0x00, 0x61, 0x80, 0x0C, 0x30,
  0x01, 0x02, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x20, 0x04, 0x0C, 0x00, 0x81, 0x80, 0x18,
  0x20, 0x01, 0x04, 0x00, 0x21, 0x80, 0x06, 0x30, 0x00, 0xC4, 0x00, 0x09,
  0x80, 0x01, 0x30, 0x00, 0x34, 0x00, 0x02, 0x80, 0x00, 0x50, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x3C,
  0x00, 0x30, 0x00, 0xB0, 0x00, 0xE0, 0x02, 0x40, 0x07, 0x80, 0x09, 0x00,
  0x12, 0x00, 0x66, 0x00, 0x48, 0x01, 0x98, 0x01, 0x30, 0x04, 0x20, 0x0C,
  0xC0, 0x10, 0x80, 0x31, 0x00, 0xC3, 0x00, 0x84, 0x03, 0x0C, 0x02, 0x10,
  0x08, 0x10, 0x18, 0x60, 0x20, 0x40, 0x60, 0x81, 0x81, 0x81, 0x02, 0x06,
  0x06, 0x04, 0x08, 0x10, 0x08, 0x30, 0x30, 0x40, 0x20, 0xC0, 0x41, 0x00,
  0xC2, 0x01, 0x0C, 0x03, 0x08, 0x04, 0x20, 0x04, 0x60, 0x18, 0x80, 0x11,
  0x80, 0x22, 0x00, 0x44, 0x00, 0x98, 0x01, 0x90, 0x02, 0x60, 0x02, 0xC0,
  0x0D, 0x00, 0x0B, 0x00, 0x14, 0x00, 0x28, 0x00, 0x50, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x04, 0x00, 0x18, 0x00, 0x40, 0x00, 0xD8,
  0x00, 0x22, 0x00, 0x18, 0xC0, 0x04, 0x10, 0x03, 0x06, 0x01, 0x80, 0x80,
  0x60, 0x30, 0x30, 0x06, 0x0C, 0x01, 0x86, 0x00, 0x31, 0x00, 0x04, 0xC0,
  0x01, 0xA0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x4C, 0x00, 0x33, 0x00, 0x08, 0x60, 0x06, 0x08, 0x01, 0x03, 0x00, 0xC0,
  0x40, 0x20, 0x18, 0x18, 0x02, 0x04, 0x00, 0xC3, 0x00, 0x11, 0x80, 0x06,
  0x60, 0x00, 0xB0, 0x00, 0x30, 0x40, 0x00, 0x2C, 0x00, 0x0D, 0x80, 0x01,
  0x90, 0x00, 0x23, 0x00, 0x04, 0x60, 0x01, 0x84, 0x00, 0x20, 0x80, 0x04,
  0x18, 0x01, 0x81, 0x00, 0x30, 0x20, 0x04, 0x06, 0x00, 0x80, 0xC0, 0x30,
  0x08, 0x04, 0x01, 0x00, 0x80, 0x30, 0x30, 0x02, 0x06, 0x00, 0x40, 0x80,
  0x0C, 0x30, 0x01, 0x86, 0x00, 0x10, 0x80, 0x02, 0x10, 0x00, 0x66, 0x00,
  0x04, 0xC0, 0x00, 0x90, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x02, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x03, 0xF0, 0x00, 0x10,
  0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x40, 0x03,
  0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x04,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x03,
  0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x40,
  0x01, 0x80, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x18, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x3F, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x01, 0xF0, 0x00, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x40, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x3C, 0x03, 0x80, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x0B, 0x87,
  0x00, 0x70, 0x0E, 0x0F, 0x00, 0x1F, 0xC0, 0x00, 0x18, 0x00,
};

const GFXglyph NotoSans_Condensed_Thin56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 40, 11, 4, -40 },
  { 16, 9, 14, 17, 4, -40 },
  { 32, 25, 40, 28, 1, -40 },
  { 157, 20, 46, 25, 2, -43 },
  { 272, 30, 42, 36, 3, -41 },
  { 430, 24, 42, 27, 2, -41 },
  { 556, 1, 14, 9, 4, -40 },
  { 558, 9, 49, 15, 3, -40 },
  { 614, 10, 49, 15, 2, -40 },
  { 676, 17, 17, 23, 3, -43 },
  { 713, 21, 26, 25, 2, -33 },
  { 782, 5, 13, 10, 2, -6 },
  { 791, 12, 2, 16, 2, -16 },
  { 794, 3, 3, 11, 4, -3 },
  { 796, 16, 40, 18, 1, -40 },
  { 876, 19, 41, 25, 3, -41 },
  { 974, 10, 40, 25, 5, -40 },
  { 1024, 19, 41, 25, 3, -41 },
  { 1122, 20, 42, 25, 2, -41 },
  { 1227, 23, 40, 25, 1, -40 },
  { 1342, 19, 41, 25, 3, -40 },
  { 1440, 19, 41, 25, 3, -40 },
  { 1538, 19, 40, 25, 3, -40 },
  { 1633, 20, 41, 25, 2, -40 },
  { 1736, 20, 42, 25, 2, -41 },
  { 1841, 3, 30, 11, 4, -30 },
  { 1853, 5, 37, 11, 2, -30 },
  { 1877, 21, 24, 25, 2, -32 },
  { 1940, 21, 13, 25, 2, -26 },
  { 1975, 21, 24, 25, 2, -32 },
  { 2038, 15, 41, 17, 1, -41 },
  { 2115, 33, 45, 38, 3, -40 },
  { 2301, 24, 40, 24, 0, -40 },
  { 2421, 20, 40, 27, 5, -40 },
  { 2521, 22, 42, 27, 3, -41 },
  { 2637, 22, 40, 30, 5, -40 },
  { 2747, 16, 40, 24, 5, -40 },
  { 2827, 16, 40, 22, 5, -40 },
  { 2907, 26, 42, 32, 3, -41 },
  { 3044, 21, 40, 31, 5, -40 },
  { 3149, 8, 40, 13, 3, -40 },
  { 3189, 10, 50, 11, -3, -40 },
  { 3252, 19, 40, 24, 5, -40 },
  { 3347, 16, 40, 22, 5, -40 },
  { 3427, 30, 40, 40, 5, -40 },
  { 3577, 22, 40, 31, 5, -40 },
  { 3687, 27, 42, 33, 3, -41 },
  { 3829, 18, 40, 25, 5, -40 },
  { 3919, 27, 51, 33, 3, -41 },
  { 4092, 19, 40, 26, 5, -40 },
  { 4187, 19, 42, 24, 3, -41 },
  { 4287, 21, 40, 22, 0, -40 },
  { 4392, 23, 41, 31, 4, -40 },
  { 4510, 24, 40, 24, 0, -40 },
  { 4630, 38, 40, 40, 1, -40 },
  { 4820, 21, 40, 22, 0, -40 },
  { 4925, 21, 40, 21, 0, -40 },
  { 5030, 19, 40, 22, 2, -40 },
  { 5125, 10, 49, 17, 5, -40 },
  { 5187, 16, 40, 18, 1, -40 },
  { 5267, 10, 49, 17, 2, -40 },
  { 5329, 23, 21, 25, 1, -40 },
  { 5390, 22, 2, 22, 0, 5 },
  { 5396, 9, 9, 13, 2, -43 },
  { 5407, 17, 31, 23, 2, -30 },
  { 5473, 20, 44, 26, 4, -43 },
  { 5583, 16, 31, 20, 3, -30 },
  { 5645, 19, 44, 26, 3, -43 },
  { 5750, 18, 31, 24, 3, -30 },
  { 5820, 14, 43, 13, 1, -43 },
  { 5896, 19, 44, 26, 3, -30 },
  { 6001, 18, 43, 26, 4, -43 },
  { 6098, 3, 40, 10, 4, -40 },
  { 6113, 8, 54, 10, -1, -40 },
  { 6167, 16, 43, 20, 4, -43 },
  { 6253, 2, 43, 10, 4, -43 },
  { 6264, 30, 30, 38, 4, -30 },
  { 6377, 18, 30, 26, 4, -30 },
  { 6445, 20, 31, 25, 3, -30 },
  { 6523, 20, 43, 26, 4, -30 },
  { 6631, 19, 43, 26, 3, -30 },
  { 6734, 12, 30, 17, 4, -30 },
  { 6779, 16, 31, 20, 2, -30 },
  { 6841, 12, 38, 14, 1, -37 },
  { 6898, 17, 31, 26, 4, -30 },
  { 6964, 19, 30, 19, 0, -30 },
  { 7036, 30, 30, 32, 1, -30 },
  { 7149, 18, 30, 20, 1, -30 },
  { 7217, 19, 44, 20, 0, -30 },
  { 7322, 14, 30, 18, 2, -30 },
  { 7375, 15, 49, 19, 2, -40 },
  { 7467, 2, 57, 24, 11, -43 },
  { 7482, 14, 49, 19, 3, -40 },
  { 7568, 21, 5, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_Thin56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin56pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_CONDENSED_THIN56PT7B_H_
