#ifndef _NOTOSANS_CONDENSED_THIN35PT7B_H_
#define _NOTOSANS_CONDENSED_THIN35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xE1, 0x80, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x84,
  0x02, 0x08, 0x08, 0x10, 0x10, 0x40, 0x20, 0x80, 0x41, 0x00, 0x82, 0x01,
  0x04, 0x3B, 0xFF, 0x08, 0x10, 0x10, 0x20, 0x20, 0x80, 0x41, 0x00, 0x82,
  0x01, 0x04, 0x02, 0x08, 0x04, 0x10, 0xFF, 0xFC, 0x20, 0x80, 0x41, 0x00,
  0x82, 0x01, 0x04, 0x02, 0x08, 0x04, 0x10, 0x10, 0x20, 0x20, 0x80, 0x02,
  0x00, 0x10, 0x01, 0xC0, 0x34, 0xE2, 0x20, 0x21, 0x01, 0x08, 0x10, 0x40,
  0x82, 0x02, 0x10, 0x10, 0x80, 0xC4, 0x03, 0x20, 0x07, 0x00, 0x0C, 0x00,
  0x58, 0x02, 0x20, 0x10, 0x80, 0x86, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08,
  0x20, 0x42, 0x82, 0x23, 0xFE, 0x00, 0x80, 0x04, 0x00, 0x20, 0x00, 0x7C,
  0x06, 0x08, 0x80, 0x82, 0x08, 0x10, 0x41, 0x04, 0x08, 0x20, 0x81, 0x04,
  0x20, 0x20, 0x84, 0x04, 0x10, 0x80, 0x82, 0x20, 0x10, 0x44, 0x02, 0x09,
  0x1E, 0x41, 0x24, 0x28, 0x24, 0x84, 0x89, 0x20, 0x9F, 0x24, 0x10, 0x08,
  0x81, 0x01, 0x10, 0x20, 0x22, 0x04, 0x08, 0x40, 0x81, 0x08, 0x10, 0x21,
  0x04, 0x08, 0x20, 0x81, 0x02, 0x10, 0x40, 0x42, 0x08, 0x07, 0x80, 0x0F,
  0x80, 0x20, 0x80, 0x41, 0x00, 0x82, 0x01, 0x04, 0x02, 0x08, 0x04, 0x10,
  0x08, 0x20, 0x10, 0x80, 0x11, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xA0, 0x06,
  0x20, 0x08, 0x40, 0xA0, 0x41, 0x40, 0x45, 0x00, 0x8A, 0x00, 0x94, 0x00,
  0xC4, 0x01, 0x88, 0x03, 0x10, 0x0D, 0x10, 0x32, 0x1F, 0x82, 0xFF, 0x80,
  0x0C, 0x21, 0x08, 0x21, 0x84, 0x10, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x04, 0x10, 0x40, 0x82, 0x04, 0x10, 0x20, 0x40,
  0xC1, 0x82, 0x04, 0x10, 0x20, 0x82, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x41, 0x08, 0x21, 0x08, 0x00,
  0x04, 0x01, 0x00, 0x40, 0x10, 0xC4, 0xCD, 0xC0, 0xC0, 0x48, 0x12, 0x08,
  0x44, 0x08, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x24, 0x94, 0x92, 0x80, 0xFF, 0x70, 0x00, 0x40,
  0x20, 0x08, 0x02, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x00, 0x80, 0x40,
  0x10, 0x04, 0x02, 0x00, 0x80, 0x00, 0x1F, 0x82, 0x0C, 0x20, 0x44, 0x02,
  0x40, 0x28, 0x02, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x02,
  0x40, 0x24, 0x02, 0x20, 0x43, 0x08, 0x1F, 0x00, 0x04, 0x33, 0x59, 0x84,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x3F, 0x0C, 0x08, 0x00, 0x40, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x04, 0x00, 0x80, 0x08,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x00, 0xFF, 0xF0, 0x1F, 0xC7, 0x03, 0x10, 0x08, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x07,
  0x01, 0xF8, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x01, 0x00, 0x08, 0x00, 0xD0, 0x0C, 0x7F, 0x80, 0x00, 0x60,
  0x01, 0x80, 0x0A, 0x00, 0x28, 0x01, 0x20, 0x04, 0x80, 0x22, 0x01, 0x08,
  0x04, 0x20, 0x20, 0x80, 0x82, 0x04, 0x08, 0x10, 0x20, 0x80, 0x86, 0x02,
  0x10, 0x08, 0x80, 0x22, 0x00, 0x8F, 0xFF, 0xC0, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x7F, 0xE4, 0x00, 0x40, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0xBF, 0x04, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x20, 0x02, 0x00, 0x48, 0x0C, 0x7F, 0x00, 0x07, 0xE1, 0x80, 0x30,
  0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x08, 0x00, 0x9F,
  0x8A, 0x04, 0xC0, 0x2C, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x40, 0x14, 0x02, 0x40, 0x22, 0x04, 0x1F, 0x80, 0xFF, 0xF0,
  0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x00, 0x10, 0x01, 0x00, 0x20, 0x02, 0x00, 0x20, 0x04, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x00, 0x80, 0x10, 0x01, 0x00, 0x30, 0x00,
  0x1F, 0x82, 0x04, 0x40, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x24, 0x02,
  0x40, 0x62, 0x0C, 0x19, 0x80, 0xE0, 0x1B, 0x03, 0x08, 0x40, 0x48, 0x02,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x26, 0x04,
  0x3F, 0x80, 0x3F, 0x06, 0x08, 0x40, 0x48, 0x02, 0x80, 0x28, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x54, 0x0D, 0x3F,
  0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x10, 0x7E, 0x00, 0x74, 0x00, 0x00, 0x00, 0x34, 0x24, 0x80, 0x00,
  0x00, 0x00, 0x01, 0x24, 0xA4, 0x94, 0x00, 0x08, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x00, 0x30, 0x06,
  0x00, 0x40, 0x0C, 0x01, 0x80, 0x30, 0x02, 0x00, 0x00, 0xFE, 0x40, 0x80,
  0x40, 0x10, 0x08, 0x04, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x80, 0x80,
  0x40, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60,
  0x30, 0x00, 0x01, 0xFC, 0x00, 0x60, 0x30, 0x0C, 0x01, 0x81, 0x00, 0x0C,
  0x30, 0x00, 0x42, 0x00, 0x02, 0x40, 0x00, 0x24, 0x07, 0x81, 0x40, 0x84,
  0x18, 0x10, 0x41, 0x82, 0x04, 0x18, 0x20, 0x41, 0x82, 0x04, 0x18, 0x20,
  0x41, 0x84, 0x04, 0x18, 0x20, 0x41, 0x82, 0x0C, 0x18, 0x20, 0xC1, 0x82,
  0x0C, 0x28, 0x31, 0x42, 0x81, 0xE3, 0xC4, 0x00, 0x00, 0x40, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x02, 0x00, 0x3F, 0xC0,
  0x01, 0x00, 0x03, 0x00, 0x0A, 0x00, 0x14, 0x00, 0x24, 0x00, 0x88, 0x01,
  0x10, 0x02, 0x20, 0x04, 0x20, 0x10, 0x40, 0x20, 0x80, 0x40, 0x80, 0x81,
  0x02, 0x02, 0x07, 0xFC, 0x08, 0x04, 0x20, 0x08, 0x40, 0x10, 0x80, 0x21,
  0x00, 0x24, 0x00, 0x48, 0x00, 0x90, 0x00, 0xC0, 0x01, 0x80, 0x02, 0xFF,
  0x88, 0x04, 0x80, 0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x28, 0x02, 0x80, 0x4F, 0xF8, 0x81, 0xC8, 0x02, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x28, 0x04, 0xFF,
  0x80, 0x07, 0xF8, 0x30, 0x11, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x80, 0x01, 0x00, 0x02, 0x01, 0x07, 0xF8, 0xFF, 0x02, 0x03,
  0x08, 0x02, 0x20, 0x04, 0x80, 0x12, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x12, 0x00, 0x48,
  0x02, 0x20, 0x30, 0xFF, 0x00, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0xFF, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0xFF,
  0xC0, 0xFF, 0xE0, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x3F, 0xF8, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x00, 0x03, 0xFE, 0x0C,
  0x03, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x40, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80,
  0x7F, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x20, 0x01, 0x20, 0x01, 0x10, 0x01, 0x0C, 0x01, 0x03, 0xFE, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0xFF, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x08, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0xF8, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x2F, 0x00, 0x80, 0x38, 0x02, 0x80,
  0x48, 0x08, 0x81, 0x88, 0x10, 0x82, 0x08, 0x60, 0x84, 0x08, 0x80, 0x90,
  0x0B, 0x80, 0xA8, 0x0C, 0x40, 0x84, 0x08, 0x20, 0x82, 0x08, 0x10, 0x81,
  0x08, 0x08, 0x80, 0x48, 0x04, 0x80, 0x28, 0x02, 0x80, 0x10, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0xFF, 0xC0, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xD0, 0x00, 0x5A, 0x00, 0x0B, 0x40, 0x01, 0x64, 0x00, 0x4C, 0x80,
  0x09, 0x90, 0x01, 0x31, 0x00, 0x46, 0x20, 0x08, 0xC4, 0x03, 0x18, 0x40,
  0x43, 0x08, 0x08, 0x61, 0x03, 0x0C, 0x10, 0x41, 0x82, 0x08, 0x30, 0x42,
  0x06, 0x04, 0x40, 0xC0, 0x88, 0x18, 0x12, 0x03, 0x01, 0x40, 0x60, 0x28,
  0x0C, 0x06, 0x01, 0x80, 0x40, 0x20, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x68,
  0x01, 0xA0, 0x06, 0x40, 0x19, 0x00, 0x62, 0x01, 0x88, 0x06, 0x10, 0x18,
  0x40, 0x60, 0x81, 0x82, 0x06, 0x04, 0x18, 0x10, 0x60, 0x21, 0x80, 0x86,
  0x01, 0x18, 0x04, 0x60, 0x09, 0x80, 0x26, 0x00, 0x58, 0x01, 0x60, 0x03,
  0x80, 0x0C, 0x07, 0xF0, 0x18, 0x08, 0x30, 0x04, 0x20, 0x02, 0x40, 0x02,
  0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x02, 0x20, 0x02, 0x30, 0x04,
  0x18, 0x08, 0x07, 0xF0, 0xFE, 0x10, 0x32, 0x01, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x28, 0x0D, 0xFE, 0x20,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x00, 0x07, 0xF0, 0x18, 0x08, 0x30, 0x04, 0x20, 0x02, 0x40,
  0x02, 0x40, 0x01, 0x40, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x02, 0x20, 0x02, 0x30,
  0x04, 0x18, 0x08, 0x07, 0xF0, 0x00, 0x60, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x0C, 0xFE, 0x08, 0x08, 0x80, 0x48, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x28, 0x02, 0x80, 0x68, 0x04, 0x81,
  0x8F, 0xE0, 0x82, 0x08, 0x20, 0x81, 0x08, 0x10, 0x80, 0x88, 0x08, 0x80,
  0x48, 0x04, 0x80, 0x28, 0x02, 0x80, 0x10, 0x1F, 0xE6, 0x02, 0x40, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x20, 0x01, 0x00, 0x10,
  0x01, 0x00, 0x20, 0x02, 0x00, 0x68, 0x0C, 0xFF, 0x80, 0xFF, 0xF8, 0x10,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x02, 0x80, 0x0A, 0x00, 0x24, 0x01, 0x08, 0x0C, 0x1F, 0xC0, 0x80, 0x03,
  0x00, 0x09, 0x00, 0x12, 0x00, 0x24, 0x00, 0x48, 0x01, 0x08, 0x02, 0x10,
  0x04, 0x20, 0x08, 0x20, 0x20, 0x40, 0x40, 0x80, 0x81, 0x02, 0x01, 0x04,
  0x02, 0x08, 0x04, 0x10, 0x08, 0x40, 0x08, 0x80, 0x11, 0x00, 0x22, 0x00,
  0x28, 0x00, 0x50, 0x00, 0xA0, 0x01, 0x80, 0x01, 0x00, 0xC0, 0x08, 0x01,
  0xA0, 0x04, 0x00, 0x90, 0x06, 0x00, 0x48, 0x02, 0x80, 0x24, 0x01, 0x40,
  0x21, 0x00, 0xA0, 0x10, 0x80, 0x50, 0x08, 0x40, 0x44, 0x04, 0x20, 0x22,
  0x02, 0x08, 0x11, 0x02, 0x04, 0x08, 0x81, 0x02, 0x08, 0x40, 0x81, 0x04,
  0x10, 0x40, 0x42, 0x08, 0x40, 0x21, 0x04, 0x20, 0x10, 0x82, 0x10, 0x08,
  0x80, 0x88, 0x04, 0x40, 0x48, 0x01, 0x20, 0x24, 0x00, 0x90, 0x12, 0x00,
  0x50, 0x09, 0x00, 0x28, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x00, 0x40, 0x09, 0x00, 0x88, 0x04, 0x20, 0x41, 0x02,
  0x0C, 0x10, 0x21, 0x01, 0x08, 0x04, 0x80, 0x24, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x12, 0x00, 0x90, 0x08, 0x40, 0x42, 0x04, 0x10, 0x20,
  0x42, 0x02, 0x10, 0x09, 0x00, 0x48, 0x01, 0x80, 0x08, 0x80, 0x0A, 0x00,
  0x90, 0x04, 0x80, 0x22, 0x02, 0x10, 0x10, 0x41, 0x02, 0x08, 0x10, 0x40,
  0x44, 0x02, 0x20, 0x09, 0x00, 0x50, 0x02, 0x80, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x7F, 0xF0, 0x02, 0x00, 0x20, 0x02, 0x00, 0x40, 0x04, 0x00,
  0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40, 0x0C,
  0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20, 0x04, 0x00, 0x40,
  0x08, 0x00, 0xFF, 0xF0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x3F, 0x80, 0x80, 0x20, 0x04, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x10, 0x04, 0x00, 0x80, 0x20, 0x08,
  0x01, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20,
  0x08, 0x02, 0x00, 0x40, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x48, 0x01, 0x20, 0x08, 0x40, 0x21, 0x01, 0x02, 0x04, 0x08, 0x20, 0x10,
  0x80, 0x44, 0x00, 0x90, 0x02, 0x80, 0x0C, 0xFF, 0xFC, 0xC1, 0x02, 0x04,
  0x08, 0x10, 0x0F, 0x06, 0x18, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0xE1, 0xE4, 0x80, 0xA0, 0x14, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x40, 0x68, 0x14, 0xFC, 0x80, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x8F, 0x0B, 0x08, 0xC0, 0x4C, 0x02, 0x80,
  0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x02, 0x80, 0x28, 0x02, 0xC0, 0x4A, 0x0C, 0x9F, 0x80, 0x07, 0x86,
  0x12, 0x01, 0x00, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x01, 0x00, 0x40, 0x08, 0x01, 0xFC, 0x00, 0x10,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x0F, 0x13,
  0x09, 0x60, 0x54, 0x03, 0xC0, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x34, 0x03, 0x40, 0x32,
  0x05, 0x1F, 0x90, 0x0F, 0x06, 0x11, 0x81, 0x20, 0x28, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x3F, 0xFE, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x04, 0x7F, 0x00, 0x07, 0x84, 0x02, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x30, 0x6F, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x00, 0x0F, 0x03, 0x0D, 0x60, 0x54, 0x03, 0x80, 0x38, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x34,
  0x03, 0x40, 0x52, 0x05, 0x1F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x02, 0x00, 0x28, 0x04, 0x7F, 0x80, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x02, 0x00, 0x8E, 0x2C, 0x6C, 0x07, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x04, 0xD0, 0x01, 0x55, 0x55, 0x55, 0x55, 0x40, 0x18,
  0x40, 0x00, 0x00, 0x01, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x22, 0xF0, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0xA0, 0x48, 0x12, 0x08, 0x84,
  0x21, 0x08, 0x82, 0x40, 0xB0, 0x2A, 0x0C, 0x82, 0x10, 0x84, 0x20, 0x88,
  0x22, 0x04, 0x81, 0x20, 0x28, 0x0C, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x0E,
  0x28, 0x44, 0x2C, 0x0A, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x18,
  0x04, 0x06, 0x02, 0x01, 0x80, 0x80, 0x60, 0x20, 0x18, 0x08, 0x06, 0x02,
  0x01, 0x80, 0x80, 0x60, 0x20, 0x18, 0x08, 0x06, 0x02, 0x01, 0x80, 0x80,
  0x60, 0x20, 0x18, 0x08, 0x04, 0x0E, 0x2C, 0x2C, 0x07, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x04, 0x0F, 0x03, 0x0C, 0x60, 0x64, 0x02, 0x80,
  0x28, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x14, 0x02, 0x40, 0x22, 0x04, 0x1F, 0x80, 0x0F, 0x0B,
  0x08, 0xA0, 0x4C, 0x02, 0x80, 0x28, 0x02, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x02, 0x80, 0x28, 0x02, 0xC0, 0x4A,
  0x0C, 0x9F, 0x88, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x00, 0x0F, 0x03, 0x09, 0x60, 0x54, 0x03, 0x80, 0x38, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x34, 0x03, 0x40, 0x52, 0x05, 0x1F, 0x90, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x0D, 0x67, 0x06, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x00, 0x0F, 0x0C, 0x34, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x60, 0x27,
  0xF0, 0x20, 0x40, 0x81, 0x07, 0xF4, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x07, 0x80, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0xC1, 0x5F, 0x90, 0x80, 0x34, 0x02,
  0x40, 0x24, 0x04, 0x40, 0x42, 0x04, 0x20, 0x42, 0x08, 0x10, 0x81, 0x08,
  0x11, 0x01, 0x10, 0x09, 0x00, 0x90, 0x0A, 0x00, 0x60, 0x06, 0x00, 0x40,
  0xC0, 0x60, 0x28, 0x0C, 0x05, 0x01, 0x80, 0xA0, 0x28, 0x22, 0x09, 0x04,
  0x41, 0x20, 0x88, 0x24, 0x11, 0x04, 0x42, 0x11, 0x08, 0x82, 0x21, 0x10,
  0x44, 0x22, 0x08, 0x84, 0x40, 0xA0, 0x50, 0x14, 0x0A, 0x02, 0x81, 0x40,
  0x50, 0x28, 0x04, 0x02, 0x00, 0x80, 0x40, 0xC0, 0x68, 0x08, 0x82, 0x10,
  0x41, 0x10, 0x22, 0x02, 0x80, 0x70, 0x04, 0x01, 0x80, 0x28, 0x08, 0x81,
  0x10, 0x41, 0x08, 0x22, 0x02, 0xC0, 0x50, 0x04, 0x40, 0x14, 0x02, 0x40,
  0x22, 0x02, 0x20, 0x22, 0x04, 0x10, 0x41, 0x04, 0x10, 0x81, 0x08, 0x08,
  0x80, 0x88, 0x09, 0x00, 0x50, 0x05, 0x00, 0x60, 0x06, 0x00, 0x20, 0x02,
  0x00, 0x40, 0x04, 0x00, 0x40, 0x08, 0x00, 0x80, 0x18, 0x0F, 0x00, 0x7F,
  0x80, 0x80, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x02,
  0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x7F, 0xC0, 0x07, 0x0C, 0x18, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0xC0,
  0x20, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x08, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x30, 0x10, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x04, 0x03,
  0x04, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x10, 0x60, 0x80, 0x3C, 0x0A, 0x18, 0x60, 0x3C,
};

const GFXglyph NotoSans_Condensed_Thin35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 25, 7, 3, -25 },
  { 5, 6, 9, 11, 2, -25 },
  { 12, 15, 25, 17, 1, -25 },
  { 59, 13, 29, 16, 1, -27 },
  { 107, 19, 25, 22, 2, -25 },
  { 167, 15, 25, 17, 1, -25 },
  { 214, 1, 9, 6, 2, -25 },
  { 216, 6, 31, 9, 2, -25 },
  { 240, 6, 31, 9, 1, -25 },
  { 264, 10, 11, 14, 2, -27 },
  { 278, 13, 16, 16, 1, -20 },
  { 304, 3, 9, 6, 1, -4 },
  { 308, 8, 1, 10, 1, -10 },
  { 309, 2, 2, 7, 2, -2 },
  { 310, 10, 25, 11, 1, -25 },
  { 342, 12, 25, 16, 2, -25 },
  { 380, 6, 25, 16, 3, -25 },
  { 399, 12, 25, 16, 2, -25 },
  { 437, 13, 25, 16, 1, -25 },
  { 478, 14, 25, 16, 1, -25 },
  { 522, 12, 25, 16, 2, -25 },
  { 560, 12, 25, 16, 2, -25 },
  { 598, 12, 25, 16, 2, -25 },
  { 636, 12, 25, 16, 2, -25 },
  { 674, 12, 25, 16, 2, -25 },
  { 712, 2, 19, 7, 2, -19 },
  { 717, 3, 24, 7, 1, -19 },
  { 726, 13, 15, 16, 1, -20 },
  { 751, 13, 8, 16, 1, -16 },
  { 764, 13, 15, 16, 1, -20 },
  { 789, 9, 25, 11, 1, -25 },
  { 818, 20, 28, 24, 2, -25 },
  { 888, 15, 25, 15, 0, -25 },
  { 935, 12, 25, 17, 3, -25 },
  { 973, 14, 25, 17, 2, -25 },
  { 1017, 14, 25, 19, 3, -25 },
  { 1061, 10, 25, 15, 3, -25 },
  { 1093, 10, 25, 14, 3, -25 },
  { 1125, 16, 25, 20, 2, -25 },
  { 1175, 13, 25, 19, 3, -25 },
  { 1216, 5, 25, 8, 2, -25 },
  { 1232, 6, 31, 7, -2, -25 },
  { 1256, 12, 25, 15, 3, -25 },
  { 1294, 10, 25, 14, 3, -25 },
  { 1326, 19, 25, 25, 3, -25 },
  { 1386, 14, 25, 20, 3, -25 },
  { 1430, 16, 25, 20, 2, -25 },
  { 1480, 11, 25, 16, 3, -25 },
  { 1515, 16, 31, 20, 2, -25 },
  { 1577, 12, 25, 16, 3, -25 },
  { 1615, 12, 25, 15, 2, -25 },
  { 1653, 13, 25, 14, 0, -25 },
  { 1694, 14, 25, 19, 3, -25 },
  { 1738, 15, 25, 15, 0, -25 },
  { 1785, 25, 25, 25, 0, -25 },
  { 1864, 13, 25, 13, 0, -25 },
  { 1905, 13, 25, 13, 0, -25 },
  { 1946, 12, 25, 14, 1, -25 },
  { 1984, 7, 31, 11, 3, -25 },
  { 2012, 10, 25, 11, 1, -25 },
  { 2044, 7, 31, 11, 1, -25 },
  { 2072, 14, 13, 16, 1, -25 },
  { 2095, 14, 1, 14, 0, 3 },
  { 2097, 6, 6, 8, 1, -27 },
  { 2102, 11, 19, 14, 1, -19 },
  { 2129, 12, 27, 17, 3, -27 },
  { 2170, 10, 19, 13, 2, -19 },
  { 2194, 12, 27, 17, 2, -27 },
  { 2235, 11, 19, 15, 2, -19 },
  { 2262, 9, 27, 8, 0, -27 },
  { 2293, 12, 27, 16, 2, -19 },
  { 2334, 10, 27, 16, 3, -27 },
  { 2368, 2, 25, 7, 2, -25 },
  { 2375, 5, 33, 7, -1, -25 },
  { 2396, 10, 27, 13, 3, -27 },
  { 2430, 1, 27, 6, 3, -27 },
  { 2434, 18, 19, 24, 3, -19 },
  { 2477, 10, 19, 16, 3, -19 },
  { 2501, 12, 19, 16, 2, -19 },
  { 2530, 12, 27, 16, 3, -19 },
  { 2571, 12, 27, 16, 2, -19 },
  { 2612, 7, 19, 10, 3, -19 },
  { 2629, 10, 19, 12, 1, -19 },
  { 2653, 7, 23, 8, 1, -23 },
  { 2674, 10, 18, 16, 3, -18 },
  { 2697, 12, 18, 12, 0, -18 },
  { 2724, 19, 18, 20, 0, -18 },
  { 2767, 11, 18, 13, 1, -18 },
  { 2792, 12, 26, 12, 0, -18 },
  { 2831, 9, 18, 11, 1, -18 },
  { 2852, 8, 31, 12, 2, -25 },
  { 2883, 1, 36, 15, 7, -27 },
  { 2888, 8, 31, 12, 2, -25 },
  { 2919, 13, 3, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_Thin35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_THIN35PT7B_H_
