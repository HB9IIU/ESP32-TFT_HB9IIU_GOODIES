#ifndef _NOTOSANS_CONDENSED_THIN40PT7B_H_
#define _NOTOSANS_CONDENSED_THIN40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x55, 0x55, 0x55, 0x55, 0x50, 0x03, 0xC0, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x40, 0x01, 0x02, 0x00, 0x40, 0x80, 0x20,
  0x40, 0x08, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x40, 0x08, 0x10,
  0x02, 0x04, 0x1F, 0xFF, 0xF0, 0x40, 0x80, 0x10, 0x20, 0x04, 0x08, 0x01,
  0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x08, 0x08, 0x02, 0x04, 0x00, 0x81,
  0x03, 0xFF, 0xFE, 0x08, 0x10, 0x02, 0x04, 0x00, 0x81, 0x00, 0x20, 0x40,
  0x10, 0x20, 0x04, 0x08, 0x01, 0x02, 0x00, 0x40, 0x80, 0x10, 0x20, 0x00,
  0x02, 0x00, 0x08, 0x01, 0xFE, 0x0C, 0x86, 0x42, 0x02, 0x08, 0x08, 0x20,
  0x20, 0x80, 0x82, 0x02, 0x08, 0x08, 0x20, 0x30, 0x80, 0x42, 0x00, 0xC8,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x09, 0x80, 0x21, 0x00, 0x82, 0x02,
  0x0C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x0C, 0x08, 0x20, 0x21, 0xB0,
  0x8C, 0x7F, 0xC0, 0x08, 0x00, 0x20, 0x00, 0x80, 0x1C, 0x00, 0x80, 0x88,
  0x06, 0x04, 0x10, 0x10, 0x10, 0x40, 0x40, 0x81, 0x02, 0x02, 0x04, 0x08,
  0x08, 0x08, 0x60, 0x20, 0x21, 0x00, 0x80, 0x84, 0x02, 0x02, 0x20, 0x08,
  0x08, 0x80, 0x20, 0x26, 0x30, 0x81, 0x11, 0x32, 0x04, 0x48, 0x44, 0x12,
  0x20, 0x90, 0x49, 0x02, 0x22, 0x24, 0x08, 0x71, 0x10, 0x20, 0x04, 0x40,
  0x80, 0x21, 0x03, 0x00, 0x84, 0x0C, 0x02, 0x10, 0x30, 0x10, 0x40, 0x80,
  0x41, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x20, 0x81, 0x00,
  0x84, 0x04, 0x01, 0xE0, 0x07, 0x00, 0x0C, 0x60, 0x04, 0x10, 0x04, 0x04,
  0x02, 0x02, 0x01, 0x01, 0x00, 0x80, 0x80, 0x40, 0x40, 0x10, 0x20, 0x08,
  0x20, 0x04, 0x10, 0x01, 0x10, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x68, 0x00,
  0x66, 0x00, 0x61, 0x00, 0x20, 0x40, 0xA0, 0x30, 0x50, 0x08, 0x28, 0x02,
  0x24, 0x00, 0x92, 0x00, 0x59, 0x00, 0x18, 0x80, 0x0C, 0x40, 0x0E, 0x10,
  0x04, 0x8C, 0x0C, 0x21, 0xFC, 0x18, 0xFF, 0xE0, 0x02, 0x08, 0x20, 0x41,
  0x02, 0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x40, 0x81, 0x03, 0x02, 0x04, 0x04, 0x08,
  0x08, 0x18, 0x18, 0x81, 0x81, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x10,
  0x30, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0C, 0x18, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x18, 0x20, 0x41, 0x82, 0x04, 0x10, 0x20, 0x82, 0x00, 0x02, 0x00,
  0x20, 0x02, 0x00, 0x20, 0xE2, 0x71, 0xB8, 0x06, 0x00, 0x90, 0x09, 0x01,
  0x08, 0x20, 0x42, 0x04, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x6D, 0x24, 0xA4, 0x80, 0xFF, 0x80, 0xF0, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x20, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01, 0x00,
  0x20, 0x04, 0x01, 0x00, 0x20, 0x04, 0x01, 0x00, 0x20, 0x0C, 0x01, 0x00,
  0x20, 0x08, 0x01, 0x00, 0x20, 0x08, 0x01, 0x00, 0x60, 0x08, 0x01, 0x00,
  0x60, 0x08, 0x00, 0x07, 0x80, 0x61, 0x83, 0x02, 0x08, 0x04, 0x60, 0x11,
  0x00, 0x24, 0x00, 0x90, 0x02, 0xC0, 0x0A, 0x00, 0x38, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0xC0, 0x09, 0x00, 0x24, 0x00, 0x90, 0x02, 0x60, 0x18, 0x80,
  0x43, 0x03, 0x06, 0x08, 0x0F, 0xC0, 0x01, 0x07, 0x0F, 0x1A, 0x22, 0xC2,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02,
  0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x02, 0x0F,
  0x81, 0xC1, 0x8C, 0x02, 0x00, 0x04, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80,
  0x02, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x30, 0x00,
  0xFF, 0xFC, 0x1F, 0x81, 0xC1, 0x8C, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x60, 0x06, 0x01, 0xF8, 0x00, 0x18, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x20, 0x18, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x50, 0x00, 0x90, 0x00, 0x90, 0x01, 0x10, 0x01, 0x10, 0x02,
  0x10, 0x06, 0x10, 0x04, 0x10, 0x0C, 0x10, 0x08, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x20, 0x10, 0x20, 0x10, 0x40, 0x10, 0xC0, 0x10, 0x80, 0x10, 0xFF,
  0xFF, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x10, 0x00, 0x10, 0x3F, 0xF0, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01,
  0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x5F, 0x81, 0x81, 0x80, 0x01, 0x00, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00,
  0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00,
  0x60, 0x01, 0x20, 0x18, 0x7F, 0xC0, 0x01, 0xF0, 0x18, 0x20, 0x80, 0x04,
  0x00, 0x30, 0x00, 0x80, 0x02, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x30, 0x00, 0x8F, 0xE2, 0x40, 0x4A, 0x00, 0xB0, 0x02, 0xC0, 0x0B,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x14, 0x00, 0x50, 0x01,
  0x40, 0x08, 0x80, 0x22, 0x01, 0x84, 0x0C, 0x0F, 0xE0, 0x04, 0x00, 0xFF,
  0xFC, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00, 0x18, 0x00, 0x40, 0x01, 0x00,
  0x0C, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x08, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0x07, 0xC0, 0x61, 0x82, 0x01, 0x10, 0x02, 0x40, 0x09, 0x00,
  0x24, 0x00, 0x90, 0x02, 0x40, 0x09, 0x00, 0x22, 0x01, 0x04, 0x08, 0x0C,
  0xC0, 0x1C, 0x00, 0x78, 0x06, 0x18, 0x30, 0x31, 0x80, 0x64, 0x00, 0xA0,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x24,
  0x01, 0x8C, 0x0C, 0x1F, 0xE0, 0x0F, 0x80, 0xC1, 0x02, 0x02, 0x10, 0x04,
  0xC0, 0x12, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00,
  0xA0, 0x03, 0x80, 0x0E, 0x00, 0x34, 0x01, 0xD8, 0x0A, 0x30, 0x68, 0x3E,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x01, 0x00, 0x04, 0x00,
  0x30, 0x00, 0x80, 0x04, 0x00, 0x30, 0x7F, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x6C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0D, 0xA4, 0x94, 0x90,
  0x00, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x02, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x02, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x00,
  0x3E, 0x30, 0x40, 0x08, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x08, 0x02, 0x01, 0x00, 0x80, 0x60, 0x30, 0x08, 0x02, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x18,
  0x00, 0x00, 0x1C, 0x00, 0x01, 0xEF, 0x00, 0x0C, 0x01, 0x80, 0x20, 0x01,
  0x80, 0x80, 0x01, 0x82, 0x00, 0x01, 0x0C, 0x00, 0x01, 0x10, 0x00, 0x02,
  0x20, 0x00, 0x04, 0x80, 0x7E, 0x05, 0x01, 0x04, 0x0A, 0x04, 0x08, 0x1C,
  0x18, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0xC0, 0x80, 0x81, 0x81,
  0x01, 0x03, 0x02, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x18, 0x10,
  0x30, 0x30, 0x20, 0x60, 0x90, 0x21, 0x61, 0x20, 0x7C, 0x6C, 0x40, 0x20,
  0x20, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x00, 0x20, 0x01, 0xC3, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x28, 0x00, 0x12, 0x00, 0x09,
  0x00, 0x08, 0x80, 0x04, 0x40, 0x02, 0x10, 0x01, 0x08, 0x01, 0x04, 0x00,
  0x81, 0x00, 0x40, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x08, 0x08, 0x04,
  0x0F, 0xFE, 0x04, 0x01, 0x82, 0x00, 0x43, 0x00, 0x21, 0x00, 0x10, 0x80,
  0x04, 0x40, 0x02, 0x40, 0x01, 0x20, 0x00, 0xD0, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x08, 0xFE, 0x01, 0x03, 0xC2, 0x00, 0x64, 0x00, 0x48, 0x00, 0x50,
  0x00, 0xA0, 0x01, 0x40, 0x02, 0x80, 0x05, 0x00, 0x0A, 0x00, 0x24, 0x00,
  0x48, 0x01, 0x1F, 0xFC, 0x20, 0x78, 0x40, 0x0C, 0x80, 0x09, 0x00, 0x0A,
  0x00, 0x14, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x02, 0x80,
  0x05, 0x00, 0x1A, 0x00, 0x64, 0x01, 0x8F, 0xFC, 0x00, 0x00, 0xFC, 0x03,
  0x03, 0x0C, 0x00, 0x18, 0x00, 0x10, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x80,
  0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x40, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x20, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x06, 0x01, 0x01, 0xFE, 0xFC, 0x00, 0x83, 0xE0, 0x80,
  0x30, 0x80, 0x08, 0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x02, 0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x08, 0x80,
  0x18, 0x80, 0x60, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x0F, 0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF,
  0xF0, 0xFF, 0xF8, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F,
  0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x70, 0x38, 0x10, 0x01, 0x04, 0x00, 0x01, 0x00, 0x00, 0x60, 0x00, 0x08,
  0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x60,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0xFF, 0x80,
  0x00, 0x30, 0x00, 0x05, 0x00, 0x00, 0xA0, 0x00, 0x14, 0x00, 0x02, 0x80,
  0x00, 0x48, 0x00, 0x09, 0x00, 0x01, 0x30, 0x00, 0x23, 0x00, 0x04, 0x30,
  0x00, 0x83, 0x00, 0x30, 0x1F, 0xF8, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0xFC, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x04, 0x0A, 0x37, 0x80, 0x80, 0x06,
  0x00, 0x28, 0x01, 0x20, 0x0C, 0x80, 0x22, 0x01, 0x08, 0x0C, 0x20, 0x20,
  0x81, 0x02, 0x08, 0x08, 0x60, 0x21, 0x00, 0x88, 0x02, 0x70, 0x09, 0x40,
  0x29, 0x80, 0xC2, 0x03, 0x04, 0x08, 0x10, 0x20, 0x20, 0x80, 0xC2, 0x01,
  0x08, 0x06, 0x20, 0x08, 0x80, 0x12, 0x00, 0x48, 0x00, 0xA0, 0x02, 0x80,
  0x04, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0xFF, 0xF0, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3A, 0x00, 0x00, 0xE8, 0x00, 0x05, 0xA0, 0x00, 0x16, 0x40,
  0x00, 0x59, 0x00, 0x02, 0x64, 0x00, 0x09, 0x88, 0x00, 0x26, 0x20, 0x01,
  0x18, 0x80, 0x04, 0x61, 0x00, 0x11, 0x84, 0x00, 0x86, 0x10, 0x02, 0x18,
  0x20, 0x08, 0x60, 0x80, 0x41, 0x82, 0x01, 0x06, 0x04, 0x04, 0x18, 0x10,
  0x20, 0x60, 0x40, 0x81, 0x80, 0x82, 0x06, 0x02, 0x10, 0x18, 0x08, 0x40,
  0x60, 0x11, 0x01, 0x80, 0x48, 0x06, 0x01, 0x20, 0x18, 0x02, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xA0,
  0x01, 0xB0, 0x01, 0x90, 0x01, 0x98, 0x01, 0x88, 0x01, 0x84, 0x01, 0x84,
  0x01, 0x82, 0x01, 0x82, 0x01, 0x81, 0x01, 0x81, 0x01, 0x80, 0x81, 0x80,
  0x81, 0x80, 0x41, 0x80, 0x41, 0x80, 0x21, 0x80, 0x21, 0x80, 0x11, 0x80,
  0x11, 0x80, 0x09, 0x80, 0x09, 0x80, 0x05, 0x80, 0x05, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0x01, 0xF8, 0x00, 0xC1, 0xC0, 0x20, 0x0C, 0x08, 0x00,
  0x83, 0x00, 0x08, 0x40, 0x01, 0x98, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00,
  0x48, 0x00, 0x05, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x05, 0x00, 0x00,
  0xA0, 0x00, 0x14, 0x00, 0x02, 0x80, 0x00, 0x90, 0x00, 0x11, 0x00, 0x02,
  0x20, 0x00, 0x82, 0x00, 0x10, 0x60, 0x04, 0x06, 0x03, 0x00, 0x3F, 0xC0,
  0xFC, 0x04, 0x3E, 0x20, 0x0D, 0x00, 0x28, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0A, 0x00,
  0x90, 0x18, 0xFE, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0xC1, 0xC0, 0x20, 0x0C, 0x08, 0x00, 0xC3, 0x00, 0x08,
  0x40, 0x01, 0x98, 0x00, 0x12, 0x00, 0x02, 0x40, 0x00, 0x68, 0x00, 0x07,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xA0, 0x00, 0x14,
  0x00, 0x02, 0x80, 0x00, 0x90, 0x00, 0x11, 0x00, 0x02, 0x20, 0x00, 0x82,
  0x00, 0x10, 0x60, 0x04, 0x06, 0x03, 0x00, 0x3F, 0xC0, 0x00, 0x20, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00,
  0x00, 0x80, 0xFC, 0x02, 0x0F, 0x08, 0x03, 0x20, 0x04, 0x80, 0x0A, 0x00,
  0x28, 0x00, 0xA0, 0x02, 0x80, 0x0A, 0x00, 0x28, 0x00, 0xA0, 0x02, 0x80,
  0x12, 0x00, 0xC8, 0x06, 0x3F, 0xE0, 0x81, 0x02, 0x06, 0x08, 0x08, 0x20,
  0x30, 0x80, 0x42, 0x01, 0x88, 0x02, 0x20, 0x0C, 0x80, 0x12, 0x00, 0x68,
  0x00, 0xA0, 0x03, 0x80, 0x04, 0x07, 0xE0, 0x60, 0x62, 0x00, 0x10, 0x00,
  0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20, 0x00,
  0x40, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x01, 0x20, 0x18, 0xFF, 0xC0, 0xFF, 0xFE, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x10, 0x08, 0x0F,
  0xF0, 0x80, 0x00, 0xC0, 0x00, 0x50, 0x00, 0x48, 0x00, 0x24, 0x00, 0x12,
  0x00, 0x08, 0x80, 0x08, 0x40, 0x04, 0x20, 0x02, 0x18, 0x03, 0x04, 0x01,
  0x02, 0x00, 0x81, 0x00, 0x40, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08,
  0x18, 0x02, 0x08, 0x01, 0x04, 0x00, 0x82, 0x00, 0x22, 0x00, 0x11, 0x00,
  0x08, 0x80, 0x04, 0x40, 0x01, 0x40, 0x00, 0xA0, 0x00, 0x50, 0x00, 0x28,
  0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x01, 0xC0, 0x06, 0x00, 0x2C, 0x00, 0xA0, 0x04, 0x80, 0x14, 0x00, 0x90,
  0x04, 0x80, 0x32, 0x00, 0x90, 0x04, 0x40, 0x13, 0x00, 0x84, 0x02, 0x20,
  0x10, 0x80, 0xC4, 0x02, 0x10, 0x10, 0x80, 0x82, 0x02, 0x10, 0x10, 0x20,
  0x41, 0x02, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x10, 0x10, 0x40, 0x82,
  0x03, 0x08, 0x18, 0x40, 0x21, 0x01, 0x08, 0x04, 0x60, 0x23, 0x00, 0x88,
  0x04, 0x40, 0x11, 0x00, 0x88, 0x01, 0x20, 0x09, 0x00, 0x24, 0x01, 0x60,
  0x05, 0x80, 0x28, 0x00, 0xA0, 0x05, 0x00, 0x0C, 0x00, 0xA0, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0x00, 0x40, 0x02, 0x40, 0x08, 0x80, 0x10, 0x80,
  0x61, 0x00, 0x83, 0x03, 0x02, 0x04, 0x06, 0x08, 0x04, 0x20, 0x08, 0x40,
  0x09, 0x00, 0x12, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x02,
  0x40, 0x04, 0x80, 0x11, 0x80, 0x21, 0x00, 0x82, 0x01, 0x02, 0x06, 0x04,
  0x08, 0x04, 0x30, 0x08, 0x40, 0x19, 0x80, 0x12, 0x00, 0x2C, 0x00, 0x20,
  0x80, 0x03, 0x80, 0x09, 0x00, 0x12, 0x00, 0x22, 0x00, 0x84, 0x01, 0x0C,
  0x06, 0x08, 0x08, 0x10, 0x10, 0x10, 0x40, 0x20, 0x80, 0x43, 0x00, 0x44,
  0x00, 0x88, 0x00, 0xA0, 0x01, 0x40, 0x03, 0x80, 0x02, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x7F, 0xFC, 0x00, 0x30, 0x00,
  0x80, 0x06, 0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01,
  0x00, 0x08, 0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x10, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x01, 0x00, 0x0C,
  0x00, 0x20, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xFF, 0xFC, 0xFF, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x10, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x60,
  0x04, 0x00, 0x80, 0x08, 0x01, 0x00, 0x20, 0x02, 0x00, 0x40, 0x0C, 0x00,
  0x80, 0x10, 0x03, 0x00, 0x20, 0x04, 0x00, 0x40, 0x08, 0x01, 0x00, 0x10,
  0x02, 0xFF, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xFF,
  0x00, 0x80, 0x01, 0x80, 0x01, 0x40, 0x02, 0x40, 0x02, 0x20, 0x04, 0x20,
  0x04, 0x30, 0x08, 0x10, 0x08, 0x18, 0x10, 0x08, 0x10, 0x0C, 0x20, 0x04,
  0x60, 0x06, 0x40, 0x02, 0xC0, 0x03, 0xFF, 0xFF, 0x83, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x3F, 0x88, 0x08, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x20, 0xFC, 0x60, 0xB0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xA0, 0x53, 0xF2, 0x80, 0x02, 0x00, 0x08, 0x00,
  0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x81, 0x02, 0x3F,
  0x89, 0x03, 0x28, 0x04, 0xC0, 0x0B, 0x00, 0x2C, 0x00, 0xA0, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x80, 0x0B, 0x00, 0x2C, 0x01, 0xA8, 0x04, 0xB0, 0x22, 0x3F, 0x00,
  0x0F, 0xF1, 0x80, 0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x04, 0x00,
  0x40, 0x06, 0x00, 0x20, 0x01, 0x00, 0x0F, 0xE0, 0x00, 0x04, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x3F, 0x11, 0x02, 0x48, 0x05, 0x40, 0x0D, 0x00, 0x34, 0x00, 0xE0, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x01, 0xC0, 0x0D, 0x00, 0x34, 0x00, 0xC8, 0x05, 0x30, 0x24, 0x7F,
  0x10, 0x0F, 0xC1, 0x81, 0x08, 0x04, 0x80, 0x24, 0x01, 0x20, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x20, 0x20, 0xFF, 0x00,
  0x01, 0x80, 0xCC, 0x30, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x03, 0xFC, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x0F, 0xE4, 0xC0, 0xD2, 0x01,
  0x50, 0x03, 0x40, 0x0D, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xF0, 0x03, 0x40,
  0x0D, 0x00, 0x52, 0x01, 0x4C, 0x09, 0x1F, 0xC4, 0x00, 0x10, 0x00, 0x40,
  0x01, 0x00, 0x04, 0x00, 0x20, 0x00, 0x80, 0x06, 0x40, 0x31, 0xE7, 0x80,
  0x70, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0xFC, 0xB0, 0x2A, 0x03, 0xC0, 0x1C, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xF8,
  0x00, 0xAA, 0xAA, 0xAA, 0xAA, 0xAA, 0x80, 0x0C, 0x30, 0x80, 0x00, 0x00,
  0x00, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0A, 0xC4,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00,
  0x80, 0x10, 0x0E, 0x03, 0x40, 0x48, 0x11, 0x06, 0x20, 0x84, 0x20, 0x88,
  0x11, 0x02, 0x70, 0x52, 0x0E, 0x21, 0x84, 0x20, 0xC4, 0x08, 0x80, 0x90,
  0x12, 0x01, 0x40, 0x28, 0x03, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFC, 0x9F,
  0x87, 0xE5, 0x02, 0x40, 0xA8, 0x1A, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01,
  0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x40, 0x18, 0x02, 0x00, 0x80, 0x8F, 0xCB, 0x02, 0xA0, 0x1C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x0F, 0xE0, 0xC0, 0xC2, 0x01, 0x90, 0x02, 0x40, 0x0B,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x50, 0x01, 0x40, 0x09, 0x00, 0x22, 0x01,
  0x0C, 0x0C, 0x0F, 0xE0, 0x8F, 0xE2, 0x40, 0xCA, 0x01, 0x30, 0x02, 0xC0,
  0x0B, 0x00, 0x28, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xF0, 0x02, 0xC0, 0x0B, 0x00, 0x6A,
  0x01, 0x24, 0x08, 0x8F, 0xC2, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x00, 0x0F, 0xC4, 0xC0,
  0x92, 0x01, 0x50, 0x03, 0x40, 0x0F, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xF0,
  0x03, 0x40, 0x0D, 0x00, 0x52, 0x01, 0x4C, 0x09, 0x1F, 0xC4, 0x00, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x8F, 0x90, 0xA0, 0xC0, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1F,
  0xE2, 0x02, 0x40, 0x04, 0x00, 0x40, 0x04, 0x00, 0x40, 0x02, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x2C, 0x06, 0x7F, 0x80, 0x20, 0x20, 0x20, 0x20, 0x20,
  0xFF, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x10, 0x1F, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x40, 0x56, 0x0D, 0x3F, 0x90, 0x80, 0x0A, 0x00, 0x50, 0x06, 0x80, 0x24,
  0x01, 0x10, 0x08, 0x80, 0x84, 0x04, 0x10, 0x20, 0x83, 0x04, 0x10, 0x20,
  0x80, 0x84, 0x04, 0x40, 0x22, 0x00, 0x90, 0x05, 0x00, 0x28, 0x01, 0x40,
  0x06, 0x00, 0x20, 0x00, 0xC0, 0x10, 0x05, 0x00, 0x40, 0x14, 0x02, 0x80,
  0x90, 0x0A, 0x02, 0x20, 0x28, 0x08, 0x80, 0xA0, 0x22, 0x04, 0x40, 0x88,
  0x11, 0x04, 0x10, 0x44, 0x10, 0x41, 0x10, 0x41, 0x08, 0x21, 0x04, 0x20,
  0x88, 0x08, 0x82, 0x20, 0x26, 0x08, 0x80, 0x90, 0x12, 0x02, 0x40, 0x50,
  0x0D, 0x01, 0x40, 0x14, 0x05, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x80, 0xC0, 0x12, 0x01, 0x88, 0x08, 0x40, 0xC1, 0x04, 0x08, 0x40,
  0x22, 0x01, 0x20, 0x05, 0x00, 0x30, 0x01, 0x80, 0x0A, 0x00, 0xD0, 0x04,
  0x40, 0x42, 0x02, 0x08, 0x20, 0x41, 0x01, 0x10, 0x08, 0x80, 0x28, 0x01,
  0x80, 0x40, 0x0D, 0x00, 0x24, 0x00, 0x88, 0x02, 0x20, 0x10, 0x80, 0x41,
  0x01, 0x04, 0x0C, 0x10, 0x20, 0x40, 0x80, 0x82, 0x02, 0x10, 0x08, 0x40,
  0x11, 0x00, 0x48, 0x01, 0x20, 0x04, 0x80, 0x0A, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0x40,
  0x03, 0x00, 0x08, 0x02, 0xC0, 0x06, 0x00, 0x00, 0x7F, 0xC0, 0x08, 0x01,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80, 0x10, 0x04,
  0x00, 0x80, 0x30, 0x04, 0x01, 0x80, 0x20, 0x04, 0x01, 0x00, 0x20, 0x0F,
  0xFE, 0x00, 0x40, 0xE0, 0x40, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x38, 0x07,
  0x00, 0x40, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x3C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x80, 0x20, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x06, 0x00,
  0x70, 0x38, 0x18, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x08, 0x06, 0x0F, 0x00, 0x3C, 0x03,
  0x1C, 0x18, 0x1F, 0xC0, 0x08,
};

const GFXglyph NotoSans_Condensed_Thin40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 29, 8, 3, -29 },
  { 9, 6, 11, 12, 3, -29 },
  { 18, 18, 29, 20, 1, -29 },
  { 84, 14, 32, 18, 2, -30 },
  { 140, 22, 29, 26, 2, -29 },
  { 220, 17, 29, 19, 2, -29 },
  { 282, 1, 11, 7, 3, -29 },
  { 284, 7, 35, 10, 2, -29 },
  { 315, 7, 35, 10, 2, -29 },
  { 346, 12, 12, 16, 2, -30 },
  { 364, 16, 18, 18, 1, -23 },
  { 400, 3, 9, 7, 2, -4 },
  { 404, 9, 1, 11, 1, -11 },
  { 406, 2, 2, 8, 3, -2 },
  { 407, 11, 29, 13, 1, -29 },
  { 447, 14, 29, 18, 2, -29 },
  { 498, 8, 29, 18, 3, -29 },
  { 527, 14, 29, 18, 2, -29 },
  { 578, 14, 29, 18, 2, -29 },
  { 629, 16, 29, 18, 1, -29 },
  { 687, 14, 29, 18, 2, -29 },
  { 738, 14, 30, 18, 2, -29 },
  { 791, 14, 29, 18, 2, -29 },
  { 842, 14, 29, 18, 2, -29 },
  { 893, 14, 29, 18, 2, -29 },
  { 944, 2, 21, 8, 3, -21 },
  { 950, 3, 26, 8, 2, -21 },
  { 960, 15, 17, 18, 1, -23 },
  { 992, 16, 10, 18, 1, -19 },
  { 1012, 15, 17, 18, 1, -23 },
  { 1044, 10, 29, 12, 1, -29 },
  { 1081, 23, 33, 27, 2, -29 },
  { 1176, 17, 29, 17, 0, -29 },
  { 1238, 15, 29, 19, 3, -29 },
  { 1293, 16, 29, 19, 2, -29 },
  { 1351, 16, 29, 22, 3, -29 },
  { 1409, 12, 29, 17, 3, -29 },
  { 1453, 12, 29, 16, 3, -29 },
  { 1497, 19, 29, 23, 2, -29 },
  { 1566, 16, 29, 22, 3, -29 },
  { 1624, 6, 29, 10, 2, -29 },
  { 1646, 7, 36, 8, -2, -29 },
  { 1678, 14, 29, 17, 3, -29 },
  { 1729, 12, 29, 16, 3, -29 },
  { 1773, 22, 29, 28, 3, -29 },
  { 1853, 16, 29, 22, 3, -29 },
  { 1911, 19, 29, 23, 2, -29 },
  { 1980, 13, 29, 18, 3, -29 },
  { 2028, 19, 36, 23, 2, -29 },
  { 2114, 14, 29, 18, 3, -29 },
  { 2165, 14, 29, 17, 2, -29 },
  { 2216, 15, 29, 15, 0, -29 },
  { 2271, 16, 29, 22, 3, -29 },
  { 2329, 17, 29, 17, 0, -29 },
  { 2391, 27, 29, 29, 1, -29 },
  { 2489, 15, 29, 15, 0, -29 },
  { 2544, 15, 29, 15, 0, -29 },
  { 2599, 14, 29, 16, 1, -29 },
  { 2650, 8, 35, 12, 3, -29 },
  { 2685, 11, 29, 13, 1, -29 },
  { 2725, 8, 35, 12, 1, -29 },
  { 2760, 16, 15, 18, 1, -29 },
  { 2790, 16, 1, 16, 0, 4 },
  { 2792, 6, 7, 9, 2, -31 },
  { 2798, 11, 21, 16, 2, -21 },
  { 2827, 14, 30, 19, 3, -30 },
  { 2880, 12, 21, 14, 2, -21 },
  { 2912, 14, 30, 19, 2, -30 },
  { 2965, 13, 21, 17, 2, -21 },
  { 3000, 11, 31, 9, 0, -31 },
  { 3043, 14, 31, 19, 2, -21 },
  { 3098, 12, 30, 18, 3, -30 },
  { 3143, 2, 29, 7, 3, -29 },
  { 3151, 6, 39, 7, -1, -29 },
  { 3181, 11, 30, 15, 3, -30 },
  { 3223, 1, 30, 7, 3, -30 },
  { 3227, 21, 21, 27, 3, -21 },
  { 3283, 12, 21, 18, 3, -21 },
  { 3315, 14, 21, 18, 2, -21 },
  { 3352, 14, 30, 19, 3, -21 },
  { 3405, 14, 30, 19, 2, -21 },
  { 3458, 8, 21, 12, 3, -21 },
  { 3479, 12, 21, 14, 1, -21 },
  { 3511, 8, 26, 10, 1, -26 },
  { 3537, 12, 21, 18, 3, -21 },
  { 3569, 13, 21, 13, 0, -21 },
  { 3604, 22, 21, 23, 0, -21 },
  { 3662, 13, 21, 15, 1, -21 },
  { 3697, 14, 31, 14, 0, -21 },
  { 3752, 11, 21, 13, 1, -21 },
  { 3781, 10, 35, 14, 2, -29 },
  { 3825, 1, 40, 17, 8, -30 },
  { 3830, 10, 35, 14, 2, -29 },
  { 3874, 14, 4, 18, 2, -16 },
};

const GFXfont NotoSans_Condensed_Thin40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_THIN40PT7B_H_
