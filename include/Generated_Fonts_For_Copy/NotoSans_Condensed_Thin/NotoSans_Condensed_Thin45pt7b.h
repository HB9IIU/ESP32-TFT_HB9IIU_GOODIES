#ifndef _NOTOSANS_CONDENSED_THIN45PT7B_H_
#define _NOTOSANS_CONDENSED_THIN45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin45pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0x00,
  0xBB, 0x83, 0x83, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82, 0x82,
  0x00, 0x81, 0x80, 0x18, 0x10, 0x01, 0x01, 0x00, 0x10, 0x10, 0x01, 0x01,
  0x00, 0x10, 0x10, 0x01, 0x01, 0x00, 0x10, 0x30, 0x03, 0x02, 0x00, 0x20,
  0x20, 0x7F, 0xFF, 0xF0, 0x20, 0x20, 0x02, 0x02, 0x00, 0x20, 0x20, 0x02,
  0x02, 0x00, 0x60, 0x60, 0x04, 0x04, 0x00, 0x40, 0x40, 0x04, 0x04, 0x00,
  0x40, 0x40, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x04, 0x0C, 0x00, 0xC0, 0x80,
  0x08, 0x08, 0x00, 0x80, 0x80, 0x08, 0x08, 0x00, 0x80, 0x80, 0x08, 0x08,
  0x00, 0x80, 0x80, 0x18, 0x18, 0x01, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x07, 0xE0, 0x1D, 0x7C, 0x31, 0x04, 0x61, 0x00, 0xC1, 0x00, 0x81, 0x00,
  0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0x81, 0x00, 0xC1, 0x00, 0x41, 0x00,
  0x61, 0x00, 0x39, 0x00, 0x0D, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x01, 0x30,
  0x01, 0x0C, 0x01, 0x04, 0x01, 0x02, 0x01, 0x02, 0x01, 0x03, 0x01, 0x01,
  0x01, 0x03, 0x01, 0x03, 0x01, 0x02, 0x01, 0x06, 0x81, 0x0C, 0xE1, 0x18,
  0x3F, 0xE0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x04, 0x00,
  0x00, 0x1D, 0x80, 0x10, 0x08, 0x60, 0x18, 0x08, 0x10, 0x08, 0x04, 0x08,
  0x04, 0x02, 0x06, 0x04, 0x03, 0x01, 0x02, 0x01, 0x00, 0x83, 0x00, 0x80,
  0x41, 0x00, 0x40, 0x20, 0x80, 0x20, 0x10, 0x80, 0x10, 0x08, 0x40, 0x08,
  0x04, 0x20, 0x06, 0x02, 0x21, 0xC3, 0x01, 0x11, 0x90, 0x81, 0x99, 0x04,
  0x40, 0x88, 0x83, 0x20, 0x44, 0x80, 0x88, 0x44, 0x40, 0x47, 0xE2, 0x20,
  0x20, 0x43, 0x10, 0x10, 0x01, 0x08, 0x08, 0x00, 0x84, 0x04, 0x00, 0x82,
  0x03, 0x00, 0x41, 0x01, 0x00, 0x60, 0x80, 0x80, 0x20, 0x40, 0x40, 0x10,
  0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x0C, 0x08, 0x0C, 0x02, 0x08, 0x04,
  0x01, 0x84, 0x06, 0x00, 0x7C, 0x00, 0x01, 0x00, 0x00, 0xFC, 0x00, 0x20,
  0xC0, 0x08, 0x08, 0x01, 0x01, 0x00, 0x20, 0x30, 0x04, 0x06, 0x00, 0x80,
  0xC0, 0x10, 0x18, 0x02, 0x02, 0x00, 0x40, 0x40, 0x04, 0x18, 0x00, 0x82,
  0x00, 0x08, 0x80, 0x01, 0xE0, 0x00, 0x18, 0x00, 0x0D, 0x00, 0x03, 0x30,
  0x00, 0xC2, 0x00, 0x30, 0x20, 0x24, 0x06, 0x05, 0x80, 0x40, 0xA0, 0x04,
  0x14, 0x00, 0xC4, 0x80, 0x08, 0x90, 0x00, 0xB2, 0x00, 0x1C, 0x40, 0x01,
  0x8C, 0x00, 0x30, 0x80, 0x0B, 0x18, 0x02, 0x21, 0x81, 0x82, 0x1F, 0xE0,
  0x20, 0xFF, 0xE0, 0x02, 0x06, 0x04, 0x08, 0x08, 0x10, 0x10, 0x30, 0x20,
  0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xC0, 0xC0, 0x40, 0x40, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10,
  0x10, 0x08, 0x0C, 0x04, 0x06, 0x03, 0xC0, 0x40, 0x20, 0x30, 0x10, 0x18,
  0x08, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02, 0x02, 0x02, 0x02, 0x02, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x02, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x18, 0x10, 0x30, 0x20, 0x40, 0xC0, 0x01, 0x00, 0x04,
  0x00, 0x10, 0x00, 0x40, 0x81, 0x05, 0xC4, 0xE0, 0xFC, 0x00, 0xC0, 0x06,
  0x80, 0x12, 0x00, 0x84, 0x04, 0x08, 0x30, 0x10, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x3F, 0xFF, 0xE0, 0x10, 0x00, 0x08, 0x00,
  0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20,
  0x00, 0x10, 0x00, 0x24, 0x96, 0x92, 0xD2, 0x00, 0xFF, 0xC0, 0x7C, 0x00,
  0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x04, 0x00, 0x20, 0x03, 0x00, 0x10, 0x00, 0x80, 0x0C, 0x00,
  0x40, 0x02, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0x80, 0x04, 0x00, 0x60,
  0x02, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0x40, 0x04, 0x00, 0x20, 0x03,
  0x00, 0x10, 0x00, 0x01, 0x80, 0x07, 0xF0, 0x08, 0x18, 0x10, 0x08, 0x30,
  0x04, 0x20, 0x04, 0x20, 0x06, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40,
  0x02, 0x40, 0x02, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x40,
  0x03, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x60, 0x02, 0x20, 0x06, 0x20,
  0x04, 0x30, 0x0C, 0x18, 0x08, 0x0C, 0x10, 0x07, 0xE0, 0x03, 0x07, 0x09,
  0x31, 0x61, 0xC1, 0x81, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x00, 0x1F, 0xE0, 0x60, 0x18, 0x40,
  0x08, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00,
  0xC0, 0x01, 0x80, 0x01, 0x00, 0x02, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0x03,
  0x00, 0x3F, 0xC1, 0x80, 0x64, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0, 0x00,
  0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0xC0,
  0x01, 0x00, 0x0C, 0x00, 0x70, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x20, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03, 0x60, 0x0C, 0x7F,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x02,
  0x40, 0x00, 0xC8, 0x00, 0x11, 0x00, 0x06, 0x20, 0x00, 0x84, 0x00, 0x30,
  0x80, 0x04, 0x10, 0x01, 0x02, 0x00, 0x20, 0x40, 0x08, 0x08, 0x03, 0x01,
  0x00, 0x40, 0x20, 0x18, 0x04, 0x02, 0x00, 0x80, 0x80, 0x10, 0x10, 0x02,
  0x04, 0x00, 0x41, 0x80, 0x08, 0x20, 0x01, 0x07, 0xFF, 0xFF, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x20, 0x7F, 0xF8, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x08, 0x00, 0x17, 0xF8, 0x30, 0x1C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x40, 0x00,
  0x80, 0x01, 0x00, 0x06, 0x00, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80,
  0x02, 0x20, 0x18, 0x3F, 0xE0, 0x01, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40,
  0x00, 0x40, 0x00, 0x40, 0x00, 0x41, 0xC0, 0x4F, 0x78, 0x58, 0x0C, 0x50,
  0x04, 0xE0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x01, 0x40, 0x01, 0x40,
  0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x01, 0x40, 0x03, 0x60, 0x02, 0x20,
  0x02, 0x20, 0x06, 0x10, 0x04, 0x18, 0x08, 0x07, 0xF0, 0x00, 0x80, 0xFF,
  0xFF, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x08, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10, 0x00, 0x10, 0x00,
  0x30, 0x00, 0x20, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x03,
  0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x08, 0x00, 0x01, 0x80, 0x0F, 0xF0, 0x18, 0x08, 0x20, 0x04, 0x60,
  0x06, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x60,
  0x06, 0x20, 0x04, 0x10, 0x0C, 0x18, 0x18, 0x06, 0x60, 0x03, 0xC0, 0x03,
  0xC0, 0x0C, 0x30, 0x18, 0x18, 0x30, 0x0C, 0x60, 0x06, 0x40, 0x02, 0xC0,
  0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x40,
  0x02, 0x40, 0x02, 0x20, 0x04, 0x38, 0x18, 0x0F, 0xF0, 0x03, 0x00, 0x0F,
  0xE0, 0x10, 0x10, 0x20, 0x08, 0x40, 0x0C, 0x40, 0x04, 0xC0, 0x06, 0x80,
  0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80,
  0x02, 0xC0, 0x03, 0x40, 0x06, 0x40, 0x06, 0x60, 0x0A, 0x30, 0x1A, 0x1E,
  0xE2, 0x07, 0x82, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x00,
  0x04, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x10, 0x00, 0x30, 0x00,
  0x60, 0x7F, 0x80, 0x0C, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x27,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x22, 0x26, 0x44,
  0x4C, 0x88, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x40, 0x00, 0x00, 0x04, 0x07, 0xF8, 0x80, 0xC0, 0x06,
  0x00, 0x20, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x01, 0x80, 0x18, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x00, 0x30, 0x03, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x20, 0x10, 0x00, 0x02, 0x06, 0x00, 0x00, 0x60, 0x80, 0x00, 0x04, 0x30,
  0x00, 0x00, 0x84, 0x01, 0xFC, 0x19, 0x80, 0x61, 0x01, 0x20, 0x10, 0x20,
  0x24, 0x04, 0x04, 0x04, 0x80, 0x80, 0x80, 0x90, 0x30, 0x10, 0x1A, 0x04,
  0x02, 0x03, 0xC0, 0x80, 0x40, 0x78, 0x10, 0x08, 0x0F, 0x02, 0x01, 0x01,
  0xE0, 0x40, 0x20, 0x2C, 0x08, 0x04, 0x05, 0x81, 0x01, 0x80, 0x90, 0x20,
  0x30, 0x12, 0x06, 0x06, 0x04, 0x40, 0x41, 0x20, 0x88, 0x0C, 0x66, 0x61,
  0x80, 0xF8, 0x78, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x01, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xA0, 0x00, 0x09, 0x00, 0x00, 0x90, 0x00, 0x09,
  0x00, 0x01, 0x18, 0x00, 0x10, 0x80, 0x01, 0x08, 0x00, 0x30, 0x80, 0x02,
  0x04, 0x00, 0x20, 0x40, 0x02, 0x04, 0x00, 0x40, 0x60, 0x04, 0x02, 0x00,
  0x40, 0x20, 0x0C, 0x02, 0x00, 0x80, 0x30, 0x0F, 0xFF, 0x00, 0x80, 0x10,
  0x10, 0x01, 0x01, 0x00, 0x18, 0x10, 0x00, 0x83, 0x00, 0x08, 0x20, 0x00,
  0xC2, 0x00, 0x04, 0x20, 0x00, 0x46, 0x00, 0x04, 0x40, 0x00, 0x64, 0x00,
  0x02, 0xC0, 0x00, 0x28, 0x00, 0x03, 0xFF, 0xE0, 0x80, 0x38, 0x80, 0x0C,
  0x80, 0x04, 0x80, 0x06, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x06, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x18, 0x81, 0xF0,
  0xFF, 0xE0, 0x80, 0x18, 0x80, 0x04, 0x80, 0x02, 0x80, 0x02, 0x80, 0x03,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x02,
  0x80, 0x02, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x38, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0xFF, 0xC1, 0x80, 0x21, 0x80, 0x01, 0x80, 0x01, 0x80, 0x00, 0x80,
  0x00, 0xC0, 0x00, 0x40, 0x00, 0x20, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00,
  0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x18, 0x00, 0x04, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x01, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x20,
  0x1C, 0x08, 0x00, 0xC2, 0x00, 0x10, 0x80, 0x02, 0x20, 0x00, 0xC8, 0x00,
  0x12, 0x00, 0x06, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00, 0x0A, 0x00, 0x02,
  0x80, 0x00, 0xA0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x02, 0x80, 0x00, 0xA0, 0x00, 0x28, 0x00,
  0x0A, 0x00, 0x06, 0x80, 0x01, 0x20, 0x00, 0x48, 0x00, 0x32, 0x00, 0x18,
  0x80, 0x0C, 0x20, 0x06, 0x08, 0x07, 0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xFE, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00,
  0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02,
  0x00, 0x10, 0x00, 0xFF, 0xF4, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40,
  0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00,
  0x40, 0x02, 0x00, 0x10, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFC, 0x07, 0x00,
  0x30, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08,
  0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x40, 0x00, 0x14, 0x00, 0x01, 0x60, 0x00,
  0x12, 0x00, 0x01, 0x30, 0x00, 0x11, 0x80, 0x01, 0x0C, 0x00, 0x10, 0x70,
  0x03, 0x01, 0xFF, 0xC0, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x7F, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0xC6, 0x78, 0x80, 0x07, 0x00, 0x1A,
  0x00, 0x24, 0x00, 0x88, 0x03, 0x10, 0x04, 0x20, 0x10, 0x40, 0x60, 0x81,
  0x81, 0x02, 0x02, 0x0C, 0x04, 0x30, 0x08, 0xC0, 0x11, 0x00, 0x27, 0x00,
  0x5A, 0x00, 0xA6, 0x01, 0x84, 0x03, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10,
  0x18, 0x20, 0x10, 0x40, 0x30, 0x80, 0x21, 0x00, 0x62, 0x00, 0x44, 0x00,
  0x48, 0x00, 0xD0, 0x00, 0xA0, 0x01, 0xC0, 0x01, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00,
  0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xA0, 0x00, 0x05,
  0xA0, 0x00, 0x05, 0xB0, 0x00, 0x0D, 0x90, 0x00, 0x09, 0x90, 0x00, 0x09,
  0x98, 0x00, 0x19, 0x88, 0x00, 0x11, 0x88, 0x00, 0x11, 0x8C, 0x00, 0x31,
  0x84, 0x00, 0x21, 0x84, 0x00, 0x21, 0x86, 0x00, 0x61, 0x82, 0x00, 0x41,
  0x82, 0x00, 0x41, 0x83, 0x00, 0xC1, 0x81, 0x00, 0x81, 0x81, 0x00, 0x81,
  0x81, 0x81, 0x81, 0x80, 0x81, 0x01, 0x80, 0x81, 0x01, 0x80, 0xC3, 0x01,
  0x80, 0x42, 0x01, 0x80, 0x42, 0x01, 0x80, 0x66, 0x01, 0x80, 0x24, 0x01,
  0x80, 0x24, 0x01, 0x80, 0x3C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x34, 0x00, 0x1A, 0x00, 0x0C, 0x80,
  0x06, 0x40, 0x03, 0x10, 0x01, 0x8C, 0x00, 0xC2, 0x00, 0x61, 0x80, 0x30,
  0x40, 0x18, 0x30, 0x0C, 0x08, 0x06, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0,
  0xC0, 0x20, 0x60, 0x18, 0x30, 0x04, 0x18, 0x03, 0x0C, 0x00, 0x86, 0x00,
  0x63, 0x00, 0x11, 0x80, 0x0C, 0xC0, 0x02, 0x60, 0x01, 0xB0, 0x00, 0x58,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x00, 0x30, 0x00, 0x1F,
  0xF0, 0x03, 0x00, 0xC0, 0x30, 0x01, 0x03, 0x00, 0x0C, 0x10, 0x00, 0x21,
  0x80, 0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x36, 0x00, 0x00, 0xA0, 0x00,
  0x05, 0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02, 0xC0,
  0x00, 0x12, 0x00, 0x01, 0x90, 0x00, 0x08, 0xC0, 0x00, 0x42, 0x00, 0x04,
  0x08, 0x00, 0x60, 0x60, 0x06, 0x01, 0x80, 0x60, 0x03, 0xFE, 0x00, 0xFF,
  0xC2, 0x01, 0xC8, 0x01, 0xA0, 0x02, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xA0, 0x04, 0x80, 0x63, 0xFF, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00,
  0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF0,
  0x03, 0x00, 0xC0, 0x30, 0x01, 0x03, 0x00, 0x0C, 0x10, 0x00, 0x31, 0x80,
  0x00, 0x88, 0x00, 0x04, 0x40, 0x00, 0x36, 0x00, 0x00, 0xA0, 0x00, 0x05,
  0x00, 0x00, 0x28, 0x00, 0x01, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0A, 0x00, 0x00, 0x50, 0x00, 0x02, 0xC0, 0x00,
  0x12, 0x00, 0x01, 0x90, 0x00, 0x08, 0xC0, 0x00, 0x42, 0x00, 0x04, 0x08,
  0x00, 0x60, 0x60, 0x06, 0x01, 0x80, 0x60, 0x03, 0xFC, 0x00, 0x00, 0x40,
  0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0x80, 0xFF, 0xC0, 0x80, 0x70, 0x80,
  0x18, 0x80, 0x08, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80,
  0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x04, 0x80, 0x0C, 0x80, 0x08, 0x80,
  0x18, 0x80, 0x30, 0xFF, 0xC0, 0xFF, 0x00, 0x81, 0x80, 0x80, 0x80, 0x80,
  0xC0, 0x80, 0x40, 0x80, 0x60, 0x80, 0x20, 0x80, 0x30, 0x80, 0x10, 0x80,
  0x18, 0x80, 0x08, 0x80, 0x0C, 0x80, 0x04, 0x80, 0x06, 0x80, 0x03, 0x00,
  0xC0, 0x0F, 0xFC, 0x18, 0x02, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x40, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00,
  0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x00,
  0x0C, 0xC0, 0x18, 0x7F, 0xE0, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80,
  0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02,
  0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10, 0x00,
  0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40,
  0x00, 0x20, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01,
  0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x24, 0x00, 0x11, 0x00, 0x10, 0x60, 0x30, 0x1F, 0xF0, 0x80, 0x00, 0x38,
  0x00, 0x0D, 0x00, 0x01, 0x20, 0x00, 0x24, 0x00, 0x04, 0x40, 0x01, 0x88,
  0x00, 0x21, 0x00, 0x04, 0x30, 0x00, 0x82, 0x00, 0x20, 0x40, 0x04, 0x08,
  0x00, 0x81, 0x80, 0x30, 0x10, 0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x04,
  0x06, 0x00, 0x80, 0x80, 0x10, 0x10, 0x03, 0x06, 0x00, 0x20, 0x80, 0x04,
  0x10, 0x00, 0x82, 0x00, 0x18, 0xC0, 0x01, 0x10, 0x00, 0x22, 0x00, 0x04,
  0x40, 0x00, 0x50, 0x00, 0x0A, 0x00, 0x01, 0x40, 0x00, 0x38, 0x00, 0x02,
  0x00, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0A, 0x00, 0x0C, 0x00,
  0x16, 0x00, 0x18, 0x00, 0x64, 0x00, 0x78, 0x00, 0x88, 0x00, 0x90, 0x01,
  0x10, 0x01, 0x20, 0x02, 0x30, 0x02, 0x40, 0x0C, 0x20, 0x0C, 0x80, 0x18,
  0x40, 0x19, 0x80, 0x20, 0x80, 0x21, 0x00, 0x41, 0x00, 0x42, 0x00, 0x83,
  0x00, 0x84, 0x03, 0x02, 0x03, 0x0C, 0x04, 0x04, 0x04, 0x08, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x18, 0x10, 0x20, 0x60, 0x10, 0x20, 0x40, 0x80, 0x20,
  0xC0, 0xC1, 0x00, 0x41, 0x00, 0x82, 0x00, 0xC2, 0x01, 0x0C, 0x00, 0x84,
  0x02, 0x10, 0x01, 0x18, 0x06, 0x20, 0x02, 0x20, 0x04, 0x40, 0x06, 0x40,
  0x09, 0x80, 0x04, 0x80, 0x13, 0x00, 0x09, 0x00, 0x24, 0x00, 0x16, 0x00,
  0x68, 0x00, 0x28, 0x00, 0x50, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x60, 0x01,
  0x80, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0x90, 0x00, 0x84, 0x00, 0xC2,
  0x00, 0x41, 0x80, 0x60, 0x40, 0x20, 0x30, 0x30, 0x08, 0x10, 0x06, 0x08,
  0x01, 0x08, 0x00, 0x84, 0x00, 0x24, 0x00, 0x12, 0x00, 0x0F, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xB0, 0x00, 0x48, 0x00, 0x66, 0x00,
  0x21, 0x00, 0x30, 0x80, 0x10, 0x20, 0x18, 0x10, 0x08, 0x0C, 0x0C, 0x02,
  0x04, 0x01, 0x86, 0x00, 0x42, 0x00, 0x23, 0x00, 0x09, 0x00, 0x05, 0x80,
  0x03, 0xC0, 0x01, 0xA0, 0x00, 0x90, 0x00, 0xCC, 0x00, 0x42, 0x00, 0x21,
  0x00, 0x30, 0x40, 0x10, 0x20, 0x18, 0x18, 0x08, 0x04, 0x04, 0x02, 0x06,
  0x00, 0x82, 0x00, 0x41, 0x00, 0x31, 0x00, 0x08, 0x80, 0x04, 0xC0, 0x01,
  0x40, 0x00, 0xA0, 0x00, 0x60, 0x00, 0x10, 0x00, 0x08, 0x00, 0x04, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x80, 0x00, 0x40, 0x00, 0x20, 0x00, 0x10,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x01, 0x00, 0x7F, 0xFE, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x10, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x00, 0x01, 0x00, 0x02, 0x00, 0x02,
  0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0x10,
  0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0x80, 0x02, 0x00, 0x10, 0x00, 0x80, 0x02, 0x00,
  0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0xC0, 0x02, 0x00, 0x10, 0x00,
  0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x18, 0x00, 0x40, 0x02,
  0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0xFF, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x07, 0xFE, 0x00, 0x40, 0x00, 0x38, 0x00, 0x1A, 0x00, 0x04,
  0xC0, 0x03, 0x10, 0x00, 0x86, 0x00, 0x60, 0x80, 0x10, 0x30, 0x0C, 0x04,
  0x02, 0x01, 0x81, 0x80, 0x20, 0x40, 0x0C, 0x30, 0x01, 0x08, 0x00, 0x66,
  0x00, 0x09, 0x00, 0x02, 0xC0, 0x00, 0x40, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x1F, 0xC1, 0x81, 0x80, 0x04, 0x00, 0x30,
  0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x0F,
  0xD1, 0x80, 0xB0, 0x05, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0xA0, 0x15, 0x81, 0x27, 0xF1, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC7, 0xF0, 0xCC, 0x18, 0xD0, 0x0C, 0xE0, 0x04,
  0xE0, 0x02, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xE0, 0x02, 0xE0, 0x04, 0xD0, 0x0C,
  0x98, 0x18, 0x8F, 0xF0, 0x03, 0xF8, 0x70, 0x46, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x00, 0x08, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08,
  0x00, 0x40, 0x03, 0x00, 0x18, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x60, 0x20, 0xFF, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x01, 0x00, 0x01, 0x07, 0xE1, 0x0C, 0x19, 0x10, 0x0D, 0x20, 0x05, 0x20,
  0x07, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x03, 0x20, 0x05, 0x30, 0x0D, 0x18,
  0x19, 0x0F, 0xF1, 0x07, 0xE0, 0x18, 0x60, 0x40, 0x21, 0x00, 0x62, 0x00,
  0x48, 0x00, 0x90, 0x01, 0xA0, 0x01, 0x40, 0x03, 0x80, 0x07, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x10, 0x00, 0x30, 0x00, 0x60, 0x00, 0x40, 0x00, 0x80,
  0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x02, 0x00, 0x06, 0x01, 0x03, 0xFC,
  0x03, 0xF0, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0xFF, 0x80, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80,
  0x08, 0x00, 0x80, 0x07, 0xE1, 0x1C, 0x19, 0x10, 0x0D, 0x20, 0x05, 0x20,
  0x03, 0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0x40,
  0x03, 0x40, 0x03, 0x40, 0x03, 0x60, 0x05, 0x20, 0x05, 0x30, 0x09, 0x18,
  0x19, 0x0F, 0xF1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x02, 0x00, 0x02, 0x00, 0x04, 0x40, 0x0C, 0x78, 0x78, 0x0F,
  0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x7E, 0x33, 0x0C, 0xD0, 0x0B,
  0x80, 0x3E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x10, 0x7C, 0x00, 0x15, 0x55, 0x55, 0x55, 0x55, 0x55, 0x40, 0x04, 0x30,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x43, 0x0C, 0x29, 0xB8, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x05, 0x80, 0x6C, 0x02, 0x60, 0x23, 0x03, 0x18, 0x30, 0xC1, 0x06, 0x10,
  0x31, 0x81, 0x88, 0x0C, 0xC0, 0x6D, 0x03, 0x48, 0x1C, 0x20, 0xC1, 0x06,
  0x04, 0x30, 0x21, 0x80, 0x8C, 0x04, 0x60, 0x13, 0x00, 0x98, 0x02, 0xC0,
  0x16, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x87, 0xC0, 0xFC, 0x98, 0x21, 0x06, 0x90, 0x12, 0x02, 0xA0, 0x14, 0x01,
  0xA0, 0x1C, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01,
  0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01,
  0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01,
  0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01,
  0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01, 0xC0, 0x08, 0x01,
  0x87, 0xE2, 0x30, 0x69, 0x00, 0xA8, 0x03, 0xA0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x07, 0xF0, 0x0C, 0x18, 0x10, 0x0C,
  0x20, 0x06, 0x60, 0x02, 0x40, 0x02, 0x40, 0x03, 0x40, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x01, 0x40, 0x01, 0x40, 0x03, 0x40, 0x02, 0x60, 0x02, 0x20, 0x06,
  0x30, 0x04, 0x18, 0x18, 0x0F, 0xF0, 0x87, 0xF0, 0x8C, 0x18, 0x90, 0x0C,
  0xB0, 0x04, 0xA0, 0x02, 0xA0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xE0, 0x02, 0xE0, 0x04,
  0xD0, 0x0C, 0xD8, 0x18, 0xC7, 0xF0, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x07, 0xE1, 0x0C, 0x19, 0x10, 0x09, 0x20, 0x05, 0x20, 0x05,
  0x40, 0x03, 0x40, 0x03, 0x40, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x40, 0x03, 0x40, 0x03, 0x60, 0x05, 0x20, 0x05, 0x30, 0x09, 0x18, 0x19,
  0x0F, 0xE1, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01,
  0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x87, 0xE2,
  0x19, 0x03, 0xC0, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x1F, 0xE3, 0x03, 0x40, 0x0C, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x40, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10,
  0x03, 0x80, 0x67, 0xFC, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x83, 0xFE,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x02, 0x01,
  0x00, 0x7C, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0xD0,
  0x03, 0x40, 0x15, 0x80, 0x53, 0x06, 0x47, 0xF1, 0x80, 0x02, 0x80, 0x0D,
  0x00, 0x12, 0x00, 0x26, 0x00, 0xC4, 0x01, 0x08, 0x02, 0x10, 0x04, 0x30,
  0x18, 0x20, 0x20, 0x40, 0x40, 0xC1, 0x80, 0x82, 0x01, 0x04, 0x02, 0x08,
  0x06, 0x30, 0x04, 0x40, 0x08, 0x80, 0x13, 0x00, 0x14, 0x00, 0x28, 0x00,
  0x50, 0x00, 0xE0, 0x00, 0x80, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x18, 0x02, 0x80, 0x38, 0x02, 0x40, 0x2C, 0x02, 0x40, 0x24, 0x06, 0x40,
  0x24, 0x04, 0x40, 0x64, 0x04, 0x20, 0x46, 0x04, 0x20, 0x42, 0x04, 0x20,
  0x42, 0x08, 0x20, 0xC2, 0x08, 0x10, 0x82, 0x08, 0x10, 0x81, 0x08, 0x10,
  0x81, 0x18, 0x11, 0x81, 0x10, 0x19, 0x01, 0x10, 0x09, 0x00, 0x90, 0x09,
  0x00, 0xB0, 0x0B, 0x00, 0xA0, 0x0E, 0x00, 0xA0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x40, 0xC0, 0x05, 0x00, 0x26, 0x00, 0x88, 0x04,
  0x10, 0x10, 0x40, 0x80, 0x86, 0x02, 0x10, 0x04, 0xC0, 0x1A, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0A, 0x00, 0x48, 0x03, 0x10, 0x08, 0x40, 0x60,
  0x81, 0x03, 0x0C, 0x04, 0x20, 0x19, 0x80, 0x24, 0x00, 0xE0, 0x01, 0x40,
  0x02, 0x80, 0x05, 0x80, 0x09, 0x00, 0x32, 0x00, 0x44, 0x00, 0x84, 0x03,
  0x08, 0x04, 0x10, 0x08, 0x30, 0x10, 0x20, 0x40, 0x40, 0x80, 0x81, 0x00,
  0x86, 0x01, 0x08, 0x02, 0x10, 0x06, 0x20, 0x04, 0x80, 0x09, 0x00, 0x12,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x18, 0x00, 0x20, 0x00, 0x40, 0x01, 0x80, 0x02, 0x00, 0x0C,
  0x01, 0x30, 0x03, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0x00, 0x20, 0x02, 0x00,
  0x40, 0x04, 0x00, 0x80, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x00, 0x10, 0x02, 0x00, 0x20,
  0x04, 0x00, 0x40, 0x0F, 0xFF, 0x00, 0xE0, 0x60, 0x18, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x70, 0x01, 0x80, 0x10, 0x03,
  0x00, 0x60, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x06, 0x00, 0x38, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x03, 0x00, 0x10, 0x03, 0x00, 0x60,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x02, 0x00, 0x60, 0x06, 0x00, 0x30, 0x18, 0x06, 0x00,
  0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x30, 0x3C, 0x00, 0x3C,
  0x00, 0x33, 0x80, 0x60, 0x30, 0xD0, 0x07, 0x80,
};

const GFXglyph NotoSans_Condensed_Thin45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 32, 9, 3, -32 },
  { 13, 8, 11, 14, 3, -32 },
  { 24, 20, 32, 22, 1, -32 },
  { 104, 16, 37, 20, 2, -34 },
  { 178, 25, 33, 29, 2, -33 },
  { 282, 19, 33, 22, 2, -33 },
  { 361, 1, 11, 7, 3, -32 },
  { 363, 8, 39, 12, 2, -32 },
  { 402, 8, 39, 12, 2, -32 },
  { 441, 14, 13, 18, 2, -34 },
  { 464, 17, 20, 20, 2, -26 },
  { 507, 3, 11, 8, 2, -5 },
  { 512, 10, 1, 13, 1, -13 },
  { 514, 2, 3, 9, 3, -3 },
  { 515, 13, 32, 15, 1, -32 },
  { 567, 16, 33, 20, 2, -33 },
  { 633, 8, 32, 20, 4, -32 },
  { 665, 16, 33, 20, 2, -33 },
  { 731, 15, 33, 20, 2, -33 },
  { 793, 19, 32, 20, 1, -32 },
  { 869, 15, 32, 20, 3, -32 },
  { 929, 16, 33, 20, 2, -32 },
  { 995, 16, 32, 20, 2, -32 },
  { 1059, 16, 33, 20, 2, -33 },
  { 1125, 16, 34, 20, 2, -33 },
  { 1193, 2, 24, 9, 3, -24 },
  { 1199, 4, 30, 9, 2, -24 },
  { 1214, 17, 18, 20, 2, -25 },
  { 1253, 17, 10, 20, 2, -21 },
  { 1275, 17, 18, 20, 2, -25 },
  { 1314, 12, 33, 14, 1, -33 },
  { 1364, 27, 36, 31, 2, -32 },
  { 1486, 20, 32, 20, 0, -32 },
  { 1566, 16, 32, 22, 4, -32 },
  { 1630, 17, 33, 21, 3, -33 },
  { 1701, 18, 32, 24, 4, -32 },
  { 1773, 13, 32, 19, 4, -32 },
  { 1825, 13, 32, 18, 4, -32 },
  { 1877, 20, 33, 26, 3, -33 },
  { 1960, 17, 32, 25, 4, -32 },
  { 2028, 7, 32, 11, 2, -32 },
  { 2056, 8, 40, 9, -3, -32 },
  { 2096, 15, 32, 19, 4, -32 },
  { 2156, 13, 32, 18, 4, -32 },
  { 2208, 24, 32, 32, 4, -32 },
  { 2304, 17, 32, 25, 4, -32 },
  { 2372, 21, 33, 26, 3, -33 },
  { 2459, 14, 32, 20, 4, -32 },
  { 2515, 21, 41, 26, 3, -33 },
  { 2623, 16, 32, 21, 4, -32 },
  { 2687, 16, 33, 20, 2, -33 },
  { 2753, 17, 32, 17, 0, -32 },
  { 2821, 17, 32, 25, 4, -32 },
  { 2889, 19, 32, 19, 0, -32 },
  { 2965, 31, 32, 32, 1, -32 },
  { 3089, 17, 32, 17, 0, -32 },
  { 3157, 17, 32, 17, 0, -32 },
  { 3225, 16, 32, 18, 1, -32 },
  { 3289, 8, 39, 14, 4, -32 },
  { 3328, 13, 32, 15, 1, -32 },
  { 3380, 9, 39, 14, 1, -32 },
  { 3424, 18, 17, 20, 1, -32 },
  { 3463, 18, 1, 18, 0, 4 },
  { 3466, 7, 7, 10, 2, -34 },
  { 3473, 13, 24, 18, 2, -24 },
  { 3512, 16, 34, 21, 3, -34 },
  { 3580, 13, 24, 16, 2, -24 },
  { 3619, 16, 34, 21, 2, -34 },
  { 3687, 15, 24, 19, 2, -24 },
  { 3732, 12, 34, 10, 0, -34 },
  { 3783, 16, 35, 21, 2, -24 },
  { 3853, 14, 34, 21, 3, -34 },
  { 3913, 2, 33, 8, 3, -33 },
  { 3922, 6, 44, 8, -1, -33 },
  { 3955, 13, 34, 16, 3, -34 },
  { 4011, 2, 34, 8, 3, -34 },
  { 4020, 24, 24, 31, 3, -24 },
  { 4092, 14, 24, 21, 3, -24 },
  { 4134, 16, 24, 20, 2, -24 },
  { 4182, 16, 34, 21, 3, -24 },
  { 4250, 16, 34, 21, 2, -24 },
  { 4318, 10, 24, 13, 3, -24 },
  { 4348, 12, 24, 16, 2, -24 },
  { 4384, 9, 30, 11, 1, -30 },
  { 4418, 14, 24, 21, 3, -24 },
  { 4460, 15, 24, 15, 0, -24 },
  { 4505, 24, 24, 25, 1, -24 },
  { 4577, 14, 24, 16, 1, -24 },
  { 4619, 15, 35, 16, 0, -24 },
  { 4685, 12, 24, 14, 1, -24 },
  { 4721, 11, 39, 15, 2, -32 },
  { 4775, 1, 45, 19, 9, -34 },
  { 4781, 11, 39, 15, 2, -32 },
  { 4835, 17, 4, 20, 2, -18 },
};

const GFXfont NotoSans_Condensed_Thin45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_THIN45PT7B_H_
