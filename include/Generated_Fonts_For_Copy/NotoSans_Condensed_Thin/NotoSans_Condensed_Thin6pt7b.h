#ifndef _NOTOSANS_CONDENSED_THIN6PT7B_H_
#define _NOTOSANS_CONDENSED_THIN6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0x80, 0x57, 0xE0, 0x69, 0xC0, 0xEE, 0x57, 0xCB, 0xF0, 0x80,
  0xF8, 0xF8, 0x70, 0x74, 0xC0, 0xC0, 0x80, 0x5A, 0xFF, 0xD5, 0xD7, 0xD7,
  0x5B, 0xA0, 0xF7, 0xFF, 0xD5, 0xFF, 0xF7, 0xA0, 0xB0, 0xD0, 0xF0, 0xF0,
  0xD8, 0xFF, 0xF8, 0x60, 0x5A, 0xD0, 0xEE, 0xF2, 0x70, 0xFE, 0xF0, 0xF0,
  0xF2, 0xF0, 0xFF, 0xF0, 0xF8, 0xEB, 0xF0, 0xBF, 0xD0, 0xFF, 0xF6, 0xF0,
  0xF0, 0xF6, 0xF2, 0xAB, 0xE7, 0xD5, 0xB6, 0xF0, 0xBB, 0x20, 0xDB, 0x56,
  0xD7, 0xD5, 0xDB, 0xF8, 0xA5, 0xF8, 0xD4, 0xC0, 0x80, 0xFC, 0x9A, 0xDE,
  0xEC, 0x5F, 0xC0, 0xEC, 0x6A, 0x80, 0xFF, 0xAF, 0xC0, 0xF0, 0xF8, 0xAE,
  0xC0, 0xF8, 0xFB, 0xB0, 0xFC, 0xFC, 0xF7, 0xC0, 0xFD, 0xE8, 0xDC, 0xF0,
  0xFC, 0xF8, 0xF6, 0x80, 0xDC, 0xDA, 0xEC, 0xEA, 0x40, 0xFC, 0xD5, 0xC0,
  0xC0,
};

const GFXglyph NotoSans_Condensed_Thin6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 1, 1, 2, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 2, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 1, 5, 2, 0, -4 },
  { 13, 1, 5, 2, 0, -4 },
  { 14, 2, 2, 2, 0, -5 },
  { 15, 2, 3, 3, 0, -4 },
  { 16, 1, 2, 1, 0, -1 },
  { 17, 2, 1, 2, 0, -2 },
  { 18, 1, 1, 1, 0, -1 },
  { 19, 2, 4, 2, 0, -4 },
  { 20, 2, 4, 3, 0, -4 },
  { 21, 2, 4, 3, 0, -4 },
  { 22, 2, 4, 3, 0, -4 },
  { 23, 2, 4, 3, 0, -4 },
  { 24, 3, 4, 3, 0, -4 },
  { 26, 2, 4, 3, 0, -4 },
  { 27, 2, 4, 3, 0, -4 },
  { 28, 2, 4, 3, 0, -4 },
  { 29, 2, 4, 3, 0, -4 },
  { 30, 2, 4, 3, 0, -4 },
  { 31, 1, 3, 1, 0, -3 },
  { 32, 1, 4, 1, 0, -3 },
  { 33, 2, 2, 3, 0, -3 },
  { 34, 2, 2, 3, 0, -3 },
  { 35, 2, 2, 3, 0, -3 },
  { 36, 2, 4, 2, 0, -4 },
  { 37, 4, 5, 4, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 2, 4, 3, 1, -4 },
  { 43, 3, 4, 3, 0, -4 },
  { 45, 2, 4, 3, 1, -4 },
  { 46, 1, 4, 3, 1, -4 },
  { 47, 1, 4, 2, 1, -4 },
  { 48, 3, 4, 3, 0, -4 },
  { 50, 2, 4, 3, 1, -4 },
  { 51, 1, 4, 1, 0, -4 },
  { 52, 1, 5, 1, 0, -4 },
  { 53, 2, 4, 3, 1, -4 },
  { 54, 1, 4, 2, 1, -4 },
  { 55, 3, 4, 4, 1, -4 },
  { 57, 2, 4, 3, 1, -4 },
  { 58, 3, 4, 4, 0, -4 },
  { 60, 1, 4, 3, 1, -4 },
  { 61, 3, 5, 4, 0, -4 },
  { 63, 2, 4, 3, 1, -4 },
  { 64, 2, 4, 3, 0, -4 },
  { 65, 2, 4, 2, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 3, 4, 3, 0, -4 },
  { 70, 4, 4, 4, 0, -4 },
  { 72, 2, 4, 2, 0, -4 },
  { 73, 2, 4, 2, 0, -4 },
  { 74, 2, 4, 2, 0, -4 },
  { 75, 1, 5, 2, 1, -4 },
  { 76, 2, 4, 2, 0, -4 },
  { 77, 1, 5, 2, 0, -4 },
  { 78, 3, 2, 3, 0, -4 },
  { 79, 2, 1, 2, 0, 0 },
  { 80, 1, 1, 1, 0, -5 },
  { 81, 2, 3, 2, 0, -3 },
  { 82, 3, 5, 3, 0, -5 },
  { 84, 2, 3, 2, 0, -3 },
  { 85, 2, 5, 3, 0, -5 },
  { 87, 2, 3, 3, 0, -3 },
  { 88, 2, 5, 1, 0, -5 },
  { 90, 2, 4, 3, 0, -3 },
  { 91, 2, 5, 3, 0, -5 },
  { 93, 1, 4, 1, 0, -4 },
  { 94, 1, 5, 1, 0, -4 },
  { 95, 2, 5, 2, 0, -5 },
  { 97, 1, 5, 1, 0, -5 },
  { 98, 4, 3, 4, 0, -3 },
  { 100, 2, 3, 3, 0, -3 },
  { 101, 2, 3, 3, 0, -3 },
  { 102, 3, 4, 3, 0, -3 },
  { 104, 2, 4, 3, 0, -3 },
  { 105, 2, 3, 2, 0, -3 },
  { 106, 2, 3, 2, 0, -3 },
  { 107, 1, 4, 1, 0, -4 },
  { 108, 2, 3, 3, 0, -3 },
  { 109, 2, 3, 2, 0, -3 },
  { 110, 3, 3, 3, 0, -3 },
  { 112, 2, 3, 2, 0, -3 },
  { 113, 2, 4, 2, 0, -3 },
  { 114, 2, 3, 2, 0, -3 },
  { 115, 2, 5, 2, 0, -4 },
  { 117, 1, 6, 3, 1, -5 },
  { 118, 2, 5, 2, 0, -4 },
  { 120, 2, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_Thin6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin6pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_CONDENSED_THIN6PT7B_H_
