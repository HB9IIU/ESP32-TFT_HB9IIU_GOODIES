#ifndef _NOTOSANS_CONDENSED_THIN67PT7B_H_
#define _NOTOSANS_CONDENSED_THIN67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin67pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00, 0xEE,
  0xFE, 0xE0, 0x36, 0x03, 0x60, 0x36, 0x03, 0x60, 0x34, 0x03, 0x40, 0x34,
  0x03, 0x40, 0x34, 0x03, 0x40, 0x24, 0x02, 0x40, 0x24, 0x02, 0x40, 0x24,
  0x02, 0x40, 0x20, 0x00, 0x0C, 0x00, 0x80, 0x00, 0x20, 0x06, 0x00, 0x00,
  0x80, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60,
  0x04, 0x00, 0x01, 0x80, 0x10, 0x00, 0x06, 0x00, 0x40, 0x00, 0x10, 0x03,
  0x00, 0x00, 0x40, 0x0C, 0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0,
  0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x08, 0x00, 0x03, 0x00, 0x20, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x20, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06,
  0x00, 0x60, 0x00, 0x18, 0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80,
  0x10, 0x00, 0x04, 0x00, 0x40, 0x00, 0x10, 0x03, 0x00, 0x00, 0xC0, 0x0C,
  0x00, 0x03, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00,
  0x00, 0xC0, 0x08, 0x00, 0x03, 0x00, 0x20, 0x00, 0x08, 0x00, 0x80, 0x3F,
  0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x60, 0x06, 0x00, 0x01, 0x80, 0x10, 0x00, 0x04, 0x00,
  0x40, 0x00, 0x10, 0x03, 0x00, 0x00, 0x40, 0x0C, 0x00, 0x03, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x00, 0xC0, 0x08, 0x00,
  0x02, 0x00, 0x20, 0x00, 0x08, 0x01, 0x80, 0x00, 0x20, 0x06, 0x00, 0x01,
  0x80, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0xFE, 0xFE, 0x07, 0x0C, 0x0E, 0x1C,
  0x18, 0x04, 0x30, 0x30, 0x00, 0xC0, 0x60, 0x03, 0x00, 0xC0, 0x06, 0x01,
  0x80, 0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x30, 0x0C, 0x00, 0x60, 0x18,
  0x00, 0xC0, 0x30, 0x01, 0x80, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x01, 0x80,
  0x06, 0x03, 0x00, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x07, 0x18, 0x00,
  0x07, 0xB0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0x78, 0x00, 0x06, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x1C, 0x00,
  0x30, 0x1C, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x60, 0x03, 0x00,
  0xC0, 0x06, 0x03, 0x30, 0x0C, 0x1C, 0x7E, 0x18, 0xF0, 0x3F, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0x80, 0x1C, 0x30, 0x00, 0x30, 0x01, 0x81, 0x80, 0x03, 0x00,
  0x30, 0x18, 0x00, 0x20, 0x02, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x08, 0x00, 0x40, 0x06, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x18, 0x00,
  0xC0, 0x06, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x06, 0x02,
  0x00, 0x0C, 0x00, 0x60, 0x60, 0x00, 0xC0, 0x06, 0x06, 0x00, 0x0C, 0x00,
  0x60, 0xC0, 0x00, 0xC0, 0x06, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x80, 0x00,
  0x40, 0x06, 0x18, 0x3F, 0x04, 0x00, 0x41, 0x86, 0x18, 0x60, 0x04, 0x10,
  0xC0, 0xC6, 0x00, 0xC3, 0x0C, 0x06, 0x60, 0x0C, 0x21, 0x80, 0x62, 0x00,
  0xC6, 0x18, 0x02, 0x30, 0x18, 0x61, 0x00, 0x31, 0x81, 0x84, 0x30, 0x03,
  0x1C, 0x70, 0xC3, 0x00, 0x30, 0xFE, 0x0C, 0x30, 0x03, 0x01, 0x01, 0x83,
  0x00, 0x10, 0x00, 0x18, 0x30, 0x01, 0x00, 0x01, 0x03, 0x00, 0x10, 0x00,
  0x30, 0x30, 0x01, 0x00, 0x03, 0x03, 0x00, 0x10, 0x00, 0x60, 0x30, 0x01,
  0x00, 0x06, 0x03, 0x00, 0x10, 0x00, 0x40, 0x30, 0x01, 0x00, 0x0C, 0x03,
  0x00, 0x10, 0x00, 0xC0, 0x30, 0x03, 0x00, 0x18, 0x03, 0x00, 0x30, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x18, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x60, 0x06, 0x00, 0x08, 0x06, 0x00, 0x60, 0x00,
  0xC0, 0xC0, 0x04, 0x00, 0x06, 0x1C, 0x00, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x30, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x40, 0x0C, 0x00,
  0x0C, 0x00, 0x40, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0,
  0x06, 0x00, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x06, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0xC0, 0x04, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x60, 0x0C, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x20, 0x18, 0x00, 0x03, 0x03, 0x00, 0x00, 0x18, 0x70,
  0x00, 0x01, 0x8E, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xB0, 0x00, 0x00, 0x73, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x04, 0x00, 0x23, 0x00, 0x60, 0x06,
  0x60, 0x03, 0x00, 0x66, 0x00, 0x18, 0x06, 0xC0, 0x01, 0x80, 0x6C, 0x00,
  0x0C, 0x04, 0xC0, 0x00, 0x60, 0xCC, 0x00, 0x06, 0x0C, 0xC0, 0x00, 0x30,
  0x88, 0x00, 0x01, 0x98, 0xC0, 0x00, 0x19, 0x0C, 0x00, 0x00, 0xF0, 0xC0,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x0F, 0x06, 0x00, 0x01,
  0x98, 0x60, 0x00, 0x38, 0x83, 0x00, 0x07, 0x0C, 0x18, 0x00, 0xE0, 0x60,
  0xE0, 0x38, 0x02, 0x07, 0xFF, 0x00, 0x30, 0x07, 0x00, 0x00, 0xED, 0xB6,
  0xD2, 0x49, 0x24, 0x92, 0x40, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x00, 0x00, 0x20, 0x00, 0x02,
  0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x0E, 0x02, 0x03, 0x78, 0x21, 0xE0, 0x72, 0x70, 0x01, 0xF8, 0x00,
  0x07, 0x00, 0x00, 0x50, 0x00, 0x08, 0x80, 0x01, 0x8C, 0x00, 0x30, 0x60,
  0x06, 0x03, 0x00, 0x40, 0x10, 0x0C, 0x01, 0x81, 0x80, 0x0C, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0xC6, 0x33, 0x18, 0xC6, 0x23, 0x18, 0xCC, 0x62,
  0x10, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x18,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0x0F, 0x00, 0x38, 0x07, 0x00, 0x60, 0x07, 0x01, 0x80, 0x06,
  0x06, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x08, 0x60, 0x00, 0x18,
  0xC0, 0x00, 0x31, 0x80, 0x00, 0x62, 0x00, 0x00, 0x4C, 0x00, 0x00, 0xD8,
  0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x00,
  0x00, 0x1A, 0x00, 0x00, 0x34, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x01,
  0xA0, 0x00, 0x03, 0x60, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x64, 0x00, 0x00, 0x8C, 0x00, 0x03, 0x18,
  0x00, 0x06, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x10, 0x60, 0x00, 0x60, 0x60,
  0x00, 0xC0, 0xC0, 0x03, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x38, 0x00, 0xE1,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x30, 0x07, 0x01, 0xF0, 0x3B, 0x07, 0x30,
  0xC3, 0x18, 0x37, 0x03, 0xE0, 0x3C, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00, 0x07, 0xFE, 0x00, 0x7C, 0x1E,
  0x01, 0xC0, 0x07, 0x06, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x20, 0x00, 0x0F, 0xFE, 0x00, 0x7C, 0x1F, 0x03, 0xC0, 0x07,
  0x0E, 0x00, 0x07, 0x10, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x06, 0x30, 0x00, 0x38, 0x7C, 0x01, 0xE0, 0x3F, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x06, 0x80, 0x00, 0x00, 0x68, 0x00, 0x00, 0x0C, 0x80, 0x00, 0x00,
  0xC8, 0x00, 0x00, 0x18, 0x80, 0x00, 0x01, 0x88, 0x00, 0x00, 0x30, 0x80,
  0x00, 0x02, 0x08, 0x00, 0x00, 0x60, 0x80, 0x00, 0x0C, 0x08, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x18, 0x08, 0x00, 0x01, 0x80, 0x80, 0x00, 0x30, 0x08,
  0x00, 0x03, 0x00, 0x80, 0x00, 0x60, 0x08, 0x00, 0x0C, 0x00, 0x80, 0x00,
  0xC0, 0x08, 0x00, 0x18, 0x00, 0x80, 0x01, 0x80, 0x08, 0x00, 0x30, 0x00,
  0x80, 0x03, 0x00, 0x08, 0x00, 0x60, 0x00, 0x80, 0x04, 0x00, 0x08, 0x00,
  0xC0, 0x00, 0x80, 0x18, 0x00, 0x08, 0x01, 0x80, 0x00, 0x80, 0x30, 0x00,
  0x08, 0x03, 0x00, 0x00, 0x80, 0x60, 0x00, 0x08, 0x06, 0x00, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x80, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x40, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x05, 0xFF,
  0xF0, 0x0F, 0xC0, 0xF0, 0x10, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x88, 0x00, 0x0E, 0x18, 0x00,
  0x38, 0x3E, 0x03, 0xE0, 0x1F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x01, 0xF0, 0xE0, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x0F, 0xF8, 0x0C, 0x3E, 0x7C, 0x19, 0xC0,
  0x1C, 0x37, 0x00, 0x0C, 0x48, 0x00, 0x08, 0xB0, 0x00, 0x19, 0x40, 0x00,
  0x13, 0x80, 0x00, 0x36, 0x00, 0x00, 0x6C, 0x00, 0x00, 0xD8, 0x00, 0x00,
  0xB0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x68, 0x00, 0x00, 0x90,
  0x00, 0x03, 0x30, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x40, 0x00, 0x10, 0xC0,
  0x00, 0x60, 0xC0, 0x00, 0x81, 0x80, 0x03, 0x01, 0x80, 0x0C, 0x01, 0xC0,
  0x70, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x07, 0xC3, 0xE0, 0x0E, 0x00, 0x70, 0x1C, 0x00,
  0x38, 0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00,
  0x04, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00,
  0x06, 0x60, 0x00, 0x04, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x03, 0x01,
  0xC0, 0x01, 0xC3, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xC3, 0x80, 0x07, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x1C, 0x00,
  0x30, 0x38, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x0E, 0x60, 0x00,
  0x06, 0xC0, 0x00, 0x06, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x0C, 0x30, 0x00,
  0x0C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x07, 0x01, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x1E, 0x1E,
  0x00, 0x60, 0x06, 0x01, 0x80, 0x06, 0x06, 0x00, 0x06, 0x0C, 0x00, 0x04,
  0x30, 0x00, 0x0C, 0x60, 0x00, 0x18, 0xC0, 0x00, 0x1B, 0x00, 0x00, 0x36,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x58, 0x00, 0x00, 0xB0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xD8, 0x00, 0x03, 0xB0, 0x00,
  0x07, 0x60, 0x00, 0x1E, 0x60, 0x00, 0x2C, 0x60, 0x00, 0xD8, 0xE0, 0x07,
  0x30, 0xF0, 0x3C, 0x60, 0x7F, 0xE0, 0xC0, 0x0C, 0x01, 0x80, 0x00, 0x02,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x18, 0x0F, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x5F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x19, 0xCE, 0x71, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x63, 0x39, 0x8C, 0x63, 0x31, 0x8C, 0x46, 0x31, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x00, 0x1F, 0xF8, 0x3C, 0x1E, 0x18,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x60,
  0x03, 0x80, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0x00, 0x60, 0x18, 0x00,
  0x00, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x00, 0x01,
  0x83, 0x00, 0x00, 0x00, 0x01, 0x86, 0x00, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x1F, 0xF0, 0x06, 0x30, 0x00, 0xF9, 0xF0, 0x04, 0x60, 0x03, 0x80, 0x40,
  0x0C, 0xC0, 0x0E, 0x00, 0x80, 0x1B, 0x00, 0x18, 0x01, 0x00, 0x36, 0x00,
  0x60, 0x02, 0x00, 0x6C, 0x00, 0xC0, 0x0C, 0x00, 0x58, 0x03, 0x00, 0x18,
  0x00, 0xB0, 0x06, 0x00, 0x30, 0x01, 0x60, 0x0C, 0x00, 0x60, 0x03, 0xC0,
  0x18, 0x00, 0xC0, 0x07, 0x00, 0x20, 0x01, 0x80, 0x0E, 0x00, 0xC0, 0x03,
  0x00, 0x1C, 0x01, 0x80, 0x06, 0x00, 0x28, 0x03, 0x00, 0x0C, 0x00, 0x50,
  0x06, 0x00, 0x18, 0x01, 0xA0, 0x0C, 0x00, 0x30, 0x03, 0x40, 0x08, 0x00,
  0x60, 0x06, 0x80, 0x10, 0x01, 0xC0, 0x0D, 0x80, 0x30, 0x03, 0x80, 0x1B,
  0x00, 0x60, 0x05, 0x00, 0x66, 0x00, 0xC0, 0x1A, 0x00, 0xCC, 0x00, 0xC0,
  0x36, 0x03, 0x18, 0x01, 0x80, 0xCC, 0x06, 0x10, 0x01, 0xC3, 0x0E, 0x38,
  0x30, 0x01, 0xFC, 0x0F, 0xE0, 0x60, 0x00, 0xC0, 0x02, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x07,
  0x80, 0x03, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0B, 0x00, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x06, 0x40, 0x00,
  0x00, 0x23, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x18, 0x40, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x04, 0x18, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x03, 0x02,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x80, 0xC0, 0x00, 0x0C, 0x06, 0x00,
  0x00, 0x60, 0x18, 0x00, 0x02, 0x00, 0xC0, 0x00, 0x30, 0x06, 0x00, 0x01,
  0x80, 0x10, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x40, 0x06, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0xF0, 0x03,
  0x00, 0x01, 0x80, 0x18, 0x00, 0x04, 0x00, 0xC0, 0x00, 0x30, 0x0C, 0x00,
  0x01, 0x80, 0x60, 0x00, 0x0C, 0x03, 0x00, 0x00, 0x30, 0x10, 0x00, 0x01,
  0x81, 0x80, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x20, 0x60, 0x00, 0x01, 0x86,
  0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x61, 0x80, 0x00, 0x01, 0x08, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x00, 0x66, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x80, 0x01, 0xE0, 0x80, 0x00, 0x70, 0x80, 0x00, 0x38, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80, 0x00, 0x04, 0x80,
  0x00, 0x04, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x18, 0x80, 0x00, 0x18, 0x80, 0x00, 0x30, 0x80, 0x00, 0xE0, 0x80,
  0x03, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0xE0, 0x80,
  0x00, 0x30, 0x80, 0x00, 0x18, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80,
  0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x02, 0x80,
  0x00, 0x02, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80, 0x00, 0x06, 0x80,
  0x00, 0x0C, 0x80, 0x00, 0x0C, 0x80, 0x00, 0x18, 0x80, 0x00, 0x70, 0x80,
  0x01, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x03, 0xFF, 0xC0, 0x03, 0xE0, 0x7C, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x00, 0x04, 0x01, 0xE0, 0x0F, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7C, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x08, 0x00, 0x3C,
  0x02, 0x00, 0x03, 0x80, 0x80, 0x00, 0x38, 0x20, 0x00, 0x06, 0x08, 0x00,
  0x00, 0xC2, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06, 0x20, 0x00, 0x00, 0xC8,
  0x00, 0x00, 0x32, 0x00, 0x00, 0x06, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00,
  0x68, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0x68, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x06,
  0x80, 0x00, 0x01, 0x20, 0x00, 0x00, 0xC8, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x18, 0x80, 0x00, 0x06, 0x20, 0x00, 0x03, 0x08, 0x00, 0x01, 0x82, 0x00,
  0x00, 0xC0, 0x80, 0x00, 0xE0, 0x20, 0x00, 0xF0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00,
  0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE,
  0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01,
  0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04,
  0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40,
  0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xF8, 0x07, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x80, 0x70,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0x0D, 0x80, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x36, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x98, 0x00,
  0x00, 0x03, 0x18, 0x00, 0x00, 0x06, 0x18, 0x00, 0x00, 0x0C, 0x30, 0x00,
  0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x38, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x7E, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF,
  0xDF, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0xC8, 0x1C, 0xFF, 0x83, 0xC0, 0x80, 0x00, 0x0D, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x64, 0x00, 0x01, 0x88, 0x00, 0x06, 0x10, 0x00, 0x1C, 0x20, 0x00,
  0x30, 0x40, 0x00, 0xC0, 0x80, 0x03, 0x01, 0x00, 0x0E, 0x02, 0x00, 0x18,
  0x04, 0x00, 0x60, 0x08, 0x01, 0xC0, 0x10, 0x03, 0x00, 0x20, 0x0C, 0x00,
  0x40, 0x30, 0x00, 0x80, 0xE0, 0x01, 0x01, 0x80, 0x02, 0x06, 0x00, 0x04,
  0x1C, 0x00, 0x08, 0x70, 0x00, 0x10, 0xE0, 0x00, 0x23, 0x60, 0x00, 0x4E,
  0xC0, 0x00, 0x98, 0xC0, 0x01, 0x61, 0x80, 0x03, 0x81, 0x80, 0x07, 0x03,
  0x00, 0x0C, 0x03, 0x00, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40, 0x06,
  0x00, 0x80, 0x0C, 0x01, 0x00, 0x0C, 0x02, 0x00, 0x18, 0x04, 0x00, 0x18,
  0x08, 0x00, 0x18, 0x10, 0x00, 0x30, 0x20, 0x00, 0x30, 0x40, 0x00, 0x60,
  0x80, 0x00, 0x61, 0x00, 0x00, 0xC2, 0x00, 0x00, 0xC4, 0x00, 0x01, 0x88,
  0x00, 0x01, 0x90, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x80,
  0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00,
  0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00,
  0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00,
  0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00,
  0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00,
  0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00,
  0x04, 0x00, 0x00, 0x80, 0x00, 0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00,
  0x08, 0x00, 0x01, 0x00, 0x00, 0x20, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00,
  0x10, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x08, 0x00, 0x01, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFB, 0x00, 0x00, 0x00, 0x0F, 0xB0,
  0x00, 0x00, 0x00, 0xBB, 0x00, 0x00, 0x00, 0x1B, 0x90, 0x00, 0x00, 0x01,
  0xB9, 0x80, 0x00, 0x00, 0x13, 0x98, 0x00, 0x00, 0x03, 0x38, 0xC0, 0x00,
  0x00, 0x33, 0x8C, 0x00, 0x00, 0x02, 0x38, 0xC0, 0x00, 0x00, 0x63, 0x86,
  0x00, 0x00, 0x06, 0x38, 0x60, 0x00, 0x00, 0x43, 0x86, 0x00, 0x00, 0x0C,
  0x38, 0x30, 0x00, 0x00, 0xC3, 0x83, 0x00, 0x00, 0x18, 0x38, 0x30, 0x00,
  0x01, 0x83, 0x81, 0x80, 0x00, 0x18, 0x38, 0x18, 0x00, 0x03, 0x03, 0x81,
  0x80, 0x00, 0x30, 0x38, 0x0C, 0x00, 0x03, 0x03, 0x80, 0xC0, 0x00, 0x60,
  0x38, 0x0C, 0x00, 0x06, 0x03, 0x80, 0x60, 0x00, 0x60, 0x38, 0x06, 0x00,
  0x0C, 0x03, 0x80, 0x60, 0x00, 0xC0, 0x38, 0x03, 0x00, 0x0C, 0x03, 0x80,
  0x30, 0x01, 0x80, 0x38, 0x03, 0x00, 0x18, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x38, 0x01, 0x80, 0x30, 0x03, 0x80, 0x18, 0x03, 0x00, 0x38, 0x00, 0xC0,
  0x30, 0x03, 0x80, 0x0C, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x60, 0x03, 0x80,
  0x06, 0x06, 0x00, 0x38, 0x00, 0x60, 0xC0, 0x03, 0x80, 0x06, 0x0C, 0x00,
  0x38, 0x00, 0x30, 0xC0, 0x03, 0x80, 0x03, 0x18, 0x00, 0x38, 0x00, 0x31,
  0x80, 0x03, 0x80, 0x01, 0x98, 0x00, 0x38, 0x00, 0x1B, 0x00, 0x03, 0x80,
  0x01, 0xB0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xB0, 0x00, 0x00, 0xEC, 0x00, 0x00,
  0x39, 0x80, 0x00, 0x0E, 0x60, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xE3, 0x00,
  0x00, 0x38, 0x60, 0x00, 0x0E, 0x18, 0x00, 0x03, 0x83, 0x00, 0x00, 0xE0,
  0xC0, 0x00, 0x38, 0x18, 0x00, 0x0E, 0x02, 0x00, 0x03, 0x80, 0xC0, 0x00,
  0xE0, 0x10, 0x00, 0x38, 0x06, 0x00, 0x0E, 0x00, 0x80, 0x03, 0x80, 0x30,
  0x00, 0xE0, 0x06, 0x00, 0x38, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x03, 0x80,
  0x0C, 0x00, 0xE0, 0x01, 0x80, 0x38, 0x00, 0x60, 0x0E, 0x00, 0x0C, 0x03,
  0x80, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x38, 0x00, 0x18, 0x0E, 0x00, 0x03,
  0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x06, 0x0E, 0x00,
  0x00, 0xC3, 0x80, 0x00, 0x30, 0xE0, 0x00, 0x06, 0x38, 0x00, 0x01, 0x8E,
  0x00, 0x00, 0x33, 0x80, 0x00, 0x0C, 0xE0, 0x00, 0x01, 0xB8, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x18,
  0x18, 0x00, 0x00, 0x30, 0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x46, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x03, 0x20, 0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x06, 0x80, 0x00, 0x00, 0x0D, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00,
  0x26, 0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03,
  0x18, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60,
  0x70, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x20, 0x01, 0xE1, 0x00, 0x03, 0x88, 0x00, 0x06, 0x40, 0x00, 0x1A, 0x00,
  0x00, 0xD0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x40, 0x00, 0x1A, 0x00, 0x01, 0x90, 0x00, 0x18, 0x80, 0x03,
  0x84, 0x00, 0xF8, 0x3F, 0xFF, 0x01, 0xFE, 0x00, 0x08, 0x00, 0x00, 0x40,
  0x00, 0x02, 0x00, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00,
  0x20, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x04, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xE0, 0x78,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x30, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x30,
  0x60, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x20,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0D, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x26, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00, 0x0C,
  0x30, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0xC0,
  0x60, 0x00, 0x03, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x02,
  0x00, 0x1E, 0x04, 0x00, 0x0E, 0x08, 0x00, 0x06, 0x10, 0x00, 0x06, 0x20,
  0x00, 0x0C, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x19, 0x00, 0x00, 0x32, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x48, 0x00, 0x00, 0x90, 0x00, 0x01, 0x20, 0x00,
  0x02, 0x40, 0x00, 0x0C, 0x80, 0x00, 0x19, 0x00, 0x00, 0x32, 0x00, 0x00,
  0x64, 0x00, 0x01, 0x88, 0x00, 0x03, 0x10, 0x00, 0x0C, 0x20, 0x00, 0x30,
  0x40, 0x01, 0xC0, 0x80, 0x1F, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x01, 0x80, 0x20, 0x03, 0x00, 0x40,
  0x03, 0x00, 0x80, 0x06, 0x01, 0x00, 0x06, 0x02, 0x00, 0x0C, 0x04, 0x00,
  0x0C, 0x08, 0x00, 0x18, 0x10, 0x00, 0x18, 0x20, 0x00, 0x30, 0x40, 0x00,
  0x30, 0x80, 0x00, 0x61, 0x00, 0x00, 0x62, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0xC8, 0x00, 0x01, 0x90, 0x00, 0x01, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x00, 0x04, 0x00, 0x03, 0xFF, 0xE0, 0x1F, 0x01, 0xF0, 0x70, 0x00, 0x61,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x06,
  0x30, 0x00, 0x38, 0x7E, 0x01, 0xE0, 0x3F, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06, 0x80,
  0x00, 0x00, 0x98, 0x00, 0x00, 0x33, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x81, 0xC0,
  0x00, 0x70, 0x1C, 0x00, 0x1C, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x40,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x03, 0x60, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x06, 0x20, 0x00, 0x00, 0x63, 0x00, 0x00, 0x04, 0x30, 0x00, 0x00, 0xC1,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x08, 0x18, 0x00,
  0x01, 0x80, 0x80, 0x00, 0x18, 0x0C, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30,
  0x0C, 0x00, 0x03, 0x00, 0x40, 0x00, 0x30, 0x06, 0x00, 0x02, 0x00, 0x60,
  0x00, 0x60, 0x02, 0x00, 0x06, 0x00, 0x30, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x01, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x80, 0x01,
  0x80, 0x18, 0x00, 0x18, 0x01, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01,
  0x00, 0x00, 0xC0, 0x30, 0x00, 0x04, 0x03, 0x00, 0x00, 0x60, 0x30, 0x00,
  0x06, 0x06, 0x00, 0x00, 0x60, 0x60, 0x00, 0x02, 0x06, 0x00, 0x00, 0x30,
  0x40, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x10, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x18, 0x80, 0x00, 0x01, 0x98, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x90, 0x00, 0x01,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x07, 0x80, 0x00, 0x19, 0x80, 0x00, 0x16,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x58, 0x00, 0x01, 0x08, 0x00, 0x03, 0x60,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0xC0, 0x00, 0x30, 0xC0, 0x00, 0x33, 0x00,
  0x00, 0xC3, 0x00, 0x00, 0xCC, 0x00, 0x03, 0x04, 0x00, 0x06, 0x30, 0x00,
  0x18, 0x18, 0x00, 0x18, 0x40, 0x00, 0x60, 0x60, 0x00, 0x61, 0x80, 0x01,
  0x81, 0x80, 0x01, 0x86, 0x00, 0x06, 0x06, 0x00, 0x04, 0x18, 0x00, 0x30,
  0x08, 0x00, 0x30, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x00,
  0xC0, 0x03, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x20, 0x04,
  0x00, 0x60, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x40, 0x06, 0x00, 0x60,
  0x06, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x06, 0x00, 0x40, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x30, 0x0C,
  0x00, 0xC0, 0x30, 0x00, 0xC0, 0x30, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x0C, 0x06, 0x00, 0x04, 0x06, 0x00, 0x30, 0x18, 0x00, 0x18, 0x18, 0x00,
  0x40, 0x60, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80, 0x06,
  0x0C, 0x00, 0x02, 0x04, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x60,
  0xC0, 0x00, 0x30, 0xC0, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x03, 0x08,
  0x00, 0x01, 0x0C, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x60, 0x00, 0x31, 0x80,
  0x00, 0x19, 0x80, 0x00, 0x46, 0x00, 0x00, 0x66, 0x00, 0x01, 0x90, 0x00,
  0x01, 0x98, 0x00, 0x06, 0xC0, 0x00, 0x02, 0x40, 0x00, 0x1B, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xA0, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x86, 0x00,
  0x00, 0xC1, 0x00, 0x00, 0x40, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x18,
  0x00, 0x30, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x08, 0x06, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x03, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x60, 0x80, 0x00, 0x18, 0xC0,
  0x00, 0x0C, 0x60, 0x00, 0x03, 0x60, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0D,
  0x00, 0x00, 0x06, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x0C, 0x00, 0x01, 0x83, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x60, 0x00,
  0xC0, 0x30, 0x00, 0x60, 0x08, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x0C,
  0x0C, 0x00, 0x02, 0x06, 0x00, 0x01, 0x82, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x31, 0x80, 0x00, 0x19, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xA0, 0x00, 0x01, 0x98, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x30, 0x40, 0x00, 0x10, 0x30, 0x00, 0x18, 0x18,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x01, 0x80, 0x02, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x01, 0x80, 0x06, 0x00, 0xC0,
  0x03, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x30, 0x00, 0x10, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC6,
  0x00, 0x00, 0x26, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0x18, 0x00, 0x01, 0x83, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x06, 0x00, 0x06, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x01, 0x80, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x01, 0xFC, 0x00,
  0xFF, 0xF0, 0x3C, 0x03, 0x81, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x02, 0x00, 0x00,
  0x20, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x1F, 0xF0, 0x1F, 0xF3, 0x07, 0x80, 0x31, 0xC0, 0x03, 0x30,
  0x00, 0x36, 0x00, 0x03, 0x60, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0B, 0x60, 0x01, 0x33, 0x00, 0x33, 0x38, 0x0E,
  0x30, 0xFF, 0xC3, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x7F, 0x80, 0xC3, 0xFF, 0xC1, 0x8E, 0x01, 0xC3, 0x30, 0x01,
  0xC6, 0xC0, 0x01, 0x8D, 0x80, 0x01, 0x9E, 0x00, 0x01, 0x38, 0x00, 0x03,
  0x70, 0x00, 0x06, 0xE0, 0x00, 0x05, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0B, 0x80, 0x00, 0x37, 0x00, 0x00,
  0x6E, 0x00, 0x00, 0x9E, 0x00, 0x03, 0x36, 0x00, 0x0E, 0x6C, 0x00, 0x18,
  0xCE, 0x00, 0xE1, 0x8F, 0x07, 0x83, 0x07, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x03, 0xC0, 0x20, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x40,
  0x00, 0x04, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x40, 0x00, 0x04, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x70, 0x0F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x7E, 0x03, 0x01, 0xFF, 0xC3,
  0x07, 0x00, 0xE3, 0x0E, 0x00, 0x33, 0x0C, 0x00, 0x13, 0x18, 0x00, 0x1B,
  0x30, 0x00, 0x0B, 0x30, 0x00, 0x0F, 0x30, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60, 0x00, 0x03, 0x40, 0x00, 0x03,
  0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x07, 0x20, 0x00, 0x07, 0x30, 0x00, 0x0F,
  0x30, 0x00, 0x0B, 0x18, 0x00, 0x1B, 0x1C, 0x00, 0x33, 0x0E, 0x00, 0x63,
  0x07, 0x81, 0xC3, 0x01, 0xFF, 0x83, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00,
  0x07, 0xFE, 0x00, 0x70, 0x1C, 0x03, 0x80, 0x18, 0x0C, 0x00, 0x30, 0x60,
  0x00, 0xC1, 0x80, 0x01, 0x8C, 0x00, 0x06, 0x30, 0x00, 0x09, 0x80, 0x00,
  0x36, 0x00, 0x00, 0xD8, 0x00, 0x03, 0x60, 0x00, 0x0D, 0x00, 0x00, 0x14,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x60, 0x3C, 0x07, 0x80, 0x7F, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0xF1, 0xC0, 0x60, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0xFF, 0xF8, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x84, 0x1C, 0x03,
  0x88, 0x70, 0x01, 0x91, 0xC0, 0x01, 0xA3, 0x00, 0x01, 0x4C, 0x00, 0x03,
  0x98, 0x00, 0x03, 0x20, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x28, 0x00, 0x00, 0x50, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xA0, 0x00,
  0x03, 0x40, 0x00, 0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00,
  0x32, 0x00, 0x00, 0xE6, 0x00, 0x01, 0x4C, 0x00, 0x06, 0x8C, 0x00, 0x09,
  0x0C, 0x00, 0x32, 0x1C, 0x00, 0xC4, 0x1E, 0x07, 0x08, 0x0F, 0xFC, 0x10,
  0x07, 0xC0, 0x20, 0x00, 0x00, 0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x40, 0x00,
  0x30, 0x70, 0x01, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x1F, 0xC0, 0xC3, 0xFF, 0x86, 0x38, 0x0E, 0x33, 0x00, 0x39,
  0xB0, 0x00, 0xCD, 0x80, 0x03, 0x78, 0x00, 0x1B, 0x80, 0x00, 0x5C, 0x00,
  0x02, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x06,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x33, 0xF1, 0xF0, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0xD8, 0x00,
  0x33, 0x00, 0x0C, 0x60, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x06,
  0x06, 0x00, 0xC0, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x03, 0x00, 0x60, 0x60,
  0x0C, 0x18, 0x01, 0x86, 0x00, 0x30, 0xE0, 0x06, 0x3C, 0x00, 0xCC, 0xC0,
  0x19, 0x18, 0x03, 0x61, 0x80, 0x78, 0x30, 0x0E, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x18,
  0x60, 0x03, 0x0C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0x66, 0x00, 0x0C,
  0xC0, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00,
  0xFC, 0x08, 0x3F, 0xE0, 0x3F, 0xF0, 0xCE, 0x03, 0x07, 0x03, 0x8C, 0xC0,
  0x18, 0xC0, 0x0C, 0xD8, 0x00, 0x88, 0x00, 0x6D, 0x00, 0x0D, 0x80, 0x06,
  0xE0, 0x00, 0xD0, 0x00, 0x6E, 0x00, 0x07, 0x00, 0x02, 0xE0, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03,
  0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60,
  0x00, 0x3C, 0x00, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0xFE, 0x06, 0x1F, 0xFC, 0x31, 0xC0, 0x71, 0x98,
  0x00, 0xCD, 0x80, 0x06, 0x68, 0x00, 0x1B, 0xC0, 0x00, 0xDC, 0x00, 0x02,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x30, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0x30, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30,
  0x00, 0x06, 0x20, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x02, 0x60,
  0x00, 0x03, 0x40, 0x00, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40, 0x00, 0x03, 0x40,
  0x00, 0x03, 0x60, 0x00, 0x03, 0x60, 0x00, 0x02, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x30, 0x00, 0x06, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18,
  0x00, 0x18, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x70, 0x03, 0x80, 0xE0, 0x01,
  0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7E, 0x01, 0x83, 0xFF, 0x83, 0x1C,
  0x03, 0x86, 0x70, 0x03, 0x8C, 0xC0, 0x03, 0x1B, 0x00, 0x03, 0x34, 0x00,
  0x02, 0x78, 0x00, 0x06, 0xE0, 0x00, 0x0D, 0xC0, 0x00, 0x0B, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x17, 0x00,
  0x00, 0x6E, 0x00, 0x00, 0xDE, 0x00, 0x01, 0x34, 0x00, 0x06, 0x6C, 0x00,
  0x18, 0xCC, 0x00, 0x31, 0x9C, 0x01, 0xC3, 0x1E, 0x07, 0x06, 0x0F, 0xFC,
  0x0C, 0x03, 0x80, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0x84, 0x1C, 0x03, 0x88, 0x70, 0x01, 0x90, 0xC0,
  0x01, 0x23, 0x00, 0x03, 0x4C, 0x00, 0x02, 0x98, 0x00, 0x07, 0x30, 0x00,
  0x06, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x34, 0x00, 0x00,
  0x28, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xA0, 0x00, 0x03, 0x40, 0x00, 0x06, 0xC0,
  0x00, 0x0D, 0x80, 0x00, 0x1B, 0x00, 0x00, 0x32, 0x00, 0x00, 0xE6, 0x00,
  0x01, 0x4C, 0x00, 0x06, 0x8C, 0x00, 0x09, 0x1C, 0x00, 0x32, 0x1C, 0x00,
  0xC4, 0x1E, 0x07, 0x08, 0x0F, 0xFC, 0x10, 0x03, 0xC0, 0x20, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x20, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x80, 0x00, 0x01, 0x00, 0x00, 0x02, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0xFB, 0x0F, 0xFC, 0x70, 0x73, 0x00,
  0xC8, 0x03, 0x60, 0x0D, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x01, 0xFE, 0x00, 0xFF,
  0xF8, 0x78, 0x03, 0x8C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0xD8, 0x00, 0x33, 0xF0, 0x3C, 0x0F, 0xFF, 0x00, 0x3E, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x03, 0xFF, 0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x04, 0x00,
  0x18, 0x00, 0x70, 0x40, 0xFF, 0x00, 0x70, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x76, 0x00, 0x05, 0x60, 0x00,
  0xD7, 0x00, 0x19, 0x38, 0x03, 0x11, 0xC0, 0xE1, 0x0F, 0xFC, 0x10, 0x1C,
  0x00, 0xC0, 0x00, 0x0D, 0x80, 0x00, 0x36, 0x00, 0x00, 0x98, 0x00, 0x06,
  0x20, 0x00, 0x18, 0xC0, 0x00, 0x63, 0x00, 0x03, 0x0C, 0x00, 0x0C, 0x18,
  0x00, 0x30, 0x60, 0x00, 0x81, 0x80, 0x06, 0x02, 0x00, 0x18, 0x0C, 0x00,
  0x60, 0x30, 0x03, 0x00, 0xC0, 0x0C, 0x01, 0x00, 0x30, 0x06, 0x00, 0x80,
  0x18, 0x06, 0x00, 0x20, 0x18, 0x00, 0xC0, 0x60, 0x03, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x10, 0x30, 0x00, 0x60, 0x80, 0x01, 0x86, 0x00, 0x02, 0x18,
  0x00, 0x0C, 0x60, 0x00, 0x33, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x30, 0x00,
  0x06, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x24, 0x00, 0x0F, 0x00, 0x06, 0x60, 0x00, 0xD0, 0x00,
  0x66, 0x00, 0x0D, 0x80, 0x06, 0x60, 0x00, 0x98, 0x00, 0x42, 0x00, 0x19,
  0x80, 0x0C, 0x30, 0x01, 0x88, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x0C, 0x30,
  0x01, 0x0C, 0x00, 0x81, 0x00, 0x30, 0xC0, 0x08, 0x18, 0x03, 0x04, 0x01,
  0x81, 0x80, 0x30, 0x40, 0x18, 0x18, 0x02, 0x06, 0x01, 0x80, 0x80, 0x60,
  0x60, 0x10, 0x0C, 0x06, 0x02, 0x03, 0x00, 0xC0, 0x60, 0x20, 0x30, 0x0C,
  0x04, 0x03, 0x03, 0x00, 0x40, 0xC0, 0x30, 0x20, 0x06, 0x0C, 0x01, 0x06,
  0x00, 0x60, 0xC0, 0x10, 0x60, 0x06, 0x08, 0x01, 0x86, 0x00, 0x21, 0x80,
  0x18, 0x40, 0x03, 0x18, 0x01, 0x84, 0x00, 0x31, 0x80, 0x08, 0xC0, 0x03,
  0x10, 0x00, 0xCC, 0x00, 0x13, 0x00, 0x0C, 0xC0, 0x01, 0xB0, 0x00, 0xC8,
  0x00, 0x1B, 0x00, 0x05, 0x80, 0x01, 0xA0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x60, 0x00, 0x1C, 0xC0, 0x00, 0x63, 0x00, 0x03,
  0x06, 0x00, 0x18, 0x08, 0x00, 0x60, 0x30, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x03, 0x01, 0x80, 0x0C, 0x0C, 0x00, 0x18, 0x30, 0x00, 0x61,
  0x80, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x06, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1B, 0x00, 0x00,
  0xCC, 0x00, 0x03, 0x18, 0x00, 0x18, 0x60, 0x00, 0xC0, 0xC0, 0x03, 0x03,
  0x00, 0x18, 0x06, 0x00, 0x60, 0x18, 0x03, 0x00, 0x30, 0x0C, 0x00, 0x60,
  0x60, 0x01, 0x81, 0x80, 0x03, 0x0C, 0x00, 0x0C, 0x30, 0x00, 0x19, 0x80,
  0x00, 0x6E, 0x00, 0x00, 0xC0, 0x60, 0x00, 0x06, 0x40, 0x00, 0x08, 0xC0,
  0x00, 0x31, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC2, 0x00, 0x01, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x08, 0x00, 0x10, 0x18, 0x00, 0x60, 0x30, 0x00,
  0xC0, 0x60, 0x01, 0x80, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x20, 0x03, 0x00, 0xC0, 0x06, 0x01, 0x80, 0x04, 0x03, 0x00,
  0x0C, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x20, 0x40, 0x00,
  0x61, 0x80, 0x00, 0xC3, 0x00, 0x00, 0x84, 0x00, 0x01, 0x98, 0x00, 0x03,
  0x30, 0x00, 0x06, 0x60, 0x00, 0x04, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x00, 0x01, 0x80, 0x00, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x00, 0x01, 0x80, 0x00,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0x80, 0x1F, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0x40, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x7E,
  0x00, 0x20, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x5C, 0x1E,
  0x00, 0x78, 0x03, 0x80, 0x68, 0x00, 0x7F, 0xE4, 0x00, 0x0F, 0xC0,
};

const GFXglyph NotoSans_Condensed_Thin67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 48, 14, 5, -48 },
  { 25, 12, 17, 20, 4, -48 },
  { 51, 30, 48, 33, 1, -48 },
  { 231, 23, 55, 30, 3, -51 },
  { 390, 36, 50, 43, 3, -49 },
  { 615, 28, 50, 32, 3, -49 },
  { 790, 3, 17, 11, 4, -48 },
  { 797, 12, 59, 17, 3, -48 },
  { 886, 11, 59, 17, 3, -48 },
  { 968, 20, 20, 27, 3, -51 },
  { 1018, 26, 31, 30, 2, -39 },
  { 1119, 5, 16, 12, 3, -7 },
  { 1129, 15, 2, 19, 2, -19 },
  { 1133, 3, 4, 13, 5, -4 },
  { 1135, 20, 48, 22, 1, -48 },
  { 1255, 23, 49, 30, 3, -49 },
  { 1396, 12, 48, 30, 6, -48 },
  { 1468, 23, 49, 30, 3, -49 },
  { 1609, 23, 50, 30, 3, -49 },
  { 1753, 28, 48, 30, 1, -48 },
  { 1921, 23, 49, 30, 4, -48 },
  { 2062, 23, 49, 30, 4, -48 },
  { 2203, 23, 48, 30, 3, -48 },
  { 2341, 24, 49, 30, 3, -48 },
  { 2488, 23, 50, 30, 3, -49 },
  { 2632, 3, 36, 13, 5, -36 },
  { 2646, 5, 45, 13, 3, -36 },
  { 2675, 26, 28, 30, 2, -38 },
  { 2766, 26, 16, 30, 2, -32 },
  { 2818, 26, 28, 30, 2, -38 },
  { 2909, 17, 49, 21, 2, -49 },
  { 3014, 39, 54, 46, 4, -48 },
  { 3278, 29, 48, 29, 0, -48 },
  { 3452, 24, 48, 33, 6, -48 },
  { 3596, 26, 50, 32, 4, -49 },
  { 3759, 26, 48, 36, 6, -48 },
  { 3915, 19, 48, 29, 6, -48 },
  { 4029, 19, 48, 26, 6, -48 },
  { 4143, 31, 50, 39, 4, -49 },
  { 4337, 25, 48, 37, 6, -48 },
  { 4487, 10, 48, 16, 3, -48 },
  { 4547, 12, 60, 13, -4, -48 },
  { 4637, 23, 48, 29, 6, -48 },
  { 4775, 19, 48, 26, 6, -48 },
  { 4889, 36, 48, 47, 6, -48 },
  { 5105, 26, 48, 38, 6, -48 },
  { 5261, 31, 50, 39, 4, -49 },
  { 5455, 21, 48, 30, 6, -48 },
  { 5581, 31, 60, 39, 4, -49 },
  { 5814, 23, 48, 31, 6, -48 },
  { 5952, 23, 50, 29, 3, -49 },
  { 6096, 25, 48, 26, 0, -48 },
  { 6246, 27, 49, 37, 5, -48 },
  { 6412, 28, 48, 28, 0, -48 },
  { 6580, 46, 48, 48, 1, -48 },
  { 6856, 25, 48, 26, 0, -48 },
  { 7006, 25, 48, 25, 0, -48 },
  { 7156, 23, 48, 27, 2, -48 },
  { 7294, 12, 59, 21, 6, -48 },
  { 7383, 20, 48, 22, 1, -48 },
  { 7503, 13, 59, 21, 2, -48 },
  { 7599, 26, 25, 30, 2, -48 },
  { 7681, 26, 2, 26, 0, 6 },
  { 7688, 10, 10, 16, 3, -51 },
  { 7701, 20, 37, 27, 3, -36 },
  { 7794, 23, 52, 32, 5, -51 },
  { 7944, 20, 37, 24, 3, -36 },
  { 8037, 24, 52, 32, 3, -51 },
  { 8193, 22, 37, 29, 3, -36 },
  { 8295, 17, 51, 15, 1, -51 },
  { 8404, 23, 52, 31, 3, -36 },
  { 8554, 21, 51, 31, 5, -51 },
  { 8688, 3, 48, 12, 5, -48 },
  { 8706, 9, 64, 12, -1, -48 },
  { 8778, 19, 51, 24, 5, -51 },
  { 8900, 2, 51, 12, 5, -51 },
  { 8913, 36, 36, 46, 5, -36 },
  { 9075, 21, 36, 31, 5, -36 },
  { 9170, 24, 37, 30, 3, -36 },
  { 9281, 23, 52, 32, 5, -36 },
  { 9431, 23, 52, 31, 3, -36 },
  { 9581, 14, 36, 20, 5, -36 },
  { 9644, 19, 37, 24, 2, -36 },
  { 9732, 14, 45, 16, 1, -44 },
  { 9811, 20, 36, 31, 5, -35 },
  { 9901, 22, 35, 22, 0, -35 },
  { 9998, 36, 35, 38, 1, -35 },
  { 10156, 22, 35, 24, 1, -35 },
  { 10253, 23, 51, 23, 0, -35 },
  { 10400, 17, 35, 21, 2, -35 },
  { 10475, 17, 59, 23, 3, -48 },
  { 10601, 2, 67, 28, 13, -51 },
  { 10618, 17, 59, 23, 3, -48 },
  { 10744, 25, 6, 30, 3, -27 },
};

const GFXfont NotoSans_Condensed_Thin67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin67pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_CONDENSED_THIN67PT7B_H_
