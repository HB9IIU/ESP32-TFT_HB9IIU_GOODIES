#ifndef _NOTOSANS_CONDENSED_THIN72PT7B_H_
#define _NOTOSANS_CONDENSED_THIN72PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Thin.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Thin72pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x76, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x72, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x00, 0x08,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x80, 0x00, 0x18, 0x01, 0x80, 0x00, 0x18,
  0x01, 0x80, 0x00, 0x10, 0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x30,
  0x01, 0x80, 0x00, 0x30, 0x01, 0x80, 0x00, 0x30, 0x01, 0x00, 0x00, 0x30,
  0x01, 0x00, 0x00, 0x30, 0x03, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60, 0x03, 0x00, 0x00, 0x60,
  0x03, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x60, 0x02, 0x00, 0x00, 0x40,
  0x06, 0x00, 0x00, 0x40, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0,
  0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x00, 0xC0,
  0x04, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x80, 0x0C, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80,
  0x0C, 0x00, 0x01, 0x80, 0x08, 0x00, 0x01, 0x80, 0x18, 0x00, 0x01, 0x00,
  0x18, 0x00, 0x01, 0x00, 0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x18, 0x00, 0x03, 0x00, 0x10, 0x00, 0x03, 0x00,
  0x30, 0x00, 0x02, 0x00, 0x30, 0x00, 0x02, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x20, 0x00, 0x06, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x1E, 0x61, 0xF8, 0x3C, 0x30, 0x1C, 0x38, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x18, 0x06, 0x00, 0x0C, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x06, 0x00,
  0xC0, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18, 0x00, 0x60,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x18, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03,
  0x00, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x30, 0x00, 0x1C, 0x18, 0x00,
  0x07, 0x8C, 0x00, 0x00, 0xE6, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x6F, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x18,
  0x78, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x03, 0x80, 0x03, 0x00, 0xE0, 0x01,
  0x80, 0x30, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x06,
  0x00, 0x18, 0x06, 0x40, 0x0C, 0x07, 0x38, 0x06, 0x0F, 0x1F, 0xE3, 0x3E,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x30, 0x03, 0x83, 0x00, 0x01,
  0x80, 0x0C, 0x06, 0x00, 0x06, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x01, 0x80,
  0x30, 0x00, 0xC0, 0x04, 0x00, 0xC0, 0x03, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x06, 0x01, 0x80,
  0x02, 0x00, 0x18, 0x06, 0x00, 0x08, 0x00, 0x60, 0x18, 0x00, 0x20, 0x01,
  0x80, 0xC0, 0x00, 0x80, 0x06, 0x03, 0x00, 0x03, 0x00, 0x18, 0x18, 0x00,
  0x08, 0x00, 0x60, 0x60, 0x00, 0x30, 0x01, 0x81, 0x80, 0x00, 0xC0, 0x06,
  0x0C, 0x02, 0x03, 0x00, 0x18, 0x30, 0x7F, 0x0C, 0x00, 0x60, 0x83, 0x86,
  0x30, 0x01, 0x86, 0x18, 0x0C, 0xC0, 0x04, 0x18, 0x60, 0x31, 0x00, 0x30,
  0xC3, 0x00, 0x66, 0x00, 0xC3, 0x0C, 0x01, 0x98, 0x06, 0x08, 0x20, 0x03,
  0x30, 0x18, 0x61, 0x80, 0x0C, 0xE0, 0xC1, 0x86, 0x00, 0x31, 0xFE, 0x0C,
  0x18, 0x00, 0xC1, 0xF0, 0x30, 0x60, 0x03, 0x00, 0x00, 0x81, 0x80, 0x0C,
  0x00, 0x06, 0x06, 0x00, 0x30, 0x00, 0x18, 0x18, 0x00, 0xC0, 0x00, 0xC0,
  0x60, 0x01, 0x00, 0x03, 0x01, 0x80, 0x04, 0x00, 0x08, 0x06, 0x00, 0x30,
  0x00, 0x60, 0x18, 0x00, 0xC0, 0x01, 0x80, 0x60, 0x03, 0x00, 0x0C, 0x01,
  0x80, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x0C, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x06, 0x00,
  0x60, 0x00, 0x60, 0x30, 0x01, 0x80, 0x01, 0x80, 0xC0, 0x0C, 0x00, 0x03,
  0x86, 0x00, 0x30, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x06, 0x03, 0x00, 0x00, 0x18,
  0x03, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80,
  0x0C, 0x00, 0x02, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x40, 0x00, 0x60, 0x00, 0x80, 0x00, 0x40, 0x03,
  0x00, 0x00, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x03, 0x00, 0x18,
  0x00, 0x02, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x00, 0x0C, 0x03, 0x00,
  0x00, 0x0C, 0x0E, 0x00, 0x00, 0x0C, 0x38, 0x00, 0x00, 0x18, 0xE0, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xB0, 0x00, 0x00, 0x0E, 0x60, 0x00, 0x00, 0x38, 0x60, 0x00, 0x00,
  0xC0, 0x60, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0xC0, 0x02, 0x18,
  0x00, 0xC0, 0x04, 0x60, 0x01, 0xC0, 0x18, 0xC0, 0x01, 0x80, 0x31, 0x80,
  0x01, 0x80, 0x66, 0x00, 0x01, 0x80, 0x8C, 0x00, 0x03, 0x03, 0x18, 0x00,
  0x03, 0x06, 0x30, 0x00, 0x03, 0x08, 0x60, 0x00, 0x06, 0x30, 0xC0, 0x00,
  0x06, 0x61, 0x80, 0x00, 0x07, 0x83, 0x00, 0x00, 0x0F, 0x06, 0x00, 0x00,
  0x0C, 0x06, 0x00, 0x00, 0x3C, 0x0C, 0x00, 0x00, 0xF8, 0x18, 0x00, 0x01,
  0x98, 0x18, 0x00, 0x06, 0x18, 0x18, 0x00, 0x38, 0x30, 0x38, 0x00, 0xE0,
  0x30, 0x3C, 0x07, 0x80, 0x30, 0x1F, 0xFC, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x10, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0xE0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x01,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x40, 0x00, 0x02, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x80, 0x10, 0x04, 0x01, 0xE0, 0x20, 0x3B, 0xE1, 0x0F, 0x83, 0xC9,
  0xE0, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x28, 0x00, 0x02, 0x20, 0x00,
  0x31, 0x80, 0x03, 0x06, 0x00, 0x30, 0x18, 0x01, 0x00, 0x40, 0x18, 0x03,
  0x01, 0x80, 0x0C, 0x08, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x71,
  0xC6, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x18, 0x61, 0x84, 0x30, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0x80, 0xE0, 0x06,
  0x00, 0x70, 0x0C, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x02, 0x40, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x03, 0x60,
  0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x30, 0x00, 0x06, 0x30,
  0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x0C,
  0x00, 0x38, 0x0E, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x03, 0xE3, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x3E, 0x03, 0xB0,
  0x71, 0x87, 0x0C, 0x70, 0x67, 0x03, 0x70, 0x1E, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0x80,
  0x3C, 0x0F, 0x00, 0x07, 0x02, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x07, 0x0E,
  0x00, 0x01, 0xC2, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x1C, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0x3F,
  0x80, 0x78, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x03, 0x18, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x00, 0x61, 0x80, 0x00, 0x03, 0x06, 0x00, 0x00, 0x0C,
  0x18, 0x00, 0x00, 0x60, 0x60, 0x00, 0x03, 0x81, 0x80, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x0C, 0x01, 0x80,
  0x00, 0x30, 0x06, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x60, 0x00,
  0x30, 0x01, 0x80, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x18, 0x00, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06,
  0x00, 0xC0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x60, 0x18, 0x00, 0x01, 0x80,
  0x60, 0x00, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80,
  0x1F, 0xFF, 0xFC, 0x08, 0x00, 0x00, 0x04, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x03, 0x00, 0x03, 0x7F, 0xFC, 0x01, 0xFC, 0x0F, 0x80,
  0x40, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x61, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x7E, 0x03, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x3C, 0x01, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x07, 0xFE, 0x03, 0x0F, 0xCF, 0xC1, 0x8E, 0x00, 0x70, 0xCC, 0x00,
  0x1C, 0x6C, 0x00, 0x06, 0x34, 0x00, 0x01, 0x9E, 0x00, 0x00, 0xCE, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x06, 0xC0,
  0x00, 0x01, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00, 0xC4, 0x00, 0x00,
  0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x30, 0x60, 0x00, 0x18, 0x30, 0x00,
  0x18, 0x0C, 0x00, 0x18, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x3C, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x78, 0x07, 0x80, 0x38, 0x00, 0x70, 0x0C, 0x00,
  0x0E, 0x06, 0x00, 0x01, 0x83, 0x80, 0x00, 0x30, 0xC0, 0x00, 0x0C, 0x30,
  0x00, 0x03, 0x0C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x18, 0x80, 0x00, 0x06,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x30, 0xC0, 0x00,
  0x0C, 0x18, 0x00, 0x03, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0x60, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0E, 0x1C,
  0x00, 0x07, 0x03, 0x80, 0x07, 0x00, 0x38, 0x03, 0x80, 0x07, 0x01, 0xC0,
  0x00, 0xE0, 0x60, 0x00, 0x18, 0x30, 0x00, 0x03, 0x1C, 0x00, 0x00, 0xE6,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x06, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x06, 0x60, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x63, 0x00, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x1C, 0x00, 0x0E,
  0x03, 0x80, 0x07, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xC0, 0x38, 0x01,
  0xC0, 0x06, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x60, 0xC0, 0x00, 0x30,
  0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0x18, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x36, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x05, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x0E, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x03, 0x98, 0x00, 0x03, 0xCC,
  0x00, 0x03, 0x63, 0x00, 0x03, 0x30, 0xC0, 0x03, 0x98, 0x70, 0x03, 0x8C,
  0x0F, 0xFF, 0x06, 0x03, 0xFE, 0x03, 0x00, 0x00, 0x01, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x04, 0x03, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xEF, 0xFF, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x1C, 0xF3, 0xC7, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7, 0x1C, 0x61, 0x86, 0x38, 0xC3,
  0x0C, 0x31, 0x86, 0x18, 0x43, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x1F, 0xFF, 0x0E, 0x00, 0xE2, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x20, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x60, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x01, 0x80,
  0x00, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x18, 0x00, 0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x00, 0x00,
  0xC3, 0x00, 0x00, 0x78, 0x00, 0x30, 0xC0, 0x00, 0xFF, 0xE0, 0x0C, 0x30,
  0x00, 0xF0, 0x38, 0x01, 0x98, 0x00, 0x70, 0x06, 0x00, 0x66, 0x00, 0x18,
  0x01, 0x80, 0x19, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x60, 0x07, 0x00, 0x18,
  0x01, 0xB0, 0x01, 0x80, 0x06, 0x00, 0x2C, 0x00, 0x60, 0x01, 0x80, 0x0F,
  0x00, 0x30, 0x00, 0x40, 0x03, 0xC0, 0x0C, 0x00, 0x30, 0x00, 0xF0, 0x03,
  0x00, 0x0C, 0x00, 0x3C, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0xC0, 0x08, 0x00, 0x30, 0x00, 0xF0, 0x06, 0x00, 0x0C, 0x00,
  0x3C, 0x01, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x60, 0x00, 0xC0, 0x06, 0xC0,
  0x08, 0x00, 0x30, 0x01, 0xB0, 0x03, 0x00, 0x0C, 0x00, 0x6C, 0x00, 0xC0,
  0x07, 0x00, 0x1B, 0x00, 0x30, 0x01, 0xC0, 0x06, 0xC0, 0x0C, 0x00, 0x50,
  0x03, 0x30, 0x03, 0x80, 0x36, 0x00, 0xCC, 0x00, 0x60, 0x0D, 0x80, 0x71,
  0x80, 0x1C, 0x06, 0x60, 0x18, 0x60, 0x03, 0x83, 0x0C, 0x1C, 0x18, 0x00,
  0x7F, 0x81, 0xFE, 0x06, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x16, 0x00, 0x00, 0x00, 0x66, 0x00, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0x01, 0x18, 0x00, 0x00, 0x06, 0x10, 0x00, 0x00,
  0x0C, 0x30, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x00,
  0xC0, 0x80, 0x00, 0x01, 0x81, 0x80, 0x00, 0x03, 0x03, 0x00, 0x00, 0x0C,
  0x06, 0x00, 0x00, 0x18, 0x06, 0x00, 0x00, 0x30, 0x0C, 0x00, 0x00, 0x40,
  0x18, 0x00, 0x01, 0x80, 0x10, 0x00, 0x03, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x60, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x60, 0x01,
  0x80, 0x00, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0x00, 0x00, 0x60, 0x06, 0x00, 0x00, 0xC0,
  0x0C, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x01, 0x80, 0x60, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x06, 0x01, 0x80, 0x00, 0x06, 0x03, 0x00, 0x00, 0x0C, 0x0C,
  0x00, 0x00, 0x18, 0x18, 0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0xC0,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x00, 0xC6, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x03, 0x60, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x18, 0xFF, 0xFF,
  0xC0, 0x30, 0x01, 0xFC, 0x0C, 0x00, 0x03, 0x83, 0x00, 0x00, 0x70, 0xC0,
  0x00, 0x06, 0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0x33, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x1B, 0x00, 0x00,
  0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x4C, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x00, 0xCC, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0x30, 0x00, 0x0E, 0x0C, 0x00, 0x0F,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x3E, 0x0C, 0x00,
  0x01, 0xC3, 0x00, 0x00, 0x38, 0xC0, 0x00, 0x07, 0x30, 0x00, 0x00, 0xCC,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x06, 0xC0, 0x00, 0x01, 0xB0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xB0,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x0E, 0xC0, 0x00, 0x03,
  0x30, 0x00, 0x01, 0x8C, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x70, 0xC0, 0x00,
  0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x01, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x01, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x06, 0x00, 0xFF, 0x00, 0x30, 0x00, 0x3C,
  0x01, 0x80, 0x00, 0x78, 0x0C, 0x00, 0x00, 0xE0, 0x60, 0x00, 0x03, 0x83,
  0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x01, 0xC6, 0x00,
  0x00, 0x06, 0x30, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0xCC, 0x00, 0x00,
  0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x01, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x06, 0xC0, 0x00,
  0x00, 0x36, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x00,
  0x6C, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x33, 0x00, 0x00, 0x01, 0x98,
  0x00, 0x00, 0x18, 0xC0, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x0E, 0x30, 0x00,
  0x00, 0x61, 0x80, 0x00, 0x07, 0x0C, 0x00, 0x00, 0x70, 0x60, 0x00, 0x07,
  0x03, 0x00, 0x00, 0x70, 0x18, 0x00, 0x0F, 0x00, 0xC0, 0x01, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF6, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x3F, 0xFF, 0xFD, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30,
  0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00,
  0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x0F, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x10, 0x0E, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x00, 0x6C,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x00, 0x0C,
  0xC0, 0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x03, 0x30, 0x00, 0x00, 0x01,
  0x8C, 0x00, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x00, 0x61, 0x80, 0x00, 0x00,
  0x30, 0xE0, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0x0C, 0x0E, 0x00, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x3C, 0x00,
  0x01, 0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x30, 0xFF, 0xE0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x03, 0xF3, 0xFF, 0x80,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01,
  0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0xEC, 0x3C, 0xFF, 0x83, 0x80,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0x30, 0x00, 0x03, 0x18, 0x00, 0x03,
  0x8C, 0x00, 0x01, 0x86, 0x00, 0x01, 0x83, 0x00, 0x01, 0xC1, 0x80, 0x01,
  0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x30, 0x00, 0xE0, 0x18, 0x00,
  0x60, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x70, 0x01, 0x80,
  0x30, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x38, 0x00, 0x30, 0x38, 0x00, 0x18,
  0x18, 0x00, 0x0C, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x03, 0x0E, 0x00, 0x01,
  0x8F, 0x80, 0x00, 0xCE, 0xC0, 0x00, 0x66, 0x30, 0x00, 0x36, 0x18, 0x00,
  0x1E, 0x06, 0x00, 0x0F, 0x03, 0x00, 0x07, 0x00, 0xC0, 0x03, 0x00, 0x70,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x00,
  0xC0, 0x18, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0E, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x18, 0x30,
  0x00, 0x0C, 0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0xC6, 0x00, 0x00, 0x63,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01,
  0xB0, 0x00, 0x00, 0x60, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFD, 0x80, 0x00, 0x00, 0x03, 0x7B, 0x00, 0x00, 0x00, 0x06, 0xF6,
  0x00, 0x00, 0x00, 0x0D, 0xE6, 0x00, 0x00, 0x00, 0x33, 0xCC, 0x00, 0x00,
  0x00, 0x67, 0x98, 0x00, 0x00, 0x00, 0xCF, 0x18, 0x00, 0x00, 0x03, 0x1E,
  0x30, 0x00, 0x00, 0x06, 0x3C, 0x60, 0x00, 0x00, 0x0C, 0x78, 0x60, 0x00,
  0x00, 0x30, 0xF0, 0xC0, 0x00, 0x00, 0x61, 0xE1, 0x80, 0x00, 0x00, 0xC3,
  0xC1, 0x80, 0x00, 0x03, 0x07, 0x83, 0x00, 0x00, 0x06, 0x0F, 0x06, 0x00,
  0x00, 0x0C, 0x1E, 0x06, 0x00, 0x00, 0x30, 0x3C, 0x0C, 0x00, 0x00, 0x60,
  0x78, 0x18, 0x00, 0x00, 0xC0, 0xF0, 0x18, 0x00, 0x03, 0x01, 0xE0, 0x30,
  0x00, 0x06, 0x03, 0xC0, 0x60, 0x00, 0x0C, 0x07, 0x80, 0x60, 0x00, 0x30,
  0x0F, 0x00, 0xC0, 0x00, 0x60, 0x1E, 0x01, 0x80, 0x00, 0xC0, 0x3C, 0x01,
  0x80, 0x03, 0x00, 0x78, 0x03, 0x00, 0x06, 0x00, 0xF0, 0x06, 0x00, 0x0C,
  0x01, 0xE0, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x80,
  0x18, 0x00, 0xC0, 0x0F, 0x00, 0x18, 0x03, 0x00, 0x1E, 0x00, 0x30, 0x06,
  0x00, 0x3C, 0x00, 0x60, 0x0C, 0x00, 0x78, 0x00, 0x60, 0x30, 0x00, 0xF0,
  0x00, 0xC0, 0x60, 0x01, 0xE0, 0x01, 0x80, 0xC0, 0x03, 0xC0, 0x01, 0x83,
  0x00, 0x07, 0x80, 0x03, 0x06, 0x00, 0x0F, 0x00, 0x06, 0x0C, 0x00, 0x1E,
  0x00, 0x06, 0x30, 0x00, 0x3C, 0x00, 0x0C, 0x60, 0x00, 0x78, 0x00, 0x19,
  0xC0, 0x00, 0xF0, 0x00, 0x1B, 0x00, 0x01, 0xE0, 0x00, 0x36, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xD8, 0x00, 0x00, 0x3D, 0x80, 0x00, 0x03,
  0xCC, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x3C, 0x60,
  0x00, 0x03, 0xC3, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x03, 0xC1, 0x80, 0x00,
  0x3C, 0x18, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x3C, 0x0C, 0x00, 0x03, 0xC0,
  0x60, 0x00, 0x3C, 0x06, 0x00, 0x03, 0xC0, 0x30, 0x00, 0x3C, 0x03, 0x00,
  0x03, 0xC0, 0x18, 0x00, 0x3C, 0x01, 0x80, 0x03, 0xC0, 0x0C, 0x00, 0x3C,
  0x00, 0xC0, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x03,
  0x00, 0x3C, 0x00, 0x30, 0x03, 0xC0, 0x01, 0x80, 0x3C, 0x00, 0x18, 0x03,
  0xC0, 0x00, 0xC0, 0x3C, 0x00, 0x0C, 0x03, 0xC0, 0x00, 0x60, 0x3C, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x30, 0x3C, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x18,
  0x3C, 0x00, 0x00, 0xC3, 0xC0, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0x63, 0xC0,
  0x00, 0x06, 0x3C, 0x00, 0x00, 0x31, 0xC0, 0x00, 0x03, 0x1C, 0x00, 0x00,
  0x19, 0xC0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x0D, 0xC0, 0x00, 0x00, 0xDC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x30, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00, 0x30,
  0x1C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0x46, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x06, 0x60, 0x00,
  0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x0B, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xD0, 0x00,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00, 0x18,
  0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x00,
  0xC1, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00, 0x00,
  0x0C, 0x03, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0xC0, 0x01, 0x80, 0x00, 0x70, 0x00, 0x38, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x01, 0x80, 0x7F, 0x83, 0x00, 0x07, 0x86, 0x00, 0x03, 0x8C,
  0x00, 0x01, 0x98, 0x00, 0x03, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xD8, 0x00, 0x01, 0xB0, 0x00, 0x07, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x31,
  0x80, 0x01, 0xE3, 0x00, 0x0F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x18,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00, 0x01, 0x81, 0x80, 0x00,
  0x00, 0x30, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00,
  0x00, 0x00, 0x66, 0x00, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x06, 0x60,
  0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x64, 0x00, 0x00, 0x00, 0x0B,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x00, 0x36, 0x00, 0x00, 0x00, 0x09, 0x80, 0x00, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x01, 0x98, 0x00, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00,
  0x18, 0xC0, 0x00, 0x00, 0x0C, 0x30, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00,
  0x00, 0xC1, 0x80, 0x00, 0x00, 0x60, 0x60, 0x00, 0x00, 0x18, 0x0C, 0x00,
  0x00, 0x0C, 0x03, 0x80, 0x00, 0x03, 0x00, 0x60, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x70, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xE0, 0xFF,
  0xFE, 0x00, 0x60, 0x3F, 0xE0, 0x30, 0x00, 0x38, 0x18, 0x00, 0x07, 0x0C,
  0x00, 0x01, 0x86, 0x00, 0x00, 0x63, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C,
  0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00, 0x00,
  0x4C, 0x00, 0x00, 0x26, 0x00, 0x00, 0x13, 0x00, 0x00, 0x09, 0x80, 0x00,
  0x0C, 0xC0, 0x00, 0x06, 0x60, 0x00, 0x03, 0x30, 0x00, 0x01, 0x98, 0x00,
  0x00, 0xCC, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x61, 0x80,
  0x00, 0x60, 0xC0, 0x00, 0xE0, 0x60, 0x01, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x0E, 0x00, 0xC0, 0x03, 0x00, 0x60, 0x01, 0xC0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x38, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x03, 0x00, 0x01,
  0x81, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x1C, 0x30, 0x00,
  0x06, 0x18, 0x00, 0x03, 0x8C, 0x00, 0x00, 0xC6, 0x00, 0x00, 0x73, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x0E, 0xC0, 0x00, 0x03, 0x60, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x60, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x01, 0xE0, 0x03,
  0xC1, 0xC0, 0x00, 0x21, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x60, 0x00, 0x3C, 0x3F, 0x80, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x02, 0x60, 0x00, 0x00,
  0x66, 0x00, 0x00, 0x06, 0x70, 0x00, 0x00, 0xC3, 0x00, 0x00, 0x0C, 0x18,
  0x00, 0x01, 0x81, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x0E, 0x00, 0x3C, 0x03,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0xC0, 0x00, 0x00, 0x0E,
  0x80, 0x00, 0x00, 0x19, 0x80, 0x00, 0x00, 0x33, 0x00, 0x00, 0x00, 0x66,
  0x00, 0x00, 0x01, 0x84, 0x00, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x06, 0x18,
  0x00, 0x00, 0x18, 0x30, 0x00, 0x00, 0x30, 0x30, 0x00, 0x00, 0x60, 0x60,
  0x00, 0x00, 0xC0, 0xC0, 0x00, 0x03, 0x00, 0x80, 0x00, 0x06, 0x01, 0x80,
  0x00, 0x0C, 0x03, 0x00, 0x00, 0x10, 0x06, 0x00, 0x00, 0x60, 0x06, 0x00,
  0x00, 0xC0, 0x0C, 0x00, 0x01, 0x80, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x18, 0x00, 0x60, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x18, 0x00, 0x06, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x60,
  0x00, 0x18, 0x01, 0x80, 0x00, 0x30, 0x03, 0x00, 0x00, 0x30, 0x06, 0x00,
  0x00, 0x60, 0x08, 0x00, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x80, 0x60, 0x00,
  0x01, 0x80, 0xC0, 0x00, 0x03, 0x03, 0x00, 0x00, 0x06, 0x06, 0x00, 0x00,
  0x06, 0x0C, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00, 0x18, 0x60, 0x00, 0x00,
  0x30, 0xC0, 0x00, 0x00, 0x31, 0x80, 0x00, 0x00, 0x62, 0x00, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x00, 0x98, 0x00, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x16, 0x00, 0x00, 0x33, 0x00, 0x00, 0x1B,
  0x00, 0x00, 0x18, 0x80, 0x00, 0x0D, 0x80, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0xC0, 0x00, 0x06, 0x30, 0x00, 0x03, 0x60, 0x00, 0x06, 0x18, 0x00, 0x03,
  0x18, 0x00, 0x03, 0x0C, 0x00, 0x01, 0x8C, 0x00, 0x01, 0x83, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x63, 0x00, 0x00, 0xC0, 0xC0, 0x00,
  0x30, 0xC0, 0x00, 0x60, 0x60, 0x00, 0x30, 0x60, 0x00, 0x30, 0x18, 0x00,
  0x18, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x00, 0x80,
  0x03, 0x01, 0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0xC0, 0x01, 0x80, 0x30,
  0x00, 0xC0, 0x60, 0x01, 0x80, 0x18, 0x00, 0x60, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x00,
  0x60, 0x04, 0x00, 0x60, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x30, 0x06, 0x00,
  0x0C, 0x03, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x0C, 0x03, 0x00,
  0x03, 0x00, 0xC0, 0x03, 0x01, 0x80, 0x00, 0x80, 0xC0, 0x01, 0x80, 0xC0,
  0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60,
  0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x18,
  0x00, 0x03, 0x0C, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x86, 0x00, 0x03, 0x0C,
  0x00, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x00, 0x61, 0x80, 0x00, 0x63,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x31, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x19,
  0x80, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0, 0x00, 0x03, 0x30, 0x00, 0x06,
  0x60, 0x00, 0x00, 0x90, 0x00, 0x01, 0xB0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xD0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x18, 0x70, 0x00,
  0x07, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x0C, 0x00, 0x06, 0x01,
  0x80, 0x00, 0xC0, 0x18, 0x00, 0x30, 0x03, 0x00, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0xE0, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x01,
  0x80, 0x60, 0x00, 0x18, 0x0C, 0x00, 0x03, 0x01, 0x80, 0x00, 0x30, 0x60,
  0x00, 0x06, 0x0C, 0x00, 0x00, 0x63, 0x00, 0x00, 0x0C, 0x60, 0x00, 0x00,
  0xD8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x06,
  0xC0, 0x00, 0x01, 0x98, 0x00, 0x00, 0x31, 0x80, 0x00, 0x0C, 0x30, 0x00,
  0x01, 0x83, 0x00, 0x00, 0x60, 0x60, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x00,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x18, 0x01, 0x80, 0x03, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x07, 0x00, 0x06, 0x00, 0xC0, 0x00,
  0xC0, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x30,
  0x00, 0x03, 0x06, 0x00, 0x00, 0x61, 0x80, 0x00, 0x06, 0x30, 0x00, 0x00,
  0xCC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x00, 0xEC,
  0x00, 0x00, 0x19, 0x80, 0x00, 0x03, 0x18, 0x00, 0x00, 0xC3, 0x00, 0x00,
  0x18, 0x60, 0x00, 0x06, 0x06, 0x00, 0x00, 0xC0, 0xC0, 0x00, 0x18, 0x0C,
  0x00, 0x06, 0x01, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x38, 0x03, 0x00, 0x06,
  0x00, 0x60, 0x00, 0xC0, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xC0, 0x01, 0x80, 0x30, 0x00, 0x30, 0x06, 0x00, 0x02, 0x01, 0x80,
  0x00, 0x60, 0x30, 0x00, 0x0C, 0x06, 0x00, 0x00, 0xC1, 0x80, 0x00, 0x18,
  0x30, 0x00, 0x03, 0x0C, 0x00, 0x00, 0x31, 0x80, 0x00, 0x06, 0x30, 0x00,
  0x00, 0x6C, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0xFF, 0xF0, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x30, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0D,
  0x80, 0x00, 0x00, 0xD8, 0x00, 0x00, 0x18, 0xC0, 0x00, 0x01, 0x8C, 0x00,
  0x00, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x00, 0x60, 0x30, 0x00, 0x06,
  0x03, 0x00, 0x00, 0xC0, 0x18, 0x00, 0x0C, 0x01, 0x80, 0x01, 0x80, 0x0C,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x70, 0x00, 0x60, 0x06,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x30, 0x0C, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x18, 0x18, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x0C, 0x30, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x06, 0x60, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x07,
  0xE0, 0xF0, 0x30, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x1F, 0xFE, 0x03, 0xF0, 0x30, 0x70,
  0x01, 0x8E, 0x00, 0x0C, 0xE0, 0x00, 0x66, 0x00, 0x03, 0x60, 0x00, 0x1B,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x2E, 0x00, 0x03, 0x58,
  0x00, 0x12, 0xE0, 0x01, 0x93, 0x80, 0x18, 0x8E, 0x03, 0x84, 0x3F, 0xF8,
  0x20, 0x3E, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x1F, 0x00, 0x60, 0x7F, 0xF0, 0x30,
  0xF0, 0x3C, 0x18, 0xE0, 0x07, 0x0C, 0xE0, 0x00, 0xC6, 0x60, 0x00, 0x73,
  0x60, 0x00, 0x19, 0xB0, 0x00, 0x0C, 0xD0, 0x00, 0x03, 0x78, 0x00, 0x01,
  0xB8, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1B, 0x80, 0x00, 0x0D, 0xE0, 0x00, 0x06, 0xD0, 0x00, 0x06,
  0x6C, 0x00, 0x03, 0x33, 0x00, 0x03, 0x19, 0x80, 0x03, 0x8C, 0x70, 0x03,
  0x86, 0x1E, 0x0F, 0x83, 0x07, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0E,
  0x00, 0x0F, 0xFF, 0x01, 0xE0, 0x70, 0x78, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x10, 0x3C, 0x07, 0x01, 0xFF, 0xF0,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0x00, 0x3C, 0x01, 0x80, 0xFF, 0xC0, 0xC0, 0xF0,
  0x78, 0x61, 0xC0, 0x0E, 0x30, 0xC0, 0x01, 0x98, 0xC0, 0x00, 0xCC, 0xE0,
  0x00, 0x36, 0x60, 0x00, 0x0B, 0x60, 0x00, 0x07, 0xB0, 0x00, 0x03, 0xD8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3B, 0x00,
  0x00, 0x1D, 0x80, 0x00, 0x1E, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x05, 0x98,
  0x00, 0x06, 0xCE, 0x00, 0x06, 0x63, 0x80, 0x03, 0x30, 0xE0, 0x07, 0x18,
  0x3C, 0x0F, 0x0C, 0x0F, 0xFE, 0x06, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0x0F, 0x00, 0x70, 0x03, 0x00, 0xC0, 0x03, 0x03,
  0x00, 0x03, 0x0E, 0x00, 0x06, 0x18, 0x00, 0x06, 0x60, 0x00, 0x0C, 0xC0,
  0x00, 0x19, 0x80, 0x00, 0x13, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x60, 0x00, 0x20, 0x70, 0x00, 0xC0, 0x78, 0x0F, 0x80, 0x7F,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1C, 0x04, 0x06,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0xC1, 0x07, 0xC1, 0xE1, 0x0E, 0x00, 0x31, 0x1C, 0x00, 0x19, 0x18,
  0x00, 0x0D, 0x30, 0x00, 0x0D, 0x30, 0x00, 0x07, 0x60, 0x00, 0x07, 0x60,
  0x00, 0x03, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x40,
  0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x05, 0x30, 0x00, 0x0D, 0x30,
  0x00, 0x0D, 0x18, 0x00, 0x19, 0x1C, 0x00, 0x31, 0x0E, 0x00, 0x73, 0x07,
  0x81, 0xE3, 0x01, 0xFF, 0x83, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x40, 0x00, 0x38, 0x70,
  0x00, 0x70, 0x3F, 0xDF, 0xE0, 0x07, 0xFF, 0x80, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x80, 0x38, 0x02, 0x07, 0xFE, 0x08, 0x7C, 0x3C,
  0x23, 0x80, 0x38, 0x9C, 0x00, 0x72, 0x60, 0x00, 0xCB, 0x00, 0x01, 0xA8,
  0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x6F, 0xFE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x03, 0x80, 0xE0, 0x3C, 0x0E, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x0C, 0x03, 0x00, 0xC0, 0x63, 0x78, 0xFC, 0x00, 0x80, 0x00, 0x08,
  0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00,
  0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x08, 0x00,
  0x00, 0x80, 0x00, 0x08, 0x00, 0x0E, 0x80, 0x00, 0xC8, 0x00, 0x18, 0x80,
  0x03, 0x08, 0x00, 0x30, 0x80, 0x06, 0x08, 0x00, 0xC0, 0x80, 0x1C, 0x08,
  0x01, 0x80, 0x80, 0x30, 0x08, 0x06, 0x00, 0x80, 0x60, 0x08, 0x0C, 0x00,
  0x81, 0x80, 0x08, 0x18, 0x00, 0x83, 0x80, 0x08, 0x78, 0x00, 0x8C, 0xC0,
  0x08, 0xCC, 0x00, 0x98, 0x60, 0x0B, 0x06, 0x00, 0xA0, 0x30, 0x0E, 0x03,
  0x00, 0xC0, 0x18, 0x08, 0x01, 0x80, 0x80, 0x0C, 0x08, 0x00, 0xC0, 0x80,
  0x06, 0x08, 0x00, 0x60, 0x80, 0x03, 0x08, 0x00, 0x30, 0x80, 0x01, 0x88,
  0x00, 0x18, 0x80, 0x00, 0xC8, 0x00, 0x0C, 0x80, 0x00, 0x68, 0x00, 0x06,
  0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78,
  0x00, 0x1E, 0x02, 0x0F, 0xF8, 0x03, 0xFE, 0x08, 0x70, 0x70, 0x1C, 0x1E,
  0x23, 0x00, 0x60, 0xC0, 0x1C, 0x98, 0x00, 0xC6, 0x00, 0x32, 0xC0, 0x03,
  0x30, 0x00, 0x6B, 0x00, 0x06, 0x80, 0x01, 0xA8, 0x00, 0x1E, 0x00, 0x06,
  0xE0, 0x00, 0x78, 0x00, 0x0B, 0x00, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x00, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x02, 0x07, 0xFE, 0x08, 0x78, 0x1C,
  0x23, 0x80, 0x18, 0x9C, 0x00, 0x32, 0x60, 0x00, 0xCB, 0x00, 0x01, 0xA8,
  0x00, 0x06, 0xE0, 0x00, 0x1B, 0x00, 0x00, 0x2C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xF0,
  0x7C, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x38, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x06, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xD8, 0x00, 0x00, 0x6C, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x33, 0x00,
  0x00, 0x19, 0x80, 0x00, 0x0C, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x06, 0x18,
  0x00, 0x07, 0x06, 0x00, 0x03, 0x03, 0x80, 0x03, 0x00, 0xE0, 0x03, 0x80,
  0x3C, 0x0F, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x81, 0xFF, 0x80, 0x83, 0xC1, 0xE0, 0x86, 0x00, 0x70, 0x8C, 0x00, 0x38,
  0x98, 0x00, 0x1C, 0x90, 0x00, 0x0C, 0xB0, 0x00, 0x0E, 0xA0, 0x00, 0x06,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x02, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x06, 0xE0, 0x00, 0x06, 0xA0, 0x00, 0x06, 0xB0, 0x00, 0x0C,
  0xB0, 0x00, 0x0C, 0x98, 0x00, 0x18, 0x9C, 0x00, 0x38, 0x8E, 0x00, 0x70,
  0x87, 0x81, 0xE0, 0x81, 0xFF, 0x80, 0x80, 0x3C, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xFF, 0x81, 0x03, 0xC1, 0xE1, 0x0E, 0x00, 0x71, 0x0C, 0x00, 0x19,
  0x18, 0x00, 0x19, 0x30, 0x00, 0x0D, 0x30, 0x00, 0x05, 0x60, 0x00, 0x07,
  0x60, 0x00, 0x07, 0x60, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x60, 0x00, 0x07, 0x60, 0x00, 0x05, 0x70, 0x00, 0x0D,
  0x30, 0x00, 0x09, 0x38, 0x00, 0x19, 0x1C, 0x00, 0x33, 0x0E, 0x00, 0x63,
  0x07, 0x83, 0xC3, 0x01, 0xFF, 0x83, 0x00, 0x3C, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x21, 0x03,
  0xFE, 0x1E, 0x34, 0x70, 0x08, 0xC0, 0x13, 0x00, 0x2C, 0x00, 0x58, 0x00,
  0xA0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04,
  0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00,
  0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x7F, 0xFC, 0x1F, 0x03, 0xE3, 0x80, 0x02, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0x68, 0x00, 0x0C, 0xC0, 0x01, 0xCF, 0xC0, 0xF8, 0x3F, 0xFE,
  0x00, 0x3E, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x08,
  0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01, 0x00, 0x02, 0x00,
  0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x01,
  0x00, 0x02, 0x00, 0x04, 0x00, 0x08, 0x00, 0x10, 0x00, 0x20, 0x00, 0x40,
  0x00, 0x80, 0x01, 0x00, 0x02, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x40, 0x7F, 0x80, 0x3C, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x76, 0x00, 0x01, 0x58, 0x00,
  0x05, 0x60, 0x00, 0x35, 0xC0, 0x01, 0x93, 0x00, 0x0E, 0x46, 0x00, 0x71,
  0x1E, 0x07, 0x84, 0x1F, 0xF8, 0x10, 0x0F, 0x80, 0x00, 0xC0, 0x00, 0x03,
  0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x60, 0x00, 0x06, 0x20, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x0C, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0xC0, 0x03, 0x00, 0xC0,
  0x03, 0x00, 0xC0, 0x01, 0x01, 0x80, 0x01, 0x81, 0x80, 0x01, 0x81, 0x80,
  0x01, 0x81, 0x80, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x00,
  0x00, 0x42, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00,
  0x00, 0x24, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x18, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0B, 0x00, 0x00, 0xE0, 0x00, 0x33, 0x00, 0x01, 0xC0, 0x00, 0x66, 0x00,
  0x02, 0xC0, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x01, 0x18, 0x00, 0x1B, 0x00,
  0x06, 0x18, 0x00, 0x32, 0x00, 0x0C, 0x30, 0x00, 0x46, 0x00, 0x18, 0x60,
  0x01, 0x8C, 0x00, 0x30, 0xC0, 0x03, 0x18, 0x00, 0x40, 0xC0, 0x06, 0x10,
  0x01, 0x81, 0x80, 0x08, 0x30, 0x03, 0x03, 0x00, 0x30, 0x60, 0x06, 0x06,
  0x00, 0x60, 0xC0, 0x08, 0x04, 0x00, 0xC0, 0x80, 0x30, 0x0C, 0x01, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x00,
  0x20, 0x18, 0x04, 0x06, 0x00, 0x60, 0x20, 0x0C, 0x0C, 0x00, 0xC0, 0xC0,
  0x18, 0x18, 0x01, 0x81, 0x80, 0x30, 0x30, 0x01, 0x03, 0x00, 0x20, 0xC0,
  0x03, 0x04, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0xC3, 0x00, 0x0C, 0x30,
  0x01, 0x86, 0x00, 0x08, 0x60, 0x01, 0x08, 0x00, 0x18, 0x80, 0x03, 0x30,
  0x00, 0x33, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x00, 0xCC,
  0x00, 0x09, 0x00, 0x00, 0xD0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x06,
  0x30, 0x00, 0x0C, 0x38, 0x00, 0x0C, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x18,
  0x0C, 0x00, 0x30, 0x06, 0x00, 0x30, 0x06, 0x00, 0x60, 0x03, 0x00, 0x60,
  0x03, 0x00, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0x81, 0x80, 0x00, 0xC3, 0x80,
  0x00, 0xC3, 0x00, 0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x66, 0x00, 0x00, 0x66, 0x00, 0x00, 0xC3, 0x00, 0x00, 0xC3, 0x80,
  0x01, 0x81, 0x80, 0x01, 0x81, 0xC0, 0x03, 0x00, 0xC0, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0x30, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x18,
  0x18, 0x00, 0x18, 0x30, 0x00, 0x0C, 0x30, 0x00, 0x0C, 0x60, 0x00, 0x06,
  0xE0, 0x00, 0x07, 0x60, 0x00, 0x01, 0x90, 0x00, 0x01, 0x8C, 0x00, 0x00,
  0xC6, 0x00, 0x00, 0x63, 0x00, 0x00, 0x20, 0xC0, 0x00, 0x30, 0x60, 0x00,
  0x18, 0x30, 0x00, 0x0C, 0x08, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00,
  0x03, 0x01, 0x80, 0x03, 0x00, 0x60, 0x01, 0x80, 0x30, 0x00, 0xC0, 0x18,
  0x00, 0x60, 0x04, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x18, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x02, 0x00,
  0x03, 0x03, 0x00, 0x01, 0x81, 0x80, 0x00, 0xC0, 0xC0, 0x00, 0x60, 0xC0,
  0x00, 0x18, 0x60, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x00, 0x01, 0x98,
  0x00, 0x00, 0xCC, 0x00, 0x00, 0x66, 0x00, 0x00, 0x16, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x70, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00,
  0x06, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x05, 0xE1, 0xE0, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x00, 0x7C, 0x3D, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x04,
  0x00,
};

const GFXglyph NotoSans_Condensed_Thin72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 52, 15, 5, -51 },
  { 27, 12, 18, 22, 5, -51 },
  { 54, 32, 51, 35, 2, -51 },
  { 258, 25, 59, 32, 3, -55 },
  { 443, 38, 53, 46, 4, -52 },
  { 695, 31, 53, 35, 3, -52 },
  { 901, 2, 18, 12, 5, -51 },
  { 906, 13, 62, 19, 3, -51 },
  { 1007, 12, 62, 19, 3, -51 },
  { 1100, 21, 22, 29, 4, -55 },
  { 1158, 27, 33, 32, 3, -42 },
  { 1270, 6, 17, 13, 3, -8 },
  { 1283, 16, 2, 20, 2, -21 },
  { 1287, 4, 5, 14, 5, -4 },
  { 1290, 20, 51, 23, 2, -51 },
  { 1418, 24, 53, 32, 4, -52 },
  { 1577, 13, 51, 32, 6, -51 },
  { 1660, 25, 52, 32, 3, -52 },
  { 1823, 25, 53, 32, 3, -52 },
  { 1989, 30, 52, 32, 1, -52 },
  { 2184, 25, 52, 32, 4, -51 },
  { 2347, 25, 53, 32, 4, -52 },
  { 2513, 25, 51, 32, 3, -51 },
  { 2673, 26, 53, 32, 3, -52 },
  { 2846, 25, 53, 32, 3, -52 },
  { 3012, 4, 38, 14, 5, -38 },
  { 3031, 6, 47, 14, 3, -38 },
  { 3067, 27, 31, 32, 3, -41 },
  { 3172, 27, 17, 32, 3, -34 },
  { 3230, 27, 31, 32, 3, -41 },
  { 3335, 18, 53, 22, 2, -52 },
  { 3455, 42, 58, 49, 4, -51 },
  { 3760, 31, 51, 31, 0, -51 },
  { 3958, 26, 51, 35, 6, -51 },
  { 4124, 28, 53, 34, 4, -52 },
  { 4310, 29, 51, 39, 6, -51 },
  { 4495, 21, 51, 31, 6, -51 },
  { 4629, 21, 51, 28, 6, -51 },
  { 4763, 33, 53, 42, 4, -52 },
  { 4982, 28, 51, 40, 6, -51 },
  { 5161, 11, 51, 17, 3, -51 },
  { 5232, 12, 64, 14, -4, -51 },
  { 5328, 25, 51, 31, 6, -51 },
  { 5488, 21, 51, 28, 6, -51 },
  { 5622, 39, 51, 51, 6, -51 },
  { 5871, 28, 51, 40, 6, -51 },
  { 6050, 34, 53, 42, 4, -52 },
  { 6276, 23, 51, 32, 6, -51 },
  { 6423, 34, 64, 42, 4, -52 },
  { 6695, 25, 51, 33, 6, -51 },
  { 6855, 25, 53, 31, 3, -52 },
  { 7021, 27, 51, 28, 0, -51 },
  { 7194, 28, 52, 40, 6, -51 },
  { 7376, 31, 51, 31, 0, -51 },
  { 7574, 49, 51, 51, 1, -51 },
  { 7887, 27, 51, 28, 0, -51 },
  { 8060, 27, 51, 27, 0, -51 },
  { 8233, 25, 51, 29, 2, -51 },
  { 8393, 14, 62, 22, 6, -51 },
  { 8502, 20, 51, 23, 2, -51 },
  { 8630, 14, 62, 22, 2, -51 },
  { 8739, 28, 26, 32, 2, -51 },
  { 8830, 28, 1, 28, 0, 7 },
  { 8834, 11, 11, 17, 3, -55 },
  { 8850, 21, 40, 29, 3, -39 },
  { 8955, 25, 56, 34, 5, -55 },
  { 9130, 20, 40, 26, 4, -39 },
  { 9230, 25, 56, 34, 4, -55 },
  { 9405, 23, 40, 31, 4, -39 },
  { 9520, 18, 55, 17, 1, -55 },
  { 9644, 24, 56, 34, 4, -39 },
  { 9812, 22, 55, 33, 6, -55 },
  { 9964, 4, 52, 13, 5, -52 },
  { 9990, 10, 69, 13, -1, -52 },
  { 10077, 20, 55, 26, 6, -55 },
  { 10215, 1, 55, 13, 6, -55 },
  { 10222, 38, 39, 49, 6, -39 },
  { 10408, 22, 39, 33, 6, -39 },
  { 10516, 25, 40, 33, 4, -39 },
  { 10641, 24, 56, 34, 6, -39 },
  { 10809, 24, 56, 34, 4, -39 },
  { 10977, 15, 39, 21, 6, -39 },
  { 11051, 20, 40, 26, 3, -39 },
  { 11151, 15, 48, 17, 1, -47 },
  { 11241, 22, 39, 33, 5, -38 },
  { 11349, 24, 38, 24, 0, -38 },
  { 11463, 39, 38, 41, 1, -38 },
  { 11649, 24, 38, 26, 1, -38 },
  { 11763, 25, 55, 25, 0, -38 },
  { 11935, 19, 38, 23, 2, -38 },
  { 12026, 18, 62, 25, 3, -51 },
  { 12166, 2, 73, 31, 14, -55 },
  { 12185, 18, 62, 25, 3, -51 },
  { 12325, 27, 7, 32, 3, -29 },
};

const GFXfont NotoSans_Condensed_Thin72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Thin72pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Thin72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_CONDENSED_THIN72PT7B_H_
