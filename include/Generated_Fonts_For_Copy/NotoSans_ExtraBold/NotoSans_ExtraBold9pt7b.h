#ifndef _NOTOSANS_EXTRABOLD9PT7B_H_
#define _NOTOSANS_EXTRABOLD9PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold9pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x30, 0xB4, 0x2B, 0xF3, 0x3E, 0x51, 0x40, 0x23, 0xF8, 0xE3,
  0xFD, 0xC4, 0x42, 0xE4, 0xA8, 0xEF, 0x55, 0x15, 0x27, 0x20, 0xF1, 0x63,
  0xBD, 0x59, 0x9F, 0x80, 0xC0, 0x29, 0x6D, 0x93, 0xC9, 0xB6, 0xDE, 0x25,
  0x7C, 0xA0, 0x27, 0xC8, 0x40, 0x70, 0xE0, 0xC0, 0x32, 0x26, 0x44, 0xC0,
  0x23, 0xB7, 0xBD, 0xAD, 0xC0, 0x7F, 0x33, 0x33, 0x27, 0xC6, 0x23, 0x23,
  0xE0, 0x27, 0xC6, 0xE1, 0xCF, 0xC0, 0x31, 0x95, 0xAF, 0x88, 0x72, 0x1C,
  0x39, 0xF8, 0x13, 0x91, 0xFD, 0xED, 0xC0, 0xF8, 0x84, 0x62, 0x30, 0x23,
  0xF6, 0xE5, 0xED, 0xC0, 0x23, 0xB7, 0xB7, 0x89, 0xC0, 0xD0, 0xC0, 0xD0,
  0x70, 0x09, 0xF8, 0xE1, 0x80, 0xF8, 0x3E, 0x87, 0x06, 0x6C, 0x00, 0x2F,
  0x13, 0x40, 0x60, 0x3E, 0x5E, 0xE5, 0xA5, 0x5E, 0x64, 0x1C, 0x30, 0xE6,
  0x9F, 0x7F, 0x10, 0xF4, 0xBD, 0x29, 0xF8, 0x15, 0xE4, 0x30, 0x41, 0x93,
  0x80, 0xF4, 0xE3, 0x39, 0xF8, 0xF8, 0xE8, 0x8F, 0xF3, 0xF9, 0x00, 0x11,
  0xF4, 0x37, 0x5D, 0xB3, 0xC0, 0x8C, 0x7F, 0x18, 0xC4, 0xED, 0xB7, 0xC0,
  0x24, 0x92, 0x4F, 0x9D, 0xB9, 0xEB, 0x4C, 0x88, 0x88, 0x8F, 0xCF, 0x9F,
  0xBD, 0x7B, 0x76, 0xC0, 0xCF, 0xBA, 0xEF, 0x9E, 0x70, 0x10, 0xF9, 0x16,
  0x34, 0x6D, 0x8F, 0x00, 0xF9, 0xBE, 0x88, 0x10, 0xF9, 0x16, 0x34, 0x6D,
  0x8F, 0x06, 0x06, 0xF4, 0xBD, 0xCB, 0x4C, 0x23, 0xF0, 0xE3, 0xCF, 0xC0,
  0xF9, 0x08, 0x42, 0x10, 0x8C, 0x63, 0x1D, 0xF8, 0xCD, 0x24, 0x9E, 0x30,
  0xC0, 0xC9, 0xAA, 0x95, 0x4A, 0xA7, 0x71, 0xB0, 0xCD, 0xE3, 0x0E, 0x6B,
  0x30, 0xCD, 0xE3, 0x0C, 0x30, 0xC0, 0xF8, 0x8C, 0xC4, 0x7C, 0xFA, 0xAB,
  0x8C, 0x44, 0x62, 0x30, 0xF5, 0x57, 0x22, 0x95, 0x10, 0xF0, 0xC4, 0x70,
  0xDF, 0xB6, 0x80, 0x88, 0xF9, 0x99, 0xF0, 0x7A, 0x30, 0x97, 0x00, 0x08,
  0x5A, 0xBC, 0xA5, 0xE0, 0x72, 0x7E, 0x87, 0x80, 0x74, 0xF4, 0x44, 0x40,
  0x7A, 0xF3, 0x97, 0x8D, 0xE0, 0x88, 0xF9, 0x99, 0x90, 0xFE, 0x55, 0x55,
  0xC0, 0x84, 0x27, 0x4E, 0x5A, 0x60, 0xFE, 0xFF, 0x26, 0x4C, 0x99, 0x20,
  0xF9, 0x99, 0x90, 0x72, 0x72, 0x97, 0x80, 0xF9, 0x99, 0xF8, 0x80, 0x6A,
  0xF3, 0x97, 0x84, 0x20, 0xFA, 0x48, 0x7C, 0x71, 0xF0, 0x4F, 0x44, 0x47,
  0x99, 0x99, 0xF0, 0xCA, 0xD4, 0xE3, 0x00, 0xDB, 0xDA, 0x5A, 0x6E, 0x66,
  0xDB, 0x8C, 0xED, 0x80, 0xCA, 0xD4, 0xE3, 0x13, 0x80, 0xF3, 0x64, 0xF0,
  0x6D, 0xE6, 0xD8, 0xFF, 0x80, 0xC4, 0x43, 0x44, 0xC0, 0xEC, 0x80,
};

const GFXglyph NotoSans_ExtraBold9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 3, 0, -6 },
  { 3, 3, 2, 5, 1, -6 },
  { 4, 6, 6, 6, 0, -6 },
  { 9, 5, 8, 5, 0, -7 },
  { 14, 8, 7, 8, 0, -7 },
  { 21, 7, 7, 7, 0, -7 },
  { 28, 1, 2, 3, 1, -6 },
  { 29, 3, 8, 3, 0, -7 },
  { 32, 3, 8, 3, 0, -7 },
  { 35, 5, 4, 5, 0, -7 },
  { 38, 5, 4, 5, 0, -5 },
  { 41, 2, 2, 3, 0, -1 },
  { 42, 3, 1, 3, 0, -3 },
  { 43, 2, 1, 3, 0, -1 },
  { 44, 4, 7, 4, 0, -7 },
  { 48, 5, 7, 5, 0, -7 },
  { 53, 4, 6, 5, 0, -6 },
  { 56, 5, 7, 5, 0, -7 },
  { 61, 5, 7, 5, 0, -7 },
  { 66, 5, 6, 5, 0, -6 },
  { 70, 5, 6, 5, 0, -6 },
  { 74, 5, 7, 5, 0, -7 },
  { 79, 5, 6, 5, 0, -6 },
  { 83, 5, 7, 5, 0, -7 },
  { 88, 5, 7, 5, 0, -7 },
  { 93, 2, 5, 3, 0, -5 },
  { 95, 2, 6, 3, 0, -5 },
  { 97, 5, 5, 5, 0, -6 },
  { 101, 5, 3, 5, 0, -5 },
  { 103, 5, 5, 5, 0, -6 },
  { 107, 4, 7, 4, 0, -7 },
  { 111, 8, 7, 8, 0, -6 },
  { 118, 6, 6, 6, 0, -6 },
  { 123, 5, 6, 6, 1, -6 },
  { 127, 6, 7, 6, 0, -7 },
  { 133, 5, 6, 7, 1, -6 },
  { 137, 4, 6, 5, 1, -6 },
  { 140, 3, 6, 5, 1, -6 },
  { 143, 6, 7, 7, 0, -7 },
  { 149, 5, 6, 7, 1, -6 },
  { 153, 3, 6, 4, 0, -6 },
  { 156, 3, 8, 3, -1, -6 },
  { 159, 5, 6, 6, 1, -6 },
  { 163, 4, 6, 5, 1, -6 },
  { 166, 7, 6, 9, 1, -6 },
  { 172, 6, 6, 7, 1, -6 },
  { 177, 7, 7, 7, 0, -7 },
  { 184, 4, 6, 6, 1, -6 },
  { 187, 7, 9, 7, 0, -7 },
  { 195, 5, 6, 6, 1, -6 },
  { 199, 5, 7, 5, 0, -7 },
  { 204, 5, 6, 5, 0, -6 },
  { 208, 5, 6, 7, 1, -6 },
  { 212, 6, 6, 6, 0, -6 },
  { 217, 9, 6, 9, 0, -6 },
  { 224, 6, 6, 6, 0, -6 },
  { 229, 6, 6, 6, 0, -6 },
  { 234, 5, 6, 5, 0, -6 },
  { 238, 2, 8, 3, 1, -7 },
  { 240, 4, 7, 4, 0, -7 },
  { 244, 2, 8, 3, 0, -7 },
  { 246, 5, 4, 5, 0, -6 },
  { 249, 4, 1, 4, 0, 1 },
  { 250, 3, 2, 4, 0, -7 },
  { 251, 5, 5, 5, 0, -5 },
  { 255, 4, 7, 6, 1, -7 },
  { 259, 5, 5, 5, 0, -5 },
  { 263, 5, 7, 6, 0, -7 },
  { 268, 5, 5, 5, 0, -5 },
  { 272, 4, 7, 4, 0, -7 },
  { 276, 5, 7, 6, 0, -5 },
  { 281, 4, 7, 6, 1, -7 },
  { 285, 1, 7, 3, 1, -7 },
  { 286, 2, 9, 3, 0, -7 },
  { 289, 5, 7, 6, 1, -7 },
  { 294, 1, 7, 3, 1, -7 },
  { 295, 7, 5, 9, 1, -5 },
  { 300, 4, 5, 6, 1, -5 },
  { 303, 5, 5, 6, 0, -5 },
  { 307, 4, 7, 6, 1, -5 },
  { 311, 5, 7, 6, 0, -5 },
  { 316, 3, 5, 4, 1, -5 },
  { 318, 4, 5, 5, 0, -5 },
  { 321, 4, 6, 4, 0, -6 },
  { 324, 4, 5, 6, 1, -5 },
  { 327, 5, 5, 5, 0, -5 },
  { 331, 8, 5, 8, 0, -5 },
  { 336, 5, 5, 5, 0, -5 },
  { 340, 5, 7, 5, 0, -5 },
  { 345, 4, 5, 4, 0, -5 },
  { 348, 3, 7, 4, 0, -6 },
  { 351, 1, 9, 5, 2, -7 },
  { 353, 4, 7, 4, 0, -6 },
  { 357, 5, 2, 5, 0, -4 },
};

const GFXfont NotoSans_ExtraBold9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold9pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_EXTRABOLD9PT7B_H_
