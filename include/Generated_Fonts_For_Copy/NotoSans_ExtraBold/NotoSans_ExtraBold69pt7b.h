#ifndef _NOTOSANS_EXTRABOLD69PT7B_H_
#define _NOTOSANS_EXTRABOLD69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold69pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD,
  0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x07, 0xFE, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFE, 0x3F, 0xE0, 0x7C, 0x00, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0x7F, 0xE0, 0xFF, 0xDF, 0xF8, 0x3F, 0xF7, 0xFE, 0x0F, 0xFD, 0xFF, 0x03,
  0xFF, 0x7F, 0xC0, 0xFF, 0xDF, 0xF0, 0x3F, 0xF7, 0xFC, 0x0F, 0xF9, 0xFF,
  0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x1F, 0xE7, 0xFC, 0x07, 0xF9,
  0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFC, 0x7E, 0x07, 0xC7, 0xFF, 0x0F, 0xC0, 0x18, 0xFF, 0xE1, 0xF8, 0x00,
  0x1F, 0xFC, 0x3F, 0x00, 0x03, 0xFF, 0xC7, 0xE0, 0x00, 0x3F, 0xFC, 0xFC,
  0x00, 0x07, 0xFF, 0xDF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xE7, 0xFF, 0x80, 0x00, 0xFC, 0x7F, 0xF0,
  0x00, 0x1F, 0x87, 0xFE, 0x80, 0x03, 0xF0, 0xFF, 0xDC, 0x00, 0x7E, 0x3F,
  0xFB, 0xF0, 0x0F, 0xC7, 0xFF, 0x7F, 0xF1, 0xFB, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFF, 0xC0,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0xFE, 0x07, 0xFE, 0x7F, 0xE3, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xE3, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC7, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xC7, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xF8, 0x7F, 0xE7, 0xFE, 0x07, 0xFF, 0xE1,
  0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x3F, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xFE,
  0x00, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xCF,
  0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF9, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF,
  0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xC7, 0xF8, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x40, 0x07, 0xF0,
  0x01, 0x3E, 0x03, 0xF8, 0x07, 0x9F, 0xE1, 0xFC, 0x3F, 0xEF, 0xFF, 0xFE,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0x1F, 0xF8, 0x01,
  0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80,
  0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x20, 0x0C, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x7F,
  0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xF8, 0x7F, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFB, 0xFF, 0x8F, 0xF8, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x1F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC,
  0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x0F,
  0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xC0,
  0x07, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x0F, 0xFE, 0xFF,
  0xE0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xE0,
  0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x0F, 0xFF, 0x7F,
  0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF,
  0xBF, 0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x07,
  0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x3F, 0xFE, 0x1F, 0xFE,
  0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x3F, 0xFC,
  0xFF, 0x8F, 0xFF, 0x3F, 0xC3, 0xFF, 0xC7, 0xE0, 0xFF, 0xF0, 0xF0, 0x3F,
  0xFC, 0x10, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xF0, 0x3F, 0xFF, 0x07, 0xF8, 0x03, 0xFF, 0xE0, 0xFC, 0x00, 0x3F, 0xFC,
  0x0F, 0x00, 0x07, 0xFF, 0x80, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0x80, 0x3F, 0xFF, 0x03, 0x80, 0x03, 0xFF, 0xE0, 0x40,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x7F,
  0xF0, 0x00, 0x07, 0xFD, 0xFF, 0xC0, 0x00, 0x3F, 0xE7, 0xFF, 0x00, 0x01,
  0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF,
  0xC0, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x3F,
  0xF0, 0x7F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x7F,
  0xFF, 0xF8, 0x10, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xA0, 0x00, 0x01, 0xFF,
  0xEF, 0x00, 0x00, 0xFF, 0xFB, 0xF8, 0x00, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x30, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x1F, 0xFF, 0x80, 0x7F, 0xE3,
  0xFF, 0xFE, 0x07, 0xFE, 0x7F, 0xFF, 0xF0, 0x7F, 0xEF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xFC,
  0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x0F,
  0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF8,
  0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0xE3,
  0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFC, 0x03, 0xFF,
  0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0x9F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFB,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFC, 0x7F,
  0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFE, 0x7F,
  0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x3F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xF0, 0x1F,
  0xFE, 0x3F, 0xFC, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xFD, 0xFF, 0xE0,
  0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x03,
  0xFF, 0xDF, 0xFE, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0xFF, 0xFC, 0xFF,
  0xC1, 0xFF, 0xFF, 0x3F, 0xF8, 0x0F, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x01, 0xF7, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0xFF,
  0x0F, 0xFC, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xDF, 0xFC, 0x3F, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x1F, 0xF9, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xBF, 0xF8, 0xFF,
  0x81, 0xF0, 0x01, 0x00, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF, 0x83, 0xFC, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC,
  0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x3F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC,
  0x3F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFC, 0x7F, 0xFF, 0x1F, 0xC0, 0x0F, 0xFF, 0x0E, 0x00, 0x07, 0xFF,
  0x08, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xF8,
  0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC3, 0xFE, 0x3F,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFE, 0x7F, 0xC1, 0xFF, 0xC0,
  0x7F, 0xC1, 0xFF, 0x7F, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x7F, 0x81,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0xFF, 0x83, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x7F,
  0x80, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0xFF, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x81,
  0xFE, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0xFF, 0x03, 0xFE, 0x00,
  0xFF, 0x81, 0xFE, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x83, 0xFC, 0xFF, 0x83,
  0xFF, 0x03, 0xFF, 0xC7, 0xFC, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF, 0xCF, 0xFF, 0xE0, 0x7F, 0xC0, 0x3F,
  0xFF, 0x87, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xBF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xCF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF1,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x87, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE3, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFD, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xFF,
  0x3F, 0xF8, 0x00, 0xFF, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xEF, 0xFE, 0x00,
  0x1F, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x07, 0xFF, 0x9F,
  0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x1F,
  0xFF, 0x3F, 0xF8, 0x03, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFE, 0x00, 0x7F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xFB, 0xFF, 0x80, 0x03,
  0xFF, 0xDF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFE, 0x00, 0x7F, 0x07, 0xFF, 0xE0, 0x00, 0x38, 0x3F, 0xFF,
  0x00, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0x0F, 0xFF, 0xF0, 0x00, 0x3C, 0x1F,
  0xFF, 0xF0, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xF0, 0x1F, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xFF,
  0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xCF, 0xFE, 0x00, 0x07, 0xFF, 0xE7, 0xFF,
  0x00, 0x01, 0xFF, 0xF3, 0xFF, 0x80, 0x00, 0x7F, 0xFD, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0xBF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFB, 0xFF, 0x80, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xBF, 0xF8,
  0x00, 0x0F, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFF, 0xCF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC7, 0xFF, 0x00, 0x0F, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x01, 0xFF,
  0xDF, 0xFF, 0x00, 0x00, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x7F, 0xF7, 0xFF,
  0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xBF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x9F, 0xFE, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0x0F, 0xFF,
  0x87, 0xFF, 0x80, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFF, 0xC1, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xFF,
  0xC1, 0xFF, 0xF0, 0x01, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0xFF, 0xF1, 0xFF,
  0xF0, 0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00,
  0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF7, 0xFF, 0xC0, 0x03, 0xFF, 0xF1, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFE,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F,
  0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xFC,
  0x00, 0x7F, 0xFE, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xC7, 0xFF, 0x80, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0xFF, 0xF9,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFC, 0x00, 0x1F, 0xF7, 0xFF, 0xFF, 0xDF, 0xF8,
  0x00, 0x7F, 0xDF, 0xFF, 0xFF, 0x3F, 0xE0, 0x01, 0xFF, 0x7F, 0xFF, 0xFC,
  0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0x00, 0x3F, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0x9F, 0xFF, 0xFF, 0x1F, 0xF0, 0x07, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0xFF, 0xF1, 0xFF, 0x80,
  0x7F, 0xC7, 0xFF, 0xFF, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xC0, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xFF, 0xFF, 0x07, 0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF8, 0x7F,
  0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xE3, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xCF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xF7, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xCF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xF1, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x3F, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x7F, 0xFF, 0xF8,
  0x01, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x9F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFB, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFD, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF9,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE7,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x00, 0x7F, 0x0F,
  0xFF, 0x00, 0x03, 0x87, 0xFF, 0x00, 0x00, 0x43, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0B, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xDF, 0xFE, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x7F, 0xF9,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x9F, 0xFF,
  0x80, 0x03, 0xFF, 0xE3, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFD, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x9F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE3,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0x87, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFE, 0x01, 0xFF,
  0xE0, 0x0F, 0xFB, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xDF,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x01,
  0xFF, 0x9F, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xC7, 0xFC, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF1,
  0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0xFF, 0xC1, 0xFF, 0x87, 0xFF, 0x00, 0x03, 0xFF, 0x87, 0xFE, 0x0F, 0xFC,
  0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0x80, 0x00,
  0x7F, 0xF1, 0xFF, 0x01, 0xFF, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x8F, 0xF8,
  0x0F, 0xF8, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x7F, 0xE7, 0xFF,
  0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x7F,
  0xDF, 0xFC, 0x00, 0x00, 0xFF, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x9F, 0xFE,
  0x00, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xE0,
  0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x01, 0xFE,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFE, 0x00,
  0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE0,
  0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x03, 0xFE,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xF0, 0x3C, 0x00, 0x3F,
  0xFC, 0x04, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0x1F,
  0xFF, 0xF8, 0x7F, 0xC3, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xFC, 0x03, 0xFC,
  0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F,
  0xFE, 0x1F, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xFC, 0x0F, 0xFE, 0x7F, 0xFF,
  0xE0, 0xFF, 0xEF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xC0, 0x7F, 0xFE, 0xFF, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x1F,
  0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xEF,
  0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x3F,
  0xFE, 0xFF, 0xFE, 0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xFF,
  0xC0, 0xFF, 0xC3, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xF8, 0x7F,
  0xFE, 0x00, 0x10, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x02, 0x7F, 0xFE, 0x00, 0x0C, 0x3F,
  0xFF, 0x00, 0x7C, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x20, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0xFF, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xFE, 0x7F, 0xF0,
  0x7F, 0xFF, 0xF7, 0xFF, 0x0F, 0xFF, 0xFF, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xF0, 0x3F, 0xFF, 0x7F, 0xFC, 0x01, 0xFF, 0xF7,
  0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xF7,
  0xFF, 0xC0, 0x1F, 0xFF, 0x7F, 0xFE, 0x03, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0xFE, 0x7F, 0xF0,
  0x3F, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x68, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xE0, 0x3F, 0xFC, 0x3F, 0xFC, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xFE,
  0x7F, 0xF8, 0x00, 0x7F, 0xE7, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x43, 0xFF, 0xE0, 0x00, 0x1C, 0x3F, 0xFF, 0x80,
  0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x02, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFC, 0x3F, 0xF0, 0x3F, 0xFF, 0xE3,
  0xFF, 0x07, 0xFF, 0xFF, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x03, 0xFF, 0xF7, 0xFF, 0xC0, 0x1F,
  0xFF, 0x7F, 0xF8, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x0F,
  0xFF, 0x7F, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0xE0, 0x1F, 0xFF, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xFF, 0xE7,
  0xFF, 0x03, 0xFF, 0xFE, 0x7F, 0xF0, 0x1F, 0xFF, 0x8F, 0xFF, 0x00, 0x7F,
  0xF0, 0xFF, 0xF0, 0x00, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF2, 0x00, 0x00, 0x1F,
  0xFF, 0x38, 0x00, 0x01, 0xFF, 0xE3, 0xF0, 0x00, 0x7F, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x60, 0x00, 0xFF, 0xE0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0xFF, 0x0F,
  0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xEF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x0F, 0xC1, 0xFF, 0x9F, 0xFC, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7F, 0xF1, 0xFF, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF,
  0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF,
  0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE,
  0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x01, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x7F, 0xF8, 0x00,
  0x7F, 0xFC, 0xFF, 0xF0, 0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xFF, 0xC3,
  0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0xE3,
  0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFF, 0x00,
  0x0F, 0xFE, 0x7F, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0xF0, 0x00, 0x3F, 0xFB,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xF3,
  0xFF, 0xC0, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x0F, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC3, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF,
  0xCF, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0xFF, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x0F,
  0xFF, 0x3F, 0xFC, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x03,
  0xFF, 0xDF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xE3, 0xFF,
  0xC0, 0x0F, 0xFF, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x07, 0xFF, 0xEF, 0xFF, 0x80, 0x3F, 0xFE,
  0xFF, 0xF8, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x01,
  0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x3F, 0xFE,
  0xFF, 0xFC, 0x03, 0xFF, 0xEF, 0xFF, 0xE0, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0xFF, 0xE0,
  0xFF, 0xE7, 0xFF, 0xFC, 0x0F, 0xFE, 0x3F, 0xFF, 0x80, 0xFF, 0xE0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFC, 0x3F, 0xF0, 0x3F, 0xFF, 0xE3, 0xFF,
  0x07, 0xFF, 0xFF, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x03, 0xFF, 0xF7, 0xFF, 0xC0, 0x1F, 0xFF,
  0x7F, 0xF8, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x0F, 0xFF,
  0x7F, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0xE0, 0x1F, 0xFF, 0x3F, 0xFF, 0xDF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xFF, 0xE7, 0xFF,
  0x03, 0xFF, 0xFE, 0x7F, 0xF0, 0x1F, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF0,
  0xFF, 0xF0, 0x00, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x3F, 0xE0, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFE, 0xFF, 0xC7, 0xFF, 0xBF, 0xF3,
  0xFF, 0xEF, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCE, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x80,
  0x3E, 0x3F, 0xF8, 0x00, 0x31, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00, 0x13,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x02, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF7, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0x07, 0xFF, 0x9F,
  0xFE, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xC0,
  0x01, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x00,
  0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x1F, 0xFB,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0x8F, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0x87, 0xFF,
  0x00, 0xFF, 0x7F, 0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xEF, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFD, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF,
  0x3F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xE7, 0xFC, 0x1F, 0xFC, 0x03,
  0xFF, 0x83, 0xFC, 0x7F, 0x83, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0x8F, 0xF0,
  0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC3,
  0xFC, 0x3F, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0x87, 0xFC, 0x7F, 0xF0,
  0x03, 0xFF, 0x9F, 0xF0, 0x7F, 0x8F, 0xFE, 0x00, 0x7F, 0xF3, 0xFE, 0x0F,
  0xF1, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F, 0xF0, 0x00, 0xFF,
  0xCF, 0xF0, 0x3F, 0xEF, 0xFE, 0x00, 0x1F, 0xF9, 0xFE, 0x03, 0xFD, 0xFF,
  0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xBF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x0F, 0xF7, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x9F, 0xFF, 0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x83,
  0xFF, 0xE0, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0xFF, 0xF9, 0xFF, 0xF0,
  0x00, 0x3F, 0xFD, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFD, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x03,
  0xFF, 0xE7, 0xFF, 0xC0, 0x01, 0xFF, 0xF7, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x9F, 0xFE,
  0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x01,
  0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0x81, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x7F,
  0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x43,
  0xFF, 0x80, 0x00, 0x13, 0xFF, 0xFC, 0x00, 0x1D, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xEE, 0x00, 0x1F, 0xFF, 0xF3, 0x00, 0x00, 0xFF, 0xF8, 0x80, 0x00,
  0x03, 0xF0, 0x00,
};

const GFXglyph NotoSans_ExtraBold69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 13, 50, 20, 3, -49 },
  { 83, 26, 18, 35, 4, -49 },
  { 142, 43, 49, 45, 1, -49 },
  { 406, 35, 56, 40, 2, -52 },
  { 651, 60, 51, 64, 2, -50 },
  { 1034, 50, 51, 53, 3, -50 },
  { 1353, 11, 18, 19, 4, -49 },
  { 1378, 19, 61, 24, 3, -50 },
  { 1523, 19, 61, 24, 2, -50 },
  { 1668, 33, 32, 37, 2, -52 },
  { 1800, 34, 33, 40, 3, -41 },
  { 1941, 14, 18, 20, 2, -9 },
  { 1973, 18, 9, 22, 2, -23 },
  { 1994, 13, 12, 20, 3, -11 },
  { 2014, 29, 51, 29, 0, -50 },
  { 2199, 35, 51, 40, 2, -50 },
  { 2423, 26, 49, 40, 4, -49 },
  { 2583, 35, 50, 40, 2, -50 },
  { 2802, 35, 51, 40, 2, -50 },
  { 3026, 38, 49, 40, 1, -49 },
  { 3259, 34, 50, 40, 3, -49 },
  { 3472, 36, 51, 40, 2, -50 },
  { 3702, 36, 49, 40, 2, -49 },
  { 3923, 36, 51, 40, 2, -50 },
  { 4153, 35, 51, 40, 2, -50 },
  { 4377, 13, 40, 20, 3, -39 },
  { 4442, 14, 48, 20, 2, -39 },
  { 4526, 34, 38, 40, 3, -44 },
  { 4688, 34, 22, 40, 3, -35 },
  { 4782, 34, 38, 40, 3, -44 },
  { 4944, 32, 51, 34, 0, -50 },
  { 5148, 56, 55, 62, 3, -50 },
  { 5533, 49, 49, 49, 0, -49 },
  { 5834, 37, 49, 46, 6, -49 },
  { 6061, 38, 51, 45, 4, -50 },
  { 6304, 41, 49, 51, 6, -49 },
  { 6556, 29, 49, 38, 6, -49 },
  { 6734, 28, 49, 38, 6, -49 },
  { 6906, 41, 51, 50, 4, -50 },
  { 7168, 41, 49, 53, 6, -49 },
  { 7420, 24, 49, 29, 2, -49 },
  { 7567, 23, 64, 24, -5, -49 },
  { 7751, 41, 49, 47, 6, -49 },
  { 8003, 31, 49, 39, 6, -49 },
  { 8193, 54, 49, 66, 6, -49 },
  { 8524, 45, 49, 57, 6, -49 },
  { 8800, 47, 51, 55, 4, -50 },
  { 9100, 34, 49, 43, 6, -49 },
  { 9309, 48, 62, 55, 4, -50 },
  { 9681, 40, 49, 46, 6, -49 },
  { 9926, 33, 51, 39, 3, -50 },
  { 10137, 37, 49, 40, 2, -49 },
  { 10364, 42, 50, 52, 5, -49 },
  { 10627, 46, 49, 46, 0, -49 },
  { 10909, 69, 49, 69, 0, -49 },
  { 11332, 48, 49, 48, 0, -49 },
  { 11626, 44, 49, 44, 0, -49 },
  { 11896, 37, 49, 41, 2, -49 },
  { 12123, 17, 61, 23, 4, -50 },
  { 12253, 29, 51, 29, 0, -50 },
  { 12438, 16, 61, 23, 2, -50 },
  { 12560, 37, 33, 38, 1, -50 },
  { 12713, 31, 7, 31, 0, 5 },
  { 12741, 21, 11, 27, 3, -53 },
  { 12770, 34, 40, 42, 3, -39 },
  { 12940, 36, 53, 44, 5, -52 },
  { 13179, 32, 40, 36, 3, -39 },
  { 13339, 36, 53, 44, 3, -52 },
  { 13578, 36, 40, 42, 3, -39 },
  { 13758, 29, 53, 28, 1, -53 },
  { 13951, 36, 56, 44, 3, -39 },
  { 14203, 36, 52, 45, 5, -52 },
  { 14437, 13, 53, 21, 4, -53 },
  { 14524, 21, 70, 21, -4, -53 },
  { 14708, 39, 52, 44, 5, -52 },
  { 14962, 11, 52, 21, 5, -52 },
  { 15034, 58, 39, 68, 5, -39 },
  { 15317, 36, 39, 45, 5, -39 },
  { 15493, 37, 40, 43, 3, -39 },
  { 15678, 36, 56, 44, 5, -39 },
  { 15930, 36, 56, 44, 3, -39 },
  { 16182, 26, 39, 32, 5, -39 },
  { 16309, 29, 40, 35, 3, -39 },
  { 16454, 27, 47, 31, 2, -46 },
  { 16613, 36, 39, 45, 5, -38 },
  { 16789, 41, 38, 41, 0, -38 },
  { 16984, 59, 38, 61, 1, -38 },
  { 17265, 41, 38, 42, 0, -38 },
  { 17460, 41, 55, 41, 0, -38 },
  { 17742, 31, 38, 34, 2, -38 },
  { 17890, 24, 61, 28, 2, -50 },
  { 18073, 8, 67, 37, 14, -52 },
  { 18140, 25, 61, 28, 2, -50 },
  { 18331, 34, 13, 40, 3, -31 },
};

const GFXfont NotoSans_ExtraBold69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold69pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_EXTRABOLD69PT7B_H_
