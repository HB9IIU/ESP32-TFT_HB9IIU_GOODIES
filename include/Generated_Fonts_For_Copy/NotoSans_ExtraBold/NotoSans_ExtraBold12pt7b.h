#ifndef _NOTOSANS_EXTRABOLD12PT7B_H_
#define _NOTOSANS_EXTRABOLD12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xFF, 0x99, 0x16, 0x14, 0x34, 0x7F, 0x2C, 0xFE,
  0xFE, 0x68, 0x68, 0x10, 0xFB, 0x57, 0x87, 0x83, 0xA5, 0xBE, 0x30, 0x20,
  0x61, 0x8E, 0x23, 0x6C, 0x6F, 0x07, 0x5C, 0x5A, 0xC2, 0x58, 0xCB, 0x31,
  0xC0, 0x18, 0x3E, 0x1B, 0x0F, 0x83, 0x9B, 0xFF, 0xBC, 0xFE, 0x7F, 0x80,
  0xFA, 0x36, 0x64, 0x4C, 0xC4, 0x66, 0x30, 0xC6, 0x63, 0x33, 0x33, 0x26,
  0xC0, 0x32, 0x5F, 0xCE, 0x6C, 0xA0, 0x21, 0x3E, 0x42, 0x10, 0x6D, 0x60,
  0xFF, 0xF0, 0x18, 0xCC, 0x63, 0x31, 0x88, 0xC0, 0x38, 0xF9, 0xB3, 0x6C,
  0xF9, 0x9B, 0x3E, 0x38, 0x37, 0xFB, 0x33, 0x33, 0x30, 0x39, 0xF9, 0x30,
  0x61, 0xC3, 0x0C, 0x3F, 0xFE, 0x3B, 0xF4, 0xC3, 0x30, 0x30, 0xFF, 0xF8,
  0x0C, 0x38, 0xF1, 0x66, 0xD9, 0xBF, 0x86, 0x0C, 0xFF, 0xF1, 0xCF, 0x8C,
  0x7F, 0xF0, 0x1C, 0x79, 0x82, 0xCF, 0xDD, 0xD9, 0xBE, 0x3C, 0xFF, 0xFC,
  0x30, 0x61, 0x83, 0x0C, 0x18, 0x70, 0x38, 0xF9, 0xB3, 0x63, 0x8D, 0xB1,
  0xB6, 0x7C, 0x30, 0xFB, 0xB6, 0x67, 0xEE, 0x83, 0x2E, 0x78, 0xB0, 0x3C,
  0x4C, 0x00, 0xDA, 0xC0, 0x08, 0xDD, 0x8E, 0x1C, 0x20, 0xF8, 0x3F, 0xF0,
  0x86, 0x1C, 0x33, 0xF2, 0x00, 0x73, 0xE8, 0xC6, 0x30, 0x80, 0x0C, 0x70,
  0x1C, 0x3F, 0xB0, 0x77, 0xDB, 0x6D, 0x36, 0xFF, 0xB6, 0x62, 0x1F, 0x00,
  0x1C, 0x0E, 0x0F, 0x06, 0xC3, 0x63, 0xF1, 0xFC, 0xC6, 0xC3, 0x80, 0xF3,
  0xFC, 0xF3, 0xFB, 0x3C, 0xFF, 0xF8, 0x39, 0xFC, 0x70, 0xC3, 0x0C, 0x3F,
  0x7C, 0xF1, 0xFB, 0x3E, 0x3C, 0x78, 0xF1, 0xFE, 0xF8, 0xFF, 0xF1, 0x8F,
  0xE3, 0x1F, 0xF8, 0xFF, 0xF1, 0x8F, 0xFF, 0x18, 0xC0, 0x1C, 0xFF, 0x86,
  0x0D, 0xFB, 0xF1, 0xFF, 0x7E, 0xC7, 0x8F, 0x1E, 0x3F, 0xF8, 0xF1, 0xE3,
  0xC6, 0xFF, 0xDC, 0xE7, 0x39, 0xCE, 0xF8, 0x33, 0x33, 0x33, 0x33, 0x33,
  0xFC, 0xC7, 0x9B, 0x76, 0xCF, 0x1F, 0x37, 0x66, 0xCE, 0xC6, 0x31, 0x8C,
  0x63, 0x1F, 0xF8, 0xE1, 0xF1, 0xF8, 0xFE, 0x5F, 0x6E, 0xB7, 0x73, 0xB9,
  0xCC, 0x80, 0xE3, 0xE3, 0xF3, 0xF3, 0xDB, 0xDB, 0xCF, 0xCF, 0xC7, 0x38,
  0x7E, 0xC6, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0x7C, 0xF3, 0xFC, 0xF3, 0xFF,
  0xEC, 0x30, 0xC0, 0x38, 0x7E, 0xC6, 0xC3, 0xC3, 0xC3, 0xC7, 0xFE, 0x7C,
  0x0E, 0x07, 0xF1, 0xFB, 0x36, 0x6F, 0xDF, 0x36, 0x66, 0xCE, 0x77, 0xF3,
  0x8F, 0x1C, 0x7F, 0xF0, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xFF, 0x7C, 0xC3, 0xE3, 0x66, 0x66,
  0x66, 0x3C, 0x3C, 0x3C, 0x18, 0xC6, 0x3C, 0x63, 0x66, 0x66, 0xF6, 0x6F,
  0x66, 0x96, 0x29, 0x43, 0x9C, 0x39, 0xC0, 0xE3, 0x66, 0x36, 0x3C, 0x1C,
  0x3C, 0x3E, 0x66, 0xE3, 0xC7, 0x66, 0x66, 0x3C, 0x3C, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0xFC, 0x30, 0xC1, 0x86, 0x18, 0x7F, 0xFE, 0xFE, 0x49, 0x24,
  0x93, 0x80, 0xC6, 0x18, 0xC2, 0x18, 0xC2, 0x18, 0xFD, 0xB6, 0xDB, 0x6F,
  0x80, 0x10, 0x60, 0xE3, 0x44, 0xD8, 0xC0, 0xF8, 0xE1, 0x38, 0xF8, 0x33,
  0xF6, 0xFD, 0xDD, 0x80, 0xC3, 0x0D, 0xBF, 0xCF, 0x3C, 0xFF, 0xF8, 0x37,
  0xF1, 0x8C, 0x7D, 0xE0, 0x0C, 0x36, 0xFF, 0xCF, 0x3C, 0xFF, 0xEC, 0x73,
  0xEC, 0xFF, 0xC3, 0x27, 0x80, 0x3B, 0x5F, 0xF6, 0x31, 0x8C, 0x60, 0x6F,
  0xFC, 0xF3, 0xCF, 0x7F, 0xC3, 0xFB, 0xC0, 0xC3, 0x0D, 0xBF, 0xCF, 0x3C,
  0xF3, 0xCC, 0xFF, 0xFF, 0xC0, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC1,
  0x83, 0x3E, 0xEF, 0x9E, 0x3E, 0x6E, 0xCE, 0xFF, 0xFF, 0xC0, 0x99, 0xBF,
  0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCC, 0x9B, 0xFC, 0xF3, 0xCF, 0x3C,
  0xC0, 0x73, 0xEC, 0xF3, 0xCF, 0x77, 0x80, 0xDB, 0xFC, 0xF3, 0xCF, 0xFF,
  0xB0, 0xC3, 0x00, 0x6F, 0xFC, 0xF3, 0xCF, 0x7F, 0xC3, 0x0C, 0x30, 0x9F,
  0xCC, 0xCC, 0xC0, 0x7F, 0xB1, 0xE3, 0xDF, 0xC0, 0x23, 0xFE, 0xC6, 0x31,
  0xE7, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xC0, 0xC7, 0x8D, 0xB3, 0x62, 0xC7,
  0x0E, 0x00, 0xCC, 0xF3, 0xB6, 0xED, 0xEB, 0x7A, 0x8C, 0xE3, 0x38, 0xE6,
  0xD8, 0xF1, 0xC3, 0xCD, 0xB9, 0x80, 0xC7, 0x8D, 0xB3, 0x62, 0xC7, 0x0E,
  0x18, 0xF1, 0xC0, 0xFF, 0xF1, 0x8C, 0x61, 0xFF, 0xC0, 0x19, 0xC8, 0x42,
  0x71, 0x84, 0x21, 0xCE, 0xFF, 0xFF, 0xFF, 0xC7, 0x18, 0xC2, 0x1C, 0xCC,
  0x67, 0x38, 0xFD, 0xC0,
};

const GFXglyph NotoSans_ExtraBold12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 4, 6, 1, -9 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 7, 10, 7, 0, -9 },
  { 24, 11, 9, 11, 0, -9 },
  { 37, 9, 9, 9, 0, -9 },
  { 48, 2, 4, 3, 1, -9 },
  { 49, 4, 11, 4, 0, -9 },
  { 55, 4, 11, 4, 0, -9 },
  { 61, 6, 6, 6, 0, -9 },
  { 66, 5, 6, 7, 1, -7 },
  { 70, 3, 4, 4, 0, -2 },
  { 72, 4, 2, 4, 0, -4 },
  { 73, 2, 2, 3, 1, -2 },
  { 74, 5, 9, 5, 0, -9 },
  { 80, 7, 9, 7, 0, -9 },
  { 88, 4, 9, 7, 1, -9 },
  { 93, 7, 9, 7, 0, -9 },
  { 101, 6, 9, 7, 0, -9 },
  { 108, 7, 9, 7, 0, -9 },
  { 116, 5, 9, 7, 1, -9 },
  { 122, 7, 9, 7, 0, -9 },
  { 130, 7, 9, 7, 0, -9 },
  { 138, 7, 9, 7, 0, -9 },
  { 146, 7, 9, 7, 0, -9 },
  { 154, 2, 7, 3, 1, -7 },
  { 156, 3, 9, 3, 0, -7 },
  { 160, 5, 7, 7, 1, -8 },
  { 165, 5, 4, 7, 1, -6 },
  { 168, 5, 7, 7, 1, -8 },
  { 173, 6, 9, 6, 0, -9 },
  { 180, 9, 10, 11, 1, -9 },
  { 192, 9, 9, 9, 0, -9 },
  { 203, 6, 9, 8, 1, -9 },
  { 210, 6, 9, 8, 1, -9 },
  { 217, 7, 9, 9, 1, -9 },
  { 225, 5, 9, 7, 1, -9 },
  { 231, 5, 9, 7, 1, -9 },
  { 237, 7, 9, 9, 1, -9 },
  { 245, 7, 9, 9, 1, -9 },
  { 253, 5, 9, 5, 0, -9 },
  { 259, 4, 12, 4, -1, -9 },
  { 265, 7, 9, 8, 1, -9 },
  { 273, 5, 9, 7, 1, -9 },
  { 279, 9, 9, 11, 1, -9 },
  { 290, 8, 9, 10, 1, -9 },
  { 299, 8, 9, 10, 1, -9 },
  { 308, 6, 9, 8, 1, -9 },
  { 315, 8, 11, 10, 1, -9 },
  { 326, 7, 9, 8, 1, -9 },
  { 334, 5, 9, 7, 1, -9 },
  { 340, 7, 9, 7, 0, -9 },
  { 348, 7, 9, 9, 1, -9 },
  { 356, 8, 9, 8, 0, -9 },
  { 365, 12, 9, 12, 0, -9 },
  { 379, 8, 9, 8, 0, -9 },
  { 388, 8, 9, 8, 0, -9 },
  { 397, 7, 9, 7, 0, -9 },
  { 405, 3, 11, 4, 1, -9 },
  { 410, 5, 9, 5, 0, -9 },
  { 416, 3, 11, 4, 0, -9 },
  { 421, 7, 6, 7, 0, -9 },
  { 427, 5, 1, 5, 0, 1 },
  { 428, 4, 2, 5, 0, -9 },
  { 429, 7, 7, 7, 0, -7 },
  { 436, 6, 9, 8, 1, -9 },
  { 443, 5, 7, 6, 1, -7 },
  { 448, 6, 9, 8, 1, -9 },
  { 455, 6, 7, 7, 1, -7 },
  { 461, 5, 9, 5, 0, -9 },
  { 467, 6, 10, 8, 1, -7 },
  { 475, 6, 9, 8, 1, -9 },
  { 482, 2, 9, 4, 1, -9 },
  { 485, 4, 12, 4, -1, -9 },
  { 491, 7, 9, 8, 1, -9 },
  { 499, 2, 9, 4, 1, -9 },
  { 502, 10, 7, 12, 1, -7 },
  { 511, 6, 7, 8, 1, -7 },
  { 517, 6, 7, 8, 1, -7 },
  { 523, 6, 10, 8, 1, -7 },
  { 531, 6, 10, 8, 1, -7 },
  { 539, 4, 7, 5, 1, -7 },
  { 543, 5, 7, 6, 1, -7 },
  { 548, 5, 8, 5, 0, -8 },
  { 553, 6, 7, 8, 1, -7 },
  { 559, 7, 7, 7, 0, -7 },
  { 566, 10, 7, 11, 0, -7 },
  { 575, 7, 7, 7, 0, -7 },
  { 582, 7, 10, 7, 0, -7 },
  { 591, 6, 7, 6, 0, -7 },
  { 597, 5, 11, 5, 0, -9 },
  { 604, 2, 12, 6, 2, -9 },
  { 607, 5, 11, 5, 0, -9 },
  { 614, 5, 2, 7, 1, -5 },
};

const GFXfont NotoSans_ExtraBold12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold12pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_EXTRABOLD12PT7B_H_
