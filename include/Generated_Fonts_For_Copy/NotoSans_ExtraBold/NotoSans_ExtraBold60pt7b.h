#ifndef _NOTOSANS_EXTRABOLD60PT7B_H_
#define _NOTOSANS_EXTRABOLD60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold60pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1,
  0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0xFE,
  0x07, 0x00, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFE, 0x7F,
  0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xC0, 0xFE, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x83,
  0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xF8, 0xF8, 0x3C, 0x3F,
  0xE1, 0xF0, 0x08, 0x7F, 0xC3, 0xE0, 0x00, 0xFF, 0xC7, 0xC0, 0x01, 0xFF,
  0x8F, 0x80, 0x03, 0xFF, 0xDF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xF3, 0xFF, 0x00, 0x03, 0xE3, 0xFF, 0x00, 0x07, 0xC7,
  0xFF, 0x00, 0x0F, 0x8F, 0xFD, 0xC0, 0x1F, 0x1F, 0xF3, 0xF0, 0x3E, 0x7F,
  0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x00,
  0x00, 0x7F, 0x83, 0xF8, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x3F, 0xC3, 0xFC,
  0x1F, 0xF0, 0x1F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFF, 0xC0, 0xFF, 0x9F, 0xF1,
  0xFE, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0x1F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0xFF, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xF1, 0xFF, 0xFF, 0x81,
  0xFF, 0xF8, 0x7F, 0x0F, 0xF3, 0xFE, 0x07, 0xFF, 0x87, 0xF8, 0xFF, 0x0F,
  0xF0, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x3F,
  0xC1, 0xFE, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x00, 0x00,
  0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xDF, 0xFE,
  0x1F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xEF,
  0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE7, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF, 0xDF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x60, 0x1F, 0x80, 0x33, 0xE0, 0xFC, 0x1F, 0xBF, 0xF7, 0xE7, 0xFD,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x1F,
  0xF0, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0x02, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x0F, 0xFB,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC7, 0xF0, 0x38,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF,
  0x80, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0x9F, 0xF8,
  0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0x80,
  0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFF,
  0x9F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xFC,
  0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x7F,
  0xE7, 0xFC, 0xFF, 0xCF, 0xE1, 0xFF, 0x8F, 0x83, 0xFF, 0x0E, 0x07, 0xFE,
  0x08, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0,
  0x7F, 0xF8, 0x3F, 0x80, 0x7F, 0xF0, 0x3C, 0x00, 0x7F, 0xF0, 0x30, 0x00,
  0xFF, 0xE0, 0x40, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0x80, 0x7F, 0xF8,
  0x38, 0x00, 0xFF, 0xE0, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x40, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFD, 0xFF, 0x80, 0x01, 0xFE, 0xFF,
  0xC0, 0x01, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0x1F,
  0xF8, 0x00, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0,
  0x7F, 0xE0, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F, 0xE0,
  0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF9, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xF9, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xBE, 0x00, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE1, 0xFF, 0x00, 0x7F, 0xC7, 0xFF, 0x80, 0xFF, 0xBF, 0xFF, 0xC3, 0xFE,
  0x7F, 0xFF, 0xC7, 0xFD, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x0F, 0xFE, 0xFF, 0xF0,
  0x0F, 0xFD, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xDF, 0xF8, 0x01,
  0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xE0, 0x1F,
  0xF8, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC, 0x1F, 0xFC, 0x7F, 0xF0,
  0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF1, 0xFF, 0x80, 0x3F, 0xE3, 0xFF, 0x00,
  0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFE, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xF9, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xE3,
  0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xBF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0x80, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xF0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x01, 0xFF,
  0xBF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF7, 0xFC, 0x1F, 0xFF, 0xCF, 0xF8, 0x1F,
  0xFF, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0xE1, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC3, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x7F, 0xDF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x3F, 0x81, 0xC0, 0x1F, 0xC3, 0xFE, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF3, 0xFF, 0x3F, 0xE0, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x1F,
  0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC7, 0xFC, 0x7F,
  0xC7, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x7F, 0xF1, 0xC0,
  0x03, 0xFF, 0x10, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xFF, 0x81,
  0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xF1, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xF0,
  0xFE, 0x3F, 0x81, 0xFF, 0xFF, 0xF0, 0xFE, 0x7F, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0x7F, 0x07, 0xFC, 0x0F, 0xF0,
  0x7F, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0,
  0x7F, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0,
  0x7F, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0,
  0x7F, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0,
  0xFE, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0xFE, 0x0F, 0xF8, 0x3F, 0xF1,
  0xFC, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x03, 0xFF, 0xF9, 0xFF,
  0xF0, 0x7F, 0x80, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0x80, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0C,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xCF, 0xFC, 0x00, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00,
  0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF,
  0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF,
  0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0x7E, 0x07, 0xFF, 0xC0, 0x03, 0x83, 0xFF, 0xC0,
  0x00, 0x20, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xC1, 0xFF, 0xF8, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0xF8, 0xFF, 0xC0, 0x07, 0xFF, 0xCF,
  0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xEF, 0xFC, 0x00, 0x0F,
  0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x1F,
  0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xC0,
  0x07, 0xFF, 0x8F, 0xFC, 0x01, 0xFF, 0xF8, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0x81, 0xFF,
  0xF8, 0x00, 0x18, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xF7, 0xFF, 0x00, 0x01, 0xFF,
  0x7F, 0xF0, 0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xF8, 0x00,
  0x1F, 0xF3, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xFC, 0x00, 0x1F, 0xF1, 0xFF,
  0xE0, 0x01, 0xFF, 0x1F, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFF,
  0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x1F, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFE,
  0xFF, 0xC0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x07,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF,
  0xC0, 0x0F, 0xFC, 0x3F, 0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC,
  0x7F, 0xF0, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0xE0, 0x00,
  0xFF, 0xDF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFB, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0xC0,
  0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F,
  0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x8F, 0xFC,
  0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xFE,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xBF, 0xFF,
  0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0xFF, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0xFF,
  0xDF, 0xE0, 0x03, 0xF9, 0xFF, 0xFF, 0x9F, 0xE0, 0x0F, 0xF3, 0xFF, 0xFF,
  0x3F, 0xC0, 0x1F, 0xE7, 0xFF, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xFF, 0xFC,
  0xFF, 0x80, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xFF, 0xF1,
  0xFE, 0x03, 0xFC, 0x7F, 0xFF, 0xE3, 0xFE, 0x07, 0xF0, 0xFF, 0xFF, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xC3, 0xFF, 0xFF, 0x0F,
  0xF0, 0x7F, 0x07, 0xFF, 0xFE, 0x1F, 0xF1, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xE3, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xC7, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F,
  0xDF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xBF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF,
  0x7F, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF7, 0xFF, 0x00, 0x7F, 0xFF, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0xCF, 0xFE,
  0x01, 0xFF, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xFF, 0x1F, 0xFC, 0x07, 0xFF,
  0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F,
  0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xF0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0xFF, 0x01,
  0xFF, 0xC7, 0xFF, 0xFE, 0x01, 0xFF, 0xCF, 0xFF, 0xFC, 0x01, 0xFF, 0x9F,
  0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0xFF, 0xF0, 0x03, 0xFF, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x87, 0xFF,
  0x80, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x00,
  0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x1F, 0xFD,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xBF, 0xF0, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xC7, 0xFF, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x00, 0x1F, 0xFB,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xBF, 0xF8,
  0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xF8,
  0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03,
  0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x07, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF,
  0xE1, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0xC7, 0xFE, 0x00,
  0x1F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xFB, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0, 0x1F,
  0xC7, 0xFF, 0x00, 0x0E, 0x3F, 0xF0, 0x00, 0x11, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xF7, 0x80, 0x01, 0xFF, 0xBF, 0xC0, 0x3F, 0xFD, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00,
  0x7F, 0xEF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xE7, 0xFF,
  0x80, 0x1F, 0xFE, 0x7F, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x81,
  0xFF, 0x80, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0x7F,
  0xE3, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x1F,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x1F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xF0, 0x07,
  0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x9F, 0xE0,
  0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xF9, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0xFF, 0x9F, 0xF0, 0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0xFF, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0xC0, 0x01,
  0xFF, 0x1F, 0xF0, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xF1, 0xFE, 0x07, 0xF8,
  0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF8, 0x00, 0x1F, 0xF1,
  0xFE, 0x07, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xF0,
  0x00, 0x0F, 0xFB, 0xFC, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xC0,
  0x3F, 0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFC, 0x03, 0xFD, 0xFF, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x07,
  0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF,
  0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x03, 0xFF, 0x8F, 0xFE,
  0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF,
  0xE0, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x3F,
  0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x00,
  0x3F, 0xF1, 0xFF, 0x80, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x00, 0x7F, 0xEF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x3F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x07,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x01,
  0xFC, 0xFF, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x01, 0x40, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x1F,
  0xFC, 0x06, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x00, 0xFF, 0xEF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0x0F, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF,
  0x03, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x30, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xDF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xFC, 0xFF, 0xF0,
  0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0,
  0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0,
  0x0F, 0xFE, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF8,
  0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x9F,
  0xFF, 0xE0, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0x00, 0x61,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x4F, 0xFF, 0x00, 0x79, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0xF9, 0xFF, 0x87,
  0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xEF, 0xFF, 0x03, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xF8,
  0x7F, 0xFF, 0x1F, 0xF0, 0x7F, 0xFC, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xC0,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0x1F, 0xF7, 0xFF,
  0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x31, 0xFF, 0xF0, 0x03,
  0xE1, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0x02,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x03, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0x8F, 0xF8, 0x7F, 0xFF, 0x9F, 0xF1,
  0xFF, 0xFF, 0xBF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F,
  0xFD, 0xFF, 0xF1, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFD, 0xFF, 0x87, 0xFF, 0xFB, 0xFF,
  0x07, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x60, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xD8,
  0x00, 0x07, 0xFF, 0xBE, 0x00, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x10, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC7,
  0xFF, 0xE0, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xDF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0,
  0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0x0F, 0xFB, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF,
  0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF,
  0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7,
  0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0x80, 0x00, 0x7E,
  0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF,
  0x80, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F,
  0xFE, 0x3F, 0xF0, 0x0F, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0x01,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xF8, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xCF, 0xFF, 0x00, 0x3F,
  0xF3, 0xFF, 0x80, 0x0F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0x9F, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0xF0, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0x8F,
  0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xC0, 0x03, 0xFF,
  0xBF, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x01, 0x00, 0x1F, 0xE0, 0x7F,
  0xF0, 0x07, 0xFF, 0x03, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFB, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0xFF, 0x03, 0xFF, 0xC0,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xBF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFE,
  0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE,
  0x7F, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xE0, 0x0F, 0xFE,
  0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xDF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFE,
  0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFE,
  0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE,
  0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFE,
  0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF8, 0x1F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xDF, 0xFF, 0xE0,
  0xFF, 0xCF, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC0, 0x30, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0x07, 0xFC,
  0x1F, 0xFF, 0x8F, 0xF8, 0x7F, 0xFF, 0x9F, 0xF1, 0xFF, 0xFF, 0xBF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFC, 0x7F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0xFD, 0xFF, 0xF1, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFD, 0xFF, 0x87, 0xFF, 0xFB, 0xFF, 0x07, 0xFF, 0xC7, 0xFE,
  0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x70, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x39, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x7F, 0xEF, 0xF9, 0xFF,
  0xDF, 0xF7, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFC, 0xFF, 0xC0, 0x3C, 0x7F, 0xC0, 0x02, 0x3F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFE, 0x01, 0x07, 0xFF, 0xDF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xC7, 0xFF, 0xFC, 0x7F, 0x87, 0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0x81,
  0xFE, 0x00, 0x28, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00,
  0x1F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x0F, 0xFB, 0xFF,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xBF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0xF0,
  0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F,
  0xBF, 0x81, 0xFF, 0x87, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xF0, 0x7F, 0xC1,
  0xFE, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0x9F, 0xE1, 0xFF, 0x81, 0xFF,
  0x87, 0xF3, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0xFE, 0x3F, 0x87, 0xFC, 0x03,
  0xFE, 0x3F, 0xC7, 0xF0, 0xFF, 0x80, 0x7F, 0xC7, 0xF8, 0xFF, 0x1F, 0xF0,
  0x0F, 0xF8, 0xFE, 0x1F, 0xE7, 0xFE, 0x00, 0xFF, 0x9F, 0xC3, 0xFC, 0xFF,
  0x80, 0x1F, 0xF3, 0xF8, 0x3F, 0x9F, 0xF0, 0x03, 0xFE, 0xFF, 0x07, 0xF3,
  0xFE, 0x00, 0x7F, 0xDF, 0xE0, 0xFF, 0x7F, 0x80, 0x07, 0xFB, 0xF8, 0x1F,
  0xEF, 0xF0, 0x00, 0xFF, 0x7F, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xEF, 0xE0,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xFC,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xF9, 0xFF,
  0xE0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF9, 0xFF,
  0xC0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE3, 0xFF,
  0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xC0, 0x00, 0x5F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x20, 0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_ExtraBold60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 11, 44, 17, 3, -43 },
  { 62, 22, 16, 30, 4, -43 },
  { 106, 37, 43, 39, 1, -43 },
  { 305, 31, 49, 34, 2, -46 },
  { 495, 53, 43, 55, 1, -43 },
  { 780, 45, 44, 46, 2, -43 },
  { 1028, 9, 16, 17, 4, -43 },
  { 1046, 17, 52, 21, 2, -43 },
  { 1157, 17, 52, 21, 2, -43 },
  { 1268, 29, 29, 32, 2, -46 },
  { 1374, 29, 29, 35, 3, -36 },
  { 1480, 12, 16, 18, 2, -8 },
  { 1504, 17, 8, 19, 1, -20 },
  { 1521, 11, 11, 17, 3, -10 },
  { 1537, 25, 43, 26, 0, -43 },
  { 1672, 31, 45, 35, 2, -44 },
  { 1847, 23, 43, 35, 3, -43 },
  { 1971, 31, 43, 35, 2, -43 },
  { 2138, 30, 44, 35, 2, -43 },
  { 2303, 33, 43, 35, 1, -43 },
  { 2481, 29, 44, 35, 3, -43 },
  { 2641, 31, 44, 35, 2, -43 },
  { 2812, 31, 43, 35, 2, -43 },
  { 2979, 31, 44, 35, 2, -43 },
  { 3150, 31, 44, 35, 2, -43 },
  { 3321, 11, 34, 17, 3, -33 },
  { 3368, 12, 41, 17, 2, -33 },
  { 3430, 29, 32, 35, 3, -38 },
  { 3546, 29, 20, 35, 3, -31 },
  { 3619, 29, 32, 35, 3, -38 },
  { 3735, 28, 44, 29, 0, -43 },
  { 3889, 48, 48, 54, 3, -43 },
  { 4177, 42, 43, 42, 0, -43 },
  { 4403, 32, 43, 40, 5, -43 },
  { 4575, 34, 44, 39, 3, -43 },
  { 4762, 36, 43, 44, 5, -43 },
  { 4956, 25, 43, 33, 5, -43 },
  { 5091, 25, 43, 33, 5, -43 },
  { 5226, 36, 44, 44, 3, -43 },
  { 5424, 36, 43, 46, 5, -43 },
  { 5618, 21, 43, 25, 2, -43 },
  { 5731, 20, 56, 20, -5, -43 },
  { 5871, 36, 43, 41, 5, -43 },
  { 6065, 27, 43, 34, 5, -43 },
  { 6211, 47, 43, 57, 5, -43 },
  { 6464, 39, 43, 49, 5, -43 },
  { 6674, 41, 45, 48, 3, -44 },
  { 6905, 30, 43, 38, 5, -43 },
  { 7067, 42, 54, 48, 3, -44 },
  { 7351, 35, 43, 40, 5, -43 },
  { 7540, 29, 44, 34, 3, -43 },
  { 7700, 33, 43, 35, 1, -43 },
  { 7878, 36, 44, 45, 5, -43 },
  { 8076, 40, 43, 40, 0, -43 },
  { 8291, 60, 43, 60, 0, -43 },
  { 8614, 41, 43, 42, 0, -43 },
  { 8835, 39, 43, 39, 0, -43 },
  { 9045, 32, 43, 36, 2, -43 },
  { 9217, 14, 53, 20, 4, -43 },
  { 9310, 25, 43, 26, 0, -43 },
  { 9445, 15, 53, 20, 1, -43 },
  { 9545, 32, 28, 33, 1, -43 },
  { 9657, 27, 5, 27, 0, 5 },
  { 9674, 19, 10, 23, 2, -46 },
  { 9698, 31, 35, 37, 2, -34 },
  { 9834, 32, 47, 38, 4, -46 },
  { 10022, 27, 35, 32, 3, -34 },
  { 10141, 31, 47, 38, 3, -46 },
  { 10324, 31, 35, 36, 3, -34 },
  { 10460, 25, 46, 24, 1, -46 },
  { 10604, 31, 48, 38, 3, -34 },
  { 10790, 32, 46, 40, 4, -46 },
  { 10974, 11, 46, 19, 4, -46 },
  { 11038, 18, 60, 19, -3, -46 },
  { 11173, 34, 46, 38, 4, -46 },
  { 11369, 10, 46, 19, 4, -46 },
  { 11427, 51, 34, 59, 4, -34 },
  { 11644, 32, 34, 40, 4, -34 },
  { 11780, 32, 35, 38, 3, -34 },
  { 11920, 32, 48, 38, 4, -34 },
  { 12112, 31, 48, 38, 3, -34 },
  { 12298, 23, 34, 27, 4, -34 },
  { 12396, 25, 35, 31, 3, -34 },
  { 12506, 24, 41, 27, 1, -40 },
  { 12629, 31, 34, 40, 4, -33 },
  { 12761, 35, 33, 35, 0, -33 },
  { 12906, 51, 33, 53, 1, -33 },
  { 13117, 36, 33, 36, 0, -33 },
  { 13266, 35, 47, 35, 0, -33 },
  { 13472, 26, 33, 30, 2, -33 },
  { 13580, 22, 53, 25, 1, -43 },
  { 13726, 8, 58, 32, 12, -45 },
  { 13784, 21, 53, 25, 2, -43 },
  { 13924, 29, 11, 35, 3, -27 },
};

const GFXfont NotoSans_ExtraBold60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold60pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_EXTRABOLD60PT7B_H_
