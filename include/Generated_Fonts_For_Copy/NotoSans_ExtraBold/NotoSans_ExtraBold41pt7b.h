#ifndef _NOTOSANS_EXTRABOLD41PT7B_H_
#define _NOTOSANS_EXTRABOLD41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x38,
  0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0xFE, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F,
  0x7E, 0x3F, 0x7E, 0x3F, 0x7E, 0x3F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xE1, 0xE0, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF0, 0x3E, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F,
  0x80, 0x07, 0x87, 0xC0, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x7C, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0x87, 0xC0, 0x07,
  0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0x9F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x71, 0xE7, 0xF3, 0x81, 0x3F,
  0x9C, 0x00, 0xFC, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0x3F, 0x80, 0x38, 0xFD, 0x01, 0xC7, 0xEE, 0x0E, 0x7F,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF,
  0xF8, 0x01, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x08, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x03,
  0xF0, 0x07, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0xFC, 0x07, 0xE0, 0x0F, 0xCF,
  0xC0, 0x7C, 0x00, 0xFC, 0x7C, 0x0F, 0x80, 0x0F, 0x87, 0xC1, 0xF8, 0x00,
  0xF8, 0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xC3, 0xF0, 0x00, 0xF8, 0x7C, 0x3E,
  0x00, 0x0F, 0x87, 0xC7, 0xE0, 0x00, 0xFC, 0x7C, 0x7C, 0x3E, 0x07, 0xCF,
  0xCF, 0xCF, 0xF8, 0x7F, 0xFC, 0xF9, 0xFF, 0xC7, 0xFF, 0x9F, 0x3F, 0xFE,
  0x3F, 0xF1, 0xF3, 0xF7, 0xE1, 0xFE, 0x3E, 0x3E, 0x3E, 0x07, 0x87, 0xE3,
  0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE3, 0xF0, 0x00,
  0xF8, 0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xE3, 0xF0, 0x01, 0xF0, 0x7E, 0x3F,
  0x00, 0x3E, 0x03, 0xE3, 0xE0, 0x03, 0xE0, 0x3F, 0x3E, 0x00, 0x7C, 0x03,
  0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0x80, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0x0F,
  0xFF, 0x81, 0xFC, 0x7F, 0xFF, 0x0F, 0xF1, 0xFF, 0xFE, 0x3F, 0x8F, 0xF3,
  0xFC, 0xFE, 0x3F, 0x87, 0xFF, 0xF0, 0xFE, 0x0F, 0xFF, 0xC3, 0xF8, 0x1F,
  0xFE, 0x0F, 0xE0, 0x3F, 0xF8, 0x3F, 0x80, 0x7F, 0xC0, 0xFF, 0x87, 0xFF,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xCF, 0xF0, 0x1F, 0xFC, 0x1F, 0xF0, 0xFE, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0x3E, 0x7C, 0xF8, 0x07, 0xE0, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xE0, 0x3E, 0x03,
  0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x06, 0x0F, 0x02, 0x7C, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0x9F, 0x01, 0xF9, 0xF8, 0x3F, 0x8F, 0xC0, 0xF0, 0xF0, 0x03, 0x04,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x7E,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38,
  0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFE, 0x3F, 0xCF, 0xE0, 0xFE, 0x7F, 0x03, 0xF3, 0xF8, 0x1F,
  0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFB, 0xF0, 0x1F, 0xDF, 0x80, 0xFE,
  0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F, 0xC7, 0xF0,
  0xFE, 0x3F, 0xCF, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x3E,
  0x7F, 0x38, 0x7F, 0x10, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFC, 0x3F, 0xC3, 0x80, 0xFF,
  0x18, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0x78, 0x3F, 0xC2, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xBF, 0x80, 0x7E, 0xFE, 0x03,
  0xF3, 0xF8, 0x0F, 0x8F, 0xE0, 0x7E, 0x3F, 0x83, 0xF0, 0xFE, 0x1F, 0x83,
  0xF8, 0x7E, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xEF, 0x83,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x7F, 0x07, 0xEF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x80, 0xFD,
  0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x3F, 0xC7, 0xF9, 0xFF, 0xFF, 0x87, 0xFF,
  0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x1F, 0xEF, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0x7E, 0x7F,
  0x03, 0xF1, 0xF8, 0x3F, 0x8F, 0xE1, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x1F, 0xE3, 0xFC, 0xFE, 0x0F, 0xF7, 0xE0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0x7F, 0x03, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x70, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF9, 0xFE, 0x3F, 0xCF, 0xE0, 0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xBF, 0x83, 0xFD, 0xFF, 0x3F,
  0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xEF, 0xC7, 0xFE, 0x7E, 0x0F,
  0xE7, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x7E, 0xFE, 0xFF,
  0xFF, 0xFE, 0x7E, 0x1E, 0x1F, 0x9F, 0xEF, 0xF7, 0xFB, 0xF8, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE7, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x1F, 0x8F, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC,
  0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xF8, 0x03, 0xFF, 0xE1, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xCF, 0x03, 0xF9, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xE0,
  0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x03, 0xFE, 0x3F,
  0x1F, 0x07, 0xFF, 0xCF, 0x9F, 0x0F, 0xFF, 0xE7, 0xCF, 0x87, 0xFF, 0xF1,
  0xF7, 0xC7, 0xE1, 0xF8, 0xFF, 0xC7, 0xE0, 0xF8, 0x7F, 0xE3, 0xE0, 0x7C,
  0x3F, 0xF1, 0xF0, 0x3E, 0x1F, 0xF8, 0xF8, 0x1F, 0x0F, 0xFC, 0x7C, 0x0F,
  0x87, 0xFE, 0x3E, 0x07, 0xC3, 0xFF, 0x1F, 0x03, 0xE3, 0xEF, 0x8F, 0xC3,
  0xF1, 0xF7, 0xC3, 0xFF, 0xFF, 0xF3, 0xE1, 0xFF, 0xFF, 0xF8, 0xF8, 0x7F,
  0xEF, 0xF8, 0x7C, 0x1F, 0xC3, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x08, 0x01, 0xFF, 0x00, 0x7C, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x00, 0xFE,
  0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xFC,
  0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x7F, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0xFE, 0x0F,
  0xFB, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x8F, 0xFC, 0x1F, 0x1F, 0xE0, 0x04, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x06, 0x3F, 0xFC, 0xFC, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xF0, 0xFF, 0xF3, 0xF8, 0x0F, 0xF9, 0xFC,
  0x01, 0xFE, 0xFE, 0x00, 0xFF, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xF7, 0xF0, 0x0F, 0xF3, 0xF8, 0x1F,
  0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xE0, 0x78, 0x7F, 0xC0, 0x04, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xFC, 0x01,
  0xFD, 0xFF, 0x00, 0xFE, 0x7F, 0xC0, 0x7F, 0x3F, 0xFC, 0x7F, 0x8F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE,
  0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xF8, 0xFF, 0x83, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x7F, 0x8F,
  0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0xC0,
  0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x9F, 0xE0, 0x1F, 0xDF, 0xE0,
  0x0F, 0xEF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xDF, 0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC3,
  0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0x9F,
  0xC0, 0x1F, 0xEF, 0xE0, 0x0F, 0xF8, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFB, 0xE0, 0x0F, 0xFF,
  0xFD, 0xF8, 0x07, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xFF, 0x7E, 0x03, 0xEF,
  0xFF, 0xDF, 0x01, 0xF7, 0xFF, 0xEF, 0xC1, 0xFB, 0xFF, 0xF7, 0xE0, 0xF9,
  0xFF, 0xF9, 0xF0, 0x7C, 0xFF, 0xFC, 0xFC, 0x7E, 0x7F, 0xFE, 0x7E, 0x3E,
  0x3F, 0xFF, 0x1F, 0x1F, 0x1F, 0xFF, 0x8F, 0xDF, 0x8F, 0xFF, 0xC7, 0xEF,
  0x87, 0xFF, 0xE3, 0xF7, 0xC3, 0xFF, 0xF0, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xF0, 0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0x07,
  0xFC, 0x1F, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0x03, 0xF8, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFD, 0xFC, 0x07, 0xFF, 0x9F, 0xC0,
  0xFF, 0xF3, 0xF8, 0x1F, 0xFF, 0x3F, 0x83, 0xFF, 0xE7, 0xF8, 0x7F, 0xFC,
  0x7F, 0x0F, 0xFF, 0x8F, 0xF1, 0xFF, 0xF0, 0xFE, 0x3F, 0xFE, 0x1F, 0xE7,
  0xFF, 0xC1, 0xFC, 0xFF, 0xF8, 0x3F, 0xDF, 0xFF, 0x03, 0xFB, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xC3, 0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x1F,
  0xE7, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80,
  0x1F, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x7F, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF,
  0xF8, 0x3F, 0xFF, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xF8, 0x03, 0xFC,
  0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x9F, 0xC0, 0x03, 0xFD, 0xFE,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0x7F, 0x80, 0x03, 0xFB, 0xFC, 0x00,
  0x1F, 0xDF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x3F,
  0xBF, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFF, 0x3F,
  0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x87, 0xFC, 0x07, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x07, 0xF0, 0x7F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFF, 0x0F,
  0xE1, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F,
  0xF0, 0xFE, 0x03, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x9F, 0xC0,
  0x1F, 0xEF, 0xE0, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFF,
  0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0x03, 0xCF, 0xE0,
  0x08, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x0F, 0xFE, 0x00, 0xFE, 0xFE, 0x3F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFB, 0xF8, 0x03,
  0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0xEF, 0xFE, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x0F,
  0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x8F, 0xE0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x3F, 0x80,
  0x0F, 0xE7, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x80, 0x3F, 0x9F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xCF, 0xE0, 0x1F, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F,
  0xF8, 0x07, 0xF1, 0xF8, 0x07, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xFE, 0x03,
  0xF8, 0x7F, 0x03, 0xFF, 0x81, 0xFC, 0x3F, 0x81, 0xF7, 0xC0, 0xFE, 0x0F,
  0xC0, 0xFB, 0xE0, 0x7E, 0x07, 0xF0, 0x7D, 0xF0, 0x7F, 0x03, 0xF8, 0x7E,
  0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x9F, 0x0F,
  0xC0, 0x3F, 0x0F, 0x8F, 0x87, 0xE0, 0x1F, 0xCF, 0xC7, 0xE7, 0xF0, 0x07,
  0xE7, 0xE3, 0xF3, 0xF8, 0x03, 0xF3, 0xF1, 0xF9, 0xF8, 0x01, 0xF9, 0xF0,
  0x7C, 0xFC, 0x00, 0xFC, 0xF8, 0x3E, 0x7E, 0x00, 0x3F, 0xFC, 0x1F, 0xFF,
  0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF3, 0xFC, 0x01,
  0xFE, 0x3F, 0xC0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80,
  0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFD,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x03,
  0xFC, 0x3F, 0xC0, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0xFF, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xF8, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F,
  0x87, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x01,
  0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE1,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7E,
  0x7E, 0x00, 0xF9, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xE0, 0x1F, 0x01, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xE0, 0xFF, 0x08, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB, 0xF7, 0xFF, 0x9F, 0x1F,
  0xE1, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x3F, 0x07, 0xF3, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7E, 0x7F, 0xE3, 0xE1, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1F, 0xE0, 0x67, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x4F, 0xF8, 0x79, 0xFF, 0xFF, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xE3, 0xF8, 0x7F, 0xDF, 0xC7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x03,
  0xFB, 0xFC, 0x3F, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xDF, 0x8F,
  0xFC, 0xFC, 0x3F, 0xC3, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x3F, 0xC3, 0xF9, 0xFC, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x01, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF0,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x03, 0xE1, 0xF8, 0x7F, 0xCF, 0xC7, 0xFF, 0x7E, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFB, 0xFC, 0x3F, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFD, 0xFC, 0x3F, 0xCF,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xD8, 0x01, 0xFE, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x07, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x3F, 0x07, 0xF7, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xE0, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFB,
  0xF8, 0x1F, 0xE7, 0xF0, 0x7F, 0x8F, 0xE1, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F,
  0x8F, 0xE0, 0x7F, 0x3F, 0xC0, 0xFE, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xEF,
  0xE0, 0x7F, 0x9F, 0xE0, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F,
  0xC7, 0xF0, 0x3F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0xBF, 0x80, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x9F, 0xF8,
  0x7F, 0xE3, 0xF7, 0xFF, 0x9F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xC1, 0xFF, 0x07, 0xFF,
  0xF8, 0x3F, 0xE0, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x01,
  0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0x80, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xF0,
  0x1F, 0xC0, 0x7F, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0x01, 0xFF,
  0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0x80,
  0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x80, 0xFE, 0x03, 0xF8, 0xF8, 0x3F,
  0x07, 0xC7, 0xFE, 0x3F, 0x7F, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF1, 0xFF, 0x3F, 0xE7, 0xF0, 0x3F, 0xBF, 0xC0, 0xFE, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0x7F, 0x03, 0xF9, 0xFE, 0x1F,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xFC, 0x3F, 0x07, 0xE7, 0xFE, 0x3F, 0x7F, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF,
  0xFC, 0x7F, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0x7F,
  0xE3, 0xF9, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0x7F, 0xCF, 0xC7,
  0xFF, 0x7E, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFF, 0x03, 0xFB, 0xFC, 0x3F, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFD, 0xFC, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0xF8, 0x1F, 0xF0,
  0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x9F, 0xFF, 0xEF,
  0xFF, 0xEF, 0xFF, 0xF7, 0xF0, 0x73, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xF1, 0xFF, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xE1, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFE,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xDF, 0x9F, 0xFC, 0xFC, 0x7F, 0xC3,
  0xE0, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x7F, 0x00,
  0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x81,
  0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xE7,
  0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x03,
  0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xC0, 0x7E, 0x7F, 0x03, 0xFC, 0x0F, 0xE7,
  0xF0, 0x3F, 0xE0, 0xFE, 0x3F, 0x07, 0xFE, 0x0F, 0xE3, 0xF0, 0x7F, 0xE0,
  0xFC, 0x3F, 0x87, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xF1, 0xFC, 0x1F, 0x8F,
  0x9F, 0x1F, 0x81, 0xF8, 0xF9, 0xF1, 0xF8, 0x1F, 0xCF, 0x9F, 0x3F, 0x80,
  0xFC, 0xF9, 0xF3, 0xF8, 0x0F, 0xDF, 0x9F, 0xBF, 0x00, 0xFD, 0xF0, 0xFB,
  0xF0, 0x0F, 0xDF, 0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0xFB, 0xE0, 0x07, 0xFF,
  0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0xFF,
  0x3F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xE3, 0xFC, 0x0F, 0xE7, 0xF8,
  0x0F, 0xF7, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xF7, 0xF0, 0x0F, 0xE7, 0xF8,
  0x1F, 0xE3, 0xFC, 0x3F, 0xC1, 0xFC, 0x3F, 0xC1, 0xFE, 0x7F, 0x80, 0xFE,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFE,
  0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC,
  0x1F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0,
  0x0F, 0xE3, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xE7, 0xE0, 0x03, 0xF7, 0xE0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xE0, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x81, 0xFE,
  0x3F, 0xF0, 0xFF, 0x83, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFC,
  0x0F, 0xF8, 0x3F, 0xF0, 0xFF, 0xC1, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xF0,
  0x7F, 0xE0, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0x80, 0x00, 0x3F, 0x80,
  0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFE, 0x80, 0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraBold41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 29, 12, 2, -29 },
  { 30, 16, 10, 21, 2, -29 },
  { 50, 25, 29, 27, 1, -29 },
  { 141, 21, 33, 24, 1, -31 },
  { 228, 36, 30, 38, 1, -30 },
  { 363, 30, 30, 32, 2, -30 },
  { 476, 7, 10, 11, 2, -29 },
  { 485, 11, 36, 14, 2, -30 },
  { 535, 12, 36, 14, 1, -30 },
  { 589, 20, 19, 22, 1, -31 },
  { 637, 20, 19, 24, 2, -24 },
  { 685, 9, 11, 12, 1, -5 },
  { 698, 11, 6, 13, 1, -14 },
  { 707, 8, 7, 12, 2, -7 },
  { 714, 17, 30, 18, 0, -30 },
  { 778, 21, 30, 24, 1, -30 },
  { 857, 16, 29, 24, 2, -29 },
  { 915, 21, 30, 24, 1, -30 },
  { 994, 21, 30, 24, 1, -30 },
  { 1073, 22, 29, 24, 1, -29 },
  { 1153, 20, 29, 24, 2, -29 },
  { 1226, 21, 30, 24, 1, -30 },
  { 1305, 21, 29, 24, 1, -29 },
  { 1382, 21, 30, 24, 1, -30 },
  { 1461, 21, 30, 24, 1, -30 },
  { 1540, 8, 23, 12, 2, -23 },
  { 1563, 9, 29, 12, 1, -23 },
  { 1596, 20, 22, 24, 2, -26 },
  { 1651, 20, 13, 24, 2, -21 },
  { 1684, 20, 22, 24, 2, -26 },
  { 1739, 19, 30, 20, 0, -30 },
  { 1811, 33, 33, 37, 2, -30 },
  { 1948, 29, 29, 29, 0, -29 },
  { 2054, 22, 29, 27, 3, -29 },
  { 2134, 23, 30, 26, 2, -30 },
  { 2221, 25, 29, 30, 3, -29 },
  { 2312, 18, 29, 23, 3, -29 },
  { 2378, 17, 29, 22, 3, -29 },
  { 2440, 25, 30, 30, 2, -30 },
  { 2534, 25, 29, 31, 3, -29 },
  { 2625, 15, 29, 17, 1, -29 },
  { 2680, 14, 38, 14, -3, -29 },
  { 2747, 25, 29, 28, 3, -29 },
  { 2838, 19, 29, 23, 3, -29 },
  { 2907, 33, 29, 39, 3, -29 },
  { 3027, 27, 29, 34, 3, -29 },
  { 3125, 28, 30, 33, 2, -30 },
  { 3230, 21, 29, 26, 3, -29 },
  { 3307, 29, 37, 33, 2, -30 },
  { 3442, 25, 29, 27, 3, -29 },
  { 3533, 20, 30, 23, 2, -30 },
  { 3608, 22, 29, 24, 1, -29 },
  { 3688, 25, 29, 31, 3, -29 },
  { 3779, 27, 29, 27, 0, -29 },
  { 3877, 41, 29, 41, 0, -29 },
  { 4026, 28, 29, 28, 0, -29 },
  { 4128, 26, 29, 26, 0, -29 },
  { 4223, 22, 29, 24, 1, -29 },
  { 4303, 9, 37, 13, 3, -30 },
  { 4345, 17, 30, 18, 0, -30 },
  { 4409, 10, 37, 13, 1, -30 },
  { 4456, 22, 19, 23, 0, -29 },
  { 4509, 19, 4, 19, 0, 3 },
  { 4519, 12, 6, 16, 2, -31 },
  { 4528, 20, 23, 25, 2, -23 },
  { 4586, 21, 31, 26, 3, -31 },
  { 4668, 19, 23, 22, 2, -23 },
  { 4723, 21, 31, 26, 2, -31 },
  { 4805, 21, 23, 25, 2, -23 },
  { 4866, 17, 31, 16, 1, -31 },
  { 4932, 21, 33, 26, 2, -23 },
  { 5019, 21, 31, 27, 3, -31 },
  { 5101, 7, 31, 13, 3, -31 },
  { 5129, 12, 41, 13, -2, -31 },
  { 5191, 23, 31, 26, 3, -31 },
  { 5281, 7, 31, 13, 3, -31 },
  { 5309, 35, 23, 40, 3, -23 },
  { 5410, 21, 23, 27, 3, -23 },
  { 5471, 22, 23, 26, 2, -23 },
  { 5535, 21, 33, 26, 3, -23 },
  { 5622, 21, 33, 26, 2, -23 },
  { 5709, 15, 23, 19, 3, -23 },
  { 5753, 17, 23, 21, 2, -23 },
  { 5802, 16, 27, 18, 1, -27 },
  { 5856, 21, 23, 27, 3, -23 },
  { 5917, 24, 23, 24, 0, -23 },
  { 5986, 36, 23, 36, 0, -23 },
  { 6090, 24, 23, 25, 0, -23 },
  { 6159, 24, 33, 24, 0, -23 },
  { 6258, 18, 23, 20, 1, -23 },
  { 6310, 14, 36, 17, 1, -29 },
  { 6373, 5, 40, 22, 8, -31 },
  { 6398, 15, 36, 17, 1, -29 },
  { 6466, 20, 7, 24, 2, -18 },
};

const GFXfont NotoSans_ExtraBold41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold41pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_EXTRABOLD41PT7B_H_
