#ifndef _NOTOSANS_EXTRABOLD57PT7B_H_
#define _NOTOSANS_EXTRABOLD57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE,
  0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F,
  0xF1, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xFB,
  0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0x7F, 0x81, 0x80, 0xFF,
  0x87, 0xFD, 0xFE, 0x1F, 0xF7, 0xF8, 0x7F, 0xDF, 0xE1, 0xFF, 0x7F, 0x87,
  0xFD, 0xFE, 0x1F, 0xF7, 0xF8, 0x3F, 0xDF, 0xE0, 0xFE, 0x7F, 0x83, 0xF9,
  0xFE, 0x0F, 0xE7, 0xF8, 0x3F, 0x9F, 0xE0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC,
  0x0F, 0xE3, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF9, 0xFF, 0xDF, 0x3F,
  0x8F, 0xF8, 0xF8, 0x1C, 0x7F, 0xC7, 0xC0, 0x03, 0xFE, 0x3E, 0x00, 0x1F,
  0xF1, 0xF0, 0x00, 0xFF, 0xEF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xF9, 0xFF, 0x80, 0x07, 0xC7, 0xFC, 0x00, 0x3E, 0x3F, 0xF8, 0x01, 0xF1,
  0xFF, 0xF8, 0x0F, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x00,
  0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0xFE,
  0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x7F, 0x8F, 0xFF, 0x07, 0xF8, 0xFF, 0x1F,
  0xC7, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xF3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3,
  0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xF1, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xF8,
  0xFF, 0x1F, 0xE7, 0xF8, 0x1F, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE3, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x3F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFF, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x7F,
  0x00, 0x01, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00,
  0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xF8, 0x7F, 0xF3, 0xFF, 0x8F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF3,
  0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xFF, 0xFC, 0x0F, 0xFC,
  0x00, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xBF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F,
  0xBF, 0xDF, 0xEF, 0xF7, 0xF3, 0xF8, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x03,
  0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x03, 0x01, 0xF8, 0x06, 0x7E, 0x1F, 0x87, 0xF7, 0xFE,
  0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xDF,
  0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80,
  0xFF, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x20,
  0x20, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F, 0x9F, 0xF3, 0xFC,
  0x7F, 0x8F, 0xF1, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x83, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF0, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0xFF, 0x80,
  0x7F, 0xE7, 0xFC, 0x01, 0xFF, 0x7F, 0xE0, 0x0F, 0xFB, 0xFF, 0x00, 0x7F,
  0xDF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xE7,
  0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0xFF, 0xCF, 0xFC,
  0x07, 0xFE, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0x7F, 0xCF, 0xFC, 0xFE, 0x3F, 0xF1, 0xF0, 0xFF, 0xC7, 0x83, 0xFF, 0x0C,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xE0, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0x83, 0x80, 0x0F, 0xFC,
  0x08, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0x00, 0x7F, 0xE0, 0x60, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0xE0, 0x00, 0x7F,
  0xF7, 0xF0, 0x0F, 0xFF, 0xBF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0x3F, 0xE0,
  0x03, 0xFC, 0x7F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xE1, 0xFF, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x87, 0xE7, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x16, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x38, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x07, 0xE0, 0x0F, 0xF1, 0xFF, 0xC0, 0x7F, 0x9F, 0xFF,
  0x87, 0xFD, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD,
  0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0xFF, 0x7F, 0xF0, 0x3F, 0xF1, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFE, 0x0F, 0xFE, 0x7F, 0xE0, 0x3F, 0xF3, 0xFE, 0x00,
  0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x03, 0xFE,
  0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xF9, 0xFF, 0xE3, 0xFF, 0x03, 0xFF, 0x9F,
  0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xDF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x14, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0xBF, 0xF0,
  0x0F, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFD,
  0xFF, 0x0F, 0xFF, 0xCF, 0xF0, 0x3F, 0xFC, 0x7F, 0x80, 0x7F, 0x83, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC1, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x0C,
  0x00, 0x0F, 0x03, 0xFC, 0x7F, 0xE7, 0xFE, 0x7F, 0xF7, 0xFF, 0x7F, 0xE7,
  0xFE, 0x3F, 0xE1, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC, 0x3F, 0xC7,
  0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x87, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0x9F, 0xFF, 0x1F,
  0x00, 0x7F, 0xE3, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0x00, 0xFF, 0x07, 0xF0, 0x0F,
  0xFF, 0xE1, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xC7, 0xF0, 0xFE, 0x07, 0xFF,
  0xFF, 0x0F, 0xE7, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0x9F, 0xC1, 0xFF, 0xFF,
  0xF0, 0xFE, 0x7F, 0x0F, 0xF8, 0x1F, 0xC1, 0xFB, 0xF8, 0x3F, 0xC0, 0x7F,
  0x07, 0xFF, 0xE1, 0xFE, 0x01, 0xFC, 0x1F, 0xFF, 0x87, 0xF8, 0x07, 0xF0,
  0x7F, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFF, 0xF0, 0x7F, 0x00, 0x7F, 0x07,
  0xFF, 0xC1, 0xFC, 0x03, 0xFC, 0x1F, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7E,
  0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFB, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xEF,
  0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0xBF, 0x87, 0xF8, 0x1F, 0xF1, 0xFC, 0xFE,
  0x1F, 0xF0, 0xFF, 0xC7, 0xF3, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xC1, 0xFF, 0xFD, 0xFF, 0xF0, 0x7F, 0x03,
  0xFF, 0xE3, 0xFF, 0x81, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0x80, 0x01, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xFF, 0xFE, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x00, 0x1F,
  0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFC,
  0x00, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x7F,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x7F, 0xFB,
  0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFE, 0xFF,
  0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0,
  0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x3F, 0xFB,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7C,
  0x3F, 0xFC, 0x00, 0x18, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x04, 0x3F, 0xFE, 0x00, 0x1C,
  0x1F, 0xFF, 0xF7, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80,
  0xFF, 0xFE, 0x3F, 0xE0, 0x07, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xF3, 0xFE,
  0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xEF,
  0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x07, 0xFE, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xE0,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x1F, 0xFB, 0xFE, 0x00, 0x0F, 0xFE, 0xFF,
  0x80, 0x03, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0xCF, 0xF8, 0x00, 0xFF, 0xF3,
  0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0x80, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x1E, 0x07, 0xFF,
  0x80, 0x00, 0x83, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF7, 0xFE,
  0x00, 0x07, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xDF,
  0xFC, 0x00, 0x1F, 0xF3, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0xF0, 0x01, 0xFF,
  0x1F, 0xFE, 0x00, 0x7F, 0xC7, 0xFF, 0xFD, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xDF, 0xF8, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xC7,
  0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xE0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF8,
  0x03, 0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xDF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF9,
  0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC,
  0x1F, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xFC, 0x3F,
  0xF0, 0x07, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0xE7,
  0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xDF, 0xFF, 0xF7, 0xF8, 0x00, 0xFE, 0xFF, 0xFF, 0xBF, 0xC0, 0x0F,
  0xF7, 0xFF, 0xFD, 0xFE, 0x00, 0x7F, 0x3F, 0xFF, 0xE7, 0xF0, 0x03, 0xF9,
  0xFF, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xFF, 0xF9, 0xFE, 0x01, 0xFE, 0x7F,
  0xFF, 0xC7, 0xF0, 0x0F, 0xE3, 0xFF, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xFF,
  0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0xFF, 0x8F, 0xF0, 0x3F, 0x87, 0xFF, 0xFC,
  0x3F, 0xC1, 0xFC, 0x3F, 0xFF, 0xE1, 0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0x0F,
  0xF0, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE,
  0x7F, 0x83, 0xFF, 0xFE, 0x0F, 0xF3, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0x9F,
  0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF7, 0xFE, 0x00, 0xFF, 0xFF, 0xBF,
  0xF8, 0x07, 0xFF, 0xFC, 0xFF, 0xC0, 0x3F, 0xFF, 0xE3, 0xFF, 0x01, 0xFF,
  0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0xF8, 0x7F, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF,
  0x81, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0xE0, 0x3F, 0xF0,
  0xFF, 0xFF, 0x01, 0xFF, 0xC7, 0xFF, 0xF8, 0x07, 0xFE, 0x3F, 0xFF, 0xC0,
  0x1F, 0xF9, 0xFF, 0xFE, 0x00, 0xFF, 0xCF, 0xFF, 0xF0, 0x03, 0xFF, 0x7F,
  0xFF, 0x80, 0x1F, 0xFB, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x00,
  0xFF, 0xE3, 0xFF, 0x80, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x01, 0xFF, 0xCF,
  0xFC, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x7F,
  0xE7, 0xFF, 0x00, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0x03, 0xFF, 0x8F, 0xFE,
  0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0xFF,
  0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFE, 0x1F, 0xF0, 0x03,
  0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00,
  0x7F, 0xE1, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07,
  0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFE,
  0x1F, 0xF0, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x7F,
  0xF3, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x1F, 0x9F, 0xF8, 0x00, 0x63,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x02, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x01,
  0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x0F, 0xFE, 0x3F,
  0xF8, 0x03, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0xFF, 0xC3,
  0xFF, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF,
  0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0x7F, 0xCF, 0xF8,
  0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xF8,
  0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x7F, 0x7F, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xBF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xEF, 0xF0, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xF8, 0x03,
  0xFE, 0x07, 0xF9, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x83, 0xFC, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFE,
  0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x1F, 0xE1, 0xFF, 0x00, 0x0F,
  0xF8, 0xFF, 0x07, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0x83, 0xFC, 0x7F,
  0xC0, 0x03, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xE0,
  0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xE0, 0x3F, 0x9F, 0xF0, 0x00, 0x3F,
  0xEF, 0xF0, 0x1F, 0xEF, 0xF8, 0x00, 0x0F, 0xF7, 0xF8, 0x0F, 0xF7, 0xFC,
  0x00, 0x07, 0xFB, 0xFC, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFC, 0x01,
  0xFD, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF,
  0xC1, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF,
  0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xFC, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xC1,
  0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x1F, 0xFB, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFE, 0x0F, 0xFE, 0x03, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x07, 0xFE, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0x9F, 0xFF, 0xF3, 0xFC,
  0x7F, 0xFE, 0x0F, 0xE0, 0xFF, 0xE0, 0x7F, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x7E, 0x00, 0xFF, 0xC7, 0xFE, 0x03,
  0xFE, 0x3F, 0xFE, 0x0F, 0xF9, 0xFF, 0xFC, 0x3F, 0xEF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC,
  0x1F, 0xFE, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x01,
  0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0xFF,
  0xC0, 0x1F, 0xFB, 0xFF, 0x80, 0x7F, 0xEF, 0xFE, 0x03, 0xFF, 0xBF, 0xFE,
  0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF, 0xC3, 0xFC, 0x7F, 0xFE,
  0x0F, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8,
  0x0E, 0x1F, 0xF8, 0x00, 0x8F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x09, 0xFF,
  0xC0, 0x0E, 0x7F, 0xFC, 0x1F, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x01, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0xFF, 0x83, 0xFF, 0xE7, 0xFC, 0x7F,
  0xFF, 0xBF, 0xE3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x07, 0xFE, 0xFF, 0xF0, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0xE7,
  0xF8, 0x3F, 0xFC, 0x3F, 0xC0, 0xFF, 0xC0, 0xFE, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF3, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x04, 0x7F, 0xF0, 0x00, 0xE1, 0xFF, 0xF9, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xC1, 0xFF, 0xF1, 0xFE, 0x3F,
  0xFF, 0xCF, 0xF1, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0x87, 0xFF, 0xF7,
  0xFC, 0x1F, 0xFF, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x00, 0x18, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF6, 0x00,
  0x03, 0xFF, 0xBF, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x3F, 0x00, 0xFF, 0x87, 0xFF, 0x83,
  0xFE, 0x7F, 0xFF, 0x0F, 0xFB, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE,
  0x0F, 0xFE, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x1E, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF,
  0xF0, 0x0F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFC,
  0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F, 0xE0,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC3, 0xFF, 0x80,
  0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x00,
  0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xBF, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFB, 0xFF, 0x00,
  0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF8,
  0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE,
  0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0x3F, 0xFF, 0xE7,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x1F, 0xFE, 0x0F, 0xF1, 0xFF,
  0xFC, 0x3F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x3F, 0xFB,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x3F, 0xFC, 0x7F, 0xF0, 0x3F, 0xF9,
  0xFF, 0x80, 0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xDF, 0xF8, 0x07, 0xFE, 0x7F, 0xF0, 0x3F, 0xF8,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x1F,
  0xFC, 0x0F, 0xF0, 0xFF, 0xF8, 0x3F, 0xE7, 0xFF, 0xF0, 0xFF, 0xBF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xF0, 0x7F, 0xFB, 0xFF, 0x80, 0xFF, 0xEF, 0xFC, 0x01, 0xFF, 0xBF,
  0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xFE, 0x01, 0xFF, 0xBF, 0xF8, 0x0F, 0xFE,
  0xFF, 0xF8, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE, 0xFF, 0xFE, 0x0F, 0xF9,
  0xFF, 0xF0, 0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0xC0, 0x40, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xC1, 0xFF, 0xF1, 0xFE, 0x3F, 0xFF,
  0xDF, 0xF1, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0x87, 0xFF, 0xF7, 0xFC,
  0x1F, 0xFE, 0x3F, 0xE0, 0x7F, 0xE1, 0xFF, 0x00, 0x38, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0xF8, 0xFF, 0x80,
  0x18, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x81, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xE7, 0xFC, 0x3F, 0xFF, 0x0F, 0xF0, 0x7F,
  0xF0, 0x3F, 0xC0, 0x08, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xDF, 0xF8,
  0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0x3F,
  0xF0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8,
  0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xCF, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xE7, 0xFC, 0x03, 0xFF, 0xE0, 0x3F,
  0xE3, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0xF8, 0x0F,
  0xF8, 0x7F, 0xC0, 0xFF, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0x3F, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0x9F, 0xC1,
  0xFF, 0x03, 0xFE, 0x1F, 0xCF, 0xE1, 0xFF, 0x01, 0xFF, 0x0F, 0xE7, 0xF0,
  0xFF, 0x80, 0xFF, 0x8F, 0xF3, 0xFC, 0x7F, 0xC0, 0x3F, 0xE7, 0xF0, 0xFE,
  0x3F, 0xC0, 0x1F, 0xF3, 0xF8, 0x7F, 0x3F, 0xE0, 0x0F, 0xF9, 0xFC, 0x3F,
  0x9F, 0xF0, 0x03, 0xFC, 0xFE, 0x1F, 0xCF, 0xF8, 0x01, 0xFE, 0x7F, 0x07,
  0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0xFF, 0x81,
  0xFD, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0xFF,
  0xC1, 0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F,
  0xFC, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x0F, 0xFC,
  0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xEF,
  0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFE,
  0x1F, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x0F, 0xFC, 0x3F, 0xF0, 0x03,
  0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xE0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE,
  0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x2F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x90, 0x00,
  0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraBold57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 42, 16, 3, -41 },
  { 59, 22, 15, 29, 3, -41 },
  { 101, 35, 41, 37, 1, -41 },
  { 281, 29, 46, 33, 2, -43 },
  { 448, 50, 41, 53, 1, -41 },
  { 705, 42, 42, 44, 2, -41 },
  { 926, 9, 15, 16, 3, -41 },
  { 943, 16, 50, 20, 2, -41 },
  { 1043, 16, 50, 20, 2, -41 },
  { 1143, 28, 27, 31, 1, -43 },
  { 1238, 27, 28, 33, 3, -34 },
  { 1333, 11, 15, 17, 2, -7 },
  { 1354, 16, 8, 18, 1, -19 },
  { 1370, 10, 10, 16, 3, -9 },
  { 1383, 24, 41, 24, 0, -41 },
  { 1506, 29, 42, 33, 2, -41 },
  { 1659, 22, 41, 33, 3, -41 },
  { 1772, 29, 41, 33, 2, -41 },
  { 1921, 29, 42, 33, 2, -41 },
  { 2074, 31, 41, 33, 1, -41 },
  { 2233, 27, 42, 33, 3, -41 },
  { 2375, 29, 42, 33, 2, -41 },
  { 2528, 29, 41, 33, 2, -41 },
  { 2677, 29, 42, 33, 2, -41 },
  { 2830, 29, 42, 33, 2, -41 },
  { 2983, 10, 33, 16, 3, -32 },
  { 3025, 12, 40, 17, 2, -32 },
  { 3085, 27, 31, 33, 3, -36 },
  { 3190, 27, 18, 33, 3, -29 },
  { 3251, 27, 31, 33, 3, -36 },
  { 3356, 27, 42, 28, 0, -41 },
  { 3498, 46, 45, 51, 3, -41 },
  { 3757, 40, 41, 40, 0, -41 },
  { 3962, 30, 41, 38, 5, -41 },
  { 4116, 32, 42, 37, 3, -41 },
  { 4284, 34, 41, 42, 5, -41 },
  { 4459, 24, 41, 32, 5, -41 },
  { 4582, 23, 41, 31, 5, -41 },
  { 4700, 34, 42, 42, 3, -41 },
  { 4879, 34, 41, 44, 5, -41 },
  { 5054, 20, 41, 24, 2, -41 },
  { 5157, 19, 53, 19, -4, -41 },
  { 5283, 33, 41, 38, 5, -41 },
  { 5453, 26, 41, 32, 5, -41 },
  { 5587, 45, 41, 54, 5, -41 },
  { 5818, 37, 41, 47, 5, -41 },
  { 6008, 39, 42, 45, 3, -41 },
  { 6213, 28, 41, 36, 5, -41 },
  { 6357, 40, 51, 45, 3, -41 },
  { 6612, 33, 41, 38, 5, -41 },
  { 6782, 27, 42, 32, 3, -41 },
  { 6924, 31, 41, 33, 1, -41 },
  { 7083, 35, 42, 43, 4, -41 },
  { 7267, 38, 41, 38, 0, -41 },
  { 7462, 57, 41, 57, 0, -41 },
  { 7755, 39, 41, 40, 0, -41 },
  { 7955, 37, 41, 37, 0, -41 },
  { 8145, 30, 41, 34, 2, -41 },
  { 8299, 13, 50, 19, 4, -41 },
  { 8381, 24, 41, 24, 0, -41 },
  { 8504, 14, 50, 19, 1, -41 },
  { 8592, 30, 27, 31, 1, -41 },
  { 8694, 26, 6, 26, 0, 4 },
  { 8714, 18, 9, 22, 2, -44 },
  { 8735, 29, 33, 35, 2, -32 },
  { 8855, 30, 44, 36, 4, -43 },
  { 9020, 26, 33, 30, 3, -32 },
  { 9128, 29, 44, 36, 3, -43 },
  { 9288, 29, 33, 35, 3, -32 },
  { 9408, 24, 44, 23, 1, -44 },
  { 9540, 29, 46, 36, 3, -32 },
  { 9707, 30, 43, 38, 4, -43 },
  { 9869, 10, 44, 18, 4, -44 },
  { 9924, 17, 58, 18, -3, -44 },
  { 10048, 32, 43, 36, 4, -43 },
  { 10220, 10, 43, 18, 4, -43 },
  { 10274, 48, 32, 56, 4, -32 },
  { 10466, 30, 32, 38, 4, -32 },
  { 10586, 30, 33, 36, 3, -32 },
  { 10710, 30, 46, 36, 4, -32 },
  { 10883, 29, 46, 36, 3, -32 },
  { 11050, 21, 32, 26, 4, -32 },
  { 11134, 24, 33, 29, 3, -32 },
  { 11233, 23, 39, 25, 1, -38 },
  { 11346, 30, 32, 38, 4, -31 },
  { 11466, 34, 31, 34, 0, -31 },
  { 11598, 49, 31, 50, 1, -31 },
  { 11788, 34, 31, 34, 0, -31 },
  { 11920, 34, 45, 34, 0, -31 },
  { 12112, 25, 31, 28, 2, -31 },
  { 12209, 20, 50, 23, 1, -41 },
  { 12334, 7, 56, 30, 12, -43 },
  { 12383, 20, 50, 23, 2, -41 },
  { 12508, 27, 10, 33, 3, -25 },
};

const GFXfont NotoSans_ExtraBold57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold57pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_EXTRABOLD57PT7B_H_
