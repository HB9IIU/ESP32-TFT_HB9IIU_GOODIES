#ifndef _NOTOSANS_EXTRABOLD11PT7B_H_
#define _NOTOSANS_EXTRABOLD11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0x8B, 0xBB, 0xB0, 0x34, 0x69, 0xFB, 0xF2, 0x9F, 0xDA, 0x2C,
  0x31, 0xFD, 0x1C, 0x3C, 0x7F, 0xDC, 0x10, 0x63, 0x34, 0x8D, 0x63, 0x56,
  0x6F, 0xC2, 0xB1, 0x3C, 0xC6, 0x38, 0x36, 0x1B, 0x07, 0x07, 0xB6, 0x71,
  0xB8, 0xF7, 0xE0, 0x36, 0x44, 0xCC, 0x44, 0x63, 0xCD, 0x92, 0x4B, 0x78,
  0x33, 0xFF, 0x9E, 0x50, 0x10, 0x4F, 0xFF, 0x10, 0x40, 0x78, 0xFC, 0xB0,
  0x19, 0x8C, 0x46, 0x31, 0x18, 0x39, 0xF4, 0xF3, 0xCD, 0x36, 0xDE, 0x3F,
  0xF3, 0x33, 0x33, 0x7B, 0xF0, 0xC6, 0x18, 0xC7, 0xFF, 0xF9, 0xF0, 0xCE,
  0x38, 0x39, 0xFE, 0x18, 0x63, 0x9E, 0x5B, 0xF1, 0x86, 0xF7, 0xB1, 0xEB,
  0x8E, 0xFE, 0x39, 0xE4, 0x3E, 0xEF, 0x36, 0xDE, 0xFF, 0xF0, 0x86, 0x18,
  0xC3, 0x18, 0x79, 0xB4, 0xDE, 0x7B, 0x3C, 0xDE, 0x79, 0xFC, 0xF3, 0x7C,
  0x31, 0x9C, 0xE0, 0xB0, 0x68, 0x02, 0xB0, 0x04, 0x77, 0x38, 0x1C, 0x10,
  0xFF, 0xF0, 0x3F, 0x81, 0x81, 0x87, 0x73, 0x00, 0x77, 0xC6, 0x72, 0x00,
  0x8C, 0x1E, 0x18, 0xD3, 0xAA, 0x5D, 0x2A, 0xB5, 0x34, 0xC2, 0x1E, 0x00,
  0x18, 0x3C, 0x3C, 0x2C, 0x66, 0x7E, 0x66, 0xC3, 0xFB, 0xFC, 0xFE, 0xFB,
  0x3D, 0xFE, 0x7F, 0xEC, 0x30, 0xC3, 0x0E, 0x9E, 0xFB, 0xFC, 0xF3, 0xCF,
  0x3F, 0xFE, 0xFF, 0xF1, 0xEF, 0x63, 0xFF, 0xFF, 0xCF, 0xFC, 0xCC, 0x3F,
  0xFC, 0x37, 0xDF, 0x3E, 0xDF, 0xC7, 0x1C, 0x7F, 0xFF, 0x1C, 0x71, 0xF7,
  0x66, 0x66, 0x6F, 0x33, 0x33, 0x33, 0x33, 0x3E, 0xCF, 0x6D, 0xBC, 0xF3,
  0x6D, 0xF3, 0xC6, 0x31, 0x8C, 0x63, 0xFF, 0xE3, 0xF1, 0xF9, 0xFC, 0xBF,
  0x5E, 0xEF, 0x77, 0xB3, 0xE7, 0xCF, 0xDF, 0xBD, 0xFB, 0x73, 0xE7, 0x79,
  0xFF, 0x1E, 0x3C, 0x78, 0xFB, 0xBE, 0xF7, 0xF3, 0xBF, 0xE3, 0x18, 0x79,
  0xFF, 0x1E, 0x3C, 0x78, 0xFB, 0xBE, 0x0C, 0x0C, 0xF3, 0xEC, 0xF6, 0xF3,
  0x6D, 0xB3, 0x3D, 0xE4, 0x1C, 0x38, 0x3D, 0xFE, 0xFF, 0xF3, 0x0C, 0x30,
  0xC3, 0x0C, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xDE, 0xC7, 0x8D, 0x9B, 0x66,
  0xC7, 0x8E, 0x1C, 0xC4, 0x79, 0xCD, 0x29, 0x35, 0x66, 0xAC, 0xF7, 0x8E,
  0xE1, 0x8C, 0xC6, 0x6E, 0x3C, 0x38, 0x38, 0x3C, 0x6E, 0xC7, 0xC6, 0xD9,
  0xB1, 0xC3, 0x82, 0x04, 0x08, 0xFF, 0xF1, 0x86, 0x31, 0x87, 0xFF, 0xEA,
  0xAA, 0xB0, 0xC2, 0x18, 0xC2, 0x18, 0xC3, 0xED, 0xB6, 0xDB, 0x7C, 0x20,
  0xC7, 0x92, 0xCC, 0xF8, 0xF0, 0x79, 0x33, 0xDB, 0xCD, 0xF0, 0xC3, 0x0F,
  0xB6, 0xCB, 0x3D, 0xAE, 0x3D, 0xA4, 0x30, 0x69, 0xE0, 0x0C, 0x37, 0xDB,
  0xCD, 0x36, 0xDD, 0x79, 0xB7, 0xF0, 0x64, 0xF0, 0x7B, 0x3C, 0xC6, 0x31,
  0x8C, 0x75, 0xBC, 0xD1, 0x6D, 0xF0, 0xDF, 0x30, 0xC3, 0x0F, 0xB6, 0xCF,
  0x3C, 0xF3, 0xCF, 0xFF, 0x30, 0x33, 0x33, 0x33, 0x3E, 0xC0, 0xC3, 0x0D,
  0xFE, 0xF3, 0xCD, 0xB3, 0xFF, 0xFF, 0xBF, 0xEE, 0xF6, 0x7B, 0x3D, 0x9E,
  0xCC, 0xBB, 0x6C, 0xF3, 0xCF, 0x30, 0x79, 0xBC, 0x51, 0x6C, 0xE0, 0xBB,
  0x6C, 0xF2, 0xDB, 0xEC, 0x30, 0xC0, 0x75, 0xBC, 0xD1, 0x6D, 0xF0, 0xC3,
  0x0C, 0xBF, 0xCC, 0xCC, 0x7E, 0x5C, 0x79, 0xFC, 0x67, 0x98, 0xC6, 0x35,
  0xE0, 0xCE, 0x73, 0x9D, 0xFC, 0xCD, 0x36, 0xDE, 0x38, 0xC0, 0xCC, 0xD7,
  0x67, 0xD9, 0xDE, 0x73, 0x0C, 0xC0, 0xEC, 0xF0, 0xE1, 0xC6, 0xD9, 0xC0,
  0xCD, 0x36, 0xDE, 0x38, 0xC3, 0x3C, 0xC0, 0xF8, 0xCC, 0xC6, 0x7C, 0x33,
  0x22, 0xEE, 0x22, 0x33, 0xFF, 0xFF, 0xF0, 0xC6, 0x66, 0x33, 0x66, 0xEC,
  0x66, 0xF0,
};

const GFXglyph NotoSans_ExtraBold11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 8, 3, 1, -8 },
  { 3, 4, 3, 6, 1, -8 },
  { 5, 7, 8, 7, 0, -8 },
  { 12, 6, 9, 6, 0, -8 },
  { 19, 10, 8, 10, 0, -8 },
  { 29, 9, 8, 9, 0, -8 },
  { 38, 1, 3, 3, 1, -8 },
  { 39, 4, 10, 4, 0, -8 },
  { 44, 3, 10, 4, 0, -8 },
  { 48, 6, 5, 6, 0, -8 },
  { 52, 6, 6, 6, 0, -7 },
  { 57, 3, 2, 3, 0, -1 },
  { 58, 3, 2, 4, 0, -4 },
  { 59, 2, 2, 3, 1, -2 },
  { 60, 5, 8, 5, 0, -8 },
  { 65, 6, 8, 6, 0, -8 },
  { 71, 4, 8, 6, 1, -8 },
  { 75, 6, 8, 6, 0, -8 },
  { 81, 6, 8, 6, 0, -8 },
  { 87, 6, 8, 6, 0, -8 },
  { 93, 5, 8, 6, 1, -8 },
  { 98, 6, 8, 6, 0, -8 },
  { 104, 6, 8, 6, 0, -8 },
  { 110, 6, 8, 6, 0, -8 },
  { 116, 6, 8, 6, 0, -8 },
  { 122, 2, 6, 3, 1, -6 },
  { 124, 3, 7, 3, 0, -6 },
  { 127, 6, 6, 6, 0, -7 },
  { 132, 6, 4, 6, 0, -6 },
  { 135, 6, 6, 6, 0, -7 },
  { 140, 5, 8, 5, 0, -8 },
  { 145, 9, 9, 10, 0, -8 },
  { 156, 8, 8, 8, 0, -8 },
  { 164, 6, 8, 7, 1, -8 },
  { 170, 6, 8, 7, 1, -8 },
  { 176, 6, 8, 8, 1, -8 },
  { 182, 5, 8, 6, 1, -8 },
  { 187, 4, 8, 6, 1, -8 },
  { 191, 6, 8, 8, 1, -8 },
  { 197, 6, 8, 8, 1, -8 },
  { 203, 4, 8, 5, 0, -8 },
  { 207, 4, 10, 4, -1, -8 },
  { 212, 6, 8, 7, 1, -8 },
  { 218, 5, 8, 6, 1, -8 },
  { 223, 9, 8, 11, 1, -8 },
  { 232, 7, 8, 9, 1, -8 },
  { 239, 7, 8, 9, 1, -8 },
  { 246, 5, 8, 7, 1, -8 },
  { 251, 7, 10, 9, 1, -8 },
  { 260, 6, 8, 7, 1, -8 },
  { 266, 6, 8, 6, 0, -8 },
  { 272, 6, 8, 6, 0, -8 },
  { 278, 6, 8, 8, 1, -8 },
  { 284, 7, 8, 7, 0, -8 },
  { 291, 11, 8, 11, 0, -8 },
  { 302, 8, 8, 8, 0, -8 },
  { 310, 7, 8, 7, 0, -8 },
  { 317, 6, 8, 7, 0, -8 },
  { 323, 2, 10, 4, 1, -8 },
  { 326, 5, 8, 5, 0, -8 },
  { 331, 3, 10, 4, 0, -8 },
  { 335, 6, 5, 6, 0, -8 },
  { 339, 5, 1, 5, 0, 1 },
  { 340, 4, 1, 4, 0, -8 },
  { 341, 6, 6, 7, 0, -6 },
  { 346, 6, 8, 7, 1, -8 },
  { 352, 6, 6, 6, 0, -6 },
  { 357, 6, 8, 7, 0, -8 },
  { 363, 6, 6, 7, 0, -6 },
  { 368, 5, 8, 4, 0, -8 },
  { 373, 6, 9, 7, 0, -6 },
  { 380, 6, 8, 7, 1, -8 },
  { 386, 2, 8, 3, 1, -8 },
  { 388, 4, 11, 3, -1, -8 },
  { 394, 6, 8, 7, 1, -8 },
  { 400, 2, 8, 3, 1, -8 },
  { 402, 9, 6, 11, 1, -6 },
  { 409, 6, 6, 7, 1, -6 },
  { 414, 6, 6, 7, 0, -6 },
  { 419, 6, 9, 7, 1, -6 },
  { 426, 6, 9, 7, 0, -6 },
  { 433, 4, 6, 5, 1, -6 },
  { 436, 5, 6, 6, 0, -6 },
  { 440, 5, 7, 5, 0, -7 },
  { 445, 5, 6, 7, 1, -6 },
  { 449, 6, 6, 6, 0, -6 },
  { 454, 10, 6, 10, 0, -6 },
  { 462, 7, 6, 7, 0, -6 },
  { 468, 6, 9, 6, 0, -6 },
  { 475, 5, 6, 5, 0, -6 },
  { 479, 4, 10, 5, 0, -8 },
  { 484, 2, 10, 6, 2, -8 },
  { 487, 4, 10, 5, 0, -8 },
  { 492, 6, 2, 6, 0, -5 },
};

const GFXfont NotoSans_ExtraBold11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold11pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_EXTRABOLD11PT7B_H_
