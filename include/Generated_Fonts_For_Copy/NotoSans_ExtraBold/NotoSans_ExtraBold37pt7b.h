#ifndef _NOTOSANS_EXTRABOLD37PT7B_H_
#define _NOTOSANS_EXTRABOLD37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold37pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xCF, 0x9F, 0x3E, 0x7C, 0x00, 0x00, 0x07, 0x9F, 0xBF, 0xFF, 0xFC, 0xF8,
  0xFC, 0xFF, 0xF1, 0xFF, 0xC7, 0xDF, 0x1F, 0x7C, 0x7D, 0xF1, 0xF7, 0xC7,
  0xDE, 0x1F, 0x78, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0xF8, 0x01, 0xE3, 0xE0, 0x0F, 0x8F, 0x00, 0x3E, 0x3C, 0x1F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC1, 0xF1,
  0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF8, 0x3F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x83, 0xC7, 0xC0, 0x0F,
  0x1F, 0x00, 0x7C, 0x78, 0x01, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3E,
  0x00, 0x78, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07,
  0xFF, 0xC3, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0x7C, 0xFC,
  0xE0, 0x9F, 0x9C, 0x03, 0xFB, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03,
  0xBF, 0x80, 0x73, 0xF4, 0x0E, 0x7E, 0xF1, 0xDF, 0xDF, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x40, 0x3F, 0xC0, 0x0F, 0x80,
  0x7F, 0xE0, 0x0F, 0x80, 0x7F, 0xF0, 0x1F, 0x00, 0xFD, 0xF0, 0x1F, 0x00,
  0xF8, 0xF8, 0x3E, 0x00, 0xF8, 0xF8, 0x3C, 0x00, 0xF8, 0xF8, 0x7C, 0x00,
  0xF8, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0xF8, 0x00, 0xF8, 0xF9, 0xF0, 0x00,
  0xF8, 0xF9, 0xF3, 0xF8, 0x7D, 0xF3, 0xE7, 0xFC, 0x7F, 0xF3, 0xEF, 0xFE,
  0x3F, 0xE7, 0xCF, 0xFE, 0x1F, 0xC7, 0x8F, 0x9F, 0x0F, 0x0F, 0x9F, 0x1F,
  0x00, 0x0F, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x1F,
  0x00, 0x3E, 0x1F, 0x1F, 0x00, 0x7C, 0x1F, 0x1F, 0x00, 0x7C, 0x0F, 0x1F,
  0x00, 0xF8, 0x0F, 0xFE, 0x00, 0xF0, 0x0F, 0xFE, 0x01, 0xF0, 0x07, 0xFC,
  0x03, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xF8, 0x7C,
  0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0xFC, 0x3F, 0xFE, 0x1F, 0xC3, 0xFF, 0xF1, 0xFC,
  0x7F, 0x7F, 0xBF, 0x87, 0xE3, 0xFF, 0xF8, 0xFE, 0x1F, 0xFF, 0x0F, 0xE0,
  0xFF, 0xF0, 0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFB, 0xFC, 0x07,
  0xFE, 0x1F, 0xF0, 0xFF, 0xFF, 0xDF, 0x7D, 0xF7, 0xDE, 0x78, 0x07, 0xE0,
  0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F,
  0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0,
  0xF8, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0xFC, 0x3F, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x1C, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xCF, 0x83, 0xF3, 0xF0,
  0x78, 0x78, 0x06, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x3E,
  0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x79, 0xFB, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0x3F, 0x9F, 0xC3, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0xEF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F,
  0xBF, 0x07, 0xF7, 0xE0, 0xFC, 0xFE, 0x3F, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xF0,
  0x7F, 0xC3, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x7C, 0xFC,
  0xC3, 0xF1, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0x03, 0xF0, 0x80,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7C,
  0x7F, 0x84, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF,
  0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3D, 0xF8,
  0x07, 0xDF, 0x80, 0xF9, 0xF8, 0x1F, 0x9F, 0x81, 0xF1, 0xF8, 0x3E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x8F, 0x81, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0xFF, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9F, 0xFF, 0xE2, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0xC0, 0x3F, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xC0, 0x8F, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF3, 0xFC, 0x3E, 0xFF,
  0xCF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFE, 0x1F,
  0xCF, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFE, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0xC7, 0xE3, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF8,
  0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0x1F, 0xCF, 0xC1, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xDF, 0xC7, 0xFB, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xFF,
  0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFE, 0x7F, 0x9F, 0x83,
  0xF7, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x07,
  0xF7, 0xE1, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xF7,
  0xE0, 0xF8, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0x31, 0xFB, 0xFF, 0xFF, 0xFF, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0xFD, 0xFF, 0xFF, 0xF7, 0xC0, 0x1C, 0x7E, 0x7F, 0x7F,
  0x7F, 0x7E, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0x00, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x3C, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0xFE, 0x3F,
  0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xF9, 0xF1, 0xFC, 0x80, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x0F, 0x81, 0xFC, 0x3C, 0x7C,
  0x3F, 0xFC, 0xF9, 0xF1, 0xFF, 0xF1, 0xEF, 0x8F, 0xFF, 0xC7, 0xBE, 0x3E,
  0x1F, 0x1E, 0xF1, 0xF0, 0x7C, 0x7F, 0xC7, 0xC1, 0xF1, 0xFF, 0x1F, 0x07,
  0xC7, 0xFC, 0x78, 0x1F, 0x1E, 0xF1, 0xF0, 0x7C, 0x7B, 0xC7, 0xC1, 0xF1,
  0xEF, 0x1F, 0x0F, 0xCF, 0xBC, 0x3F, 0xFF, 0xFC, 0xF8, 0xFF, 0xDF, 0xE3,
  0xE1, 0xFE, 0x7F, 0x07, 0xC0, 0xE0, 0x78, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0x00, 0x7F, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xCF, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x87,
  0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF9, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFC, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0xFC, 0x7F, 0xEF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F,
  0xEF, 0xC1, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xEF, 0xC0, 0xFE, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xFF,
  0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFB, 0xF0, 0xFE,
  0x01, 0x8F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x38, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F, 0xEF, 0xC0,
  0x3F, 0xBF, 0x00, 0xFE, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0xBF, 0x01,
  0xFE, 0xFC, 0x1F, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFF, 0xE7, 0xE3, 0xFC, 0x01, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x03,
  0xF7, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0x7F, 0x80, 0xFC, 0xFF, 0x03, 0xF3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE1, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x7F, 0xFB, 0xFF, 0x9F,
  0xF8, 0xFF, 0x87, 0xF0, 0x00, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0,
  0x7F, 0x3F, 0x03, 0xF8, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC3, 0xF8,
  0x3F, 0x1F, 0xC0, 0xFC, 0xFE, 0x03, 0xF3, 0xF8, 0x0F, 0xDF, 0xC0, 0x3F,
  0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xDF,
  0xC0, 0xFE, 0x7F, 0x03, 0xF0, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0,
  0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7F, 0x3F, 0x01, 0xFC, 0xFC,
  0x03, 0xFB, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xEF,
  0x80, 0x7B, 0xFF, 0x7C, 0x07, 0xDF, 0xFF, 0xE0, 0x3F, 0xFF, 0xEF, 0x81,
  0xEF, 0xFF, 0x7C, 0x1F, 0x7F, 0xFB, 0xE0, 0xFB, 0xFF, 0xDF, 0x87, 0xDF,
  0xFE, 0x7C, 0x7C, 0xFF, 0xF3, 0xE3, 0xE7, 0xFF, 0x9F, 0x1F, 0x3F, 0xFC,
  0x7D, 0xF1, 0xFF, 0xE3, 0xEF, 0x8F, 0xFF, 0x1F, 0x7C, 0x7F, 0xF8, 0xFF,
  0xC3, 0xFF, 0xC3, 0xFE, 0x1F, 0xFE, 0x1F, 0xF0, 0xFF, 0xF0, 0xFF, 0x07,
  0xFF, 0x83, 0xF8, 0x3F, 0xFC, 0x1F, 0xC1, 0xFF, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFB, 0xF8, 0x1F,
  0xF9, 0xF8, 0x1F, 0xFD, 0xFC, 0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFE, 0x1F,
  0xFC, 0x7E, 0x1F, 0xFC, 0x7F, 0x1F, 0xFC, 0x3F, 0x9F, 0xFC, 0x3F, 0x9F,
  0xFC, 0x1F, 0xDF, 0xFC, 0x0F, 0xDF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0x9F,
  0xF1, 0xFE, 0x03, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF8, 0x07, 0xF1,
  0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x3F, 0xBF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0x7E, 0x3F, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFC, 0xFF, 0x87, 0xF8, 0x0F, 0xF1, 0xFC, 0x01, 0xFC, 0x7F,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0x7E,
  0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00,
  0x7E, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0xFE, 0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFC, 0xFF, 0xC3, 0xF0,
  0x3F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F,
  0x8F, 0xC1, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFC, 0x7F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF8, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x8F, 0xC0, 0x7F,
  0x3F, 0x01, 0xFC, 0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x07,
  0xFF, 0x8F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF7, 0xF9, 0xFB, 0xF0, 0x0D,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF,
  0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x7F, 0x03, 0xF9, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x3F, 0x01,
  0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x3F, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F,
  0xCF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xFB, 0xF0, 0x0F, 0xE0, 0x1F, 0x9F, 0x80, 0x7F, 0x00, 0xFC,
  0xFC, 0x03, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0xE0, 0x7F, 0x1F, 0x81, 0xFF,
  0x03, 0xF0, 0xFC, 0x0F, 0xF8, 0x1F, 0x87, 0xE0, 0x7B, 0xC0, 0xFC, 0x1F,
  0x07, 0xDF, 0x07, 0xE0, 0xFC, 0x3E, 0xF8, 0x7E, 0x07, 0xE1, 0xF7, 0xC3,
  0xF0, 0x3F, 0x0F, 0xBE, 0x1F, 0x80, 0xF8, 0xF8, 0xF8, 0xFC, 0x07, 0xE7,
  0xC7, 0xCF, 0xC0, 0x3F, 0x3E, 0x3E, 0x7E, 0x01, 0xF9, 0xF1, 0xF3, 0xF0,
  0x07, 0xDF, 0x87, 0xDF, 0x80, 0x3E, 0xF8, 0x3E, 0xF8, 0x01, 0xFF, 0xC1,
  0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xF0, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x7F, 0x8F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xDF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x7F, 0x3F,
  0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xF8,
  0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xF0,
  0xFE, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xE7, 0xF0,
  0x07, 0xE7, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x7B, 0xE0, 0x07, 0x9E, 0x00, 0xF9, 0xF0, 0x0F, 0x0F,
  0x01, 0xF0, 0xF8, 0x1E, 0x07, 0x83, 0xE0, 0x7C, 0x3C, 0x03, 0xC7, 0xC0,
  0x3E, 0x7C, 0x01, 0xEF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0x00, 0x70,
  0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x18, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xF0, 0x7E, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F,
  0x7F, 0x1F, 0xEF, 0xFF, 0xFD, 0xFF, 0xEF, 0x9F, 0xF9, 0xF1, 0xFE, 0x3E,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE1, 0xC0, 0xFC, 0xFE, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xF3, 0xFD, 0xFC, 0x1F, 0xBF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x87, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF,
  0xFF, 0xF3, 0xEF, 0xFC, 0x7C, 0x7F, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xC7,
  0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xE3, 0xFC, 0x73, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x06, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3,
  0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x18, 0x3F, 0x1F,
  0xE7, 0xE7, 0xFE, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC,
  0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x83, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xDF, 0x87, 0xF1, 0xF0, 0x00,
  0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFC,
  0x1F, 0xBF, 0x81, 0xF7, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x02, 0x7F, 0x83, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F,
  0xF0, 0x03, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xE1, 0xFD, 0xC3, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC1,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x03, 0xFC, 0xFC, 0xFF,
  0xDF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x9F, 0xFB, 0xF0, 0xFE, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x7F, 0x70, 0x1F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF,
  0xC7, 0xFF, 0xE0, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE1,
  0xE0, 0xFD, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xF1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03,
  0xF0, 0x7F, 0xFF, 0xFB, 0xF7, 0xC0, 0x00, 0x00, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF0, 0x07, 0xC1, 0xFC, 0x3F, 0x83, 0xF0, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x7F, 0xFF, 0xDF,
  0xFB, 0xFE, 0x7F, 0x8F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x0F, 0xF7, 0xE0, 0x7F, 0x3F, 0x07, 0xF1, 0xF8, 0x7F,
  0x0F, 0xC7, 0xF0, 0x7E, 0x7F, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0x3F, 0x83, 0xF0, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0,
  0x7F, 0x3F, 0x03, 0xFD, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x03, 0x81, 0xF3, 0xFE, 0x1F, 0xE3,
  0xEF, 0xFE, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0x3F, 0xFF, 0x83, 0xF8, 0x3F, 0xFE, 0x07, 0xF0, 0x3F, 0xFC,
  0x0F, 0xE0, 0x7F, 0xF8, 0x1F, 0x80, 0xFF, 0xF0, 0x3F, 0x01, 0xFF, 0xE0,
  0x7E, 0x03, 0xFF, 0xC0, 0xFC, 0x07, 0xFF, 0x81, 0xF8, 0x0F, 0xFF, 0x03,
  0xF0, 0x1F, 0xFE, 0x07, 0xE0, 0x3F, 0xFC, 0x0F, 0xC0, 0x7F, 0xF8, 0x1F,
  0x80, 0xFF, 0xF0, 0x3F, 0x01, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0xC0, 0xFC,
  0x07, 0xE0, 0x00, 0x38, 0x1F, 0x3F, 0xE3, 0xEF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7E, 0x01, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xF1, 0xFE, 0xFE, 0x0F, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7E, 0xFE, 0x07, 0xEF, 0xE0, 0xFE, 0x7F, 0x9F, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x38, 0x1F,
  0x3F, 0xC3, 0xEF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFE, 0x7F, 0xBF,
  0x83, 0xF7, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0xFE, 0xFF,
  0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xCF, 0xE1, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x03,
  0xFC, 0xFC, 0xFF, 0xDF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x7F,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x9F, 0xFB, 0xF0, 0xFE, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC7,
  0xFE, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0x80, 0x7F, 0xF9,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF, 0x81, 0xBF, 0x00, 0x7F, 0x00, 0xFF,
  0xC0, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0xFC, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xCF, 0x8F, 0xF1, 0xF0, 0xFE, 0x01, 0xFD, 0xF8,
  0x07, 0xE7, 0xE0, 0x3F, 0x9F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x1F,
  0xC1, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00,
  0xFC, 0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x7E, 0x0F, 0xF0, 0x3F, 0x7E,
  0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF8, 0x7E, 0x3F, 0x0F, 0xF8, 0x7E, 0x3F,
  0x1F, 0x78, 0x7E, 0x3F, 0x1F, 0x78, 0xFC, 0x1F, 0x1F, 0x7C, 0xFC, 0x1F,
  0x9E, 0x7C, 0xFC, 0x1F, 0x9E, 0x7C, 0xF8, 0x1F, 0xBE, 0x3D, 0xF8, 0x0F,
  0xBE, 0x3D, 0xF8, 0x0F, 0xBC, 0x3F, 0xF8, 0x0F, 0xBC, 0x3F, 0xF0, 0x07,
  0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x7F,
  0x03, 0xFC, 0xFE, 0x0F, 0xE3, 0xF8, 0x7F, 0x07, 0xF3, 0xF8, 0x0F, 0xCF,
  0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFE, 0xFE, 0x07, 0xF3, 0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F,
  0xC7, 0xF0, 0x3F, 0xBF, 0xC0, 0x7F, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xE7,
  0xE0, 0x3F, 0x9F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8,
  0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC,
  0x01, 0xF3, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x1F, 0xC1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x87, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x0F, 0xE3, 0xFE, 0x1F, 0xE0, 0xFC, 0x07, 0xF8, 0x3F,
  0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x3F, 0xC1, 0xFF,
  0x0F, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0xE0, 0xFF, 0x01, 0xF8, 0x1F, 0xC3,
  0xFE, 0x1F, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x3F, 0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xC0, 0xF8, 0x00,
  0x7F, 0x80, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xE0,
  0x1F, 0xC0,
};

const GFXglyph NotoSans_ExtraBold37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 26, 11, 2, -26 },
  { 24, 14, 9, 19, 2, -26 },
  { 40, 22, 26, 24, 1, -26 },
  { 112, 19, 30, 21, 1, -28 },
  { 184, 32, 27, 34, 1, -27 },
  { 292, 28, 27, 29, 1, -27 },
  { 387, 6, 9, 10, 2, -26 },
  { 394, 11, 33, 13, 1, -27 },
  { 440, 10, 33, 13, 1, -27 },
  { 482, 18, 17, 20, 1, -28 },
  { 521, 18, 18, 21, 2, -22 },
  { 562, 8, 10, 11, 1, -5 },
  { 572, 10, 5, 12, 1, -12 },
  { 579, 7, 6, 11, 2, -6 },
  { 585, 16, 27, 16, 0, -27 },
  { 639, 19, 27, 21, 1, -27 },
  { 704, 14, 26, 21, 2, -26 },
  { 750, 19, 27, 21, 1, -27 },
  { 815, 19, 27, 21, 1, -27 },
  { 880, 20, 26, 21, 1, -26 },
  { 945, 18, 26, 21, 2, -26 },
  { 1004, 19, 27, 21, 1, -27 },
  { 1069, 19, 26, 21, 1, -26 },
  { 1131, 19, 27, 21, 1, -27 },
  { 1196, 19, 27, 21, 1, -27 },
  { 1261, 7, 21, 11, 2, -21 },
  { 1280, 8, 26, 11, 1, -21 },
  { 1306, 18, 20, 21, 2, -23 },
  { 1351, 18, 12, 21, 2, -19 },
  { 1378, 18, 20, 21, 2, -23 },
  { 1423, 17, 27, 18, 0, -27 },
  { 1481, 30, 30, 33, 2, -27 },
  { 1594, 26, 27, 26, 0, -27 },
  { 1682, 20, 26, 25, 3, -26 },
  { 1747, 21, 27, 24, 2, -27 },
  { 1818, 22, 26, 27, 3, -26 },
  { 1890, 16, 26, 21, 3, -26 },
  { 1942, 15, 26, 20, 3, -26 },
  { 1991, 22, 27, 27, 2, -27 },
  { 2066, 22, 26, 28, 3, -26 },
  { 2138, 13, 26, 15, 1, -26 },
  { 2181, 13, 34, 13, -3, -26 },
  { 2237, 22, 26, 25, 3, -26 },
  { 2309, 17, 26, 21, 3, -26 },
  { 2365, 29, 26, 35, 3, -26 },
  { 2460, 24, 26, 30, 3, -26 },
  { 2538, 25, 27, 29, 2, -27 },
  { 2623, 19, 26, 23, 3, -26 },
  { 2685, 26, 33, 29, 2, -27 },
  { 2793, 22, 26, 25, 3, -26 },
  { 2865, 17, 27, 21, 2, -27 },
  { 2923, 20, 26, 22, 1, -26 },
  { 2988, 22, 26, 28, 3, -26 },
  { 3060, 25, 26, 25, 0, -26 },
  { 3142, 37, 26, 37, 0, -26 },
  { 3263, 26, 26, 26, 0, -26 },
  { 3348, 24, 26, 24, 0, -26 },
  { 3426, 20, 26, 22, 1, -26 },
  { 3491, 9, 33, 12, 2, -27 },
  { 3529, 16, 27, 16, 0, -27 },
  { 3583, 9, 33, 12, 1, -27 },
  { 3621, 20, 18, 20, 0, -27 },
  { 3666, 17, 3, 17, 0, 3 },
  { 3673, 12, 6, 14, 1, -28 },
  { 3682, 19, 21, 23, 1, -21 },
  { 3732, 19, 28, 24, 3, -28 },
  { 3799, 17, 21, 20, 2, -21 },
  { 3844, 19, 28, 24, 2, -28 },
  { 3911, 19, 21, 22, 2, -21 },
  { 3961, 15, 28, 15, 1, -28 },
  { 4014, 19, 30, 24, 2, -21 },
  { 4086, 19, 28, 24, 3, -28 },
  { 4153, 7, 28, 12, 2, -28 },
  { 4178, 11, 37, 11, -2, -28 },
  { 4229, 21, 28, 24, 3, -28 },
  { 4303, 6, 28, 11, 3, -28 },
  { 4324, 31, 21, 36, 3, -21 },
  { 4406, 19, 21, 24, 3, -21 },
  { 4456, 20, 21, 23, 2, -21 },
  { 4509, 19, 30, 24, 3, -21 },
  { 4581, 19, 30, 24, 2, -21 },
  { 4653, 13, 21, 17, 3, -21 },
  { 4688, 15, 21, 19, 2, -21 },
  { 4728, 14, 25, 17, 1, -25 },
  { 4772, 19, 20, 24, 3, -20 },
  { 4820, 22, 20, 22, 0, -20 },
  { 4875, 32, 20, 33, 0, -20 },
  { 4955, 22, 20, 22, 0, -20 },
  { 5010, 22, 29, 22, 0, -20 },
  { 5090, 16, 20, 18, 1, -20 },
  { 5130, 13, 33, 15, 1, -27 },
  { 5184, 4, 36, 20, 8, -28 },
  { 5202, 13, 33, 15, 1, -27 },
  { 5256, 18, 6, 21, 2, -16 },
};

const GFXfont NotoSans_ExtraBold37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold37pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_EXTRABOLD37PT7B_H_
