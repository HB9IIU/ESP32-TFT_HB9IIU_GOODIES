#ifndef _NOTOSANS_EXTRABOLD24PT7B_H_
#define _NOTOSANS_EXTRABOLD24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x79, 0xCE, 0x73, 0x9C, 0x00, 0x3B, 0xFF, 0x70,
  0xF3, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0, 0x07, 0x38, 0x0E, 0x70,
  0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x0F, 0xFF, 0xDF, 0xFF, 0x87, 0x38, 0x0E,
  0x70, 0x1C, 0xE3, 0xFF, 0xF7, 0xFF, 0xE1, 0xCE, 0x03, 0x9C, 0x07, 0x38,
  0x0C, 0x60, 0x39, 0xC0, 0x06, 0x00, 0x70, 0x3F, 0xF7, 0xFE, 0xFF, 0xEF,
  0x62, 0xF6, 0x0F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xE0, 0x7F, 0x06, 0xFC,
  0x6F, 0xFF, 0xFF, 0xFE, 0x7F, 0x80, 0x60, 0x06, 0x00, 0x7C, 0x07, 0x07,
  0xF0, 0x70, 0x3B, 0xC3, 0x81, 0xCE, 0x38, 0x0E, 0x71, 0xC0, 0x73, 0x9C,
  0x03, 0x9C, 0xE2, 0x1D, 0xEE, 0xFC, 0xFE, 0xF7, 0xF3, 0xE7, 0x7B, 0x80,
  0x73, 0x9C, 0x03, 0x9C, 0xF0, 0x38, 0xE7, 0x81, 0xC7, 0x38, 0x1C, 0x1D,
  0xC0, 0xE0, 0xFE, 0x0E, 0x03, 0xE0, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0x01, 0xE3, 0xC0, 0x38, 0xF0, 0x0F, 0x78, 0x03, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x8F, 0x9F, 0xF3, 0xCF, 0xBF, 0xF3, 0xC7, 0xF8, 0xF0, 0xFE, 0x3E,
  0x3F, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x1F, 0xCF, 0xC0, 0xF7, 0x77, 0x77,
  0x1E, 0x78, 0xE3, 0xC7, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x0F, 0x1E,
  0x3C, 0x38, 0x70, 0xF0, 0xE1, 0xE1, 0xE0, 0xF1, 0xC7, 0x8E, 0x3C, 0xF1,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xCF, 0x38, 0xE7, 0x9C, 0xE0, 0x0E,
  0x01, 0xC0, 0x38, 0x77, 0x7F, 0xFF, 0xFF, 0xC7, 0xC1, 0xF8, 0x3B, 0x8F,
  0x78, 0x44, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x7B, 0xBD, 0xEE, 0x70,
  0xFF, 0xFF, 0xC0, 0x77, 0xFE, 0xE0, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07,
  0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x1E, 0x07,
  0x81, 0xC0, 0xF0, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xEF, 0x9E, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7,
  0x9E, 0x7F, 0xE3, 0xFC, 0x1F, 0x80, 0x07, 0x87, 0xC7, 0xEF, 0xFF, 0xFB,
  0xBC, 0x9E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x80, 0x3F, 0x87, 0xFE, 0xFF, 0xE7, 0x1F, 0x20, 0xF0, 0x1F, 0x01,
  0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xCF, 0xFE, 0x7F, 0xE6, 0x1E, 0x01, 0xE0,
  0x1E, 0x07, 0xC1, 0xF8, 0x1F, 0xC1, 0xFE, 0x01, 0xF0, 0x0F, 0x01, 0xF8,
  0x1F, 0xFF, 0xEF, 0xFC, 0xFF, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x0F,
  0xE0, 0x7F, 0x07, 0x78, 0x7B, 0xC3, 0x9E, 0x38, 0xF3, 0xC7, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0x80, 0x78, 0x07, 0x00, 0x7F, 0x87, 0xFC, 0xFF, 0xE2,
  0x3F, 0x01, 0xF0, 0x0F, 0x01, 0xFC, 0x1E, 0xFF, 0xEF, 0xFC, 0x7F, 0x80,
  0x0F, 0xE1, 0xFE, 0x3F, 0xE7, 0xC0, 0x70, 0x0F, 0x00, 0xF7, 0xCF, 0xFE,
  0xFF, 0xFF, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x9F, 0x7F, 0xE3, 0xFE,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x00, 0x3F, 0xC7, 0xFE, 0x7F, 0xEF, 0x0F, 0xF0, 0xE7,
  0x9E, 0x7F, 0xE3, 0xF8, 0x3F, 0x87, 0xFE, 0xF9, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xFF, 0xF7, 0xFE, 0x3F, 0xC0, 0x3F, 0x87, 0xFC, 0xFF, 0xEF, 0x1E,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xF7, 0xFF, 0x3E, 0xF0, 0x0F,
  0x01, 0xE0, 0x3E, 0x7F, 0xC7, 0xF8, 0x7E, 0x00, 0xF7, 0xFE, 0xE0, 0x00,
  0x00, 0x03, 0xBF, 0xF7, 0x00, 0xF7, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0xEF, 0x7B, 0x9C, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7E, 0x1F, 0x87, 0xC0,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF0, 0x07, 0x00, 0x10, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0E,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF0, 0x7F, 0x1F, 0xCF,
  0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x7F, 0x9F, 0xFD, 0xFF, 0xB0, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00,
  0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0x07, 0x83, 0xC0, 0x1C, 0x78, 0xFC, 0xE7, 0x3F, 0xEE, 0x73, 0xDE, 0x6E,
  0x71, 0xE6, 0xE7, 0x1C, 0x7E, 0x71, 0xC6, 0xE7, 0x1C, 0xEE, 0x71, 0xCE,
  0xE7, 0xFF, 0xC7, 0x3E, 0x78, 0x70, 0x00, 0x03, 0xC0, 0x10, 0x1F, 0xFE,
  0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xEE, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x3C, 0x78, 0x1E,
  0x3C, 0x0F, 0x1E, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0xF9,
  0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0x80, 0xFF, 0xC7, 0xFF, 0xBF, 0xFD,
  0xE1, 0xEF, 0x0F, 0xF8, 0x7B, 0xC7, 0xDF, 0xFC, 0xFF, 0xE7, 0xFF, 0xBC,
  0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x7F, 0xFF, 0xDF, 0xFC, 0xFF, 0xC0, 0x07,
  0xF8, 0x7F, 0xF3, 0xFF, 0x9F, 0x86, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x63,
  0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0xBC, 0x7E,
  0xF0, 0x7F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x1F, 0xF0, 0x7B, 0xCF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0xFF,
  0xF3, 0xF0, 0x47, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x7F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xE0, 0x7B, 0xC0, 0xF7, 0xC1, 0xEF, 0xC3, 0xCF, 0xFF, 0x8F,
  0xFF, 0x07, 0xFC, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3C, 0xFF, 0xFF, 0x7E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFF,
  0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0xFE, 0xFE, 0xFC,
  0xF0, 0x7F, 0xC3, 0xEF, 0x0F, 0x3C, 0x78, 0xF3, 0xE3, 0xDF, 0x0F, 0x78,
  0x3F, 0xC0, 0xFF, 0x83, 0xFF, 0x0F, 0xBC, 0x3C, 0xF8, 0xF1, 0xF3, 0xC3,
  0xCF, 0x0F, 0xBC, 0x1E, 0xF0, 0x7C, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFF, 0x07, 0xFE, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7, 0x7F, 0xB8,
  0xEF, 0xF7, 0x1D, 0xFE, 0xE7, 0xBF, 0xDE, 0xE7, 0xF9, 0xDC, 0xFF, 0x3F,
  0x9F, 0xE7, 0xE3, 0xFC, 0x7C, 0x7F, 0x8F, 0x8F, 0xF1, 0xE1, 0xE0, 0xFC,
  0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0F, 0xEF, 0x0F, 0xEF, 0x0F, 0xF7,
  0x8F, 0xF7, 0xCF, 0xF3, 0xCF, 0xF3, 0xEF, 0xF1, 0xEF, 0xF1, 0xFF, 0xF0,
  0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0x0F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0xC3, 0xE7, 0x80, 0xF3, 0xC0, 0x7B, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xEF, 0x01, 0xE7, 0xC1,
  0xF3, 0xF1, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x8F,
  0xFE, 0xFF, 0xEF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xEF,
  0xFC, 0xFF, 0x8F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00,
  0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xC3, 0xE7, 0x80, 0xF3, 0xC0,
  0x7B, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xEF,
  0x01, 0xE7, 0xC1, 0xF3, 0xF1, 0xF8, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0xFF, 0x83, 0xFF,
  0x8F, 0xFF, 0x3C, 0x7C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3F, 0xF8, 0xFF,
  0xE3, 0xFE, 0x0F, 0xFC, 0x3C, 0xF8, 0xF1, 0xE3, 0xC7, 0xCF, 0x0F, 0x3C,
  0x1E, 0xF0, 0x7C, 0x1F, 0xF7, 0xFE, 0x7F, 0xEF, 0x86, 0xF0, 0x0F, 0x80,
  0x7E, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xE0, 0x1F, 0x80, 0xFE, 0x1E,
  0xFF, 0xEF, 0xFC, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xF1, 0xF7, 0xFF, 0x8F, 0xFC, 0x1F,
  0xE0, 0xF8, 0x0F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x78, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0xF0,
  0x3C, 0x0F, 0x78, 0x3C, 0x1E, 0x78, 0x7E, 0x1E, 0x78, 0x7E, 0x1E, 0x78,
  0x7E, 0x1E, 0x38, 0x7E, 0x1C, 0x3C, 0xFF, 0x3C, 0x3C, 0xF7, 0x3C, 0x3C,
  0xE7, 0x3C, 0x1C, 0xE7, 0x38, 0x1E, 0xE7, 0x78, 0x1F, 0xE7, 0xF8, 0x1F,
  0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x3E, 0x0F, 0x0F, 0x8F, 0x83, 0xCF, 0x81, 0xF7,
  0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0x01, 0xE7, 0xC1, 0xF1, 0xE0, 0xF0, 0xF8, 0xF8, 0x3E,
  0xF8, 0x0F, 0x80, 0xF8, 0x1E, 0xF0, 0x7D, 0xF0, 0xF1, 0xE3, 0xC3, 0xE7,
  0x83, 0xDE, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFC, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x3F, 0xFF, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x3C, 0x0F,
  0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x38,
  0x0F, 0x03, 0xC0, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x38, 0x03, 0xE0, 0x1F, 0x01,
  0xDC, 0x0E, 0xE0, 0xE3, 0x87, 0x1C, 0x70, 0x73, 0x83, 0xB8, 0x0E, 0xFF,
  0xFF, 0xFC, 0xF8, 0x78, 0x78, 0x7F, 0xC3, 0xFE, 0x3F, 0xF0, 0x0F, 0x00,
  0xF3, 0xFF, 0x7F, 0xFF, 0x8F, 0xF0, 0xFF, 0x1F, 0xFF, 0xFF, 0xF7, 0x7E,
  0x70, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x7C, 0xFF, 0xEF,
  0xFF, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF9, 0xFF,
  0xFE, 0xFF, 0xEE, 0x7C, 0x1F, 0xE7, 0xFD, 0xFF, 0x7C, 0x2F, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x0D, 0xFF, 0x9F, 0xF1, 0xFC, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x9F, 0xBD, 0xFF, 0xEF, 0xFF, 0xF8,
  0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE3, 0xEF, 0xFF,
  0x7F, 0x79, 0xF3, 0xC0, 0x1F, 0xC1, 0xFF, 0x1F, 0x7D, 0xF1, 0xEF, 0x07,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x03, 0xC0, 0x9F, 0xFC, 0x7F, 0xE1,
  0xFE, 0x00, 0x0F, 0xC7, 0xF1, 0xFC, 0xF8, 0x3C, 0x1F, 0xEF, 0xFB, 0xFE,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x00, 0x3F, 0x7B, 0xFF, 0xDF, 0xFF, 0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC7, 0xDF, 0xFE, 0xFE, 0xF3, 0xE7, 0x80, 0x7C,
  0x03, 0xCF, 0x7E, 0x7F, 0xF3, 0xFF, 0x0F, 0xE0, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x7E, 0xFF, 0xEF, 0xFF, 0xF8, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78, 0x00,
  0x03, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xFF, 0xFF, 0xBF, 0x78, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x7F, 0xC7, 0xDE, 0x7C, 0xF7, 0xC7, 0xFC, 0x3F, 0xC1, 0xFF,
  0x0F, 0xF8, 0x7D, 0xE3, 0xCF, 0x9E, 0x3E, 0xF0, 0xF7, 0x87, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0x8F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0xF0, 0xF0, 0xEF, 0xEE, 0xFF, 0xFF, 0xFF, 0x8F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xF0, 0x1F, 0xC1, 0xFF, 0x1F, 0xFD, 0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7B, 0xC7, 0xDF, 0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0xE7,
  0xCF, 0xFE, 0xFF, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x9F, 0xFF, 0xEF, 0xFE, 0xF7, 0xCF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x00, 0x3F, 0x7B, 0xFF, 0xDF, 0xFF, 0xF1, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xC7, 0xDF, 0xFE, 0xFE, 0xF3,
  0xE7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0xE7,
  0xF7, 0xFF, 0xDF, 0x9F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x00, 0x3F, 0xDF, 0xFF, 0xBB, 0xC0, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F,
  0x03, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x18, 0x1C, 0x0E, 0x0F, 0xFF,
  0xFF, 0xFD, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xFC, 0xFE,
  0x3F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xFF, 0xF7, 0x7E, 0x70, 0xF0, 0x3D, 0xE1,
  0xF7, 0x87, 0x9E, 0x1E, 0x3C, 0xF0, 0xF3, 0xC1, 0xCF, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0xF0, 0xF8, 0x7B, 0xC7,
  0xC3, 0x9E, 0x3E, 0x3C, 0xF3, 0xB9, 0xE3, 0x9D, 0xCF, 0x1E, 0xEE, 0x70,
  0xF7, 0x77, 0x87, 0xB9, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3,
  0xF0, 0x1F, 0x1F, 0x80, 0xF0, 0x78, 0x00, 0xF8, 0x7D, 0xF1, 0xE3, 0xCF,
  0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0xFB,
  0xC3, 0xCF, 0x9F, 0x1E, 0xF8, 0x7C, 0xF0, 0x3D, 0xE1, 0xF7, 0x87, 0x9E,
  0x1E, 0x3C, 0xF0, 0xF3, 0xC1, 0xCF, 0x07, 0xB8, 0x1F, 0xE0, 0x3F, 0x80,
  0xFC, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x1F, 0xC0, 0x7F, 0x01,
  0xF8, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x87, 0xC1,
  0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x1F, 0x1F,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0xF8, 0xE0, 0xF8, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1F, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xF0, 0xF8, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3E,
  0x1F, 0x0F, 0x3F, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF8, 0xE0,
  0x10, 0x1F, 0xE3, 0xFF, 0xFC, 0xFF, 0x81, 0xC0,
};

const GFXglyph NotoSans_ExtraBold24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 5, 17, 7, 1, -17 },
  { 12, 10, 6, 12, 1, -17 },
  { 20, 15, 17, 16, 0, -17 },
  { 52, 12, 19, 14, 1, -18 },
  { 81, 21, 17, 22, 1, -17 },
  { 126, 18, 17, 19, 1, -17 },
  { 165, 4, 6, 7, 1, -17 },
  { 168, 7, 21, 8, 1, -17 },
  { 187, 6, 21, 8, 1, -17 },
  { 203, 11, 11, 13, 1, -18 },
  { 219, 12, 11, 14, 1, -14 },
  { 236, 5, 6, 7, 1, -3 },
  { 240, 6, 3, 8, 1, -8 },
  { 243, 5, 4, 7, 1, -4 },
  { 246, 10, 17, 10, 0, -17 },
  { 268, 12, 17, 14, 1, -17 },
  { 294, 9, 17, 14, 1, -17 },
  { 314, 12, 17, 14, 1, -17 },
  { 340, 12, 17, 14, 1, -17 },
  { 366, 13, 17, 14, 0, -17 },
  { 394, 12, 17, 14, 1, -17 },
  { 420, 12, 17, 14, 1, -17 },
  { 446, 12, 17, 14, 1, -17 },
  { 472, 12, 17, 14, 1, -17 },
  { 498, 12, 17, 14, 1, -17 },
  { 524, 5, 13, 7, 1, -13 },
  { 533, 5, 16, 7, 1, -13 },
  { 543, 12, 13, 14, 1, -15 },
  { 563, 12, 7, 14, 1, -12 },
  { 574, 12, 13, 14, 1, -15 },
  { 594, 11, 17, 12, 0, -17 },
  { 618, 20, 19, 22, 1, -17 },
  { 666, 17, 17, 17, 0, -17 },
  { 703, 13, 17, 16, 2, -17 },
  { 731, 14, 17, 15, 1, -17 },
  { 761, 14, 17, 18, 2, -17 },
  { 791, 10, 17, 13, 2, -17 },
  { 813, 10, 17, 13, 2, -17 },
  { 835, 15, 17, 18, 1, -17 },
  { 867, 14, 17, 18, 2, -17 },
  { 897, 8, 17, 10, 1, -17 },
  { 914, 8, 22, 8, -2, -17 },
  { 936, 14, 17, 16, 2, -17 },
  { 966, 11, 17, 14, 2, -17 },
  { 990, 19, 17, 23, 2, -17 },
  { 1031, 16, 17, 20, 2, -17 },
  { 1065, 17, 17, 19, 1, -17 },
  { 1102, 12, 17, 15, 2, -17 },
  { 1128, 17, 21, 19, 1, -17 },
  { 1173, 14, 17, 16, 2, -17 },
  { 1203, 12, 17, 14, 1, -17 },
  { 1229, 12, 17, 14, 1, -17 },
  { 1255, 14, 17, 18, 2, -17 },
  { 1285, 16, 17, 16, 0, -17 },
  { 1319, 24, 17, 24, 0, -17 },
  { 1370, 17, 17, 17, 0, -17 },
  { 1407, 15, 17, 15, 0, -17 },
  { 1439, 13, 17, 14, 1, -17 },
  { 1467, 5, 21, 8, 2, -17 },
  { 1481, 10, 17, 10, 0, -17 },
  { 1503, 5, 21, 8, 1, -17 },
  { 1517, 13, 11, 13, 0, -17 },
  { 1535, 11, 2, 11, 0, 2 },
  { 1538, 7, 3, 9, 1, -18 },
  { 1541, 12, 13, 15, 1, -13 },
  { 1561, 12, 18, 15, 2, -18 },
  { 1588, 11, 13, 13, 1, -13 },
  { 1606, 13, 18, 15, 1, -18 },
  { 1636, 13, 13, 15, 1, -13 },
  { 1658, 10, 18, 10, 0, -18 },
  { 1681, 13, 19, 15, 1, -13 },
  { 1712, 12, 18, 16, 2, -18 },
  { 1739, 4, 18, 7, 2, -18 },
  { 1748, 7, 24, 7, -1, -18 },
  { 1769, 13, 18, 15, 2, -18 },
  { 1799, 4, 18, 7, 2, -18 },
  { 1808, 20, 13, 24, 2, -13 },
  { 1841, 12, 13, 16, 2, -13 },
  { 1861, 13, 13, 15, 1, -13 },
  { 1883, 12, 19, 15, 2, -13 },
  { 1912, 13, 19, 15, 1, -13 },
  { 1943, 9, 13, 11, 2, -13 },
  { 1958, 10, 13, 12, 1, -13 },
  { 1975, 9, 16, 11, 1, -16 },
  { 1993, 12, 13, 16, 2, -13 },
  { 2013, 14, 13, 14, 0, -13 },
  { 2036, 21, 13, 21, 0, -13 },
  { 2071, 14, 13, 14, 0, -13 },
  { 2094, 14, 19, 14, 0, -13 },
  { 2128, 10, 13, 12, 1, -13 },
  { 2145, 8, 21, 10, 1, -17 },
  { 2166, 3, 23, 13, 5, -18 },
  { 2175, 8, 21, 10, 1, -17 },
  { 2196, 12, 5, 14, 1, -11 },
};

const GFXfont NotoSans_ExtraBold24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold24pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_EXTRABOLD24PT7B_H_
