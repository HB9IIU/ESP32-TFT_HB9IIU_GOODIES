#ifndef _NOTOSANS_EXTRABOLD13PT7B_H_
#define _NOTOSANS_EXTRABOLD13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xC0, 0xDE, 0xF4, 0x1A, 0x16, 0x7F, 0x7F, 0x34, 0xFF,
  0x2C, 0x2C, 0x6C, 0x10, 0x7D, 0xFE, 0x87, 0x07, 0x87, 0xCB, 0x7E, 0x70,
  0x40, 0x71, 0x8D, 0x90, 0xDB, 0x0D, 0xAC, 0x77, 0xE0, 0xDB, 0x0D, 0xB1,
  0x9A, 0x18, 0xE0, 0x3C, 0x19, 0x87, 0x60, 0xF0, 0x79, 0xDB, 0x6E, 0x79,
  0xFE, 0x3D, 0xC0, 0xFC, 0x36, 0x66, 0x4C, 0x46, 0x66, 0x30, 0xE6, 0x33,
  0x33, 0x33, 0x36, 0xE0, 0x10, 0x23, 0xFB, 0xE2, 0x8D, 0x80, 0x30, 0xC3,
  0x3F, 0x30, 0xC3, 0x00, 0x6D, 0x60, 0xF0, 0xF0, 0x1C, 0x63, 0x0C, 0x31,
  0x86, 0x18, 0xC0, 0x7C, 0xDD, 0x9F, 0x3E, 0x6C, 0xD9, 0xBF, 0x3C, 0x3B,
  0xFF, 0x73, 0x9C, 0xE7, 0x38, 0x7D, 0xDC, 0x18, 0x71, 0xC7, 0x1C, 0x7F,
  0xFE, 0xFC, 0xDC, 0x19, 0xE3, 0xC1, 0xC1, 0xFF, 0xFC, 0x0C, 0x38, 0xF1,
  0x66, 0xDF, 0xFF, 0x86, 0x0C, 0xFB, 0xEC, 0x3E, 0xFC, 0x30, 0xFF, 0xF8,
  0x3C, 0xE1, 0x83, 0xEF, 0xFC, 0xD9, 0xBF, 0x3C, 0xFF, 0xFC, 0x30, 0x61,
  0xC3, 0x06, 0x18, 0x70, 0x7C, 0xCD, 0x9B, 0xE3, 0xCD, 0xF1, 0xB7, 0x7C,
  0x7C, 0xDF, 0x9F, 0x37, 0xE6, 0xC1, 0xBE, 0x78, 0xF0, 0x3C, 0x6C, 0x00,
  0xDA, 0xC0, 0x04, 0x77, 0x30, 0x70, 0x70, 0x40, 0xFF, 0xF0, 0x3F, 0xFC,
  0x83, 0x83, 0x83, 0x7B, 0x08, 0x00, 0xFD, 0x30, 0xC7, 0x30, 0xC0, 0x0C,
  0x30, 0x3F, 0x18, 0x6D, 0xEE, 0xC9, 0xB2, 0x6C, 0xBB, 0xFB, 0x24, 0x63,
  0x0F, 0xC0, 0x1C, 0x0F, 0x0D, 0x86, 0xC3, 0x73, 0xF9, 0xFC, 0xC7, 0xE1,
  0x80, 0xFD, 0x9F, 0x1F, 0xEF, 0xD8, 0xF1, 0xFF, 0xFC, 0x7F, 0xEB, 0x06,
  0x0C, 0x18, 0x38, 0x7F, 0x3E, 0xFC, 0xFE, 0xC7, 0xC7, 0xC3, 0xC7, 0xC6,
  0xFE, 0xF8, 0xFF, 0xFC, 0x3E, 0xFB, 0x0C, 0x3F, 0xFC, 0xFF, 0xF1, 0x8F,
  0xE3, 0x18, 0xC0, 0x7E, 0xF6, 0xC0, 0xC0, 0xCF, 0xC7, 0xE7, 0x7F, 0x3F,
  0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xF9, 0x8C, 0x63,
  0x18, 0xCE, 0xF8, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC7, 0xCC, 0xDC,
  0xD8, 0xF8, 0xFC, 0xCC, 0xCE, 0xC7, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F,
  0xFC, 0xE1, 0xFC, 0x7F, 0x3F, 0xCF, 0xDB, 0xF6, 0xBD, 0xEF, 0x3B, 0xCC,
  0xC0, 0xE1, 0xF8, 0xFC, 0x7B, 0x3D, 0xDE, 0x6F, 0x3F, 0x8F, 0xC7, 0x80,
  0x7E, 0x73, 0xB0, 0xD8, 0x7C, 0x3E, 0x1F, 0x8C, 0xFE, 0x3E, 0x00, 0xFD,
  0xFB, 0x3E, 0x7F, 0xDF, 0x30, 0x60, 0xC0, 0x7E, 0x73, 0xB0, 0xD8, 0x7C,
  0x3E, 0x1F, 0x8C, 0xFE, 0x3E, 0x03, 0x01, 0xE0, 0xFC, 0xCE, 0xCE, 0xCC,
  0xFC, 0xF8, 0xCC, 0xCE, 0xC7, 0xFF, 0x2C, 0x3C, 0x78, 0x70, 0xFF, 0xF8,
  0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC7, 0xFE, 0x7C, 0xE3, 0xB1, 0x98, 0xCC, 0xC3, 0x61, 0xB0,
  0xF0, 0x38, 0x1C, 0x00, 0xC7, 0x1B, 0x39, 0x99, 0x4C, 0xCA, 0x66, 0xDB,
  0x1E, 0xF0, 0xF7, 0x87, 0x1C, 0x38, 0xE0, 0xE3, 0xBB, 0x8D, 0x83, 0x81,
  0xC1, 0xF0, 0xD8, 0xCE, 0xE3, 0x80, 0xE3, 0x66, 0x76, 0x3C, 0x1C, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0xFC, 0x30, 0xE1, 0x86, 0x1C, 0x7F, 0xFE, 0xFB,
  0x6D, 0xB6, 0xDB, 0x80, 0xC3, 0x18, 0xC3, 0x18, 0x63, 0x18, 0xE4, 0x92,
  0x49, 0x27, 0x80, 0x10, 0x70, 0xA3, 0x64, 0x58, 0xC0, 0xFC, 0xC7, 0x7C,
  0x4C, 0x1B, 0xFE, 0x6D, 0xDF, 0x80, 0xC1, 0x83, 0x07, 0xEE, 0xD9, 0xF3,
  0xE7, 0xFD, 0xF8, 0x7F, 0xAC, 0x30, 0xC3, 0xE7, 0x80, 0x0C, 0x30, 0xFF,
  0xFF, 0x3C, 0xF3, 0xFD, 0xF0, 0x7B, 0x3C, 0xFF, 0xC3, 0xB7, 0xC0, 0x3D,
  0xE6, 0x3E, 0xF9, 0x86, 0x18, 0x61, 0x80, 0xFF, 0xFC, 0xF3, 0xCF, 0xF7,
  0xC3, 0xFF, 0xE0, 0xC1, 0x83, 0x07, 0xEE, 0xF9, 0xF3, 0xE7, 0xCF, 0x9C,
  0xF3, 0xFF, 0xF0, 0x33, 0x03, 0x33, 0x33, 0x33, 0x3F, 0xE0, 0xC1, 0x83,
  0x06, 0x7D, 0xDF, 0x3E, 0x7E, 0xCD, 0x9C, 0xFF, 0xFF, 0xF0, 0xFD, 0xDD,
  0xDF, 0x39, 0xE7, 0x3C, 0xE7, 0x9C, 0xF3, 0x98, 0xFD, 0xDF, 0x3E, 0x7C,
  0xF9, 0xF3, 0x80, 0x79, 0xDB, 0x3E, 0x7C, 0xFF, 0x9E, 0x00, 0xFD, 0xDB,
  0x3E, 0x7C, 0xFF, 0xBF, 0x60, 0xC1, 0x80, 0xFF, 0xFC, 0xF3, 0xCF, 0xF7,
  0xC3, 0x0C, 0x30, 0xFF, 0xF1, 0x8C, 0x63, 0x00, 0xFE, 0x79, 0xF1, 0xFF,
  0xC0, 0x21, 0x3F, 0xF6, 0x31, 0x8F, 0x38, 0xCF, 0x9F, 0x3E, 0x7C, 0xFF,
  0xDD, 0x80, 0xC7, 0x66, 0x66, 0x6C, 0x3C, 0x3C, 0x18, 0xCE, 0x6D, 0xCD,
  0xAD, 0xB5, 0xE7, 0xBC, 0x73, 0x8E, 0x60, 0xE7, 0x7E, 0x3C, 0x38, 0x3C,
  0x6E, 0xE7, 0xE7, 0x66, 0x66, 0x6C, 0x3C, 0x3C, 0x18, 0x18, 0x70, 0x70,
  0x7D, 0xF1, 0x8C, 0x71, 0xFF, 0xC0, 0x39, 0x8C, 0x67, 0x71, 0xC6, 0x31,
  0xCE, 0xFF, 0xF8, 0xE3, 0x08, 0x43, 0x8C, 0xC4, 0x23, 0x38, 0xE7, 0xF8,
  0x80,
};

const GFXglyph NotoSans_ExtraBold13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 4, 1, -9 },
  { 4, 5, 3, 7, 1, -9 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 7, 11, 7, 0, -10 },
  { 25, 12, 9, 12, 0, -9 },
  { 39, 10, 9, 10, 0, -9 },
  { 51, 2, 3, 4, 1, -9 },
  { 52, 4, 11, 5, 0, -9 },
  { 58, 4, 11, 5, 0, -9 },
  { 64, 7, 6, 7, 0, -10 },
  { 70, 6, 7, 8, 1, -8 },
  { 76, 3, 4, 4, 0, -2 },
  { 78, 4, 1, 4, 0, -4 },
  { 79, 2, 2, 4, 1, -2 },
  { 80, 6, 9, 6, 0, -9 },
  { 87, 7, 9, 8, 0, -9 },
  { 95, 5, 9, 8, 1, -9 },
  { 101, 7, 9, 8, 0, -9 },
  { 109, 7, 9, 8, 0, -9 },
  { 117, 7, 9, 8, 0, -9 },
  { 125, 6, 9, 8, 1, -9 },
  { 132, 7, 9, 8, 0, -9 },
  { 140, 7, 9, 8, 0, -9 },
  { 148, 7, 9, 8, 0, -9 },
  { 156, 7, 9, 8, 0, -9 },
  { 164, 2, 7, 4, 1, -7 },
  { 166, 3, 9, 4, 0, -7 },
  { 170, 6, 7, 8, 1, -8 },
  { 176, 6, 5, 8, 1, -7 },
  { 180, 6, 7, 8, 1, -8 },
  { 186, 6, 9, 6, 0, -9 },
  { 193, 10, 10, 12, 1, -9 },
  { 206, 9, 9, 9, 0, -9 },
  { 217, 7, 9, 9, 1, -9 },
  { 225, 7, 9, 8, 1, -9 },
  { 233, 8, 9, 10, 1, -9 },
  { 242, 6, 9, 7, 1, -9 },
  { 249, 5, 9, 7, 1, -9 },
  { 255, 8, 9, 10, 1, -9 },
  { 264, 8, 9, 10, 1, -9 },
  { 273, 5, 9, 5, 0, -9 },
  { 279, 4, 12, 4, -1, -9 },
  { 285, 8, 9, 9, 1, -9 },
  { 294, 6, 9, 7, 1, -9 },
  { 301, 10, 9, 12, 1, -9 },
  { 313, 9, 9, 11, 1, -9 },
  { 324, 9, 9, 10, 1, -9 },
  { 335, 7, 9, 8, 1, -9 },
  { 343, 9, 11, 10, 1, -9 },
  { 356, 8, 9, 9, 1, -9 },
  { 365, 6, 9, 7, 1, -9 },
  { 372, 7, 9, 8, 0, -9 },
  { 380, 8, 9, 10, 1, -9 },
  { 389, 9, 9, 9, 0, -9 },
  { 400, 13, 9, 13, 0, -9 },
  { 415, 9, 9, 9, 0, -9 },
  { 426, 8, 9, 8, 0, -9 },
  { 435, 7, 9, 8, 0, -9 },
  { 443, 3, 11, 4, 1, -9 },
  { 448, 5, 9, 6, 0, -9 },
  { 454, 3, 11, 4, 0, -9 },
  { 459, 7, 6, 7, 0, -9 },
  { 465, 6, 1, 6, 0, 1 },
  { 466, 4, 2, 5, 1, -10 },
  { 467, 7, 7, 8, 0, -7 },
  { 474, 7, 10, 8, 1, -10 },
  { 483, 6, 7, 7, 1, -7 },
  { 489, 6, 10, 8, 1, -10 },
  { 497, 6, 7, 8, 1, -7 },
  { 503, 6, 10, 5, 0, -10 },
  { 511, 6, 10, 8, 1, -7 },
  { 519, 7, 10, 9, 1, -10 },
  { 528, 2, 10, 4, 1, -10 },
  { 531, 4, 13, 4, -1, -10 },
  { 538, 7, 10, 8, 1, -10 },
  { 547, 2, 10, 4, 1, -10 },
  { 550, 11, 7, 13, 1, -7 },
  { 560, 7, 7, 9, 1, -7 },
  { 567, 7, 7, 8, 1, -7 },
  { 574, 7, 10, 8, 1, -7 },
  { 583, 6, 10, 8, 1, -7 },
  { 591, 5, 7, 6, 1, -7 },
  { 596, 5, 7, 7, 1, -7 },
  { 601, 5, 9, 6, 0, -9 },
  { 607, 7, 7, 9, 1, -7 },
  { 614, 8, 7, 8, 0, -7 },
  { 621, 11, 7, 11, 0, -7 },
  { 631, 8, 7, 8, 0, -7 },
  { 638, 8, 10, 8, 0, -7 },
  { 648, 6, 7, 6, 0, -7 },
  { 654, 5, 11, 5, 0, -9 },
  { 661, 1, 13, 7, 3, -10 },
  { 663, 5, 11, 5, 0, -9 },
  { 670, 6, 3, 8, 1, -6 },
};

const GFXfont NotoSans_ExtraBold13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold13pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_EXTRABOLD13PT7B_H_
