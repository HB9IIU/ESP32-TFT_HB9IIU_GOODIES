#ifndef _NOTOSANS_EXTRABOLD55PT7B_H_
#define _NOTOSANS_EXTRABOLD55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xBF, 0xEF, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE1, 0xFE, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xF0, 0x30, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE, 0xFF,
  0x0F, 0xF7, 0xF8, 0x7F, 0xBF, 0xC3, 0xFD, 0xFC, 0x1F, 0xEF, 0xE0, 0xFF,
  0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0,
  0x7F, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFE, 0xF3, 0xF8, 0xFF, 0x8F, 0x03, 0x8F,
  0xF0, 0xF0, 0x00, 0xFF, 0x0F, 0x00, 0x0F, 0xF8, 0xF0, 0x00, 0xFF, 0xCF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xF7, 0xFF, 0x00, 0x0F, 0x1F, 0xF0, 0x00, 0xF1, 0xFF, 0x80,
  0x0F, 0x1F, 0xFF, 0x00, 0xF1, 0xFF, 0xFE, 0x0F, 0x3F, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x0F,
  0xF0, 0x1F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F,
  0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F,
  0xE3, 0xF8, 0x7F, 0xF0, 0x7F, 0x9F, 0xE3, 0xF8, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC7, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xF3, 0xFF, 0xFE, 0x1F, 0xFF,
  0x8F, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0x1F, 0xE3, 0xF8, 0xFF, 0x07, 0xFE,
  0x1F, 0xC7, 0xF8, 0x7F, 0x01, 0xF8, 0x3F, 0xC7, 0xF8, 0x7F, 0x00, 0x00,
  0x3F, 0x87, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x03,
  0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x7F, 0x00, 0x07,
  0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0x0F,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F,
  0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xF0, 0x7F, 0xF7, 0xFF, 0x9F, 0xF8,
  0x3F, 0xF1, 0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFD, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x7F, 0xF8,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF,
  0xE7, 0xF3, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x03, 0x00, 0xFC, 0x02, 0x7C, 0x1F, 0x87, 0xEF, 0xFB, 0xF7, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xFE, 0x00, 0x7F, 0x9F, 0xE0,
  0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0x07, 0xF0, 0x01, 0xE0,
  0x78, 0x00, 0x0C, 0x0C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3E,
  0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x03, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC7, 0xFE, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xE7, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x3F, 0xEF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F,
  0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x7F, 0xE3, 0xFE, 0x07, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE,
  0xFF, 0x9F, 0xF3, 0xF8, 0xFF, 0x9F, 0x8F, 0xFC, 0x70, 0x7F, 0xE1, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0xE1, 0xF8, 0x07,
  0xFE, 0x1E, 0x00, 0x7F, 0xE0, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x1F, 0x00, 0xFF, 0xC0, 0xC0, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xEC, 0x00,
  0x0F, 0xFE, 0xF8, 0x01, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFB, 0xFE, 0x00, 0x1F, 0xCF, 0xF8, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xF8,
  0xFF, 0x80, 0x1F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x07, 0xF8, 0x3F,
  0xE0, 0x1F, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF8,
  0x1F, 0xC0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x87, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x83, 0xF0, 0x07, 0xF8, 0xFF, 0xE0, 0xFF, 0xBF, 0xFF, 0x0F, 0xFB,
  0xFF, 0xF8, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xDF, 0xFE, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7,
  0xFE, 0x03, 0xFE, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x7F, 0xC0, 0x7F, 0xE7,
  0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0,
  0x7F, 0xC3, 0xFE, 0x07, 0xFC, 0x3F, 0xF9, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xBF, 0xFC, 0x7F, 0xF0, 0xFF, 0xC7, 0xFC, 0x07, 0xFE, 0xFF,
  0x80, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0xFF, 0xCF,
  0xFC, 0x07, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80,
  0x3F, 0xEF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFD, 0xFE, 0x0F, 0xFF, 0x9F, 0xE0, 0x7F, 0xF1, 0xFE, 0x00,
  0x78, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0C, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0x8F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE1, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xF0, 0x30, 0x06, 0x07, 0xF9, 0xFF,
  0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x3F, 0xC3, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE3, 0xFC,
  0xFF, 0x9F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0x00, 0xFF, 0xC6, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x78, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0xFE, 0x1F, 0xC1,
  0xFC, 0x0F, 0xFF, 0xFC, 0x7F, 0x1F, 0xE0, 0xFF, 0xFF, 0xE3, 0xF8, 0xFE,
  0x0F, 0xFF, 0xFF, 0x0F, 0xC7, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0x7F, 0x07,
  0xF8, 0x1F, 0xC3, 0xFB, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xDF, 0xC3, 0xF8,
  0x07, 0xE0, 0xFE, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF7, 0xE1, 0xFC, 0x01,
  0xF8, 0x3F, 0xFF, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0xF8, 0x7F, 0x00, 0xFE,
  0x0F, 0xFF, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0xFE, 0x1F, 0xC0, 0x3F, 0x83,
  0xF7, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0x9F, 0x87, 0xF8, 0x1F, 0xE1, 0xFC,
  0xFC, 0x1F, 0xC0, 0xFF, 0x0F, 0xC7, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0x83, 0xFF, 0xFF, 0xFF, 0xE1, 0xFC, 0x1F, 0xFF, 0xDF, 0xFF, 0x07, 0xF0,
  0x7F, 0xFC, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xC1, 0xFE, 0x01, 0xFE, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x00, 0xFF,
  0xDF, 0xFC, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xF0, 0x1F, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xFB,
  0xFF, 0x00, 0x7F, 0xCF, 0xFC, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFC, 0x07,
  0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x01,
  0xF8, 0x7F, 0xF8, 0x00, 0x60, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0x1F, 0xFE, 0x00, 0x1C, 0x1F, 0xFF, 0x81, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0x68, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0x83,
  0xFF, 0xFC, 0xFF, 0xC0, 0x1F, 0xFE, 0x7F, 0xE0, 0x07, 0xFF, 0xBF, 0xF0,
  0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x7C, 0x1F, 0xFF, 0x00, 0x06, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x1F, 0xF7, 0xFE,
  0x00, 0x0F, 0xFB, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0xE0, 0x03, 0xFE, 0x7F,
  0xF8, 0x01, 0xFF, 0x1F, 0xFF, 0x81, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3,
  0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x1F,
  0xF8, 0xFF, 0x80, 0x3F, 0xF8, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0x83, 0xFF,
  0x80, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x8F, 0xFE,
  0x00, 0xFF, 0x8F, 0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xBF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF7, 0xFE, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x81, 0xFF,
  0x80, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x80, 0x7F,
  0xE0, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x3F,
  0xF8, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0x80, 0x0F,
  0xFE, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xDF, 0xC0, 0x03, 0xFB, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF7, 0xF0, 0x03, 0xFB, 0xFF, 0xFE, 0xFE, 0x00,
  0x7F, 0x7F, 0xFF, 0xDF, 0xE0, 0x0F, 0xEF, 0xFF, 0xFB, 0xFC, 0x03, 0xF9,
  0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0x3F, 0xFF, 0xE7, 0xF8, 0x0F, 0xE7, 0xFF,
  0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0x8F, 0xE0, 0x7F, 0x1F, 0xFF, 0xF1,
  0xFE, 0x0F, 0xE3, 0xFF, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0xFF, 0xC3, 0xF8,
  0x7F, 0x0F, 0xFF, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0x0F, 0xF1, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFE, 0x7F, 0x07, 0xFF, 0xFC, 0x1F, 0xCF, 0xE0, 0xFF,
  0xFF, 0x83, 0xFD, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x7F, 0xE0, 0x1F, 0xFF, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0x3F, 0xF0, 0x1F,
  0xFF, 0xF1, 0xFF, 0x01, 0xFF, 0xFF, 0x1F, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xE1, 0xFF, 0xFF,
  0x07, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0x1F,
  0xFF, 0xF0, 0x1F, 0xF9, 0xFF, 0xFF, 0x00, 0xFF, 0x9F, 0xFF, 0xF0, 0x0F,
  0xFD, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF,
  0xC3, 0xFF, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0,
  0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x01, 0xFF,
  0xBF, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFB,
  0xFF, 0x00, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xC3,
  0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xCF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xC3, 0xFF, 0x00, 0x07,
  0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x3F, 0xF9, 0xFF,
  0x80, 0x00, 0x7F, 0xEF, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFE, 0x7F, 0xE0,
  0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xCF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xE0, 0xFF,
  0xC0, 0x3F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x07, 0xFE, 0x1F,
  0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x7F, 0xE1, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0,
  0x03, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0,
  0x1F, 0x8F, 0xFC, 0x00, 0x61, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x3F,
  0xF7, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x1F,
  0xFC, 0x7F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0x40, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x07,
  0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x03, 0xFC,
  0xFF, 0x80, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF3,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x1F, 0xE0,
  0x07, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0x7F, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0xFE, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFD,
  0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xF8, 0x07, 0xFC,
  0x0F, 0xF7, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE7, 0xF0, 0x3F, 0xC0,
  0x0F, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x1F, 0xE1,
  0xFF, 0x00, 0x3F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC3, 0xFC,
  0x7F, 0x87, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x7F, 0x0F, 0xF0, 0x00, 0xFF,
  0x8F, 0xE0, 0xFE, 0x3F, 0xE0, 0x01, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0xC0,
  0x01, 0xFE, 0x7F, 0x83, 0xFC, 0xFF, 0x00, 0x03, 0xFC, 0xFE, 0x03, 0xF9,
  0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x07, 0xF3, 0xFC, 0x00, 0x0F, 0xFB, 0xF8,
  0x0F, 0xEF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF,
  0x87, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0,
  0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F,
  0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0xC0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F, 0xF9, 0xFF,
  0xC0, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8,
  0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x0F, 0xF8,
  0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x03,
  0xFF, 0x3F, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF8,
  0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7E, 0x07, 0xFE, 0x03, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xE1, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE1, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0x3F, 0xFF, 0xCF, 0xF1, 0xFF, 0xF8, 0x7F, 0x07, 0xFE, 0x07, 0xF0,
  0x04, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x03, 0xE0, 0x0F, 0xF8,
  0xFF, 0xC0, 0x7F, 0xCF, 0xFF, 0x83, 0xFE, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xC0, 0xFF, 0xEF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFE,
  0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x07, 0xFE, 0xFF,
  0xC0, 0x3F, 0xF7, 0xFF, 0x03, 0xFF, 0xBF, 0xFC, 0x3F, 0xF9, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x1F, 0xE7, 0xFF, 0xF0, 0xFF, 0x1F, 0xFF, 0x07, 0xF0, 0x7F, 0xE0, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x0E, 0x1F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x18, 0xFF, 0xE0, 0x3E, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x14, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0xFF, 0x83, 0xFF,
  0xE7, 0xFC, 0x3F, 0xFF, 0xBF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x7F, 0xF7,
  0xFF, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFD, 0xFF, 0x00, 0x3F, 0xEF, 0xF8,
  0x01, 0xFF, 0x7F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFD,
  0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF, 0x7F, 0xE0, 0x0F, 0xFB, 0xFF,
  0x80, 0xFF, 0xDF, 0xFE, 0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF,
  0x07, 0xFF, 0xC7, 0xF8, 0x0F, 0xF8, 0x1F, 0xC0, 0x04, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x87, 0xFE, 0x07, 0xFE, 0x3F, 0xE0, 0x1F, 0xF3, 0xFF, 0x00, 0x7F, 0x9F,
  0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x0C, 0x3F, 0xFE, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0x04, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xFC, 0x3F, 0xC1, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0xCF, 0xF1, 0xFF,
  0xFF, 0x7F, 0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFE,
  0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0x3F, 0xDF, 0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0xFF,
  0xBF, 0xF0, 0x07, 0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xFE, 0x07, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFE, 0xFF, 0x83, 0xFF, 0xE7, 0xFC, 0x07, 0xFC, 0x3F,
  0xE0, 0x06, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x60, 0x00, 0x7F, 0xF3, 0xF0, 0x0F, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x01, 0xF0, 0x0F, 0xF8, 0xFF, 0xE0, 0x7F,
  0xCF, 0xFF, 0xC3, 0xFE, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0x7F,
  0xEF, 0xFE, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0x3F, 0xEF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF,
  0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB,
  0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF,
  0xBF, 0xE0, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFD, 0x0F, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0x3F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F,
  0xF0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x0F, 0xFE,
  0x07, 0xFC, 0x3F, 0xF8, 0x0F, 0xF8, 0xFF, 0xE0, 0x1F, 0xF1, 0xFF, 0x80,
  0x3F, 0xE7, 0xFE, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xF3, 0xFF, 0x80, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE,
  0x07, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0,
  0x0F, 0xFE, 0x3F, 0xE0, 0x0F, 0xFE, 0x7F, 0xC0, 0x0F, 0xFC, 0xFF, 0x80,
  0x1F, 0xFD, 0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x01,
  0xFC, 0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x87,
  0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFD, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xF8,
  0x07, 0xF0, 0x7F, 0xF8, 0x3F, 0x87, 0xFF, 0xE1, 0xFE, 0x7F, 0xFF, 0x8F,
  0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xF0, 0x3F, 0xF7, 0xFF, 0x01, 0xFF, 0xBF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF9,
  0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0x7F,
  0xC0, 0x0F, 0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFD, 0xFF, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x7F, 0xDF, 0xF0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F,
  0xE3, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xF8, 0x7F, 0xF0, 0x3F, 0xC7, 0xFF,
  0xC1, 0xFE, 0x7F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x7F, 0xF7, 0xFE,
  0x01, 0xFF, 0xBF, 0xF0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x01,
  0xFF, 0x7F, 0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFD, 0xFF,
  0x00, 0x3F, 0xEF, 0xFC, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xFB, 0xFF, 0x81,
  0xFF, 0xDF, 0xFE, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFB, 0xFF, 0xF0, 0x7F,
  0xCF, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x1F, 0xF0, 0x18, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFC,
  0x3F, 0xC1, 0xFF, 0xF1, 0xFE, 0x1F, 0xFF, 0xCF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xF0, 0x3F, 0xFB, 0xFF, 0x00, 0xFF, 0xDF, 0xF8, 0x03, 0xFE, 0xFF, 0x80,
  0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xDF,
  0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xBF, 0xF0,
  0x07, 0xFD, 0xFF, 0x80, 0x7F, 0xEF, 0xFE, 0x07, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFE, 0xFF, 0x83, 0xFF, 0xE7, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x02,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0xC0, 0x78, 0xFF, 0x80, 0x08, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x87, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x00, 0xB0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x04,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x05, 0x00, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xF3, 0xFF, 0xFE, 0x7F,
  0x1F, 0xFF, 0xC7, 0xF0, 0x7F, 0xF0, 0x7F, 0x00, 0x20, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFE, 0x7F,
  0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xFC, 0x1F,
  0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x03,
  0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x01,
  0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFB, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xF3, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xE7, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xCF, 0xF8, 0x0F, 0xFF, 0x81, 0xFF, 0x1F, 0xF0,
  0x1F, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0xFE, 0x07, 0xFC, 0x3F, 0xE0,
  0xFE, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0xFD, 0xFC, 0x3F, 0xE0, 0x7F, 0x83,
  0xF3, 0xF8, 0x7F, 0xC0, 0xFF, 0x8F, 0xE7, 0xF0, 0xFF, 0x81, 0xFF, 0x1F,
  0xCF, 0xE1, 0xFE, 0x03, 0xFE, 0x3F, 0x8F, 0xE7, 0xFC, 0x03, 0xFC, 0x7E,
  0x1F, 0xCF, 0xF8, 0x07, 0xF9, 0xFC, 0x3F, 0x9F, 0xE0, 0x0F, 0xFB, 0xF8,
  0x7F, 0x3F, 0xC0, 0x0F, 0xF7, 0xF0, 0xFE, 0x7F, 0x80, 0x1F, 0xEF, 0xE0,
  0xFC, 0xFF, 0x00, 0x3F, 0xDF, 0x81, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0x7E, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x1F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF,
  0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFF, 0x87,
  0xFE, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x1F, 0xFC,
  0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFE,
  0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xE0, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFC,
  0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0,
  0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0,
  0x03, 0xFE, 0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0,
  0x01, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x21, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x10, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xF0,
  0x7F, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x27, 0xFF, 0xC0, 0x0D, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0xC0, 0x01, 0xFF, 0x90, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_ExtraBold55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 40, 16, 3, -39 },
  { 51, 21, 14, 28, 3, -39 },
  { 88, 34, 39, 36, 1, -39 },
  { 254, 28, 45, 32, 2, -42 },
  { 412, 48, 40, 51, 1, -40 },
  { 652, 41, 41, 43, 2, -40 },
  { 863, 9, 14, 15, 3, -39 },
  { 879, 16, 49, 19, 2, -40 },
  { 977, 15, 49, 19, 2, -40 },
  { 1069, 27, 26, 30, 1, -42 },
  { 1157, 27, 27, 32, 2, -33 },
  { 1249, 11, 14, 16, 2, -7 },
  { 1269, 15, 7, 18, 1, -18 },
  { 1283, 10, 10, 16, 3, -9 },
  { 1296, 23, 40, 23, 0, -40 },
  { 1411, 28, 41, 32, 2, -40 },
  { 1555, 21, 39, 32, 3, -39 },
  { 1658, 28, 40, 32, 2, -40 },
  { 1798, 28, 41, 32, 2, -40 },
  { 1942, 30, 39, 32, 1, -39 },
  { 2089, 26, 40, 32, 3, -39 },
  { 2219, 28, 41, 32, 2, -40 },
  { 2363, 28, 39, 32, 2, -39 },
  { 2500, 28, 41, 32, 2, -40 },
  { 2644, 28, 41, 32, 2, -40 },
  { 2788, 10, 32, 16, 3, -31 },
  { 2828, 11, 38, 16, 2, -31 },
  { 2881, 27, 30, 32, 2, -35 },
  { 2983, 27, 18, 32, 2, -28 },
  { 3044, 27, 30, 32, 2, -35 },
  { 3146, 26, 41, 27, 0, -40 },
  { 3280, 45, 44, 49, 2, -40 },
  { 3528, 39, 39, 39, 0, -39 },
  { 3719, 30, 39, 37, 4, -39 },
  { 3866, 31, 41, 35, 3, -40 },
  { 4025, 33, 39, 40, 4, -39 },
  { 4186, 23, 39, 31, 5, -39 },
  { 4299, 22, 39, 30, 5, -39 },
  { 4407, 33, 41, 40, 3, -40 },
  { 4577, 32, 39, 42, 5, -39 },
  { 4733, 19, 39, 23, 2, -39 },
  { 4826, 18, 51, 19, -4, -39 },
  { 4941, 32, 39, 37, 5, -39 },
  { 5097, 25, 39, 31, 4, -39 },
  { 5219, 43, 39, 52, 5, -39 },
  { 5429, 36, 39, 45, 5, -39 },
  { 5605, 38, 41, 44, 3, -40 },
  { 5800, 28, 39, 34, 4, -39 },
  { 5937, 38, 49, 44, 3, -40 },
  { 6170, 33, 39, 37, 4, -39 },
  { 6331, 27, 41, 31, 2, -40 },
  { 6470, 30, 39, 32, 1, -39 },
  { 6617, 33, 40, 42, 4, -39 },
  { 6782, 37, 39, 37, 0, -39 },
  { 6963, 55, 39, 55, 0, -39 },
  { 7232, 38, 39, 38, 0, -39 },
  { 7418, 35, 39, 35, 0, -39 },
  { 7589, 30, 39, 33, 1, -39 },
  { 7736, 13, 49, 18, 4, -40 },
  { 7816, 23, 40, 23, 0, -40 },
  { 7931, 14, 49, 18, 1, -40 },
  { 8017, 30, 25, 30, 0, -39 },
  { 8111, 25, 5, 25, 0, 4 },
  { 8127, 17, 9, 21, 2, -42 },
  { 8147, 28, 32, 34, 2, -31 },
  { 8259, 29, 43, 35, 4, -42 },
  { 8415, 26, 32, 29, 2, -31 },
  { 8519, 29, 43, 35, 2, -42 },
  { 8675, 29, 32, 33, 2, -31 },
  { 8791, 23, 42, 22, 1, -42 },
  { 8912, 29, 44, 35, 2, -31 },
  { 9072, 29, 42, 36, 4, -42 },
  { 9225, 10, 42, 17, 4, -42 },
  { 9278, 17, 55, 17, -3, -42 },
  { 9395, 31, 42, 35, 4, -42 },
  { 9558, 9, 42, 17, 4, -42 },
  { 9606, 47, 31, 54, 4, -31 },
  { 9789, 29, 31, 36, 4, -31 },
  { 9902, 30, 32, 35, 2, -31 },
  { 10022, 29, 44, 35, 4, -31 },
  { 10182, 29, 44, 35, 2, -31 },
  { 10342, 20, 31, 25, 4, -31 },
  { 10420, 24, 32, 28, 2, -31 },
  { 10516, 22, 37, 25, 1, -36 },
  { 10618, 28, 31, 36, 4, -30 },
  { 10727, 32, 30, 32, 0, -30 },
  { 10847, 47, 30, 48, 1, -30 },
  { 11024, 33, 30, 33, 0, -30 },
  { 11148, 32, 43, 32, 0, -30 },
  { 11320, 25, 30, 27, 1, -30 },
  { 11414, 20, 49, 23, 1, -40 },
  { 11537, 7, 54, 29, 11, -42 },
  { 11585, 19, 49, 23, 2, -40 },
  { 11702, 27, 10, 32, 2, -24 },
};

const GFXfont NotoSans_ExtraBold55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold55pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_EXTRABOLD55PT7B_H_
