#ifndef _NOTOSANS_EXTRABOLD16PT7B_H_
#define _NOTOSANS_EXTRABOLD16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xB0, 0x5F, 0x80, 0xCF, 0x3C, 0xF3, 0x0D, 0x86, 0x61,
  0xB1, 0xFF, 0x7F, 0xC4, 0xCF, 0xFF, 0xFF, 0x36, 0x0D, 0x83, 0x60, 0x10,
  0x7E, 0xFE, 0xD2, 0xD0, 0xF8, 0x7E, 0x1F, 0x17, 0xFE, 0xFE, 0x10, 0x10,
  0x30, 0x11, 0xE1, 0x86, 0xCC, 0x3B, 0x30, 0xED, 0x81, 0xB6, 0xE7, 0xB7,
  0xCC, 0xDB, 0x06, 0x6C, 0x19, 0xB0, 0xC7, 0xC7, 0x0E, 0x18, 0x0F, 0xC1,
  0x98, 0x33, 0x07, 0xE0, 0x78, 0x1F, 0x3F, 0xFE, 0xC7, 0xDC, 0x73, 0xFF,
  0x3F, 0xF0, 0xFF, 0x36, 0x6E, 0xCC, 0xCC, 0xCC, 0xCE, 0x66, 0x30, 0xE3,
  0x0C, 0x63, 0x9C, 0x63, 0x19, 0xCE, 0x63, 0x33, 0x80, 0x18, 0x18, 0x6B,
  0xFF, 0x1C, 0x3E, 0x76, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x76, 0x6E, 0xFF, 0xC0, 0x5F, 0x80, 0x0E, 0x18, 0x30, 0xE1, 0x83, 0x0E,
  0x18, 0x70, 0xC1, 0x87, 0x00, 0x18, 0x7C, 0xFE, 0xE6, 0xC7, 0xC7, 0xC7,
  0xC7, 0xC7, 0xEE, 0xFE, 0x7C, 0x3D, 0xFF, 0xD7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC0, 0x0C, 0x3F, 0xBF, 0xC4, 0x60, 0x30, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x1F, 0xEF, 0xF0, 0x38, 0xFE, 0xFE, 0x06, 0x0E, 0x7C, 0x7C, 0x0E,
  0x07, 0x8F, 0xFE, 0xFC, 0x07, 0x07, 0x87, 0xC7, 0xE3, 0x73, 0x3B, 0x9D,
  0xFF, 0xFF, 0x83, 0x81, 0xC0, 0xFE, 0xFE, 0xE0, 0xE0, 0xFC, 0xFE, 0x06,
  0x07, 0x8E, 0xFE, 0xFC, 0x0E, 0x3E, 0x7E, 0xE0, 0xC8, 0xFE, 0xFE, 0xC7,
  0xC7, 0xE7, 0xFE, 0x7C, 0xFF, 0xFF, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38,
  0x38, 0x70, 0x70, 0x18, 0x7E, 0xEE, 0xC6, 0xEE, 0x7C, 0x7C, 0xEE, 0xC7,
  0xC7, 0xFE, 0x7C, 0x10, 0x7C, 0xFE, 0xC6, 0xC7, 0xC7, 0xFF, 0x7F, 0x06,
  0x0E, 0xFC, 0xF8, 0xDF, 0x00, 0x17, 0xE0, 0x67, 0x60, 0x00, 0x07, 0x66,
  0xE0, 0x03, 0x0F, 0x3C, 0xF0, 0xE0, 0x78, 0x1F, 0x07, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x78, 0x1E, 0x0F, 0x3E, 0xF0, 0xC0, 0x80,
  0x18, 0xFE, 0x7E, 0x07, 0x0E, 0x1E, 0x38, 0x30, 0x00, 0x10, 0x38, 0x38,
  0x02, 0x00, 0xFE, 0x1C, 0x18, 0xC6, 0x6C, 0xF9, 0x6C, 0xCF, 0x66, 0x7B,
  0x32, 0xD9, 0xB6, 0x77, 0x38, 0x00, 0xF3, 0x81, 0xFC, 0x00, 0x0F, 0x03,
  0xE0, 0x6C, 0x0D, 0xC3, 0xB8, 0x73, 0x0F, 0xF3, 0xFE, 0x7F, 0xCC, 0x1F,
  0x83, 0x80, 0xFF, 0x7F, 0xF8, 0xFC, 0x6F, 0xF7, 0xFB, 0x8F, 0xC7, 0xE3,
  0xFF, 0xBF, 0x80, 0x0C, 0x1F, 0xDF, 0xDE, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x78, 0x9F, 0xC7, 0xE0, 0xFF, 0x3F, 0xEE, 0x3B, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE7, 0xBF, 0xCF, 0xE0, 0xFF, 0xFF, 0x87, 0x0F, 0xFF,
  0xF8, 0x70, 0xE1, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0x0F, 0xFF, 0xFF, 0xF0,
  0xE1, 0xC3, 0x80, 0x06, 0x0F, 0xE7, 0xFB, 0xC0, 0xE0, 0x39, 0xFE, 0x7F,
  0x9F, 0xE1, 0xDC, 0x77, 0xFC, 0xFE, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xFF,
  0xFF, 0xFE, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C, 0xFF, 0x9C, 0xE7, 0x39,
  0xCE, 0x77, 0xFE, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0xF8,
  0xE3, 0xF9, 0xCE, 0x73, 0xB8, 0xFC, 0x3F, 0x0F, 0xE3, 0x9C, 0xE7, 0x38,
  0xEE, 0x3C, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xC3, 0xFE, 0x3F, 0xF1, 0xFF, 0xCF, 0xF6, 0xDF, 0xB6,
  0xFD, 0xB7, 0xEF, 0xBF, 0x39, 0xF9, 0xCE, 0xF0, 0xFF, 0x1F, 0xE3, 0xFE,
  0x7E, 0xEF, 0xDD, 0xF9, 0xFF, 0x3F, 0xE3, 0xFC, 0x7F, 0x87, 0x80, 0x0E,
  0x07, 0xF1, 0xFF, 0x70, 0xEE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFE,
  0x39, 0xFF, 0x1F, 0x80, 0xFE, 0xFF, 0xE7, 0xE3, 0xE7, 0xFF, 0xFE, 0xE0,
  0xE0, 0xE0, 0xE0, 0x0E, 0x07, 0xF1, 0xFF, 0x70, 0xEE, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFE, 0x39, 0xFF, 0x1F, 0x80, 0x38, 0x03, 0x80, 0x78,
  0xFE, 0x3F, 0xCE, 0x33, 0x8C, 0xE7, 0x3F, 0x8F, 0xE3, 0x98, 0xE7, 0x38,
  0xEE, 0x3C, 0x18, 0xFF, 0xFF, 0x0E, 0x1F, 0x1F, 0x8F, 0x07, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x00, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0x73, 0xDF, 0xE3, 0xF0, 0xE0, 0xEC, 0x39, 0xC7, 0x38, 0xC3, 0x38, 0x77,
  0x0E, 0xC0, 0xD8, 0x1F, 0x03, 0xC0, 0x38, 0x00, 0xE1, 0xC7, 0x63, 0xC6,
  0x63, 0xC6, 0x73, 0xCE, 0x73, 0xEE, 0x36, 0x6C, 0x36, 0x6C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x1E, 0x78, 0x1C, 0x38, 0xF1, 0xEE, 0x38, 0xEE, 0x0F, 0x81,
  0xF0, 0x1C, 0x07, 0xC1, 0xDC, 0x3B, 0x8E, 0x3B, 0x83, 0x80, 0xE1, 0xDC,
  0xE3, 0x38, 0xFC, 0x1F, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x7F, 0xBF, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x7F, 0xFF,
  0xE0, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xE1, 0xC1, 0x83,
  0x83, 0x06, 0x0E, 0x0C, 0x18, 0x38, 0x30, 0x70, 0xFF, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x3F, 0xF0, 0x18, 0x0E, 0x0F, 0x06, 0xC6, 0x63, 0x1B, 0x0E,
  0xFF, 0xFC, 0xE1, 0xC0, 0x7C, 0x7E, 0x47, 0x0F, 0xFF, 0xE7, 0xC7, 0xFF,
  0xFB, 0xE0, 0xE0, 0xE0, 0xEE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE7, 0xFF,
  0xDE, 0x3E, 0xFF, 0x97, 0x0C, 0x1C, 0x38, 0xFF, 0x7E, 0x07, 0x07, 0x07,
  0x7F, 0xFF, 0xE7, 0xE7, 0xC3, 0xE3, 0xE7, 0xFF, 0x7B, 0x3C, 0x7E, 0xE7,
  0xE3, 0xFF, 0xC0, 0xE0, 0xFE, 0x3E, 0x3E, 0x78, 0xC3, 0xEF, 0xC6, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x80, 0x7B, 0xFF, 0xE7, 0xE7, 0xC3, 0xE3, 0xE7,
  0xFF, 0x7F, 0x07, 0x87, 0xFE, 0x7C, 0xE0, 0xE0, 0xE0, 0xEE, 0xFF, 0xF7,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0x39,
  0xC0, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xDC, 0xE0, 0x70, 0x38,
  0x1C, 0x7E, 0x77, 0x73, 0xF1, 0xF8, 0xFE, 0x77, 0x39, 0xDC, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xDE, 0x7B, 0xFF, 0xEE, 0x79, 0xF8, 0xC7, 0xE3,
  0x1F, 0x8C, 0x7E, 0x31, 0xF8, 0xC7, 0xE3, 0x1C, 0xCE, 0xFF, 0xF7, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x3C, 0x7E, 0xE7, 0xE3, 0xC3, 0xE3, 0xE7,
  0x7F, 0x3E, 0xCE, 0xFF, 0xE7, 0xE3, 0xE3, 0xE3, 0xE7, 0xFF, 0xFE, 0xE0,
  0xE0, 0xE0, 0xE0, 0x7B, 0xFF, 0xE7, 0xE7, 0xC3, 0xE3, 0xE7, 0xFF, 0x7F,
  0x07, 0x07, 0x07, 0x07, 0xCF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE0, 0x7F,
  0xFC, 0x7C, 0x7C, 0xF8, 0xFF, 0xF8, 0x30, 0x61, 0xFF, 0xF7, 0x0E, 0x1C,
  0x38, 0x30, 0x7C, 0xF8, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE7, 0xFF,
  0x7B, 0xE1, 0xF1, 0xDC, 0xEE, 0x63, 0x71, 0xB0, 0xF8, 0x3C, 0x1C, 0x00,
  0xE3, 0x9D, 0x9E, 0x76, 0x79, 0x9D, 0xEE, 0x76, 0xF8, 0xF3, 0xC3, 0xCF,
  0x0F, 0x3C, 0x3C, 0xF0, 0xE3, 0x9C, 0xE3, 0xF0, 0xF8, 0x1E, 0x0F, 0x83,
  0xF1, 0xCE, 0xE3, 0xC0, 0xE1, 0xF1, 0xDC, 0xEE, 0x63, 0x71, 0xF0, 0x78,
  0x3C, 0x1C, 0x0E, 0x0F, 0x0F, 0x07, 0x00, 0x7E, 0x7E, 0x0E, 0x1C, 0x18,
  0x38, 0x70, 0xFF, 0xFF, 0x04, 0x73, 0x8E, 0x38, 0xE7, 0x38, 0xF0, 0xE3,
  0x8E, 0x38, 0x70, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x38, 0xC6, 0x31,
  0xE3, 0x7B, 0x18, 0xCE, 0x72, 0x00, 0xF1, 0xFF, 0x8E,
};

const GFXglyph NotoSans_ExtraBold16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 11, 5, 1, -11 },
  { 6, 6, 4, 8, 1, -11 },
  { 9, 10, 11, 10, 0, -11 },
  { 23, 8, 13, 9, 1, -12 },
  { 36, 14, 12, 15, 0, -12 },
  { 57, 11, 12, 12, 1, -12 },
  { 74, 2, 4, 4, 1, -11 },
  { 75, 4, 15, 6, 1, -12 },
  { 83, 5, 15, 6, 0, -12 },
  { 93, 8, 7, 9, 0, -12 },
  { 100, 8, 8, 9, 1, -10 },
  { 108, 4, 4, 5, 0, -2 },
  { 110, 5, 2, 5, 0, -5 },
  { 112, 3, 3, 5, 1, -3 },
  { 114, 7, 12, 7, 0, -12 },
  { 125, 8, 12, 9, 1, -12 },
  { 137, 6, 11, 9, 1, -11 },
  { 146, 9, 12, 9, 0, -12 },
  { 160, 8, 12, 9, 1, -12 },
  { 172, 9, 11, 9, 0, -11 },
  { 185, 8, 11, 9, 1, -11 },
  { 196, 8, 12, 9, 1, -12 },
  { 208, 8, 11, 9, 1, -11 },
  { 219, 8, 12, 9, 1, -12 },
  { 231, 8, 12, 9, 1, -12 },
  { 243, 3, 9, 5, 1, -9 },
  { 247, 4, 11, 5, 0, -9 },
  { 253, 8, 9, 9, 1, -10 },
  { 262, 8, 5, 9, 1, -8 },
  { 267, 8, 9, 9, 1, -10 },
  { 276, 8, 12, 8, 0, -12 },
  { 288, 13, 13, 14, 1, -12 },
  { 310, 11, 11, 11, 0, -11 },
  { 326, 9, 11, 11, 1, -11 },
  { 339, 9, 12, 10, 1, -12 },
  { 353, 10, 11, 12, 1, -11 },
  { 367, 7, 11, 9, 1, -11 },
  { 377, 7, 11, 9, 1, -11 },
  { 387, 10, 12, 12, 1, -12 },
  { 402, 10, 11, 12, 1, -11 },
  { 416, 5, 11, 7, 1, -11 },
  { 423, 5, 14, 5, -1, -11 },
  { 432, 10, 11, 11, 1, -11 },
  { 446, 8, 11, 9, 1, -11 },
  { 457, 13, 11, 15, 1, -11 },
  { 475, 11, 11, 13, 1, -11 },
  { 491, 11, 12, 13, 1, -12 },
  { 508, 8, 11, 10, 1, -11 },
  { 519, 11, 15, 13, 1, -12 },
  { 540, 10, 11, 11, 1, -11 },
  { 554, 7, 12, 9, 1, -12 },
  { 565, 9, 11, 9, 0, -11 },
  { 578, 10, 11, 12, 1, -11 },
  { 592, 11, 11, 11, 0, -11 },
  { 608, 16, 11, 16, 0, -11 },
  { 630, 11, 11, 11, 0, -11 },
  { 646, 10, 11, 10, 0, -11 },
  { 660, 9, 11, 10, 0, -11 },
  { 673, 4, 15, 5, 1, -12 },
  { 681, 7, 12, 7, 0, -12 },
  { 692, 4, 15, 5, 0, -12 },
  { 700, 9, 7, 9, 0, -11 },
  { 708, 7, 2, 7, 0, 1 },
  { 710, 5, 2, 6, 1, -12 },
  { 712, 8, 9, 10, 1, -9 },
  { 721, 8, 12, 10, 1, -12 },
  { 733, 7, 9, 8, 1, -9 },
  { 741, 8, 12, 10, 1, -12 },
  { 753, 8, 9, 10, 1, -9 },
  { 762, 7, 12, 6, 0, -12 },
  { 773, 8, 13, 10, 1, -9 },
  { 786, 8, 12, 11, 1, -12 },
  { 798, 3, 12, 5, 1, -12 },
  { 803, 5, 16, 5, -1, -12 },
  { 813, 9, 12, 10, 1, -12 },
  { 827, 3, 12, 5, 1, -12 },
  { 832, 14, 9, 16, 1, -9 },
  { 848, 8, 9, 11, 1, -9 },
  { 857, 8, 9, 10, 1, -9 },
  { 866, 8, 13, 10, 1, -9 },
  { 879, 8, 13, 10, 1, -9 },
  { 892, 6, 9, 7, 1, -9 },
  { 899, 6, 9, 8, 1, -9 },
  { 906, 7, 11, 7, 0, -11 },
  { 916, 8, 9, 11, 1, -9 },
  { 925, 9, 9, 9, 0, -9 },
  { 936, 14, 9, 14, 0, -9 },
  { 952, 10, 9, 10, 0, -9 },
  { 964, 9, 13, 9, 0, -9 },
  { 979, 8, 9, 8, 0, -9 },
  { 988, 6, 15, 7, 0, -12 },
  { 1000, 2, 16, 9, 3, -12 },
  { 1004, 5, 15, 7, 1, -12 },
  { 1014, 8, 3, 9, 1, -7 },
};

const GFXfont NotoSans_ExtraBold16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold16pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_EXTRABOLD16PT7B_H_
