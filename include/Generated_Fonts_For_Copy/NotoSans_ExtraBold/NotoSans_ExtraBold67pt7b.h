#ifndef _NOTOSANS_EXTRABOLD67PT7B_H_
#define _NOTOSANS_EXTRABOLD67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold67pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF9, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0xFF, 0x8F, 0xFE, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xF9, 0xFF, 0xC7, 0xFC, 0x0F, 0x80, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFD, 0xFF, 0x07, 0xFE, 0xFF, 0x83, 0xFF, 0x7F, 0xC0,
  0xFF, 0xBF, 0xE0, 0x7F, 0xDF, 0xF0, 0x3F, 0xEF, 0xF8, 0x1F, 0xF7, 0xFC,
  0x0F, 0xF3, 0xFE, 0x07, 0xF9, 0xFF, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F,
  0x80, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x1F, 0x07,
  0xE3, 0xFF, 0x87, 0xC0, 0x18, 0xFF, 0xE1, 0xF0, 0x00, 0x3F, 0xF8, 0x7C,
  0x00, 0x0F, 0xFE, 0x1F, 0x00, 0x01, 0xFF, 0xC7, 0xC0, 0x00, 0x7F, 0xFD,
  0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0xFF, 0xF0, 0x00, 0x1F,
  0x1F, 0xFC, 0x00, 0x07, 0xC3, 0xFF, 0x00, 0x01, 0xF0, 0xFF, 0xD8, 0x00,
  0x7C, 0x3F, 0xF7, 0xC0, 0x1F, 0x1F, 0xFD, 0xFF, 0x07, 0xCF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x7F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x8F, 0xF8, 0x7F, 0xFE, 0x07, 0xFC, 0x7F, 0xC3, 0xFE, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x7F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xE3, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFC, 0x7F,
  0xE3, 0xFE, 0x07, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0xE0,
  0xFF, 0x87, 0xFC, 0x1F, 0xF0, 0x01, 0x00, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x81, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xDF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xEF, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0xE3,
  0xFF, 0xF3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0x9F, 0xF3, 0xFE,
  0x7F, 0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFC, 0x7F,
  0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x78,
  0x07, 0xF0, 0x0E, 0x7F, 0x07, 0xF0, 0xFF, 0x7F, 0xF7, 0xE7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F,
  0xFC, 0x1F, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0x10, 0x04, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x81, 0xFF, 0x1F, 0xFC,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF3, 0xFF, 0x8F,
  0xF8, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8,
  0x07, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xF9, 0xFF,
  0xC0, 0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xF7,
  0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xDF, 0xFC,
  0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0x7F,
  0xF0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x3F, 0xFD,
  0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x8F, 0xFE, 0x01, 0xFF,
  0xE3, 0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xC7, 0xFF, 0x1F, 0xC1, 0xFF, 0xC3,
  0xE0, 0x7F, 0xF0, 0x70, 0x1F, 0xFC, 0x08, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xC1, 0xFF, 0xF8, 0x7F, 0x80, 0x1F, 0xFE, 0x0F, 0xC0, 0x07, 0xFF, 0x81,
  0xC0, 0x00, 0xFF, 0xE0, 0x20, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xF8, 0x1C, 0x00, 0x1F, 0xFE,
  0x04, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0xFF,
  0xE3, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xFE,
  0x00, 0x03, 0xFE, 0x7F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x03, 0xFF,
  0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xE0, 0x01, 0xFF, 0x87, 0xFF, 0x00,
  0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFB,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x83,
  0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE8, 0x00, 0x00, 0xFF, 0xF7, 0x00, 0x00, 0xFF,
  0xFB, 0xF0, 0x00, 0xFF, 0xFD, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xBE, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0x8F, 0xFF, 0xE0, 0x3F, 0xF3,
  0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF3, 0xFF, 0xFB, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xFC, 0x01,
  0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xFC,
  0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xEF,
  0xFE, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0xFF,
  0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF8, 0x07, 0xFF, 0x8F, 0xFF, 0x81,
  0xFF, 0xF0, 0xFF, 0xFD, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xE3, 0xFF,
  0x80, 0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x8F,
  0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x3F, 0xF8, 0x7F, 0xF0, 0x1F, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xEF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0xE7,
  0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x1F, 0xFD, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE,
  0xFF, 0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xF7, 0xFF, 0xC1, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xEF, 0xFC, 0x3F, 0xFF, 0xFB, 0xFF, 0x07, 0xFF, 0xFC, 0xFF,
  0xC0, 0xFF, 0xFE, 0x3F, 0xF0, 0x1F, 0xFE, 0x1F, 0xF8, 0x00, 0x3C, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x70, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xC3, 0xFF, 0x9F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xF3, 0xFF, 0x87, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0xC7,
  0xFF, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFC, 0xFF,
  0xE3, 0xFE, 0x07, 0xC0, 0x0F, 0xE0, 0x7F, 0xE3, 0xFF, 0x8F, 0xFF, 0x7F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8, 0x7F, 0xE0, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xFE,
  0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x83, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0x00, 0x7F, 0xF8, 0x70, 0x00, 0x7F,
  0xF0, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF,
  0xFC, 0x3F, 0xC1, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0x87, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE1, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xF8, 0xFF,
  0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xF7, 0xFC, 0x1F, 0xFF, 0xBF, 0xF0, 0x3F,
  0xDF, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0xFF, 0x7F, 0x83, 0xFF, 0x00, 0xFF,
  0x03, 0xFD, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xC0,
  0x0F, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xFF,
  0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xFF, 0xC1, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xF0, 0x07,
  0xFC, 0x0F, 0xEF, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xBF, 0xC1, 0xFF,
  0x00, 0xFF, 0xC1, 0xFE, 0xFF, 0x03, 0xFE, 0x03, 0xFF, 0x0F, 0xF3, 0xFC,
  0x0F, 0xFC, 0x3F, 0xFE, 0x7F, 0xC7, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xBF,
  0xFF, 0xC1, 0xFF, 0x01, 0xFF, 0xFE, 0x7F, 0xFE, 0x03, 0xFC, 0x03, 0xFF,
  0xE0, 0xFF, 0xF0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFD, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x8F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xF9, 0xFF,
  0xE0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0x7F,
  0xF3, 0xFF, 0xC0, 0x03, 0xFF, 0x9F, 0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xF0,
  0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xE0, 0x7F, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFE, 0x7F, 0xF8,
  0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x1F, 0xFE,
  0xFF, 0xF0, 0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0x7F,
  0xF8, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x1F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0xFF, 0x00, 0x07, 0x83, 0xFF, 0xF0,
  0x00, 0x04, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x08, 0xFF, 0xFE,
  0x00, 0x03, 0x83, 0xFF, 0xFC, 0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFC, 0x00,
  0xFF, 0xFF, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x00, 0x07, 0xFF,
  0xE7, 0xFF, 0x80, 0x01, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x7F, 0xF9, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x01, 0xFF,
  0xEF, 0xFF, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x03, 0xFF,
  0xDF, 0xFE, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0xFF, 0xF7, 0xFF,
  0x80, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFF,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x9F, 0xFE, 0x00, 0x0F, 0xFF, 0x8F, 0xFF,
  0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x03,
  0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x30, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFB, 0xFF,
  0x80, 0x01, 0xFF, 0xE7, 0xFF, 0x00, 0x07, 0xFF, 0xCF, 0xFE, 0x00, 0x1F,
  0xFF, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F,
  0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x0F,
  0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x3F,
  0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF8, 0x00, 0xFF, 0xE3, 0xFF, 0xE0, 0x01,
  0xFF, 0xC7, 0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xFF, 0x00, 0x07, 0xFF, 0x7F,
  0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x9F, 0xFE, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x7F,
  0xF0, 0x03, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0xE1, 0xFF, 0xC0, 0x07,
  0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFF, 0xCF,
  0xFE, 0x00, 0x0F, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFF, 0xBF, 0xF8, 0x00,
  0x1F, 0xFF, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xBF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFE, 0x00, 0x07, 0xFB, 0xFF, 0xFF, 0xBF, 0xE0, 0x00,
  0xFF, 0xBF, 0xFF, 0xFB, 0xFF, 0x00, 0x0F, 0xFB, 0xFF, 0xFF, 0x9F, 0xF0,
  0x00, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFF, 0xFF, 0xDF,
  0xF8, 0x01, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFF, 0xFF,
  0xCF, 0xF8, 0x01, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0x80, 0x3F, 0xE3, 0xFF,
  0xFF, 0xC7, 0xFC, 0x03, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xC0, 0x3F, 0xC3,
  0xFF, 0xFF, 0xC7, 0xFC, 0x07, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xE0, 0x7F,
  0xC3, 0xFF, 0xFF, 0xC3, 0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xE0,
  0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xF0, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xF1, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xF9, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x9F, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x7F,
  0xF8, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFC,
  0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xF8, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFC, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFE, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xBF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFB,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xBF,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFB, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x3F, 0xFF, 0xEF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFD, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xBF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFB,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xBF,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFB, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00,
  0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFC, 0x03, 0xF8, 0x7F, 0xF8, 0x00, 0x78, 0x7F, 0xF0,
  0x00, 0x08, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x8F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xFB, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x7F,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x1F,
  0xEF, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07, 0xFD, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFE, 0xFF, 0x80,
  0x7F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x1F, 0xF1, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFE, 0x3F,
  0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x1F, 0xF8, 0xFF, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0xC0, 0x00, 0xFF, 0xE3,
  0xFF, 0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xC7,
  0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F,
  0xF1, 0xFF, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x3F, 0xE0, 0x3F,
  0xE7, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x00,
  0x0F, 0xFD, 0xFF, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xE0,
  0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xE0,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF3, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x87,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xBF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xEF, 0xFF,
  0x00, 0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x7F, 0xF1, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x1F,
  0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFF,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0xF0, 0x0F, 0xFF, 0x81, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xCF,
  0xFF, 0xFE, 0x3F, 0xE1, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFC, 0x07, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x07, 0xFF, 0x1F,
  0xFF, 0x80, 0xFF, 0xE7, 0xFF, 0xF8, 0x1F, 0xFD, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xE0, 0x7F,
  0xFC, 0xFF, 0xF8, 0x07, 0xFF, 0xDF, 0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0xC0,
  0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0xC0,
  0x03, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x1F, 0xFE, 0xFF,
  0xF8, 0x07, 0xFF, 0xDF, 0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFE, 0xFF, 0xFF, 0xE0, 0xFF, 0xCF,
  0xFF, 0xF8, 0x1F, 0xF0, 0x7F, 0xFE, 0x03, 0xFE, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFC, 0x01, 0xE1, 0xFF, 0xF0, 0x00, 0x83, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x23, 0xFF, 0xF0, 0x03, 0xC3, 0xFF, 0xFC, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x3F, 0xF8, 0x0F, 0xFF, 0xC7, 0xFF, 0x03, 0xFF, 0xFC, 0xFF, 0xE0, 0xFF,
  0xFF, 0xDF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xF0, 0x3F, 0xFF, 0x7F, 0xFC, 0x03, 0xFF, 0xEF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFB, 0xFF,
  0xC0, 0x0F, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xEF, 0xFF, 0x80, 0x7F, 0xFD,
  0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xBF, 0xF8, 0x7F, 0xFF,
  0xF3, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xE0, 0x7F, 0xFF, 0x07, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0x87,
  0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x7F,
  0xE7, 0xFF, 0x00, 0x0F, 0xFD, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x83, 0xFF,
  0xF0, 0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xE3, 0xC0, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0x83, 0xFF, 0xFF, 0x3F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0x80,
  0x7F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFD,
  0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xF7, 0xFF, 0xF0, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xDF, 0xFC, 0x1F,
  0xFF, 0xF3, 0xFF, 0x81, 0xFF, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x1C, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE4, 0x00, 0x00, 0x3F, 0xFC, 0xE0, 0x00,
  0x0F, 0xFF, 0x1F, 0x80, 0x07, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFF, 0xC0, 0xFF, 0xE7, 0xFF, 0xFE,
  0x1F, 0xFD, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xC3, 0xFF, 0x9F, 0xFD, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F,
  0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF,
  0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F, 0xF3,
  0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x7F,
  0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE,
  0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F,
  0xFE, 0x01, 0xFF, 0xE8, 0x3F, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xFC, 0xFF, 0xE0, 0x03,
  0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFF, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xFE, 0x00, 0xFF,
  0xE1, 0xFF, 0xF0, 0x03, 0xFF, 0x8F, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xFC,
  0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x03, 0xFF,
  0xBF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFB, 0xFF, 0xC0, 0x0F, 0xFF, 0x8F, 0xFF, 0x80, 0x3F, 0xFC,
  0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0xE0,
  0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xFE,
  0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0xF3, 0xFF, 0x80,
  0x03, 0xFF, 0xEF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xE3, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFB, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xDF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xF0, 0x7F, 0xFF, 0x03, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xC7, 0xFF, 0xFF,
  0x8F, 0xFD, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0x80, 0xFF, 0xFB, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFE, 0x7F, 0xF8,
  0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x0F, 0xFE, 0x7F, 0xF8,
  0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xFE, 0x3F, 0xFE, 0x07, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xFE,
  0x03, 0xFF, 0x1F, 0xFF, 0xE0, 0x7F, 0xE7, 0xFF, 0xFE, 0x0F, 0xFD, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0x81, 0xFF, 0xFB,
  0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0xF8, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x3F,
  0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x0F,
  0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x7F, 0xFB, 0xFF, 0xE0,
  0x1F, 0xFF, 0x7F, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xBF, 0xFF,
  0xE0, 0x7F, 0xF3, 0xFF, 0xF8, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x3F, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0x83, 0xFF, 0xFF,
  0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF,
  0xFF, 0x80, 0x7F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFF, 0x00,
  0x1F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xBF, 0xFE, 0x01, 0xFF, 0xF7, 0xFF,
  0xF0, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xDF,
  0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0x81, 0xFF, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFE, 0x00, 0x1C, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF,
  0xEF, 0xF8, 0xFF, 0xF7, 0xFE, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0x5F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0x8F, 0xFC,
  0xFF, 0xE0, 0x07, 0x8F, 0xFE, 0x00, 0x08, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xE8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x04, 0x3F, 0xFF, 0x1F, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F,
  0xF1, 0xFF, 0xFF, 0xC7, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0x03, 0xFF, 0xE0,
  0x3F, 0xC0, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00,
  0xFF, 0xE3, 0xFF, 0x80, 0x03, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFF, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x03, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF8,
  0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x3F, 0xF9, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFE, 0x1F,
  0xFC, 0x07, 0xFB, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFD, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0x81, 0xFE, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xFF,
  0x7F, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0xE0, 0x3F,
  0xF0, 0x7F, 0x8F, 0xF0, 0x7F, 0xE0, 0x1F, 0xFC, 0x3F, 0xC7, 0xF8, 0x7F,
  0xF0, 0x0F, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xF8, 0x03, 0xFF, 0x1F, 0xE1,
  0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0x8F, 0xF0, 0x7F, 0x8F, 0xFC, 0x00, 0xFF,
  0xC7, 0xF8, 0x3F, 0xC7, 0xFE, 0x00, 0x7F, 0xE3, 0xFC, 0x1F, 0xE7, 0xFF,
  0x00, 0x1F, 0xFB, 0xFE, 0x0F, 0xFB, 0xFF, 0x00, 0x0F, 0xFD, 0xFE, 0x07,
  0xFD, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0xC0, 0x03, 0xFF,
  0x7F, 0x80, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0xBF, 0xC0, 0x7F, 0xBF, 0xE0,
  0x00, 0x7F, 0xDF, 0xC0, 0x3F, 0xDF, 0xF0, 0x00, 0x3F, 0xEF, 0xE0, 0x0F,
  0xEF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFF,
  0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x03,
  0xFF, 0xE3, 0xFF, 0xC0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0xFF, 0xF7,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x03, 0xFF,
  0xE3, 0xFF, 0xC0, 0x03, 0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0xFF, 0xC1, 0xFF,
  0xE0, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFD, 0xFF, 0xE0,
  0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x03, 0xFF,
  0xC7, 0xFF, 0x80, 0x07, 0xFF, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x03,
  0xFF, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x3F, 0xEF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x8F, 0xFF, 0x00, 0x00, 0x4F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xB0, 0x00, 0x3F, 0xFF, 0x90,
  0x00, 0x03, 0xFF, 0x00,
};

const GFXglyph NotoSans_ExtraBold67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 13, 49, 19, 3, -48 },
  { 81, 25, 17, 34, 4, -48 },
  { 135, 41, 48, 44, 1, -48 },
  { 381, 34, 55, 38, 2, -51 },
  { 615, 58, 50, 62, 2, -49 },
  { 978, 49, 50, 52, 3, -49 },
  { 1285, 11, 17, 19, 4, -48 },
  { 1309, 18, 59, 23, 3, -48 },
  { 1442, 19, 59, 23, 2, -48 },
  { 1583, 32, 32, 36, 2, -51 },
  { 1711, 33, 33, 39, 3, -40 },
  { 1848, 14, 18, 20, 2, -9 },
  { 1880, 18, 10, 21, 2, -23 },
  { 1903, 13, 12, 19, 3, -11 },
  { 1923, 28, 49, 29, 0, -48 },
  { 2095, 34, 50, 39, 2, -49 },
  { 2308, 26, 48, 39, 3, -48 },
  { 2464, 34, 49, 39, 2, -49 },
  { 2673, 34, 50, 39, 2, -49 },
  { 2886, 37, 48, 39, 1, -48 },
  { 3108, 33, 49, 39, 3, -48 },
  { 3311, 35, 49, 39, 2, -48 },
  { 3526, 35, 48, 39, 2, -48 },
  { 3736, 34, 49, 39, 2, -48 },
  { 3945, 34, 49, 39, 2, -48 },
  { 4154, 13, 38, 19, 3, -37 },
  { 4216, 14, 46, 20, 2, -37 },
  { 4297, 33, 36, 39, 3, -42 },
  { 4446, 33, 21, 39, 3, -34 },
  { 4533, 33, 36, 39, 3, -42 },
  { 4682, 31, 50, 33, 0, -49 },
  { 4876, 54, 53, 60, 3, -48 },
  { 5234, 47, 48, 47, 0, -48 },
  { 5516, 37, 48, 45, 5, -48 },
  { 5738, 37, 50, 43, 4, -49 },
  { 5970, 41, 48, 49, 5, -48 },
  { 6216, 28, 48, 37, 6, -48 },
  { 6384, 27, 48, 36, 6, -48 },
  { 6546, 40, 50, 49, 4, -49 },
  { 6796, 40, 48, 51, 6, -48 },
  { 7036, 23, 48, 28, 2, -48 },
  { 7174, 22, 62, 23, -5, -48 },
  { 7345, 39, 48, 45, 6, -48 },
  { 7579, 31, 48, 38, 5, -48 },
  { 7765, 52, 48, 64, 6, -48 },
  { 8077, 44, 48, 55, 6, -48 },
  { 8341, 46, 50, 53, 4, -49 },
  { 8629, 34, 48, 42, 5, -48 },
  { 8833, 46, 60, 53, 4, -49 },
  { 9178, 40, 48, 45, 5, -48 },
  { 9418, 32, 50, 38, 3, -49 },
  { 9618, 37, 48, 39, 1, -48 },
  { 9840, 40, 49, 51, 5, -48 },
  { 10085, 45, 48, 45, 0, -48 },
  { 10355, 67, 48, 67, 0, -48 },
  { 10757, 46, 48, 47, 0, -48 },
  { 11033, 43, 48, 43, 0, -48 },
  { 11291, 36, 48, 40, 2, -48 },
  { 11507, 16, 59, 22, 4, -48 },
  { 11625, 28, 49, 29, 0, -48 },
  { 11797, 16, 59, 22, 2, -48 },
  { 11915, 35, 31, 37, 1, -48 },
  { 12051, 30, 6, 30, 0, 5 },
  { 12074, 20, 10, 26, 3, -51 },
  { 12099, 33, 38, 41, 3, -37 },
  { 12256, 35, 52, 43, 5, -51 },
  { 12484, 31, 38, 35, 3, -37 },
  { 12632, 35, 52, 43, 3, -51 },
  { 12860, 35, 38, 41, 3, -37 },
  { 13027, 28, 51, 27, 1, -51 },
  { 13206, 35, 53, 43, 3, -37 },
  { 13438, 35, 51, 44, 5, -51 },
  { 13662, 13, 51, 21, 4, -51 },
  { 13745, 20, 67, 21, -3, -51 },
  { 13913, 38, 51, 43, 5, -51 },
  { 14156, 11, 51, 21, 5, -51 },
  { 14227, 57, 37, 66, 5, -37 },
  { 14491, 35, 37, 44, 5, -37 },
  { 14653, 36, 38, 42, 3, -37 },
  { 14824, 35, 53, 43, 5, -37 },
  { 15056, 35, 53, 43, 3, -37 },
  { 15288, 25, 37, 31, 5, -37 },
  { 15404, 28, 38, 34, 3, -37 },
  { 15537, 26, 45, 30, 2, -44 },
  { 15684, 34, 38, 44, 5, -37 },
  { 15846, 39, 37, 39, 0, -37 },
  { 16027, 57, 37, 59, 1, -37 },
  { 16291, 40, 37, 40, 0, -37 },
  { 16476, 39, 53, 39, 0, -37 },
  { 16735, 30, 37, 33, 2, -37 },
  { 16874, 24, 59, 28, 1, -48 },
  { 17051, 8, 66, 36, 14, -51 },
  { 17117, 24, 59, 28, 2, -48 },
  { 17294, 33, 12, 39, 3, -30 },
};

const GFXfont NotoSans_ExtraBold67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold67pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_EXTRABOLD67PT7B_H_
