#ifndef _NOTOSANS_EXTRABOLD35PT7B_H_
#define _NOTOSANS_EXTRABOLD35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0x78, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0xFF, 0xE7, 0xFE,
  0x3F, 0xF1, 0xFF, 0x8F, 0xBC, 0x7D, 0xE3, 0xEF, 0x1F, 0x78, 0x78, 0x01,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x7C,
  0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x83,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x83, 0xC7,
  0x80, 0x3E, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x80, 0x3E, 0x3C, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x1F, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0x7C, 0xFC,
  0xC1, 0x3F, 0x30, 0x0F, 0xCC, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x37, 0xF0, 0x0C, 0xFC,
  0x03, 0x1F, 0xE0, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC, 0x7F,
  0xFE, 0x03, 0xFC, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0xFF, 0x00, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xFC,
  0x0F, 0x00, 0xF9, 0xF0, 0x7C, 0x03, 0xE7, 0xC1, 0xE0, 0x0F, 0x0F, 0x0F,
  0x80, 0x3C, 0x3C, 0x3C, 0x00, 0xF0, 0xF1, 0xF0, 0x03, 0xE7, 0xCF, 0x80,
  0x0F, 0x9F, 0x3E, 0x7E, 0x1F, 0xFD, 0xF3, 0xFE, 0x7F, 0xE7, 0x9F, 0xF8,
  0xFF, 0x3E, 0x7D, 0xF1, 0xF8, 0xF3, 0xE7, 0xC0, 0x07, 0xCF, 0x8F, 0x00,
  0x1E, 0x3E, 0x3C, 0x00, 0xF8, 0xF8, 0xF0, 0x07, 0xC3, 0xE3, 0xC0, 0x1F,
  0x0F, 0x8F, 0x00, 0xF8, 0x3E, 0x7C, 0x03, 0xC0, 0x7D, 0xF0, 0x1F, 0x01,
  0xFF, 0x80, 0x78, 0x03, 0xFE, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x1F,
  0xBF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x7E,
  0x1F, 0xF8, 0x3F, 0x8F, 0xFF, 0x0F, 0xC7, 0xFF, 0xE3, 0xF1, 0xF9, 0xFD,
  0xFC, 0xFE, 0x3F, 0xFE, 0x3F, 0x07, 0xFF, 0x8F, 0xE0, 0xFF, 0xC3, 0xF8,
  0x1F, 0xE0, 0x7F, 0xBF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFD, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xBE, 0xF9, 0xE7,
  0x9E, 0x78, 0x07, 0xC3, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE1, 0xF8,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x3E, 0x0F, 0x81, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07,
  0xC1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F,
  0x07, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1C, 0x07, 0x0E, 0x1B, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC1, 0xFC, 0x01, 0xFF, 0x01, 0xF7, 0x80,
  0xFB, 0xE0, 0xF8, 0xF8, 0x3C, 0x78, 0x04, 0x10, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x3E, 0x7D,
  0xFB, 0xF7, 0xCF, 0x9F, 0x3C, 0xF9, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x33, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7C, 0x0F, 0xDF, 0x83, 0xF7, 0xE1, 0xF9,
  0xF8, 0x7E, 0x3F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xF3, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xBF, 0x79, 0xF9, 0x8F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0x87,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0x07, 0xE1, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF,
  0xFE, 0x3F, 0xFF, 0x8C, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0xFC, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xBF, 0x01, 0xF7,
  0xE0, 0x7C, 0xFC, 0x1F, 0x1F, 0x83, 0xE3, 0xF0, 0xF8, 0x7E, 0x3E, 0x0F,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE3,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xD0, 0x07, 0xEF, 0xDF, 0xF7, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0xE1, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x3F, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF7,
  0xE0, 0xFD, 0xF8, 0x3F, 0x7F, 0xBF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F,
  0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7E, 0x1F,
  0x9F, 0x83, 0xE7, 0xE0, 0xF9, 0xF8, 0x7E, 0x3F, 0x3F, 0x8F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xF1, 0xF8,
  0x7E, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F,
  0xDF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0xBF, 0x87, 0xEF,
  0xC0, 0xFB, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF8,
  0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F, 0xBF, 0x03, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x21, 0xFF, 0x0F, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x33, 0xFF, 0xFF, 0xFF, 0xF3,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x3F, 0xFF, 0xFF, 0xFE, 0x08, 0xFD,
  0xFB, 0xF7, 0xEF, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x3E, 0xFD, 0xFB, 0xE7, 0xCF, 0xBE, 0x7C, 0xF0, 0x00, 0x01, 0x80, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x80, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xF8,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xFE, 0xFF, 0xFE,
  0x7F, 0xFF, 0x7E, 0x7F, 0x20, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x1F, 0x80,
  0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x3E, 0x0F, 0xC3, 0xE7, 0xC3, 0xFF, 0x9E,
  0x78, 0xFF, 0xF9, 0xEF, 0x8F, 0xFF, 0x9F, 0xF1, 0xF0, 0xF8, 0xFF, 0x1E,
  0x0F, 0x8F, 0xF3, 0xE0, 0xF8, 0xFF, 0x3E, 0x0F, 0x0F, 0xF3, 0xE0, 0xF0,
  0xFF, 0x3E, 0x0F, 0x1E, 0xF1, 0xE1, 0xF1, 0xEF, 0x1F, 0x3F, 0xBE, 0xF1,
  0xFF, 0xFF, 0xCF, 0x8F, 0xFB, 0xF8, 0x78, 0x3E, 0x1F, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x03,
  0xE7, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC3, 0xF0, 0x07, 0xE3, 0xF8, 0x03, 0xF9, 0xF8, 0x01, 0xFD, 0xFC, 0x00,
  0x7E, 0xFE, 0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF8, 0x3F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E,
  0xFC, 0x0F, 0xDF, 0x87, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3F, 0x0F, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7,
  0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0x01, 0x9F, 0xC0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x23, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0,
  0x3F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7E, 0x0F, 0xF3, 0xF0, 0x1F, 0xDF,
  0x80, 0x7E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7E, 0xFC,
  0x03, 0xF7, 0xE0, 0x3F, 0xBF, 0x01, 0xFD, 0xF8, 0x3F, 0xCF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0xBF, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xC0, 0x11, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x3F,
  0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0xC0, 0x7E, 0xFF, 0x03, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xE0,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07,
  0xF8, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF0, 0x10, 0x00, 0xFC, 0x03,
  0xFF, 0xE0, 0x3F, 0xBF, 0x03, 0xF9, 0xF8, 0x3F, 0x8F, 0xC1, 0xF8, 0x7E,
  0x1F, 0xC3, 0xF1, 0xFC, 0x1F, 0x9F, 0xC0, 0xFC, 0xFC, 0x07, 0xEF, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1F, 0xDF, 0xC0, 0xFC, 0x7F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xE1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xFC, 0x7E, 0x07, 0xF3, 0xF0, 0x3F, 0x9F, 0x80,
  0xFE, 0xFC, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFB, 0xE0, 0x7B,
  0xFF, 0x7C, 0x1F, 0x7F, 0xEF, 0x83, 0xEF, 0xFC, 0xF0, 0x79, 0xFF, 0x9F,
  0x0F, 0x3F, 0xF3, 0xE3, 0xE7, 0xFE, 0x3C, 0x78, 0xFF, 0xC7, 0xCF, 0x1F,
  0xF8, 0xFB, 0xE3, 0xFF, 0x1F, 0x7C, 0x7F, 0xE1, 0xFF, 0x0F, 0xFC, 0x3F,
  0xE1, 0xFF, 0x87, 0xFC, 0x3F, 0xF0, 0x7F, 0x07, 0xFE, 0x0F, 0xE0, 0xFF,
  0xC1, 0xFC, 0x1F, 0xF8, 0x3F, 0x03, 0xE0, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFD, 0xF8, 0x1F, 0xFB, 0xF0, 0x3F, 0xF3, 0xF0, 0x7F,
  0xE7, 0xE0, 0xFF, 0xC7, 0xE1, 0xFF, 0x8F, 0xE3, 0xFF, 0x0F, 0xC7, 0xFE,
  0x1F, 0xCF, 0xFC, 0x1F, 0x9F, 0xF8, 0x3F, 0xBF, 0xF0, 0x3F, 0x7F, 0xE0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0x81,
  0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0xBF, 0x0F, 0xEF,
  0xC1, 0xFB, 0xF0, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xEF, 0xC1, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0x81,
  0xFE, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0x7F, 0x00, 0xFE, 0x7F, 0x81, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7E, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x7E,
  0x07, 0xE3, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x7E,
  0x07, 0xE3, 0xF0, 0x3F, 0x9F, 0x80, 0xFE, 0xFC, 0x07, 0xF8, 0x0F, 0xFC,
  0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFC, 0x06, 0xFC, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF,
  0x00, 0xFD, 0xFC, 0x0F, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x03, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFD,
  0xF8, 0x03, 0xFB, 0xF0, 0x07, 0xE7, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F,
  0xC0, 0x7E, 0x1F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x01, 0xF9,
  0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xEF, 0x80,
  0x7F, 0x00, 0xF9, 0xF8, 0x0F, 0xE0, 0x3F, 0x3F, 0x01, 0xFC, 0x07, 0xE7,
  0xE0, 0x3F, 0x80, 0xFC, 0x7C, 0x0F, 0xF8, 0x1F, 0x0F, 0xC1, 0xFF, 0x07,
  0xE1, 0xF8, 0x3D, 0xE0, 0xFC, 0x3F, 0x07, 0xBC, 0x1F, 0x83, 0xE1, 0xF7,
  0xC3, 0xE0, 0x7C, 0x3E, 0xF8, 0x7C, 0x0F, 0xC7, 0xDF, 0x1F, 0x81, 0xF8,
  0xF1, 0xE3, 0xF0, 0x1F, 0x3E, 0x3E, 0x7C, 0x03, 0xE7, 0xC7, 0xCF, 0x80,
  0x7E, 0xF8, 0xFB, 0xF0, 0x0F, 0xDF, 0x0F, 0x7E, 0x00, 0xFB, 0xC1, 0xEF,
  0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0xFF, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x3F,
  0x00, 0xFE, 0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F,
  0xE3, 0xF0, 0x07, 0xE7, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x07,
  0xE7, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF8, 0x3F,
  0x81, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0xFE, 0xFC, 0x03, 0xF9, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF8,
  0x3F, 0x03, 0xF0, 0xFE, 0x07, 0xF1, 0xF8, 0x07, 0xE7, 0xE0, 0x07, 0xEF,
  0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x7D, 0xE0, 0x0F,
  0x1E, 0x03, 0xE3, 0xE0, 0x78, 0x3C, 0x1F, 0x07, 0xC3, 0xC0, 0x78, 0x78,
  0x0F, 0x9E, 0x00, 0xF7, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x00, 0x20, 0x03,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC3, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFD, 0xFE, 0x3F,
  0x7E, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF3, 0xFF, 0x7C, 0x7F, 0x0F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0xC0, 0xFC, 0xFE, 0x1F, 0xBF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xF1,
  0xFD, 0xFC, 0x1F, 0xBF, 0x83, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFD, 0xFC, 0x1F, 0xBF, 0xEF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xBF, 0xE3, 0xE3, 0xF8, 0x00, 0x00,
  0xC0, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0x0C, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x02, 0xFF, 0xBE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F,
  0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x08, 0x3F, 0x1F, 0xCF, 0xCF,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0xC0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF3, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF,
  0xF9, 0xF1, 0xFC, 0x7C, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF,
  0xFC, 0x7F, 0xFF, 0xBF, 0x87, 0xEF, 0xC0, 0xFB, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x0E, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F,
  0xF8, 0x01, 0xF0, 0x3F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0xF8, 0x7E, 0x01,
  0xF0, 0x07, 0xC0, 0x7F, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x02, 0x00, 0x07, 0xF1, 0xF3, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFC,
  0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3, 0xFE, 0xFC, 0x7F, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x01, 0xFD, 0xE0, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xC7,
  0xFF, 0xE1, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0xC0, 0xFC,
  0xFF, 0x1F, 0xBF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xF1, 0xFF, 0xFC,
  0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0x80, 0x38, 0xFB, 0xFF,
  0xF7, 0xC6, 0x00, 0x00, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF0, 0x03, 0x80, 0xF8,
  0x3F, 0x87, 0xF0, 0x7C, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0xA7, 0xF7, 0xFE, 0xFF, 0x9F, 0xF3, 0xFC, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0x03, 0xF3, 0xE0, 0xFE,
  0x7C, 0x3F, 0x8F, 0x8F, 0xE1, 0xF3, 0xF8, 0x3E, 0x7E, 0x07, 0xDF, 0x80,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xEF, 0xE1,
  0xF0, 0xFC, 0x3E, 0x0F, 0xC7, 0xC1, 0xFC, 0xF8, 0x1F, 0xDF, 0x01, 0xFB,
  0xE0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x10, 0x03, 0x83, 0xE3, 0xFC, 0x7F, 0xCF, 0xDF, 0xFB, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xC7, 0xFF, 0xE0,
  0xFE, 0x0F, 0xFF, 0x83, 0xF8, 0x3F, 0xFE, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F,
  0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0,
  0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x3F,
  0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF,
  0x03, 0xF0, 0x3F, 0x00, 0x10, 0x1F, 0x1F, 0xE3, 0xE7, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xF0, 0x00, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC,
  0x7F, 0xFF, 0xBF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xFD, 0xFC, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F, 0xE0,
  0x00, 0x10, 0x1F, 0x9F, 0xC3, 0xF7, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD,
  0xFE, 0x3F, 0xBF, 0x83, 0xF7, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xBF, 0x83, 0xF7,
  0xFD, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xF7, 0xFC, 0x7E, 0x7F, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x02, 0x00, 0x07, 0xF1, 0xF3,
  0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF3,
  0xFE, 0xFC, 0x7F, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1B,
  0xE3, 0xFF, 0x9F, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xF8, 0x3F, 0x80,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0x00, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xE0, 0x2F, 0xC0, 0x3F, 0xC0, 0xFF,
  0xC1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xF8, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xE2, 0x3F, 0xF1, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0xFC, 0x07,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xDF, 0xCF, 0xFB, 0xFF, 0xFF,
  0x7F, 0xFF, 0xE7, 0xFE, 0x7C, 0x7F, 0x8F, 0x80, 0xFC, 0x03, 0xFB, 0xF0,
  0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xE0,
  0x7C, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0x80, 0x7C, 0xFC, 0x03, 0xE7,
  0xE0, 0x1F, 0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x0F,
  0xE0, 0x7D, 0xF8, 0x3F, 0x83, 0xF7, 0xE0, 0xFE, 0x0F, 0xDF, 0x87, 0xFC,
  0x3E, 0x3E, 0x1F, 0xF0, 0xF8, 0xFC, 0x7B, 0xC7, 0xE3, 0xF1, 0xEF, 0x1F,
  0x87, 0xCF, 0xBC, 0x7C, 0x1F, 0x3C, 0xF9, 0xF0, 0x7C, 0xF1, 0xEF, 0xC1,
  0xFB, 0xC7, 0xBE, 0x03, 0xEF, 0x1E, 0xF8, 0x0F, 0xFC, 0x7B, 0xE0, 0x3F,
  0xE1, 0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFF, 0x07,
  0xF9, 0xF8, 0x3F, 0x8F, 0xE3, 0xF8, 0x3F, 0x1F, 0x80, 0xFD, 0xFC, 0x07,
  0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xEF, 0xC0, 0x7F,
  0x3F, 0x07, 0xF1, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0xBF, 0x80, 0xFE,
  0xFC, 0x03, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x0F, 0xC3, 0xF0,
  0x7E, 0x1F, 0x83, 0xE0, 0x7C, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0x80,
  0x7C, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0x3F, 0xC0,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xF0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x3F, 0x8F, 0xF0, 0xFE, 0x0F, 0xC0, 0xFF,
  0x0F, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0x07, 0xF8, 0x7F, 0xC7, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0x80, 0x00, 0x7F, 0x00, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xF4, 0x01, 0xE0,
};

const GFXglyph NotoSans_ExtraBold35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 25, 10, 2, -25 },
  { 20, 13, 9, 18, 2, -25 },
  { 35, 21, 25, 23, 1, -25 },
  { 101, 18, 29, 20, 1, -27 },
  { 167, 30, 25, 32, 1, -25 },
  { 261, 26, 25, 27, 1, -25 },
  { 343, 6, 9, 10, 2, -25 },
  { 350, 10, 31, 12, 1, -25 },
  { 389, 10, 31, 12, 1, -25 },
  { 428, 17, 17, 19, 1, -27 },
  { 465, 17, 17, 20, 2, -21 },
  { 502, 7, 10, 10, 1, -5 },
  { 511, 9, 5, 11, 1, -12 },
  { 517, 6, 6, 10, 2, -6 },
  { 522, 15, 25, 15, 0, -25 },
  { 569, 18, 25, 20, 1, -25 },
  { 626, 13, 25, 20, 2, -25 },
  { 667, 18, 25, 20, 1, -25 },
  { 724, 18, 25, 20, 1, -25 },
  { 781, 19, 25, 20, 1, -25 },
  { 841, 17, 25, 20, 2, -25 },
  { 895, 18, 25, 20, 1, -25 },
  { 952, 18, 25, 20, 1, -25 },
  { 1009, 18, 25, 20, 1, -25 },
  { 1066, 18, 25, 20, 1, -25 },
  { 1123, 6, 20, 10, 2, -20 },
  { 1138, 7, 25, 10, 1, -20 },
  { 1160, 17, 19, 20, 2, -22 },
  { 1201, 17, 11, 20, 2, -18 },
  { 1225, 17, 19, 20, 2, -22 },
  { 1266, 16, 25, 17, 0, -25 },
  { 1316, 28, 28, 31, 2, -25 },
  { 1414, 25, 25, 25, 0, -25 },
  { 1493, 19, 25, 23, 3, -25 },
  { 1553, 19, 25, 23, 2, -25 },
  { 1613, 21, 25, 26, 3, -25 },
  { 1679, 15, 25, 19, 3, -25 },
  { 1726, 14, 25, 19, 3, -25 },
  { 1770, 21, 25, 26, 2, -25 },
  { 1836, 21, 25, 27, 3, -25 },
  { 1902, 12, 25, 14, 1, -25 },
  { 1940, 12, 33, 12, -3, -25 },
  { 1990, 21, 25, 24, 3, -25 },
  { 2056, 16, 25, 20, 3, -25 },
  { 2106, 27, 25, 33, 3, -25 },
  { 2191, 23, 25, 29, 3, -25 },
  { 2263, 24, 25, 28, 2, -25 },
  { 2338, 18, 25, 22, 3, -25 },
  { 2395, 24, 31, 28, 2, -25 },
  { 2488, 21, 25, 23, 3, -25 },
  { 2554, 16, 25, 20, 2, -25 },
  { 2604, 19, 25, 20, 1, -25 },
  { 2664, 21, 25, 26, 3, -25 },
  { 2730, 23, 25, 23, 0, -25 },
  { 2802, 35, 25, 35, 0, -25 },
  { 2912, 24, 25, 24, 0, -25 },
  { 2987, 23, 25, 23, 0, -25 },
  { 3059, 19, 25, 21, 1, -25 },
  { 3119, 9, 31, 11, 2, -25 },
  { 3154, 15, 25, 15, 0, -25 },
  { 3201, 8, 31, 11, 1, -25 },
  { 3232, 19, 16, 19, 0, -25 },
  { 3270, 16, 3, 16, 0, 3 },
  { 3276, 11, 6, 14, 1, -27 },
  { 3285, 18, 20, 21, 1, -20 },
  { 3330, 19, 27, 22, 2, -27 },
  { 3395, 16, 20, 18, 2, -20 },
  { 3435, 18, 27, 22, 2, -27 },
  { 3496, 18, 20, 21, 2, -20 },
  { 3541, 14, 27, 14, 1, -27 },
  { 3589, 18, 28, 22, 2, -20 },
  { 3652, 19, 27, 23, 2, -27 },
  { 3717, 7, 27, 11, 2, -27 },
  { 3741, 11, 35, 11, -2, -27 },
  { 3790, 19, 27, 22, 3, -27 },
  { 3855, 6, 27, 11, 2, -27 },
  { 3876, 30, 20, 35, 2, -20 },
  { 3951, 19, 20, 23, 2, -20 },
  { 3999, 18, 20, 22, 2, -20 },
  { 4044, 19, 28, 22, 2, -20 },
  { 4111, 18, 28, 22, 2, -20 },
  { 4174, 14, 20, 16, 2, -20 },
  { 4209, 14, 20, 18, 2, -20 },
  { 4244, 13, 23, 16, 1, -23 },
  { 4282, 19, 19, 23, 2, -19 },
  { 4328, 21, 19, 21, 0, -19 },
  { 4378, 30, 19, 31, 0, -19 },
  { 4450, 21, 19, 21, 0, -19 },
  { 4500, 21, 27, 21, 0, -19 },
  { 4571, 15, 19, 17, 1, -19 },
  { 4607, 12, 31, 14, 1, -25 },
  { 4654, 4, 35, 19, 7, -27 },
  { 4672, 13, 31, 14, 1, -25 },
  { 4723, 17, 6, 20, 2, -15 },
};

const GFXfont NotoSans_ExtraBold35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold35pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_EXTRABOLD35PT7B_H_
