#ifndef _NOTOSANS_EXTRABOLD71PT7B_H_
#define _NOTOSANS_EXTRABOLD71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold71pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xDF, 0xFF, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9,
  0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE,
  0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x8F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x1F,
  0xE0, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0x7F, 0xF9, 0xFF, 0xE1, 0xFF, 0x01, 0xF0, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xBF, 0xF0, 0x7F, 0xF7, 0xFE, 0x0F,
  0xFE, 0xFF, 0xC1, 0xFF, 0xDF, 0xF8, 0x3F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F,
  0xE0, 0x7F, 0xEF, 0xFC, 0x0F, 0xF9, 0xFF, 0x81, 0xFF, 0x3F, 0xF0, 0x3F,
  0xE7, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF0, 0x1F, 0xF3, 0xFE,
  0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFB, 0xE7, 0xFE, 0x0F, 0xFF, 0x1F, 0x01, 0xF0, 0x7F, 0xF0, 0xF8, 0x01,
  0x87, 0xFF, 0x07, 0xC0, 0x00, 0x3F, 0xF8, 0x3E, 0x00, 0x00, 0xFF, 0xE1,
  0xF0, 0x00, 0x07, 0xFF, 0x8F, 0x80, 0x00, 0x3F, 0xFF, 0x7C, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x01, 0xF3, 0xFF, 0xE0, 0x00, 0x0F, 0x87, 0xFF, 0x00, 0x00, 0x7C,
  0x3F, 0xFC, 0x00, 0x03, 0xE0, 0xFF, 0xEC, 0x00, 0x1F, 0x0F, 0xFE, 0x78,
  0x00, 0xF8, 0x7F, 0xF3, 0xFC, 0x07, 0xC7, 0xFF, 0x9F, 0xFF, 0xBF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x81,
  0xFF, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0xFF,
  0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xF9, 0xFF,
  0xC7, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0x87, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC7,
  0xFE, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xF0, 0xFF, 0xEF, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0x83, 0xFE,
  0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC7, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFE, 0xFF,
  0xFE, 0x1F, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFF, 0xBF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xF7, 0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF,
  0xF7, 0xFE, 0xFF, 0x9F, 0xF3, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x0C, 0x00, 0xFF, 0x00, 0x31, 0xF8, 0x1F, 0xE0, 0x3E, 0x3F, 0xE1, 0xFC,
  0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x38, 0x03, 0x00, 0x00, 0x01, 0x00,
  0x40, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x7F, 0x83, 0xFF,
  0x1F, 0xFE, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFD, 0xFF,
  0xE7, 0xFF, 0x87, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xFE, 0x3F, 0xFE, 0x03,
  0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0x9F, 0xFC,
  0x00, 0x7F, 0xF7, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF7, 0xFF,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0x9F, 0xFE, 0x00, 0xFF, 0xF3,
  0xFF, 0xC0, 0x1F, 0xFE, 0x3F, 0xFC, 0x07, 0xFF, 0x87, 0xFF, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFB,
  0xFF, 0xCF, 0xFF, 0x3F, 0xF1, 0xFF, 0xE3, 0xF8, 0x3F, 0xFC, 0x7E, 0x07,
  0xFF, 0x87, 0x80, 0xFF, 0xF0, 0x60, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0x7C, 0x00,
  0x1F, 0xFE, 0x01, 0xC0, 0x00, 0xFF, 0xF0, 0x08, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0x00, 0x3F, 0xFF, 0x07, 0x00,
  0x03, 0xFF, 0xE0, 0x40, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xEF,
  0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xFC, 0x00,
  0x0F, 0xFC, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0xFF, 0xF0, 0x00, 0x7F, 0xE1,
  0xFF, 0xE0, 0x01, 0xFF, 0x83, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x80,
  0x0F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xF0,
  0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE7, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF6, 0x00, 0x00,
  0x3F, 0xFE, 0xF8, 0x00, 0x0F, 0xFF, 0xDF, 0xF0, 0x07, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x04, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0xFF,
  0xE3, 0xFF, 0xF8, 0x07, 0xFF, 0x3F, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0xFF,
  0xC1, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFE, 0x07, 0xFF, 0xEF, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F, 0xFE, 0x00,
  0x7F, 0xFB, 0xFF, 0xE0, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0x7F,
  0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xFF, 0xBF, 0xFC,
  0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFE,
  0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xDF, 0xFF, 0xE1, 0xFF, 0xF0,
  0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x01, 0xFF, 0xC3,
  0xFF, 0x80, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0x03,
  0xFF, 0x87, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE3, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFC, 0x01, 0xFF,
  0xE3, 0xFF, 0xC0, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xE0,
  0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00,
  0x7F, 0xF3, 0xFF, 0xE0, 0x07, 0xFF, 0x9F, 0xFF, 0x80, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x03, 0xFF,
  0xC7, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0xC0,
  0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF7,
  0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x01,
  0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xFD, 0xFF,
  0xE0, 0x07, 0xFF, 0xEF, 0xFF, 0x80, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xBF, 0xF8,
  0x1F, 0xFF, 0xF9, 0xFF, 0xC0, 0x7F, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0xF8,
  0x7F, 0xF0, 0x00, 0x7C, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x1F,
  0xFE, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFD, 0xFF, 0xE7,
  0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x7F, 0x83, 0xFF,
  0x1F, 0xFE, 0x7F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFD, 0xFF,
  0xE7, 0xFF, 0x87, 0xFC, 0x07, 0xC0, 0x01, 0x80, 0x1F, 0xF0, 0x7F, 0xF1,
  0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x7F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0,
  0xFF, 0xE1, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0xFF, 0x81, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x0F, 0xFF, 0xC7, 0xE0, 0x01, 0xFF,
  0xE1, 0xC0, 0x00, 0x7F, 0xF0, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x87, 0xFC, 0x1F, 0xF0,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xE3, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x81, 0xFE, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0x9F, 0xF0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE7, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x07,
  0xFD, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x7F, 0x83, 0xFF, 0x00,
  0x3F, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8,
  0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x81,
  0xFF, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xBF, 0xE0, 0xFF, 0x80,
  0x1F, 0xF8, 0x1F, 0xEF, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFB, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFE, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0x3F, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xCF, 0xF8, 0x1F, 0xF0,
  0x0F, 0xFE, 0x1F, 0xF3, 0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x8F, 0xF8, 0x7F,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x01, 0xFF,
  0xFF, 0x9F, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x0F,
  0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x2A, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xF1, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xBF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0x00, 0x3F, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xFE,
  0xFF, 0xF0, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x03, 0xFF, 0xEF, 0xFF, 0x00,
  0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF3,
  0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFF, 0x3F, 0xFC, 0x01,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xC0, 0x1F,
  0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xFF, 0xBF, 0xFC, 0x00, 0x3F, 0xFE, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x03,
  0xF8, 0x1F, 0xFF, 0xC0, 0x00, 0x70, 0x3F, 0xFF, 0x80, 0x00, 0x10, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x18, 0x1F, 0xFF, 0xE0, 0x00, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xE3,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0xCF, 0xFF, 0x00, 0x01, 0xFF, 0xFB, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xBF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xEF, 0xFF, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xCF, 0xFF, 0x00,
  0x07, 0xFF, 0xE3, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x00,
  0x3F, 0xFD, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xBF, 0xFE, 0x00, 0x00, 0xFF,
  0xF7, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xCF,
  0xFF, 0xC0, 0x00, 0x7F, 0xF9, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xE1, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0xE3, 0xFF, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x01, 0xFF,
  0xF3, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0xFF,
  0xFC, 0x00, 0x3F, 0xFC, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xCF, 0xFF, 0xC0, 0x00, 0xFF, 0xF3, 0xFF, 0xE0, 0x00, 0x3F,
  0xFD, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x3F,
  0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x8F, 0xFF,
  0x00, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xEF, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xDF, 0xF8, 0x00, 0x1F, 0xF7, 0xFF, 0xFF, 0xDF,
  0xF8, 0x00, 0x1F, 0xF7, 0xFF, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xF7, 0xFF,
  0xFF, 0xCF, 0xF8, 0x00, 0x3F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFC, 0x00, 0x3F,
  0xE7, 0xFF, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xE7, 0xFF, 0xFF, 0xE7, 0xFC,
  0x00, 0x7F, 0xC7, 0xFF, 0xFF, 0xE7, 0xFE, 0x00, 0x7F, 0xC7, 0xFF, 0xFF,
  0xE7, 0xFE, 0x00, 0x7F, 0xC7, 0xFF, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0x87,
  0xFF, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0x00,
  0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0xFF, 0xE1,
  0xFF, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0x81, 0xFF, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0x83, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xC7, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xC7, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xE7, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xE7, 0xFC, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xEF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xEF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF7, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x7F, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFC, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xE3, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFB,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xDF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF7, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFD, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFD, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x1F, 0xFF,
  0xEF, 0xFF, 0x00, 0x7F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0x00,
  0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xEF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0x00,
  0x3F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xEF, 0xFF, 0x07, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xDF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFD, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF7, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFD, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x9F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xCF,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE1,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xFE,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x3F,
  0xFC, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xE3, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0xEF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF7,
  0xFF, 0xC7, 0xFF, 0xC0, 0x07, 0xE1, 0xFF, 0xE0, 0x00, 0x38, 0x7F, 0xF8,
  0x00, 0x02, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xEF, 0xFF,
  0xC0, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00,
  0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF9,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x7F,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF7,
  0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xEF, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x7F,
  0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x3F, 0xF1, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x3F, 0xF0, 0x3F, 0xE1, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0xFF,
  0xC0, 0x7F, 0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xF1, 0xFF, 0x80, 0xFF, 0xC7,
  0xFF, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x00,
  0xFF, 0xE7, 0xFE, 0x01, 0xFF, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xCF, 0xF8,
  0x03, 0xFE, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x9F, 0xF0, 0x07, 0xFC, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF1, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xDF, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xCF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE3, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xBF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x01, 0xFF, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xFC,
  0x07, 0x80, 0x0F, 0xFF, 0x80, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x3F, 0xFB, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xBF, 0xF3, 0xFF, 0xFF, 0xE3, 0xFE, 0x3F, 0xFF,
  0xF8, 0x7F, 0xC3, 0xFF, 0xFE, 0x0F, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x1C,
  0x00, 0x1F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xF1, 0xFF, 0xFC, 0x07, 0xFF,
  0x9F, 0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0xFF, 0xF7,
  0xFF, 0xE0, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x01,
  0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xFF, 0x00, 0x7F, 0xFD, 0xFF,
  0xF8, 0x07, 0xFF, 0xEF, 0xFF, 0xF0, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFB, 0xFF, 0xFF, 0xC1,
  0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0x1F, 0x07, 0xFF, 0xC0, 0x03, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x23, 0xFF, 0xF0, 0x00, 0x70, 0xFF,
  0xFE, 0x01, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x1E, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFF, 0x01,
  0xFF, 0xFC, 0x7F, 0xF8, 0x1F, 0xFF, 0xF3, 0xFF, 0xC1, 0xFF, 0xFF, 0xCF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0x83, 0xFF, 0xFB, 0xFF, 0xF0, 0x07, 0xFF, 0xDF, 0xFF, 0x00,
  0x3F, 0xFE, 0xFF, 0xF8, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0x7F, 0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0xE0, 0x03, 0xFF, 0xDF,
  0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xFC, 0x01, 0xFF, 0xF3, 0xFF, 0xF0, 0x3F,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFD, 0xFF,
  0xC1, 0xFF, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xF0, 0x1F, 0xFF,
  0xC1, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x07, 0xFF,
  0x3F, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x10, 0xFF, 0xFC, 0x00, 0x07, 0x87,
  0xFF, 0xF8, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x80,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFE, 0x07,
  0xFF, 0xFE, 0x7F, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF, 0x87, 0xFF, 0xFF, 0xDF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xC0, 0x7F, 0xFE,
  0xFF, 0xFC, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xFE, 0x00,
  0x3F, 0xFD, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xDF, 0xFE, 0x00,
  0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x07, 0xFF, 0xBF,
  0xFF, 0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0x07, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xFF, 0xF7, 0xFF,
  0x81, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xFE,
  0x0F, 0xFF, 0x00, 0x07, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x98, 0x00, 0x00, 0xFF, 0xFC, 0xF8, 0x00, 0x0F, 0xFF, 0xC7, 0xFF,
  0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x1E, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF,
  0xF1, 0xFF, 0xFE, 0x07, 0xFF, 0x9F, 0xFF, 0xFC, 0x3F, 0xFD, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x06, 0x01, 0xFE, 0x1F, 0xFD,
  0xFF, 0xEF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xF7, 0xFF, 0x8F,
  0xF8, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF7, 0xFF,
  0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE,
  0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x00,
  0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0xFF, 0xF1,
  0xFF, 0xF8, 0x00, 0xFF, 0xF3, 0xFF, 0xF0, 0x00, 0xFF, 0xF3, 0xFF, 0xE0,
  0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0xFF, 0xC1, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFC, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xCF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x8F,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xF7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xE1, 0xFF, 0xE0, 0x07,
  0xFF, 0xC7, 0xFF, 0xC0, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0x0F, 0xFF, 0x9F,
  0xFE, 0x00, 0x0F, 0xFF, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xF8, 0x00,
  0x3F, 0xFD, 0xFF, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0xFF, 0xF7,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x7F, 0xFC, 0x00, 0x1F, 0xFE,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x7F, 0xF9, 0xFF, 0xE0,
  0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x03, 0xFF, 0xE7, 0xFF, 0xC0, 0x07, 0xFF,
  0x87, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xF7, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xFF,
  0x01, 0xFF, 0xC7, 0xFF, 0xFC, 0x0F, 0xFE, 0x7F, 0xFF, 0xF0, 0x7F, 0xF7,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0x81,
  0xFF, 0xFD, 0xFF, 0xF8, 0x07, 0xFF, 0xEF, 0xFF, 0x80, 0x1F, 0xFF, 0x7F,
  0xFC, 0x00, 0x7F, 0xFB, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0xC0, 0x1F,
  0xFF, 0x7F, 0xFE, 0x01, 0xFF, 0xFB, 0xFF, 0xFC, 0x1F, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFB, 0xFF, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xF0, 0x1F,
  0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xFF, 0x07,
  0xFE, 0x07, 0xFF, 0xFE, 0x7F, 0xF0, 0x7F, 0xFF, 0xFB, 0xFF, 0x87, 0xFF,
  0xFF, 0xDF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xC0,
  0x7F, 0xFE, 0xFF, 0xFC, 0x01, 0xFF, 0xF7, 0xFF, 0xC0, 0x07, 0xFF, 0xBF,
  0xFE, 0x00, 0x3F, 0xFD, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xDF,
  0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0xC0, 0x07,
  0xFF, 0xBF, 0xFF, 0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0x07, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xFF,
  0xF7, 0xFF, 0x81, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0xF1, 0xFF, 0xE0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x00, 0x07, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0x9F, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0x7F, 0xE1, 0xFF,
  0xEF, 0xFC, 0x7F, 0xFD, 0xFF, 0x8F, 0xFF, 0xBF, 0xFB, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xC0, 0x1F, 0x8F, 0xFF, 0x00, 0x0E, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x41, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xDF, 0xFE, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80,
  0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC3, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x0F,
  0xFD, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xBF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFC, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x3F, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x87, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0x7F, 0x80, 0xFF, 0xF0,
  0x3F, 0xF8, 0x0F, 0xFB, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0x9F,
  0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0xC0, 0x3F,
  0xF8, 0x3F, 0xE7, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x1F, 0xF0,
  0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xF8, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF8,
  0xFF, 0x87, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xC7, 0xFC, 0x3F, 0xE1, 0xFF,
  0xC0, 0x0F, 0xFE, 0x3F, 0xE1, 0xFF, 0x1F, 0xFC, 0x00, 0x7F, 0xF1, 0xFF,
  0x07, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0x8F, 0xF0, 0x3F, 0xE7, 0xFF, 0x00,
  0x0F, 0xFE, 0x7F, 0x81, 0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xF7, 0xFC, 0x0F,
  0xF9, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xE0, 0x3F, 0xCF, 0xFC, 0x00, 0x0F,
  0xFD, 0xFF, 0x01, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xEF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0x7F, 0x80, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFB,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xCF, 0xFF, 0x80, 0x07, 0xFF, 0xE1, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0x00, 0x03, 0xFF, 0xEF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xEF, 0xFF,
  0x80, 0x01, 0xFF, 0xF1, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x9F, 0xFF, 0x80, 0x03, 0xFF, 0xEF, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xDF, 0xFE, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80,
  0x00, 0x7F, 0xF9, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x23, 0xFF, 0xF8, 0x00, 0x0D, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFB, 0x00, 0x01, 0xFF, 0xFC, 0x40, 0x00, 0x07,
  0xFE, 0x00,
};

const GFXglyph NotoSans_ExtraBold71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 14, 52, 20, 3, -51 },
  { 92, 27, 19, 36, 4, -51 },
  { 157, 44, 51, 46, 1, -51 },
  { 438, 37, 58, 41, 2, -54 },
  { 707, 62, 52, 66, 2, -51 },
  { 1110, 52, 52, 55, 3, -51 },
  { 1448, 11, 19, 20, 4, -51 },
  { 1475, 20, 62, 25, 3, -51 },
  { 1630, 20, 62, 25, 2, -51 },
  { 1785, 35, 34, 38, 2, -54 },
  { 1934, 35, 34, 41, 3, -42 },
  { 2083, 15, 19, 21, 2, -9 },
  { 2119, 19, 10, 23, 2, -24 },
  { 2143, 14, 13, 20, 3, -12 },
  { 2166, 30, 52, 30, 0, -51 },
  { 2361, 35, 52, 41, 3, -51 },
  { 2589, 27, 51, 41, 4, -51 },
  { 2762, 37, 51, 41, 2, -51 },
  { 2998, 35, 52, 41, 3, -51 },
  { 3226, 39, 51, 41, 1, -51 },
  { 3475, 35, 52, 41, 3, -51 },
  { 3703, 37, 52, 41, 2, -51 },
  { 3944, 37, 51, 41, 2, -51 },
  { 4180, 37, 52, 41, 2, -51 },
  { 4421, 37, 52, 41, 2, -51 },
  { 4662, 14, 41, 20, 3, -40 },
  { 4734, 15, 50, 21, 2, -40 },
  { 4828, 35, 38, 41, 3, -45 },
  { 4995, 35, 22, 41, 3, -36 },
  { 5092, 35, 38, 41, 3, -45 },
  { 5259, 33, 52, 35, 0, -51 },
  { 5474, 58, 57, 64, 3, -51 },
  { 5888, 50, 51, 50, 0, -51 },
  { 6207, 38, 51, 48, 6, -51 },
  { 6450, 40, 52, 46, 4, -51 },
  { 6710, 42, 51, 52, 6, -51 },
  { 6978, 30, 51, 39, 6, -51 },
  { 7170, 29, 51, 39, 6, -51 },
  { 7355, 43, 52, 52, 4, -51 },
  { 7635, 42, 51, 54, 6, -51 },
  { 7903, 25, 51, 29, 2, -51 },
  { 8063, 23, 66, 24, -5, -51 },
  { 8253, 42, 51, 48, 6, -51 },
  { 8521, 32, 51, 40, 6, -51 },
  { 8725, 56, 51, 68, 6, -51 },
  { 9082, 46, 51, 58, 6, -51 },
  { 9376, 49, 52, 56, 4, -51 },
  { 9695, 36, 51, 44, 6, -51 },
  { 9925, 49, 63, 56, 4, -51 },
  { 10311, 42, 51, 47, 6, -51 },
  { 10579, 34, 52, 40, 3, -51 },
  { 10800, 38, 51, 41, 2, -51 },
  { 11043, 42, 52, 54, 6, -51 },
  { 11316, 48, 51, 48, 0, -51 },
  { 11622, 71, 51, 71, 0, -51 },
  { 12075, 49, 51, 49, 0, -51 },
  { 12388, 46, 51, 46, 0, -51 },
  { 12682, 38, 51, 42, 2, -51 },
  { 12925, 17, 63, 23, 5, -51 },
  { 13059, 30, 52, 30, 0, -51 },
  { 13254, 17, 63, 23, 2, -51 },
  { 13388, 38, 33, 39, 1, -51 },
  { 13545, 32, 6, 32, 0, 6 },
  { 13569, 22, 11, 28, 3, -54 },
  { 13600, 35, 41, 43, 3, -40 },
  { 13780, 37, 55, 45, 5, -54 },
  { 14035, 33, 41, 37, 3, -40 },
  { 14205, 37, 55, 45, 3, -54 },
  { 14460, 37, 41, 43, 3, -40 },
  { 14650, 30, 54, 28, 1, -54 },
  { 14853, 37, 57, 45, 3, -40 },
  { 15117, 37, 54, 47, 5, -54 },
  { 15367, 13, 55, 22, 5, -55 },
  { 15457, 22, 72, 22, -4, -55 },
  { 15655, 40, 54, 45, 5, -54 },
  { 15925, 12, 54, 22, 5, -54 },
  { 16006, 60, 40, 70, 5, -40 },
  { 16306, 37, 40, 47, 5, -40 },
  { 16491, 39, 41, 45, 3, -40 },
  { 16691, 37, 57, 45, 5, -40 },
  { 16955, 37, 57, 45, 3, -40 },
  { 17219, 27, 40, 32, 5, -40 },
  { 17354, 30, 41, 36, 3, -40 },
  { 17508, 27, 48, 32, 2, -47 },
  { 17670, 37, 40, 47, 5, -39 },
  { 17855, 42, 39, 42, 0, -39 },
  { 18060, 61, 39, 63, 1, -39 },
  { 18358, 42, 39, 43, 0, -39 },
  { 18563, 42, 56, 42, 0, -39 },
  { 18857, 31, 39, 35, 2, -39 },
  { 19009, 25, 63, 29, 2, -51 },
  { 19206, 8, 70, 38, 15, -54 },
  { 19276, 25, 63, 29, 3, -51 },
  { 19473, 35, 12, 41, 3, -31 },
};

const GFXfont NotoSans_ExtraBold71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold71pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_EXTRABOLD71PT7B_H_
