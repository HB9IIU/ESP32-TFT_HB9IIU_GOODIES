#ifndef _NOTOSANS_EXTRABOLD18PT7B_H_
#define _NOTOSANS_EXTRABOLD18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE3, 0xFE, 0xEF, 0xDF, 0xBF, 0x7E, 0xE0, 0x0C,
  0xC1, 0x98, 0x37, 0x06, 0xC7, 0xFE, 0xFF, 0xC6, 0x67, 0xFF, 0xFF, 0xE6,
  0x60, 0xCC, 0x19, 0x83, 0x70, 0x18, 0x0C, 0x1F, 0xFF, 0xED, 0x97, 0xC3,
  0xE0, 0xFC, 0x1F, 0x0D, 0xE6, 0xFF, 0xEF, 0xF0, 0xC0, 0x60, 0x38, 0x38,
  0x7C, 0x30, 0x6E, 0x70, 0xEE, 0x60, 0xEE, 0xE0, 0x6E, 0xDE, 0x7D, 0xBF,
  0x39, 0xB3, 0x03, 0x33, 0x07, 0x33, 0x06, 0x33, 0x0E, 0x3F, 0x0C, 0x1E,
  0x3E, 0x03, 0xF8, 0x1C, 0xE0, 0xE6, 0x07, 0x70, 0x1F, 0x01, 0xF1, 0xDF,
  0xCE, 0xE7, 0xE7, 0x1F, 0x3C, 0xF1, 0xFF, 0xC7, 0xE7, 0x80, 0xFF, 0xFE,
  0x3B, 0x99, 0xCE, 0x73, 0x18, 0xC6, 0x39, 0xCE, 0x31, 0xC7, 0xC7, 0x1C,
  0xE3, 0x18, 0xE7, 0x39, 0xCC, 0xE7, 0x3B, 0x98, 0x0C, 0x06, 0x03, 0x0F,
  0xFF, 0xF8, 0xF0, 0xF8, 0xEE, 0x12, 0x00, 0x18, 0x0C, 0x06, 0x03, 0x0F,
  0xFF, 0xFC, 0x60, 0x30, 0x18, 0x00, 0xFF, 0x60, 0xFF, 0xC0, 0xFF, 0x80,
  0x07, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x70, 0x70, 0x60,
  0xE0, 0x3C, 0x3F, 0xBD, 0xDC, 0xEE, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3,
  0xBD, 0xCF, 0xE3, 0xE0, 0x0E, 0x3D, 0xFF, 0xF6, 0xE9, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE0, 0x3E, 0x7F, 0xBF, 0xC8, 0xE0, 0x70, 0x38, 0x38,
  0x3C, 0x38, 0x38, 0x3F, 0xFF, 0xFF, 0xF8, 0x7E, 0x7F, 0xBB, 0xC0, 0xE0,
  0x71, 0xF0, 0xF8, 0x7E, 0x07, 0x83, 0xE1, 0xDF, 0xEF, 0xE0, 0x03, 0x81,
  0xE0, 0xF8, 0x3E, 0x1B, 0x8E, 0xE7, 0x39, 0x8E, 0xFF, 0xFF, 0xF0, 0x38,
  0x0E, 0x03, 0x80, 0x7F, 0x7F, 0xBF, 0xDC, 0x0E, 0x07, 0xF3, 0xFC, 0x0E,
  0x07, 0x83, 0xF1, 0xDF, 0xEF, 0xE0, 0x1F, 0x1F, 0x9E, 0x5C, 0x0E, 0x06,
  0xFB, 0xFD, 0xC7, 0xE3, 0xF1, 0xFD, 0xEF, 0xE3, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x00,
  0x3E, 0x7F, 0xB9, 0xDC, 0x6F, 0x73, 0xF0, 0xF9, 0xFE, 0xE7, 0xE1, 0xF8,
  0xFF, 0xE7, 0xE0, 0x3C, 0x7F, 0xBD, 0xDC, 0x7E, 0x3F, 0x3F, 0xFE, 0xFF,
  0x33, 0x03, 0x83, 0xDF, 0xCF, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0xFF, 0x60, 0x01, 0x83, 0xC7, 0x8F, 0x0E, 0x07, 0xC0, 0xF8, 0x1F,
  0x01, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x78, 0xF9, 0xF1, 0xE0, 0xC0, 0x00, 0x7E, 0xFF, 0x67, 0x03,
  0x07, 0x0F, 0x1C, 0x18, 0x18, 0x00, 0x18, 0x3C, 0x38, 0x07, 0xC0, 0x7F,
  0xC3, 0x83, 0x98, 0xF7, 0xEF, 0xEF, 0x33, 0xBD, 0xCE, 0xF7, 0x3B, 0xDC,
  0xEF, 0x3F, 0xFE, 0x73, 0x98, 0x00, 0x3C, 0xE0, 0x7F, 0x80, 0x0F, 0x00,
  0x7C, 0x03, 0xE0, 0x3B, 0x01, 0xDC, 0x0E, 0xE0, 0xE3, 0x87, 0x1C, 0x3F,
  0xE3, 0xFF, 0x9C, 0x1C, 0xE0, 0xEF, 0x07, 0x80, 0xFF, 0x3F, 0xEF, 0xFF,
  0xC7, 0xF1, 0xFF, 0xEF, 0xF3, 0xDF, 0xF1, 0xFC, 0x7F, 0x3F, 0xFE, 0xFF,
  0x00, 0x1F, 0x8F, 0xF7, 0xF9, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x3C, 0x07, 0x8C, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xF3, 0xFF, 0x78, 0xFF,
  0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x3F, 0xFF, 0x7F, 0xCF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x0E, 0x1F, 0xFF, 0xFF, 0xE1, 0xC3, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x3F, 0xFF, 0xE1, 0xC3, 0x87, 0x0E, 0x00,
  0x0F, 0xE7, 0xF9, 0xFF, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0xFF, 0x1F, 0xE0,
  0xFE, 0x1D, 0xE3, 0x9F, 0xF1, 0xFE, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xC0, 0xFF,
  0xF7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x3F, 0xFC, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xFF, 0xBE, 0xE0, 0xE1, 0xF8,
  0xEE, 0x73, 0xBC, 0xEE, 0x3F, 0x0F, 0xC3, 0xF8, 0xEE, 0x39, 0xCE, 0x7B,
  0x8E, 0xE3, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3F, 0xFF, 0xFF, 0xF8, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE,
  0x3F, 0xF8, 0xFF, 0x63, 0x7D, 0xCD, 0xF7, 0x77, 0xCD, 0x9F, 0x36, 0x7C,
  0xF9, 0xF1, 0xC7, 0xC7, 0x1C, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3D, 0xC7,
  0xB8, 0xF3, 0x9E, 0x7B, 0xC7, 0x78, 0xFF, 0x0F, 0xE0, 0xFC, 0x1E, 0x1F,
  0x83, 0xFE, 0x7D, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7F, 0x0F, 0x79, 0xE3, 0xFE, 0x1F, 0x80, 0xFE, 0x3F, 0xEF, 0xFB, 0xCF,
  0xF3, 0xFC, 0xEF, 0xFB, 0xFC, 0xFC, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00,
  0x1F, 0x83, 0xFE, 0x7D, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0x0F, 0x79, 0xE3, 0xFE, 0x1F, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0xFE, 0x1F, 0xF3, 0xFE, 0x79, 0xEF, 0x3D, 0xE7, 0x3F, 0xE7, 0xF0, 0xF7,
  0x1E, 0x73, 0xCE, 0x78, 0xEF, 0x1E, 0x3F, 0x7F, 0xF7, 0xE0, 0xF0, 0xF8,
  0x7E, 0x1F, 0x07, 0x07, 0xC7, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xEE, 0x1D, 0xE7, 0xBF, 0xE1, 0xF8, 0xE0, 0x7F, 0x0F, 0x70, 0xE7, 0x0E,
  0x79, 0xE3, 0x9C, 0x39, 0xC3, 0x9C, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF0,
  0x0F, 0x00, 0xE1, 0xE1, 0xF8, 0x78, 0x77, 0x1E, 0x39, 0xC7, 0x8E, 0x73,
  0xF3, 0x9C, 0xFC, 0xE3, 0xB3, 0x70, 0xEC, 0xDC, 0x3B, 0x37, 0x0F, 0xCF,
  0xC1, 0xF3, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x00, 0xF0, 0xF7, 0x8E, 0x39,
  0xE3, 0xDC, 0x1F, 0x80, 0xF8, 0x0F, 0x00, 0xF8, 0x1F, 0x83, 0xDC, 0x39,
  0xE7, 0x0E, 0xF0, 0x70, 0xF0, 0xF7, 0x0E, 0x71, 0xC3, 0x9C, 0x3B, 0x81,
  0xF8, 0x1F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x7F, 0xDF, 0xF7, 0xFC, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x3C, 0x0E,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xFF, 0xE0, 0x60, 0x70, 0x70, 0x30, 0x38, 0x38, 0x1C, 0x1C, 0x0C, 0x0E,
  0x0E, 0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9F, 0xFF,
  0x0C, 0x07, 0x01, 0xE0, 0xF8, 0x37, 0x0C, 0xC6, 0x39, 0x86, 0xC1, 0xC0,
  0xFF, 0xFF, 0xE3, 0x8E, 0x7E, 0x3F, 0x91, 0xE0, 0x77, 0xFF, 0xFF, 0x8F,
  0xCF, 0xFF, 0xBD, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xEF, 0x3F, 0xEF,
  0x3B, 0x8F, 0xE1, 0xF8, 0x7E, 0x3F, 0xCE, 0xFF, 0xBB, 0xC0, 0x3F, 0x7F,
  0xF2, 0xE0, 0xE0, 0xE0, 0xE0, 0xF3, 0x7F, 0x3E, 0x03, 0x81, 0xC0, 0xE0,
  0x73, 0xBB, 0xFF, 0xDF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFE, 0x77, 0xFB, 0xCC,
  0x3E, 0x3F, 0xBC, 0xFC, 0x7F, 0xFF, 0xFF, 0x81, 0xE1, 0x7F, 0x9F, 0x80,
  0x0E, 0x3F, 0x3E, 0x38, 0x7E, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x39, 0xBF, 0xFD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xE7, 0x7F,
  0xBF, 0xC0, 0xF0, 0x7F, 0xFF, 0xF8, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xEF,
  0x3F, 0xEF, 0x3F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70,
  0x7F, 0x8F, 0xFF, 0xFF, 0xFF, 0xC0, 0x19, 0xCE, 0x03, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE1,
  0xF8, 0xEE, 0x73, 0xB8, 0xFE, 0x3F, 0x8F, 0x73, 0x9E, 0xE3, 0xB8, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xEF, 0x3C, 0xFF, 0xFE, 0xF3, 0xCE,
  0xF3, 0xCF, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F, 0xE3, 0x8F,
  0xE3, 0x8F, 0xEF, 0x3F, 0xEF, 0x3F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x70, 0x3E, 0x1F, 0xCF, 0x3B, 0x8E, 0xE3, 0xF8, 0xFE, 0x3B,
  0xCE, 0x7F, 0x8F, 0x80, 0xEF, 0x3F, 0xEF, 0x3B, 0x8F, 0xE1, 0xF8, 0x7E,
  0x3F, 0xCE, 0xFF, 0xBB, 0xCE, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x39, 0xBF,
  0xFD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xE7, 0x7F, 0xBD, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0xEF, 0xFF, 0xFF, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x7F,
  0xFF, 0x8F, 0x8F, 0xC7, 0xC3, 0xC7, 0xFF, 0xF8, 0x18, 0x71, 0xFF, 0xF3,
  0x87, 0x0E, 0x1C, 0x38, 0x74, 0xF8, 0xF0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x3F, 0xCF, 0x7F, 0xDF, 0x70, 0xE1, 0xEE, 0x39, 0xC7,
  0x39, 0xC3, 0xB8, 0x77, 0x0F, 0xC0, 0xF8, 0x1E, 0x01, 0xC0, 0xE3, 0xC7,
  0x73, 0xCE, 0x73, 0xCE, 0x77, 0xCE, 0x76, 0xEC, 0x36, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x1E, 0x78, 0x1C, 0x78, 0xF1, 0xEE, 0x78, 0xEE, 0x1F, 0x81,
  0xF0, 0x3E, 0x0F, 0xC1, 0xDC, 0x73, 0xDE, 0x3C, 0xE1, 0xEE, 0x39, 0xC7,
  0x39, 0xC3, 0xB8, 0x77, 0x07, 0xC0, 0xF8, 0x1E, 0x01, 0xC0, 0x38, 0x0E,
  0x07, 0xC0, 0xF0, 0x00, 0x7F, 0x7F, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x70,
  0xFF, 0xFF, 0x0E, 0x3C, 0x70, 0xC1, 0x83, 0x0E, 0x78, 0xF0, 0x70, 0x60,
  0xC1, 0x83, 0x87, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xC7, 0x1C,
  0x71, 0xC7, 0x0F, 0x3D, 0xC7, 0x1C, 0x71, 0xCF, 0x38, 0xF0, 0xFF, 0xE7,
  0xC0,
};

const GFXglyph NotoSans_ExtraBold18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 7, 5, 9, 1, -13 },
  { 11, 11, 13, 12, 0, -13 },
  { 29, 9, 15, 10, 1, -14 },
  { 46, 16, 13, 17, 0, -13 },
  { 72, 13, 13, 14, 1, -13 },
  { 94, 3, 5, 5, 1, -13 },
  { 96, 5, 16, 6, 1, -13 },
  { 106, 5, 16, 6, 1, -13 },
  { 116, 9, 9, 10, 0, -14 },
  { 127, 9, 9, 10, 1, -11 },
  { 138, 3, 4, 5, 1, -2 },
  { 140, 5, 2, 6, 0, -6 },
  { 142, 3, 3, 5, 1, -3 },
  { 144, 8, 13, 8, 0, -13 },
  { 157, 9, 13, 10, 1, -13 },
  { 172, 7, 13, 10, 1, -13 },
  { 184, 9, 13, 10, 1, -13 },
  { 199, 9, 13, 10, 1, -13 },
  { 214, 10, 13, 10, 0, -13 },
  { 231, 9, 13, 10, 1, -13 },
  { 246, 9, 13, 10, 1, -13 },
  { 261, 9, 13, 10, 1, -13 },
  { 276, 9, 13, 10, 1, -13 },
  { 291, 9, 13, 10, 1, -13 },
  { 306, 3, 10, 5, 1, -10 },
  { 310, 3, 12, 5, 1, -10 },
  { 315, 9, 9, 10, 1, -11 },
  { 326, 9, 6, 10, 1, -9 },
  { 333, 9, 9, 10, 1, -11 },
  { 344, 8, 13, 9, 0, -13 },
  { 357, 14, 14, 16, 1, -13 },
  { 382, 13, 13, 13, 0, -13 },
  { 404, 10, 13, 12, 1, -13 },
  { 421, 10, 13, 12, 1, -13 },
  { 438, 11, 13, 13, 1, -13 },
  { 456, 7, 13, 10, 2, -13 },
  { 468, 7, 13, 10, 2, -13 },
  { 480, 11, 13, 13, 1, -13 },
  { 498, 10, 13, 14, 2, -13 },
  { 515, 6, 13, 7, 1, -13 },
  { 525, 6, 17, 6, -1, -13 },
  { 538, 10, 13, 12, 2, -13 },
  { 555, 9, 13, 10, 1, -13 },
  { 570, 14, 13, 17, 2, -13 },
  { 593, 11, 13, 15, 2, -13 },
  { 611, 12, 13, 14, 1, -13 },
  { 631, 10, 13, 11, 1, -13 },
  { 648, 12, 16, 14, 1, -13 },
  { 672, 11, 13, 12, 1, -13 },
  { 690, 8, 13, 10, 1, -13 },
  { 703, 10, 13, 11, 0, -13 },
  { 720, 11, 13, 14, 1, -13 },
  { 738, 12, 13, 12, 0, -13 },
  { 758, 18, 13, 18, 0, -13 },
  { 788, 12, 13, 12, 0, -13 },
  { 808, 12, 13, 12, 0, -13 },
  { 828, 10, 13, 11, 0, -13 },
  { 845, 4, 16, 6, 1, -13 },
  { 853, 8, 13, 8, 0, -13 },
  { 866, 5, 16, 6, 0, -13 },
  { 876, 10, 9, 10, 0, -13 },
  { 888, 8, 2, 8, 0, 1 },
  { 890, 5, 3, 7, 1, -14 },
  { 892, 9, 10, 11, 1, -10 },
  { 904, 10, 14, 11, 1, -14 },
  { 922, 8, 10, 9, 1, -10 },
  { 932, 9, 14, 11, 1, -14 },
  { 948, 9, 10, 11, 1, -10 },
  { 960, 8, 14, 7, 0, -14 },
  { 974, 9, 14, 11, 1, -10 },
  { 990, 10, 14, 12, 1, -14 },
  { 1008, 3, 14, 6, 1, -14 },
  { 1014, 5, 18, 6, -1, -14 },
  { 1026, 10, 14, 11, 1, -14 },
  { 1044, 3, 14, 6, 1, -14 },
  { 1050, 16, 10, 18, 1, -10 },
  { 1070, 10, 10, 12, 1, -10 },
  { 1083, 10, 10, 11, 1, -10 },
  { 1096, 10, 14, 11, 1, -10 },
  { 1114, 9, 14, 11, 1, -10 },
  { 1130, 7, 10, 8, 1, -10 },
  { 1139, 7, 10, 9, 1, -10 },
  { 1148, 7, 12, 8, 0, -12 },
  { 1159, 10, 10, 12, 1, -10 },
  { 1172, 11, 10, 11, 0, -10 },
  { 1186, 16, 10, 16, 0, -10 },
  { 1206, 11, 10, 11, 0, -10 },
  { 1220, 11, 14, 11, 0, -10 },
  { 1240, 8, 10, 9, 0, -10 },
  { 1250, 7, 16, 7, 0, -13 },
  { 1264, 2, 18, 10, 4, -14 },
  { 1269, 6, 16, 7, 1, -13 },
  { 1281, 9, 3, 10, 1, -8 },
};

const GFXfont NotoSans_ExtraBold18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold18pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_EXTRABOLD18PT7B_H_
