#ifndef _NOTOSANS_EXTRABOLD38PT7B_H_
#define _NOTOSANS_EXTRABOLD38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x00, 0x00, 0x0F, 0xBF, 0xFF, 0xFF, 0xFD,
  0xF0, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x8F,
  0x9F, 0x1F, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF8, 0x00, 0xF0, 0xF0, 0x03,
  0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0xF8, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x7C, 0x7C, 0x00, 0xF8, 0xF8,
  0x01, 0xF1, 0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xF0, 0xF0, 0x01, 0xE3, 0xE0, 0x03,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0xFE, 0xE1,
  0xCF, 0xCE, 0x00, 0xFC, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0E, 0x7F, 0x00, 0xE3, 0xF4, 0x0E, 0x3F, 0x7C, 0xE7, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x3F, 0x80,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x03, 0xE0, 0x0F, 0xF8, 0x01, 0xF0, 0x0F, 0xFE, 0x01, 0xF0,
  0x07, 0xFF, 0x81, 0xF0, 0x07, 0xC7, 0xC0, 0xF8, 0x03, 0xE3, 0xE0, 0xF8,
  0x01, 0xF1, 0xF0, 0x7C, 0x00, 0xF8, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x3E,
  0x00, 0x3E, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x1F, 0x0E, 0x0F, 0x8F, 0x9F,
  0x3F, 0xC3, 0xFF, 0xDF, 0x3F, 0xF1, 0xFF, 0xCF, 0x9F, 0xFC, 0x7F, 0xCF,
  0x9F, 0xBE, 0x1F, 0xC7, 0xCF, 0x8F, 0x81, 0x07, 0xC7, 0xC7, 0xC0, 0x03,
  0xE3, 0xE3, 0xE0, 0x03, 0xE1, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0xF8, 0x01,
  0xF0, 0x7C, 0x7C, 0x01, 0xF0, 0x3E, 0x3E, 0x00, 0xF8, 0x1F, 0x1F, 0x00,
  0xF8, 0x07, 0xFF, 0x00, 0x7C, 0x03, 0xFF, 0x80, 0x7C, 0x00, 0xFF, 0x80,
  0x7E, 0x00, 0x3F, 0x80, 0x00, 0x30, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFC, 0x7E,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xFC, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0xFE, 0x1F, 0xFC, 0x0F, 0xE3, 0xFF, 0xE0, 0xFC,
  0x7F, 0xFF, 0x9F, 0xC7, 0xF3, 0xFD, 0xFC, 0x7E, 0x1F, 0xFF, 0x8F, 0xE0,
  0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x03, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xDF, 0xE0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF0, 0x07, 0xE1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0, 0x7E,
  0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0xC3, 0xC1,
  0xBF, 0x7B, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0x7C, 0x07, 0xCF, 0xC1, 0xF8, 0xF8,
  0x0E, 0x1E, 0x00, 0x41, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x0F, 0xC7, 0xF0,
  0xFE, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xEF, 0xE0, 0x7E, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xF7,
  0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xF0, 0xFE,
  0x3F, 0x0F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0xF1, 0xFF,
  0xE7, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0x7C, 0xFE, 0x71, 0xFC, 0x43, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x20, 0x00, 0x7F, 0xE0, 0x1F,
  0xFF, 0x07, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3E, 0x0F, 0xE1,
  0x80, 0xFE, 0x10, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x40, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x86, 0x03, 0xF8, 0x80, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x7D, 0xF8,
  0x0F, 0x9F, 0x81, 0xF9, 0xF8, 0x1F, 0x1F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xC1, 0xF8, 0xF8, 0x1F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xB0, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF, 0xFF,
  0xBF, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x87, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x7C, 0xFF, 0x87,
  0xDF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x8F, 0xEF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07,
  0xE7, 0xF0, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0x9F,
  0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x3F, 0x0F, 0xC3, 0xF9,
  0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0x1F, 0xE7, 0xE0, 0x7E, 0xFC, 0x07, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0x7F, 0x9F, 0xE7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xF0, 0xFE, 0xFE,
  0x07, 0xEF, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0x7F, 0x1F, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xBE,
  0x1F, 0xF3, 0xE0, 0x3C, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x03, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x3E,
  0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0xF8,
  0xF8, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x40, 0x07, 0xFF, 0x07, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF,
  0x9F, 0xFF, 0xF3, 0x81, 0xFC, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x7E,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x8F, 0x83, 0xFF, 0x1E, 0x7C, 0x3F,
  0xFE, 0x7D, 0xF1, 0xFF, 0xF9, 0xFF, 0x8F, 0xE3, 0xE3, 0xFE, 0x3E, 0x0F,
  0x8F, 0xF9, 0xF0, 0x3E, 0x3F, 0xC7, 0xC0, 0xF0, 0xFF, 0x1F, 0x03, 0xC3,
  0xFC, 0x7C, 0x0F, 0x0F, 0xF1, 0xF0, 0x7C, 0x3F, 0xC7, 0xC1, 0xF1, 0xFF,
  0x0F, 0x8F, 0xE7, 0xBE, 0x3F, 0xFF, 0xFE, 0xF8, 0x7F, 0xFF, 0xF1, 0xE0,
  0xFF, 0x3F, 0x87, 0xC0, 0xF0, 0x38, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0x00, 0x7F, 0x0F,
  0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x07, 0xFB, 0xF8, 0x1F, 0xDF,
  0xC0, 0xFE, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0x3F, 0x8F, 0xF9, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xC3, 0xFE, 0xFE,
  0x07, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7F,
  0x7F, 0x07, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x01, 0xCF, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x04, 0xFF, 0x81, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0xC1, 0xFF, 0x3F,
  0x80, 0xFF, 0x7F, 0x00, 0xFE, 0xFE, 0x01, 0xFD, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x07,
  0xF7, 0xF0, 0x1F, 0xEF, 0xE0, 0x7F, 0x9F, 0xC7, 0xFF, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x02, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xF8, 0x06, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x01, 0xFB, 0xF8, 0x03, 0xF7, 0xF0, 0x07,
  0xEF, 0xF0, 0x0F, 0xCF, 0xF8, 0x1F, 0x9F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFE, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xFB,
  0xFF, 0xDF, 0xFC, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x1F, 0xC3,
  0xF8, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x7F, 0x01, 0xFD, 0xFC,
  0x03, 0xFB, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0x7F, 0x01, 0xFC, 0x7F, 0x03,
  0xF8, 0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F,
  0x81, 0xFC, 0x7F, 0x03, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xFB, 0xF8,
  0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF7, 0xC0,
  0xFB, 0xFF, 0xDF, 0x03, 0xEF, 0xFF, 0x7C, 0x0F, 0xBF, 0xFC, 0xF8, 0x7C,
  0xFF, 0xF3, 0xE1, 0xF3, 0xFF, 0xCF, 0x87, 0xCF, 0xFF, 0x3F, 0x3E, 0x3F,
  0xFC, 0x7C, 0xF8, 0xFF, 0xF1, 0xF3, 0xE3, 0xFF, 0xC7, 0xEF, 0x8F, 0xFF,
  0x0F, 0xFC, 0x3F, 0xFC, 0x3F, 0xF0, 0xFF, 0xF0, 0xFF, 0xC3, 0xFF, 0xC3,
  0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x3F, 0xFC, 0x1F, 0xE0, 0xFF, 0xF0, 0x7F,
  0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xC0, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFD, 0xF8, 0x1F, 0xFE, 0xFE,
  0x0F, 0xFF, 0x3F, 0x07, 0xFF, 0x9F, 0xC3, 0xFF, 0xC7, 0xF1, 0xFF, 0xE3,
  0xF8, 0xFF, 0xF0, 0xFE, 0x7F, 0xF8, 0x7F, 0x3F, 0xFC, 0x1F, 0xDF, 0xFE,
  0x0F, 0xEF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFC, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0xFF,
  0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x1F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFC, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x7F, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0xFF,
  0x7F, 0x00, 0x3F, 0x9F, 0xE0, 0x1F, 0xE3, 0xFE, 0x1F, 0xF0, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xC1, 0xFC, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xE1,
  0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x87, 0xF0, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFC,
  0x7E, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1,
  0xFC, 0x3F, 0x83, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x03, 0xF9, 0xFC, 0x07,
  0xFB, 0xF8, 0x07, 0xF8, 0x00, 0x40, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xE0, 0x73, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xEF, 0xF0, 0x1F, 0xCF, 0xF0, 0x7F, 0x9F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x3F,
  0xBF, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x0F, 0xE3, 0xF0, 0x07,
  0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x80,
  0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x3F, 0x80, 0xFE,
  0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xE7, 0xE0, 0x03,
  0xF3, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x3E, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0xE0, 0x1F,
  0x9F, 0x80, 0x7F, 0x80, 0x7E, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0xFC, 0x07,
  0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0xF0, 0x3F, 0x0F, 0xC0, 0xFF, 0xC0, 0xFC,
  0x3F, 0x83, 0xFF, 0x07, 0xF0, 0x7E, 0x0F, 0xFC, 0x1F, 0x81, 0xF8, 0x7C,
  0xF8, 0x7E, 0x07, 0xE1, 0xF3, 0xE1, 0xF8, 0x1F, 0x87, 0xCF, 0x87, 0xE0,
  0x3F, 0x1F, 0x3E, 0x3F, 0x00, 0xFC, 0xFC, 0xFC, 0xFC, 0x03, 0xF3, 0xE1,
  0xF3, 0xF0, 0x0F, 0xCF, 0x87, 0xCF, 0xC0, 0x1F, 0xBE, 0x1F, 0x7E, 0x00,
  0x7E, 0xF8, 0x7D, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xCF, 0xE0,
  0x1F, 0xE3, 0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0xFE, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xCF, 0xE0,
  0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x01,
  0xFC, 0x3F, 0x80, 0x7F, 0x9F, 0xC0, 0x0F, 0xEF, 0xF0, 0x03, 0xFC, 0xFE,
  0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFC, 0x3F,
  0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xE3, 0xF0, 0x07,
  0xE7, 0xF0, 0x07, 0xF7, 0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xF3, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x78, 0x03,
  0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0xF0, 0x0F,
  0x8F, 0x80, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0x9F, 0xE0, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xFF, 0xF1,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0x07, 0xFF, 0xE0, 0x7F,
  0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0x7F, 0x1F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF3, 0xFF, 0xBF, 0x1F, 0xE1, 0xF0, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x7E, 0x0F, 0xDF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xE1, 0xFE, 0xFE, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x07,
  0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0,
  0x7E, 0xFE, 0x0F, 0xEF, 0xF1, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0x9F, 0xF8, 0xF8, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0xC7,
  0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0xF3, 0xF8, 0x13, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xFE, 0x06, 0x7F, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3,
  0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x0F, 0xE7, 0xF1, 0xFF, 0x7F, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1,
  0xFF, 0x3F, 0x0F, 0xE3, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE7, 0xF9, 0xFC, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x02, 0x7F, 0xC7, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFD, 0x07, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xE3, 0xF1, 0xFF, 0x3F, 0x3F, 0xFB,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xE8, 0x00, 0x7E, 0x70, 0x1F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x7F, 0x0F, 0xDF, 0xF8, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7F,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07,
  0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xF0, 0x7C, 0xFF, 0xFB,
  0xF7, 0xE7, 0x80, 0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xE0, 0x07,
  0xC0, 0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xEF, 0xF9, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0xBF, 0x03, 0xF9, 0xF8, 0x3F, 0x8F,
  0xC3, 0xF8, 0x7E, 0x3F, 0x83, 0xF3, 0xF8, 0x1F, 0xBF, 0x80, 0xFD, 0xF8,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F,
  0xBF, 0x83, 0xF8, 0xFE, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F,
  0x3F, 0x03, 0xF9, 0xF8, 0x0F, 0xEF, 0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0xFF, 0x07, 0xF0, 0xF9,
  0xFF, 0x8F, 0xFC, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0xFE,
  0x0F, 0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x7F, 0xFC,
  0x07, 0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x7F, 0xFC,
  0x07, 0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x7F, 0xFC,
  0x07, 0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x7F, 0xFC,
  0x07, 0xE0, 0x7F, 0xFC, 0x07, 0xE0, 0x7F, 0xF8, 0xFF, 0x0F, 0x9F, 0xF8,
  0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xF0, 0xFE, 0xFE, 0x07,
  0xEF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE7, 0xF0, 0xFE, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xF7, 0xF0, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x7E, 0x0F, 0x9F, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0xE1, 0xFE, 0xFE, 0x0F, 0xEF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xFF, 0xC0, 0x7E, 0xFC,
  0x07, 0xEF, 0xC0, 0x7E, 0xFE, 0x0F, 0xEF, 0xE1, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xDF, 0xF0, 0xFC, 0xFE, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE3, 0xF1, 0xFF,
  0x3F, 0x3F, 0xFB, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0x7F, 0x0F, 0xE7,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF8,
  0x7F, 0xE7, 0xFF, 0xBF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xF0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFC, 0x3C, 0xFC, 0x04,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0xC7,
  0xFF, 0x87, 0xFF, 0x07, 0xFC, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xEF, 0x9F, 0xF9, 0xF1, 0xFE, 0x3E, 0xFE, 0x00, 0xFD, 0xF8, 0x07,
  0xF7, 0xE0, 0x1F, 0x9F, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3,
  0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0xFC,
  0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xBF, 0x03, 0xFC,
  0x1F, 0xDF, 0x81, 0xFE, 0x0F, 0xCF, 0xE1, 0xFF, 0x07, 0xE3, 0xF0, 0xFF,
  0x83, 0xF1, 0xF8, 0x7F, 0xE3, 0xF8, 0xFC, 0x3D, 0xF1, 0xF8, 0x7F, 0x3E,
  0xF8, 0xFC, 0x1F, 0x9F, 0x7C, 0x7E, 0x0F, 0xCF, 0x9E, 0x7E, 0x07, 0xE7,
  0x8F, 0xBF, 0x01, 0xF3, 0xC7, 0xDF, 0x80, 0xFB, 0xE3, 0xEF, 0xC0, 0x7F,
  0xF0, 0xF7, 0xC0, 0x3F, 0xF8, 0x7B, 0xE0, 0x0F, 0xF8, 0x3D, 0xF0, 0x07,
  0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0xFF,
  0x07, 0xF8, 0xFE, 0x0F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xFD,
  0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8,
  0x03, 0xFB, 0xF0, 0x07, 0xF7, 0xF0, 0x1F, 0xC7, 0xF0, 0x7F, 0x8F, 0xE0,
  0xFE, 0x0F, 0xE3, 0xF8, 0x0F, 0xEF, 0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0xFD,
  0xF8, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x3F, 0x1F,
  0x80, 0xFC, 0x7E, 0x01, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x80, 0xFC, 0x0F, 0xE3, 0xFE, 0x1F, 0xE0, 0xFC, 0x07, 0xF8, 0x3F, 0xE0,
  0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0x00, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x3F,
  0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF, 0xC0, 0xFF, 0x00, 0xFC,
  0x1F, 0xF0, 0xFF, 0xC3, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF8,
  0x3F, 0xC0, 0xFC, 0x00, 0x1E, 0x00, 0x5F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xF8, 0x03, 0xF0,
};

const GFXglyph NotoSans_ExtraBold38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 7, 27, 11, 2, -27 },
  { 25, 15, 10, 19, 2, -27 },
  { 44, 23, 27, 25, 1, -27 },
  { 122, 20, 31, 22, 1, -29 },
  { 200, 33, 28, 35, 1, -28 },
  { 316, 28, 28, 29, 1, -28 },
  { 414, 6, 10, 11, 2, -27 },
  { 422, 11, 33, 13, 1, -27 },
  { 468, 11, 33, 13, 1, -27 },
  { 514, 19, 18, 21, 1, -29 },
  { 557, 18, 19, 22, 2, -23 },
  { 600, 8, 10, 11, 1, -5 },
  { 610, 10, 5, 12, 1, -13 },
  { 617, 7, 6, 11, 2, -6 },
  { 623, 16, 27, 16, 0, -27 },
  { 677, 20, 28, 22, 1, -28 },
  { 747, 15, 27, 22, 2, -27 },
  { 798, 20, 28, 22, 1, -28 },
  { 868, 19, 28, 22, 1, -28 },
  { 935, 20, 27, 22, 1, -27 },
  { 1003, 18, 27, 22, 2, -27 },
  { 1064, 20, 27, 22, 1, -27 },
  { 1132, 20, 27, 22, 1, -27 },
  { 1200, 20, 27, 22, 1, -27 },
  { 1268, 20, 27, 22, 1, -27 },
  { 1336, 7, 21, 11, 2, -21 },
  { 1355, 8, 26, 11, 1, -21 },
  { 1381, 18, 20, 22, 2, -24 },
  { 1426, 18, 13, 22, 2, -20 },
  { 1456, 18, 20, 22, 2, -24 },
  { 1501, 18, 28, 19, 0, -28 },
  { 1564, 30, 30, 34, 2, -27 },
  { 1677, 27, 27, 27, 0, -27 },
  { 1769, 21, 27, 25, 3, -27 },
  { 1840, 21, 28, 25, 2, -28 },
  { 1914, 23, 27, 28, 3, -27 },
  { 1992, 16, 27, 21, 3, -27 },
  { 2046, 16, 27, 21, 3, -27 },
  { 2100, 23, 28, 28, 2, -28 },
  { 2181, 23, 27, 29, 3, -27 },
  { 2259, 13, 27, 16, 1, -27 },
  { 2303, 13, 35, 13, -3, -27 },
  { 2360, 23, 27, 26, 3, -27 },
  { 2438, 17, 27, 22, 3, -27 },
  { 2496, 30, 27, 36, 3, -27 },
  { 2598, 25, 27, 31, 3, -27 },
  { 2683, 26, 28, 30, 2, -28 },
  { 2774, 19, 27, 24, 3, -27 },
  { 2839, 26, 34, 30, 2, -28 },
  { 2950, 23, 27, 25, 3, -27 },
  { 3028, 18, 28, 21, 2, -28 },
  { 3091, 20, 27, 22, 1, -27 },
  { 3159, 23, 27, 29, 3, -27 },
  { 3237, 25, 27, 25, 0, -27 },
  { 3322, 38, 27, 38, 0, -27 },
  { 3451, 26, 27, 26, 0, -27 },
  { 3539, 24, 27, 24, 0, -27 },
  { 3620, 21, 27, 23, 1, -27 },
  { 3691, 10, 33, 12, 2, -27 },
  { 3733, 16, 27, 16, 0, -27 },
  { 3787, 9, 33, 12, 1, -27 },
  { 3825, 21, 18, 21, 0, -27 },
  { 3873, 17, 3, 17, 0, 3 },
  { 3880, 11, 6, 15, 2, -29 },
  { 3889, 20, 21, 23, 1, -21 },
  { 3942, 20, 29, 24, 3, -29 },
  { 4015, 17, 21, 20, 2, -21 },
  { 4060, 20, 29, 24, 2, -29 },
  { 4133, 19, 21, 23, 2, -21 },
  { 4183, 16, 29, 15, 1, -29 },
  { 4241, 20, 30, 24, 2, -21 },
  { 4316, 20, 29, 25, 3, -29 },
  { 4389, 7, 29, 12, 2, -29 },
  { 4415, 11, 38, 12, -2, -29 },
  { 4468, 21, 29, 24, 3, -29 },
  { 4545, 6, 29, 12, 3, -29 },
  { 4567, 32, 21, 37, 3, -21 },
  { 4651, 20, 21, 25, 3, -21 },
  { 4704, 20, 21, 24, 2, -21 },
  { 4757, 20, 30, 24, 3, -21 },
  { 4832, 20, 30, 24, 2, -21 },
  { 4907, 14, 21, 17, 3, -21 },
  { 4944, 16, 21, 19, 2, -21 },
  { 4986, 15, 25, 17, 1, -25 },
  { 5033, 19, 21, 25, 3, -21 },
  { 5083, 22, 21, 22, 0, -21 },
  { 5141, 33, 21, 33, 0, -21 },
  { 5228, 23, 21, 23, 0, -21 },
  { 5289, 22, 30, 22, 0, -21 },
  { 5372, 17, 21, 19, 1, -21 },
  { 5417, 13, 33, 16, 1, -27 },
  { 5471, 4, 37, 20, 8, -29 },
  { 5490, 14, 33, 16, 1, -27 },
  { 5548, 18, 7, 22, 2, -17 },
};

const GFXfont NotoSans_ExtraBold38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold38pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_EXTRABOLD38PT7B_H_
