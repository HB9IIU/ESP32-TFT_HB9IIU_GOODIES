#ifndef _NOTOSANS_EXTRABOLD27PT7B_H_
#define _NOTOSANS_EXTRABOLD27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x0F, 0xFF,
  0xDE, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xB8, 0xEE, 0x38, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x0F, 0x38, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x70, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x3C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x39, 0xE0, 0x39, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x78, 0x0F, 0xFE, 0x7F, 0xFB, 0xFF, 0xEF, 0x31,
  0x3C, 0xC0, 0xFB, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F,
  0xE0, 0x37, 0xE0, 0xDF, 0xF3, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x08, 0x00, 0x20, 0xFC, 0x03, 0x81, 0xFC,
  0x0F, 0x07, 0xBC, 0x3C, 0x0E, 0x78, 0x70, 0x1C, 0x71, 0xE0, 0x38, 0xE3,
  0x80, 0x71, 0xCF, 0x00, 0xE7, 0x9C, 0xF1, 0xEF, 0x7B, 0xF9, 0xFC, 0xEF,
  0xF3, 0xF3, 0xDE, 0xF0, 0x8F, 0x38, 0xE0, 0x1C, 0x71, 0xC0, 0x78, 0xE3,
  0x80, 0xE1, 0xC7, 0x03, 0xC3, 0xDE, 0x07, 0x07, 0xFC, 0x1E, 0x07, 0xF0,
  0x78, 0x07, 0xC0, 0x01, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFC, 0x3E, 0x3F, 0xC3, 0xE7, 0xFE, 0x3C, 0xFD, 0xF7, 0xCF,
  0x8F, 0xFC, 0xF8, 0x7F, 0x8F, 0x83, 0xF0, 0xFE, 0xFF, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC1, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0xE0, 0x0F, 0x1E, 0x3C,
  0x3C, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x1C, 0x1F, 0xF1, 0xE1, 0xE1,
  0xC3, 0xC7, 0x87, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x0C, 0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0xFE, 0x0F, 0x78,
  0xF3, 0xC1, 0x8C, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x00, 0x7B, 0xDE, 0xFF, 0x7B, 0xDC, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFE, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0,
  0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x00, 0x02, 0x00, 0x7F, 0x83, 0xFF, 0x1F,
  0xFC, 0x7C, 0xFB, 0xE1, 0xEF, 0x87, 0xBE, 0x1E, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xEF, 0x87, 0x9E, 0x3E, 0x7D, 0xF8,
  0xFF, 0xC3, 0xFE, 0x03, 0xF0, 0x03, 0xE0, 0xFC, 0x7F, 0x9F, 0xFF, 0xFE,
  0xF7, 0xCC, 0xF9, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x01, 0x00, 0xFF, 0x87,
  0xFF, 0x3F, 0xFE, 0x79, 0xF8, 0x81, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0xFF, 0x8F, 0xFF,
  0x1F, 0xFE, 0x71, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x1F, 0xE0, 0x7F,
  0x01, 0xFE, 0x07, 0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xE0, 0x3E, 0xF3,
  0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0xC0, 0x7F, 0x80, 0xEF, 0x03, 0xFE, 0x0F, 0x7C, 0x1E, 0xF8, 0x79,
  0xF1, 0xE3, 0xE3, 0xC7, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF,
  0xE7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xFC, 0x7F, 0xF3, 0xFF, 0xC8, 0x7E,
  0x01, 0xF0, 0x07, 0x80, 0x3E, 0x03, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0x1F,
  0xF0, 0x00, 0x60, 0x1F, 0xC1, 0xFF, 0x0F, 0xFC, 0x3E, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x70, 0xF7, 0xF3, 0xFF, 0xEF, 0xFF, 0xBE, 0x1F, 0xF8, 0x7F,
  0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0x03, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x02, 0x00,
  0x7F, 0x87, 0xFF, 0x1F, 0xFE, 0x78, 0xF9, 0xE1, 0xE7, 0x87, 0x9F, 0x7C,
  0x3F, 0xF0, 0x7F, 0x01, 0xFE, 0x1F, 0xFC, 0x7C, 0xFB, 0xE1, 0xEF, 0x07,
  0xFC, 0x1F, 0xF8, 0x79, 0xFF, 0xE7, 0xFF, 0x07, 0xF8, 0x02, 0x00, 0x7F,
  0x07, 0xFF, 0x1F, 0xFC, 0xF8, 0xFB, 0xE1, 0xEF, 0x07, 0xBC, 0x1F, 0xF8,
  0x7F, 0xE3, 0xFF, 0xFF, 0xDF, 0xFF, 0x3F, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x47, 0xF1, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0x7F, 0xFE, 0xF3, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFD, 0xE0, 0x7F, 0xFE, 0xF3, 0x00, 0x00, 0x00,
  0x00, 0xF7, 0xBD, 0xFE, 0xF7, 0xB8, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC,
  0x03, 0xF0, 0x07, 0x80, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x3E,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x03, 0xF8, 0x7F,
  0x1F, 0xE1, 0xFC, 0x0F, 0x80, 0x60, 0x00, 0x03, 0x03, 0xFF, 0x3F, 0xFC,
  0xFF, 0xE7, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF8, 0x3F,
  0x07, 0x80, 0x3C, 0x3C, 0x10, 0x79, 0xE3, 0xFE, 0xE7, 0x1F, 0xF9, 0xDC,
  0xF1, 0xC7, 0xF3, 0x87, 0x1F, 0xCE, 0x1C, 0x7E, 0x78, 0x71, 0xF9, 0xE1,
  0xC7, 0xF3, 0x8F, 0x3B, 0xCF, 0xFF, 0xE7, 0x1F, 0xFF, 0x1E, 0x3C, 0x78,
  0x78, 0x00, 0x00, 0xF8, 0x02, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xDE, 0x00,
  0x7B, 0xC0, 0x0F, 0x7C, 0x03, 0xEF, 0x80, 0x78, 0xF0, 0x0F, 0x1F, 0x03,
  0xE3, 0xE0, 0x78, 0x3C, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xDF, 0x80, 0x7F, 0xE0, 0x0F, 0x80,
  0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xC7, 0xEF, 0x87, 0xDF, 0x07, 0xBE,
  0x1F, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xC3, 0xEF, 0x83,
  0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0xFE, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0x80,
  0x00, 0x40, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0x9E, 0x7E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x02, 0x3F, 0xFE, 0x1F, 0xFE,
  0x0F, 0xFE, 0x07, 0xFC, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF9, 0xFE,
  0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7E, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x00, 0x00, 0x20, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE3, 0xF8,
  0x63, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x3F, 0xFE,
  0x1F, 0xEF, 0x0F, 0xF7, 0x87, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xFC, 0x1F,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xC0, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFF, 0xFB, 0xFD, 0xFC,
  0xF8, 0x00, 0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF9, 0xF0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0,
  0xFD, 0xF0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xFC, 0xF8, 0x7C, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x1F, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFB, 0x81,
  0xFF, 0xDE, 0x1F, 0xFE, 0xF0, 0xEF, 0xF7, 0x87, 0x7F, 0x9C, 0x7B, 0xFC,
  0xF3, 0x9F, 0xE7, 0x9C, 0xFF, 0x1D, 0xE7, 0xF8, 0xFF, 0x3F, 0xC7, 0xF1,
  0xFE, 0x3F, 0x8F, 0xF0, 0xFC, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1E, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFD, 0xE0,
  0xFF, 0x7C, 0x3F, 0xCF, 0x8F, 0xF3, 0xE3, 0xFC, 0x7C, 0xFF, 0x1F, 0x3F,
  0xC3, 0xEF, 0xF0, 0xFB, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC3, 0xF1, 0xFC, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0,
  0x1F, 0x78, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF7, 0x80,
  0x3E, 0xF8, 0x07, 0xDF, 0x01, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0x83, 0xFF,
  0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBE,
  0x7E, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF9, 0xFB, 0xFF, 0xEF,
  0xFF, 0x3F, 0xF8, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC3, 0xF1, 0xFC, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x1F, 0x78,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF7, 0x80, 0x3E, 0xF8,
  0x07, 0xDF, 0x01, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F,
  0xFC, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xF8, 0xFC,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0xE0, 0xF9, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x7C,
  0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x1F, 0x01, 0x00, 0xFF, 0x8F, 0xFE, 0xFF,
  0xF7, 0xC7, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7F, 0x01, 0xFE, 0x07, 0xFC,
  0x1F, 0xE0, 0x3F, 0x80, 0x7C, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xF8, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7F, 0xFE, 0x7F, 0xFE, 0x3F,
  0xFC, 0x0F, 0xF0, 0xF8, 0x07, 0xDE, 0x01, 0xF7, 0xC0, 0xF9, 0xF0, 0x3E,
  0x3C, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x7C, 0x1F, 0x1E, 0x07,
  0xCF, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xF8, 0x1F,
  0x03, 0xEF, 0x03, 0xE0, 0x79, 0xE0, 0x7C, 0x0F, 0x3E, 0x1F, 0xC3, 0xE7,
  0xC3, 0xF8, 0x7C, 0x78, 0x77, 0x0F, 0x0F, 0x0E, 0xE1, 0xE1, 0xE3, 0xDE,
  0x3C, 0x3E, 0x7B, 0xCF, 0x83, 0xCF, 0x79, 0xE0, 0x79, 0xC7, 0x3C, 0x0F,
  0x78, 0xF7, 0x81, 0xEF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x3F,
  0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x7C, 0x0F, 0x8F,
  0x81, 0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x7C,
  0x07, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x8F, 0x81, 0xFB, 0xF0, 0x1F,
  0x80, 0xF8, 0x0F, 0xBE, 0x0F, 0x9F, 0x07, 0xC7, 0xC3, 0xC1, 0xE3, 0xE0,
  0xF9, 0xE0, 0x3D, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFF, 0xF0, 0x1F,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xE0,
  0x3C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3F, 0xFF, 0xFF, 0x03, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xDC, 0x07, 0x3C, 0x1E, 0x38, 0x38,
  0x78, 0xF0, 0x71, 0xC0, 0xF7, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x7C, 0x3E, 0x0F, 0x07, 0x1F, 0xE0, 0xFF, 0xC3, 0xFF, 0x86, 0x3E,
  0x00, 0x7C, 0x01, 0xF1, 0xFF, 0xDF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x3F, 0xFF, 0xFD, 0xFE, 0xF3, 0xF3, 0xC0, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x3E, 0x3D, 0xFC, 0xFF, 0xFB,
  0xFF, 0xEF, 0x87, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F,
  0xF8, 0x7F, 0xFF, 0xEF, 0xFF, 0xBF, 0xFC, 0xF3, 0xE0, 0x0F, 0xE8, 0xFF,
  0x8F, 0xFC, 0xFF, 0xE7, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x04, 0xFD, 0xE7, 0xFF, 0x1F, 0xF8, 0x3F, 0x80, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF1, 0xF3, 0xCF, 0xEF,
  0x7F, 0xFD, 0xFF, 0xF7, 0xC7, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3D, 0xFB, 0xF7, 0xFF, 0xCF, 0xEF, 0x1F, 0x1C, 0x0F,
  0xE0, 0x7F, 0xC3, 0xFF, 0x9F, 0x1F, 0x78, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x1F, 0x02, 0x3F, 0xF8, 0xFF, 0xE0,
  0xFF, 0x80, 0x07, 0x83, 0xFC, 0xFF, 0x1F, 0xE3, 0xC0, 0x78, 0x1F, 0xF7,
  0xFE, 0xFF, 0xDF, 0xF8, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x1F, 0x3C, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFF, 0x7C, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x83, 0xDF, 0x1F, 0x7F, 0xFC, 0xFE, 0xF1, 0xF3, 0xC0, 0x0F, 0x00,
  0x7D, 0x83, 0xF7, 0xFF, 0xDF, 0xFE, 0x7F, 0xE0, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x3E, 0x3D, 0xFE, 0xFF, 0xFB,
  0xFF, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7C, 0x77, 0xFF, 0xE2,
  0x03, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x00, 0x0C,
  0x1F, 0x1F, 0x1E, 0x04, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0xFE,
  0xFE, 0xFC, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x0F, 0xFC, 0x3E, 0xF8, 0xF9, 0xF3, 0xE3, 0xCF, 0x87, 0xBE,
  0x0F, 0x78, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF0, 0xF9, 0xF1, 0xF1, 0xF3,
  0xE3, 0xE7, 0xC3, 0xEF, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF3, 0xE1, 0xF1, 0xEF, 0xF7, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x87, 0xC3, 0xFF, 0x0F, 0x87, 0xFE, 0x1F,
  0x0F, 0xF8, 0x3E, 0x1F, 0xF0, 0x7C, 0x3F, 0xE0, 0xF8, 0x7F, 0xC1, 0xF0,
  0xFF, 0x83, 0xE1, 0xFF, 0x07, 0xC3, 0xFE, 0x0F, 0x87, 0xFC, 0x1F, 0x0F,
  0x80, 0xE3, 0xF3, 0xDF, 0xEF, 0xFF, 0xBF, 0xFF, 0xF8, 0x7F, 0xE1, 0xFF,
  0x87, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xF7, 0xE7,
  0x83, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7D, 0xE0,
  0xF3, 0xF7, 0xE3, 0xFF, 0x87, 0xFF, 0x03, 0xF8, 0x00, 0xF3, 0xE3, 0xDF,
  0xCF, 0xFF, 0xBF, 0xFE, 0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0x3E, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1F, 0x3C,
  0xFE, 0xF7, 0xFF, 0xDF, 0xFF, 0x7C, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xDF, 0x3F, 0x7F, 0xFC, 0xFE, 0xF1, 0xF3,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xE3,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x1F, 0xC7, 0xFE, 0x7F, 0xEF, 0x8C,
  0xF8, 0x0F, 0xE0, 0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0x3F, 0x01, 0xFE, 0x1F,
  0xFF, 0xEF, 0xFE, 0xFF, 0x80, 0x1C, 0x07, 0x03, 0xC1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE4,
  0xFF, 0x3F, 0xC7, 0xF0, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x87, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFE, 0xF3, 0xF3, 0xC0, 0xF8, 0x1F, 0x78, 0x1E, 0x78,
  0x3E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3C, 0x7C, 0x3E, 0x7C, 0x1E, 0x78, 0x1E,
  0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0xF8, 0x7E, 0x1E, 0xF0, 0xFC, 0x3D, 0xE1, 0xF8, 0xFB, 0xE3, 0xF1,
  0xF7, 0xCF, 0xE3, 0xC7, 0x9D, 0xE7, 0x8F, 0x3B, 0xDF, 0x1E, 0x73, 0xBC,
  0x1F, 0xE7, 0x78, 0x3F, 0xCE, 0xF0, 0x7F, 0x1F, 0xE0, 0xFE, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x7C,
  0x3E, 0x3E, 0x7C, 0x1E, 0x7C, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x3E, 0x7C, 0x3E, 0x7C, 0x7C,
  0x3E, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFF, 0xEF, 0xFE,
  0xFF, 0xEF, 0xFE, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xE0,
  0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x8F, 0xC7, 0xE3,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x3F, 0x3F, 0x1E, 0x0F, 0xC3, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF8, 0xFC, 0x3E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x3F, 0x0F, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0xC1, 0xFC, 0x1F, 0x1F,
  0xC7, 0xC3, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0xFC, 0x3F, 0x0F,
  0x80, 0x3C, 0x0F, 0xFC, 0xFF, 0xFF, 0xCF, 0xF8, 0x0F, 0x00,
};

const GFXglyph NotoSans_ExtraBold27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 19, 8, 1, -19 },
  { 13, 10, 7, 14, 2, -19 },
  { 22, 16, 19, 18, 1, -19 },
  { 60, 14, 23, 16, 1, -21 },
  { 101, 23, 20, 25, 1, -20 },
  { 159, 20, 20, 21, 1, -20 },
  { 209, 4, 7, 8, 2, -19 },
  { 213, 8, 24, 9, 1, -20 },
  { 237, 7, 24, 9, 1, -20 },
  { 258, 13, 13, 15, 1, -21 },
  { 280, 13, 13, 16, 1, -16 },
  { 302, 5, 8, 8, 1, -4 },
  { 307, 7, 4, 9, 1, -9 },
  { 311, 5, 4, 8, 1, -4 },
  { 314, 11, 20, 12, 0, -20 },
  { 342, 14, 20, 16, 1, -20 },
  { 377, 11, 19, 16, 1, -19 },
  { 404, 14, 20, 16, 1, -20 },
  { 439, 14, 20, 16, 1, -20 },
  { 474, 15, 19, 16, 0, -19 },
  { 510, 13, 19, 16, 1, -19 },
  { 541, 14, 20, 16, 1, -20 },
  { 576, 14, 19, 16, 1, -19 },
  { 610, 14, 20, 16, 1, -20 },
  { 645, 14, 20, 16, 1, -20 },
  { 680, 5, 15, 8, 1, -15 },
  { 690, 5, 19, 8, 1, -15 },
  { 702, 13, 14, 16, 1, -17 },
  { 725, 13, 9, 16, 1, -14 },
  { 740, 13, 14, 16, 1, -17 },
  { 763, 13, 20, 13, 0, -20 },
  { 796, 22, 21, 24, 1, -19 },
  { 854, 19, 19, 19, 0, -19 },
  { 900, 15, 19, 18, 2, -19 },
  { 936, 16, 20, 17, 1, -20 },
  { 976, 16, 19, 20, 2, -19 },
  { 1014, 12, 19, 15, 2, -19 },
  { 1043, 11, 19, 15, 2, -19 },
  { 1070, 17, 20, 20, 1, -20 },
  { 1113, 16, 19, 21, 2, -19 },
  { 1151, 9, 19, 11, 1, -19 },
  { 1173, 9, 25, 9, -2, -19 },
  { 1202, 16, 19, 18, 2, -19 },
  { 1240, 12, 19, 15, 2, -19 },
  { 1269, 21, 19, 26, 2, -19 },
  { 1319, 18, 19, 22, 2, -19 },
  { 1362, 19, 20, 21, 1, -20 },
  { 1410, 14, 19, 17, 2, -19 },
  { 1444, 19, 25, 21, 1, -20 },
  { 1504, 16, 19, 18, 2, -19 },
  { 1542, 13, 20, 15, 1, -20 },
  { 1575, 14, 19, 16, 1, -19 },
  { 1609, 16, 19, 20, 2, -19 },
  { 1647, 18, 19, 18, 0, -19 },
  { 1690, 27, 19, 27, 0, -19 },
  { 1755, 19, 19, 19, 0, -19 },
  { 1801, 17, 19, 17, 0, -19 },
  { 1842, 14, 19, 16, 1, -19 },
  { 1876, 6, 24, 9, 2, -20 },
  { 1894, 11, 20, 12, 0, -20 },
  { 1922, 6, 24, 9, 1, -20 },
  { 1940, 15, 12, 15, 0, -19 },
  { 1963, 12, 3, 12, 0, 2 },
  { 1968, 8, 5, 11, 1, -21 },
  { 1973, 14, 15, 16, 1, -15 },
  { 2000, 14, 21, 17, 2, -21 },
  { 2037, 13, 15, 14, 1, -15 },
  { 2062, 14, 21, 17, 1, -21 },
  { 2099, 14, 15, 16, 1, -15 },
  { 2126, 11, 21, 11, 1, -21 },
  { 2155, 14, 21, 17, 1, -15 },
  { 2192, 14, 21, 18, 2, -21 },
  { 2229, 5, 21, 8, 2, -21 },
  { 2243, 8, 27, 8, -1, -21 },
  { 2270, 15, 21, 17, 2, -21 },
  { 2310, 4, 21, 8, 2, -21 },
  { 2321, 23, 15, 27, 2, -15 },
  { 2365, 14, 15, 18, 2, -15 },
  { 2392, 15, 15, 17, 1, -15 },
  { 2421, 14, 21, 17, 2, -15 },
  { 2458, 14, 21, 17, 1, -15 },
  { 2495, 10, 15, 12, 2, -15 },
  { 2514, 12, 15, 14, 1, -15 },
  { 2537, 10, 18, 12, 1, -18 },
  { 2560, 14, 15, 18, 2, -15 },
  { 2587, 16, 15, 16, 0, -15 },
  { 2617, 23, 15, 24, 0, -15 },
  { 2661, 16, 15, 16, 0, -15 },
  { 2691, 16, 21, 16, 0, -15 },
  { 2733, 12, 15, 13, 1, -15 },
  { 2756, 9, 23, 11, 1, -19 },
  { 2782, 3, 26, 14, 6, -20 },
  { 2792, 10, 23, 11, 1, -19 },
  { 2821, 13, 5, 16, 1, -12 },
};

const GFXfont NotoSans_ExtraBold27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold27pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_EXTRABOLD27PT7B_H_
