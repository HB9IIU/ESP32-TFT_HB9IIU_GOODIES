#ifndef _NOTOSANS_EXTRABOLD32PT7B_H_
#define _NOTOSANS_EXTRABOLD32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF,
  0x80, 0x00, 0x0F, 0xBE, 0xFF, 0xEF, 0x80, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF,
  0x9F, 0xF9, 0xFF, 0x9F, 0xF0, 0xFF, 0x0E, 0x03, 0xC7, 0x80, 0x78, 0xF0,
  0x0F, 0x1C, 0x01, 0xE7, 0x80, 0x38, 0xF0, 0x0F, 0x1E, 0x1F, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x3C, 0x78, 0x07, 0x8F, 0x00,
  0xF1, 0xC1, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC3,
  0xC7, 0x80, 0x79, 0xE0, 0x0F, 0x3C, 0x01, 0xC7, 0x80, 0x78, 0xF0, 0x0F,
  0x1E, 0x00, 0x01, 0x80, 0x01, 0x80, 0x0F, 0xF8, 0x3F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFE, 0xFD, 0x8E, 0xF9, 0x80, 0xF9, 0x80, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xBF, 0x01, 0x9F,
  0x81, 0x9F, 0xF9, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x1F, 0xF0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1F, 0x00, 0x3C, 0x07, 0xF8, 0x07,
  0x80, 0x7F, 0xC0, 0x78, 0x0F, 0xBE, 0x0F, 0x00, 0xF1, 0xE0, 0xF0, 0x0F,
  0x1E, 0x1E, 0x00, 0xF1, 0xE3, 0xE0, 0x0F, 0x1E, 0x3C, 0x00, 0xF1, 0xE7,
  0xC0, 0x0F, 0x1E, 0x79, 0xF8, 0xFB, 0xEF, 0x3F, 0xC7, 0xFC, 0xF7, 0xFE,
  0x7F, 0x9E, 0x7F, 0xE1, 0xF1, 0xE7, 0x9E, 0x00, 0x3C, 0xF9, 0xF0, 0x07,
  0xCF, 0x8F, 0x00, 0x78, 0xF8, 0xF0, 0x0F, 0x87, 0x9F, 0x00, 0xF0, 0x79,
  0xF0, 0x1E, 0x07, 0x9E, 0x01, 0xE0, 0x7F, 0xE0, 0x3C, 0x03, 0xFC, 0x07,
  0xC0, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x7E,
  0x1F, 0xF0, 0x7C, 0x3F, 0xF8, 0xFC, 0x7F, 0xFC, 0xFC, 0x7C, 0xFE, 0xF8,
  0xFC, 0x7F, 0xF8, 0xFC, 0x3F, 0xF0, 0xFC, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFE, 0xFC, 0x0F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x0F, 0x87, 0x87, 0xC7, 0xC3, 0xE1, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x1E, 0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xC1,
  0xF0, 0xF8, 0x3E, 0x0F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x07,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE1,
  0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x1E, 0x1F, 0x1F, 0x00, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x0E, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xE0, 0x1F, 0xC0, 0x7B, 0xC0, 0xF7, 0xC3, 0xE7, 0xC3, 0x8E, 0x01,
  0x08, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7E, 0xF9, 0xF3, 0xE7,
  0x8F, 0x3E, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xFE, 0xF8,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFE, 0x7E, 0x7E, 0x7C, 0x3F, 0x7C, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC,
  0x1F, 0x7C, 0x3F, 0x7C, 0x3F, 0x7E, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xF0, 0x01, 0xF0, 0x3F, 0x0F, 0xF1, 0xFF, 0x3F, 0xF7, 0xFF,
  0xFF, 0xF7, 0xBF, 0x73, 0xF2, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE, 0xFF, 0xFE, 0x7E, 0x7F,
  0x38, 0x3F, 0x10, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xF0, 0x7F, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x38, 0x7E, 0x20, 0x3F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x0F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x0F, 0x7C, 0x0F, 0x3E, 0x0F, 0x9F, 0x07, 0x8F, 0x87,
  0x87, 0xC7, 0xC3, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0x9F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xE7, 0xFF, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0xFF,
  0xEF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xFE, 0x0F,
  0xFE, 0x1F, 0xFE, 0x3F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x79,
  0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC,
  0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0x7C, 0x1F, 0x7E, 0x3F, 0x3F, 0xFF, 0x3F,
  0xFE, 0x1F, 0xFC, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x7C,
  0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7E, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0x7F, 0xFF, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F,
  0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0xFC,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0x7F,
  0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0x9F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x73,
  0xEF, 0xFE, 0xF9, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xEF, 0xBF, 0xFB,
  0xE0, 0x38, 0xF9, 0xFB, 0xF7, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xBE, 0x7C, 0xF9, 0xE3, 0xCF, 0x9E, 0x00, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x7F, 0x03,
  0xFE, 0x0F, 0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0,
  0x00, 0x1F, 0xF0, 0xFF, 0xF3, 0xFF, 0xF3, 0xFF, 0xF7, 0x87, 0xE4, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x81, 0xFC, 0x0F, 0x80,
  0x1F, 0x07, 0x80, 0x01, 0xE3, 0xC1, 0xFE, 0x78, 0xF1, 0xFF, 0xCF, 0x78,
  0xFF, 0xF3, 0xDE, 0x7C, 0x3C, 0xF7, 0x9E, 0x0F, 0x1D, 0xC7, 0x83, 0xC7,
  0xF1, 0xE0, 0xF1, 0xFC, 0x78, 0x7C, 0xFF, 0x1E, 0x1E, 0x3D, 0xC7, 0x87,
  0xCF, 0x79, 0xFF, 0xFF, 0x9E, 0x3F, 0xDF, 0xC7, 0x87, 0xE3, 0xE0, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xF8, 0x3E, 0x03,
  0xF0, 0x7C, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xC7, 0xE0, 0x0F, 0xDF, 0x80,
  0x1F, 0xBF, 0x00, 0x1F, 0x80, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F,
  0xFF, 0xEF, 0x87, 0xF7, 0xC1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x3F,
  0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xF7, 0xC3, 0xFB, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFF, 0xFE, 0x3F, 0x8F, 0x1F, 0xC0, 0x47, 0xE0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x27, 0xF8,
  0x78, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF9, 0xF0, 0x3F,
  0xBE, 0x03, 0xF7, 0xC0, 0x7E, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x7E,
  0xF8, 0x0F, 0xDF, 0x03, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xBF, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0xFD, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFC, 0x78, 0xFE, 0x01, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFE,
  0x03, 0xEF, 0xC0, 0x7D, 0xFE, 0x0F, 0x9F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC0, 0xFF, 0xE0, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xF1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x0F, 0xFF, 0xFF, 0xFB, 0xFC, 0xFE, 0x3E, 0x00, 0xF8, 0x0F, 0xFF,
  0x01, 0xFB, 0xE0, 0x7E, 0x7C, 0x1F, 0x8F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E,
  0x3F, 0x07, 0xCF, 0xC0, 0xFB, 0xF0, 0x1F, 0x7E, 0x03, 0xFF, 0x80, 0x7F,
  0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x3E, 0x07, 0xC7, 0xE0, 0xF8,
  0x7E, 0x1F, 0x0F, 0xC3, 0xE0, 0xFC, 0x7C, 0x1F, 0xCF, 0x81, 0xF9, 0xF0,
  0x1F, 0xBE, 0x03, 0xF8, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xDE, 0x03, 0xFF, 0xEF, 0x03, 0xDF, 0xF7, 0xC1,
  0xEF, 0xFB, 0xE0, 0xF7, 0xFC, 0xF0, 0xF3, 0xFF, 0x78, 0x79, 0xFF, 0xBE,
  0x3C, 0xFF, 0xCF, 0x3E, 0x7F, 0xE7, 0x9E, 0x3F, 0xF3, 0xEF, 0x1F, 0xF8,
  0xFF, 0x8F, 0xFC, 0x7F, 0x87, 0xFE, 0x3F, 0xC3, 0xFF, 0x1F, 0xE1, 0xFF,
  0x87, 0xE0, 0xFF, 0xC3, 0xF0, 0x7F, 0xE1, 0xF8, 0x3E, 0xFE, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x7F, 0xDF, 0x03, 0xFE, 0xFC, 0x1F, 0xF3, 0xE0, 0xFF, 0x9F, 0x87, 0xFC,
  0x7C, 0x3F, 0xF3, 0xF1, 0xFF, 0x8F, 0xCF, 0xFC, 0x7E, 0x7F, 0xE1, 0xFB,
  0xFF, 0x0F, 0xDF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0x8F, 0xF1,
  0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF8, 0x0F, 0xE7,
  0xF8, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF9, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F,
  0x8F, 0xF1, 0xF8, 0x0F, 0xEF, 0xE0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x00,
  0xFB, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xBF, 0x00, 0x7E, 0xFC, 0x01, 0xF9, 0xF8,
  0x0F, 0xE7, 0xF8, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0x8F, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xC1, 0xF8,
  0xF8, 0x3F, 0x1F, 0x0F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81,
  0xFF, 0xE0, 0x3E, 0x7E, 0x07, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x0F, 0xC3,
  0xE0, 0xFC, 0x7C, 0x1F, 0x8F, 0x81, 0xF9, 0xF0, 0x3F, 0xBE, 0x03, 0xF8,
  0x07, 0xF8, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFE, 0x7E, 0x3E, 0x7C, 0x04,
  0x7C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F,
  0xF8, 0x7F, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0,
  0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xDF, 0x81, 0xFB, 0xFC, 0x7F, 0x3F, 0xFF, 0xC3, 0xFF,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xDF,
  0x80, 0x7E, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xFC, 0x0F,
  0x87, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x1F,
  0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xE0,
  0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x7C,
  0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7E,
  0x0F, 0xF0, 0x7E, 0x3E, 0x0F, 0xF0, 0x7C, 0x3E, 0x0F, 0xF0, 0x7C, 0x3E,
  0x0F, 0xF0, 0x7C, 0x3E, 0x1F, 0xF8, 0x7C, 0x1F, 0x1F, 0x78, 0xF8, 0x1F,
  0x1E, 0x78, 0xF8, 0x1F, 0x1E, 0x78, 0xF8, 0x1F, 0x3E, 0x7C, 0xF8, 0x0F,
  0xBE, 0x7D, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F, 0xBC, 0x3D, 0xF0, 0x0F,
  0xBC, 0x3D, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xFD, 0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x07,
  0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x3F, 0x00, 0x7C, 0xFC, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x03,
  0xF1, 0xF8, 0x07, 0xEF, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xFB, 0xF0, 0x1F,
  0x9F, 0x80, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7C, 0x0F, 0xC7, 0xE0, 0x7E,
  0x3E, 0x01, 0xF3, 0xF0, 0x0F, 0xDF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0xF8, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x3D, 0xE0, 0x1E, 0x70,
  0x1E, 0x3C, 0x0F, 0x1F, 0x0F, 0x07, 0x87, 0x83, 0xE7, 0x80, 0xF3, 0xC0,
  0x7F, 0xE0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x1F, 0x83,
  0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x07, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x1C, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x07, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFF, 0x7E, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0x7F, 0xEF, 0x3F, 0x8F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF3, 0xE1, 0xFB, 0xF8, 0xFB, 0xFE,
  0x7F, 0xFF, 0xBF, 0xDF, 0xDF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC7, 0xEF,
  0xFF, 0xF7, 0xFF, 0xF3, 0xEF, 0xF9, 0xF3, 0xF0, 0x03, 0xF8, 0x1F, 0xFC,
  0x7F, 0xF9, 0xFF, 0xE7, 0xFB, 0xCF, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xE1, 0x8F, 0xFF,
  0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x1E, 0x3E, 0x3F, 0xDF, 0x3F,
  0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xC3, 0xF7, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0xC3,
  0xF7, 0xFF, 0xF9, 0xFF, 0xFC, 0x7F, 0xBE, 0x1F, 0x8F, 0x03, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xE1, 0xF3, 0xE0, 0x7D, 0xF0, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x08, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0xC7, 0xFC, 0x7F, 0xE3, 0xF0, 0x1F, 0x80, 0xFF, 0xDF,
  0xFE, 0xFF, 0xF7, 0xFF, 0x8F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x07, 0x8F, 0x8F, 0xF7, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7,
  0xF3, 0xFB, 0xF0, 0xFD, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xF0, 0xFD, 0xFF, 0xFE, 0x7F,
  0xFF, 0x1F, 0xEF, 0x87, 0xE7, 0xC0, 0x03, 0xE0, 0x01, 0xF4, 0x01, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF3, 0xE1, 0xFB, 0xFC, 0xFB, 0xFF, 0x7F, 0xFF, 0xBF, 0xDF, 0xFF, 0xC3,
  0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0x33, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x03, 0xF0,
  0xFC, 0x3F, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF, 0xBF, 0xEF, 0xFB,
  0xFC, 0x78, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xFF, 0xF0, 0x7E, 0xFC, 0x3F, 0x3F,
  0x1F, 0x8F, 0xCF, 0xC3, 0xF3, 0xF0, 0xFD, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xBF, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8,
  0xFC, 0x3F, 0x3F, 0x07, 0xEF, 0xC1, 0xFB, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0x1F, 0x7F, 0xCF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0xFF, 0xFC, 0x3F, 0x0F, 0xFF,
  0x07, 0xE0, 0xFF, 0xE0, 0xFC, 0x1F, 0xFC, 0x1F, 0x83, 0xFF, 0x83, 0xF0,
  0x7F, 0xF0, 0x7E, 0x0F, 0xFE, 0x0F, 0xC1, 0xFF, 0xC1, 0xF8, 0x3F, 0xF8,
  0x3F, 0x07, 0xFF, 0x07, 0xE0, 0xFF, 0xE0, 0xFC, 0x1F, 0xFC, 0x1F, 0x83,
  0xFF, 0x83, 0xF0, 0x7C, 0xF0, 0xF8, 0x7D, 0xFF, 0x3E, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0x3F, 0x9F, 0x87, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3F, 0x7C, 0x0F,
  0x9F, 0x87, 0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00,
  0xF8, 0xF8, 0x7C, 0xFE, 0x3E, 0xFF, 0x9F, 0xFF, 0xEF, 0xF7, 0xF7, 0xE0,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0xFF, 0xF1, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0xFB, 0xFE,
  0x7E, 0xFC, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x8F, 0x8F, 0xF7,
  0xCF, 0xFF, 0xE7, 0xFF, 0xF7, 0xF3, 0xFB, 0xF0, 0xFD, 0xF0, 0x3F, 0xF8,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB,
  0xF0, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x1F, 0xEF, 0x87, 0xE7, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0xF0, 0xFF, 0x9F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFF, 0xF7, 0xFF,
  0x9F, 0xFE, 0xFC, 0x1B, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF9, 0xFF, 0x80, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3F, 0x13, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFC,
  0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC1, 0xFF, 0xF1, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xEF, 0x8F,
  0xE3, 0xC0, 0xFC, 0x07, 0xFF, 0x80, 0xF9, 0xF0, 0x1F, 0x3F, 0x07, 0xE3,
  0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x87, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03,
  0xE7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x1F, 0x81,
  0xF7, 0xC1, 0xF8, 0x3F, 0x7C, 0x1F, 0xC3, 0xE7, 0xC3, 0xFC, 0x3E, 0x7E,
  0x3F, 0xC3, 0xE3, 0xE3, 0xFC, 0x7C, 0x3E, 0x3D, 0xE7, 0xC3, 0xE7, 0x9E,
  0x7C, 0x1F, 0x79, 0xE7, 0xC1, 0xF7, 0x9E, 0xF8, 0x1F, 0x79, 0xEF, 0x81,
  0xF7, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xEF, 0xC1, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xC1, 0xFB, 0xF0,
  0x1F, 0x7E, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0x7E, 0x0F, 0xC7, 0xE1,
  0xF8, 0x7C, 0x7E, 0x0F, 0xDF, 0xC0, 0xFC, 0xFC, 0x07, 0xFF, 0x80, 0xF9,
  0xF0, 0x1F, 0x3F, 0x07, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0xC7, 0xE0,
  0xF8, 0xF8, 0x1F, 0x1F, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00,
  0x7B, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xF8,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x1F, 0x8F, 0xF1, 0xF8,
  0x3F, 0x07, 0xF0, 0x3F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x7C, 0x0F, 0xE1, 0xFC, 0x3F, 0x81, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x1F, 0xC3, 0xF8,
  0x7F, 0x03, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0xC0, 0xFE, 0x0F, 0xC0, 0xF8, 0x7F, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7C, 0x00, 0x3F,
  0x01, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFE, 0x80, 0x10,
};

const GFXglyph NotoSans_ExtraBold32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 23, 9, 2, -23 },
  { 19, 12, 8, 16, 2, -23 },
  { 31, 19, 23, 21, 1, -23 },
  { 86, 16, 26, 18, 1, -24 },
  { 138, 28, 23, 30, 1, -23 },
  { 219, 24, 23, 25, 1, -23 },
  { 288, 5, 8, 9, 2, -23 },
  { 293, 9, 28, 11, 1, -23 },
  { 325, 9, 28, 11, 1, -23 },
  { 357, 15, 15, 17, 1, -24 },
  { 386, 16, 15, 19, 1, -19 },
  { 416, 7, 8, 9, 1, -4 },
  { 423, 8, 5, 10, 1, -11 },
  { 428, 6, 5, 9, 2, -5 },
  { 432, 14, 23, 14, 0, -23 },
  { 473, 16, 23, 19, 1, -23 },
  { 519, 12, 23, 19, 2, -23 },
  { 554, 16, 23, 19, 1, -23 },
  { 600, 16, 23, 19, 1, -23 },
  { 646, 17, 23, 19, 1, -23 },
  { 695, 15, 23, 19, 2, -23 },
  { 739, 16, 23, 19, 1, -23 },
  { 785, 16, 23, 19, 1, -23 },
  { 831, 16, 23, 19, 1, -23 },
  { 877, 16, 23, 19, 1, -23 },
  { 923, 6, 18, 9, 2, -18 },
  { 937, 7, 22, 9, 1, -18 },
  { 957, 16, 17, 19, 1, -20 },
  { 991, 16, 10, 19, 1, -16 },
  { 1011, 16, 17, 19, 1, -20 },
  { 1045, 15, 23, 16, 0, -23 },
  { 1089, 26, 26, 29, 1, -23 },
  { 1174, 23, 23, 23, 0, -23 },
  { 1241, 17, 23, 21, 3, -23 },
  { 1290, 18, 23, 21, 2, -23 },
  { 1342, 19, 23, 23, 3, -23 },
  { 1397, 13, 23, 18, 3, -23 },
  { 1435, 13, 23, 17, 3, -23 },
  { 1473, 19, 23, 23, 2, -23 },
  { 1528, 19, 23, 24, 3, -23 },
  { 1583, 11, 23, 13, 1, -23 },
  { 1615, 10, 30, 11, -2, -23 },
  { 1653, 19, 23, 22, 3, -23 },
  { 1708, 14, 23, 18, 3, -23 },
  { 1749, 25, 23, 31, 3, -23 },
  { 1821, 21, 23, 26, 3, -23 },
  { 1882, 22, 23, 25, 2, -23 },
  { 1946, 16, 23, 20, 3, -23 },
  { 1992, 22, 28, 25, 2, -23 },
  { 2069, 19, 23, 21, 3, -23 },
  { 2124, 16, 23, 18, 1, -23 },
  { 2170, 17, 23, 19, 1, -23 },
  { 2219, 19, 23, 24, 3, -23 },
  { 2274, 21, 23, 21, 0, -23 },
  { 2335, 32, 23, 32, 0, -23 },
  { 2427, 22, 23, 22, 0, -23 },
  { 2491, 21, 23, 21, 0, -23 },
  { 2552, 17, 23, 19, 1, -23 },
  { 2601, 8, 28, 11, 2, -23 },
  { 2629, 14, 23, 14, 0, -23 },
  { 2670, 7, 28, 11, 1, -23 },
  { 2695, 17, 15, 18, 0, -23 },
  { 2727, 15, 3, 14, 0, 2 },
  { 2733, 10, 6, 12, 1, -25 },
  { 2741, 16, 18, 20, 1, -18 },
  { 2777, 17, 24, 20, 2, -24 },
  { 2828, 15, 18, 17, 1, -18 },
  { 2862, 17, 24, 20, 1, -24 },
  { 2913, 17, 18, 19, 1, -18 },
  { 2952, 13, 24, 13, 1, -24 },
  { 2991, 17, 26, 20, 1, -18 },
  { 3047, 17, 24, 21, 2, -24 },
  { 3098, 6, 25, 10, 2, -25 },
  { 3117, 10, 33, 10, -2, -25 },
  { 3159, 18, 24, 20, 2, -24 },
  { 3213, 6, 24, 10, 2, -24 },
  { 3231, 27, 18, 32, 2, -18 },
  { 3292, 17, 18, 21, 2, -18 },
  { 3331, 18, 18, 20, 1, -18 },
  { 3372, 17, 26, 20, 2, -18 },
  { 3428, 17, 26, 20, 1, -18 },
  { 3484, 12, 18, 15, 2, -18 },
  { 3511, 14, 18, 16, 1, -18 },
  { 3543, 12, 21, 14, 1, -21 },
  { 3575, 17, 18, 21, 2, -18 },
  { 3614, 19, 18, 19, 0, -18 },
  { 3657, 28, 18, 28, 0, -18 },
  { 3720, 19, 18, 19, 0, -18 },
  { 3763, 19, 26, 19, 0, -18 },
  { 3825, 14, 18, 16, 1, -18 },
  { 3857, 11, 28, 13, 1, -23 },
  { 3896, 3, 31, 17, 7, -24 },
  { 3908, 11, 28, 13, 1, -23 },
  { 3947, 16, 6, 19, 1, -14 },
};

const GFXfont NotoSans_ExtraBold32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold32pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_EXTRABOLD32PT7B_H_
