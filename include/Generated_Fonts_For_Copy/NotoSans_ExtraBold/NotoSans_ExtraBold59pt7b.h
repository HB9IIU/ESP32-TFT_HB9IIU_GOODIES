#ifndef _NOTOSANS_EXTRABOLD59PT7B_H_
#define _NOTOSANS_EXTRABOLD59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold59pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F,
  0xCF, 0xF9, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF,
  0xF9, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0xF1,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xCF, 0xF0, 0x38,
  0x00, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC1, 0xFE, 0xFF,
  0x07, 0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0xBF, 0xC0, 0xFE, 0x7F, 0x03,
  0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xE7, 0x8F, 0xE3, 0xFF, 0x1E, 0x03, 0x8F, 0xF8, 0x78, 0x00,
  0x3F, 0xE1, 0xE0, 0x00, 0xFF, 0xC7, 0x80, 0x03, 0xFF, 0x9E, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1E, 0x7F, 0xF0, 0x00, 0x78, 0xFF,
  0xC0, 0x01, 0xE1, 0xFF, 0x80, 0x07, 0x87, 0xFD, 0x80, 0x1E, 0x1F, 0xF7,
  0xE0, 0x78, 0xFF, 0xDF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF8,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x00, 0x00,
  0x7F, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x7F, 0x87, 0xF0, 0x3F,
  0x80, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xFE, 0x07, 0xF8, 0xFF, 0x0F, 0xE1,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF1, 0xFE, 0x3F, 0xFF, 0x83, 0xFF, 0xFF, 0x3F,
  0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x7F, 0x8F, 0xFB, 0xFE, 0x0F, 0xFF, 0x87, 0xF8, 0xFF, 0x1F, 0xE0, 0x3F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x00, 0xF8, 0x0F, 0xE1, 0xFE, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x7F, 0x81, 0xFE,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xF3, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0xBF, 0xFC, 0x7F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE7, 0xFF,
  0x07, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x3F, 0xFC, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF, 0xDF, 0xE7,
  0xF3, 0xF9, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x70, 0x1F, 0x80, 0xEF, 0xE1, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF9, 0xFF, 0x01, 0xFF,
  0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0x7E, 0x07, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0x04, 0x02, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF3,
  0xFF, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xC7, 0xFC, 0x7F, 0xC7,
  0xF8, 0x7F, 0x87, 0xF8, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0E, 0x0F, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xCF, 0xF0, 0x38, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFC, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF,
  0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xF9, 0xFF, 0x80,
  0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x7F, 0xC0, 0x0F, 0xFD, 0xFF, 0x80,
  0x3F, 0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F,
  0xF8, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xF7, 0xFE, 0x7F, 0xE7, 0xF8, 0xFF, 0xC7, 0xE1,
  0xFF, 0x8F, 0x03, 0xFF, 0x0C, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0x81, 0xFF, 0xE1, 0xF8, 0x03, 0xFF,
  0x83, 0x80, 0x07, 0xFE, 0x04, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xE1, 0xFF, 0xF0, 0x7C,
  0x01, 0xFF, 0xC0, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xEF, 0x00, 0x07, 0xFF,
  0xBF, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xBF, 0xE0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x01, 0xFF,
  0x3F, 0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0x7F, 0xE0, 0x07, 0xFC,
  0x7F, 0xE0, 0x07, 0xF8, 0x7F, 0xE0, 0x0F, 0xF0, 0x7F, 0xE0, 0x1F, 0xF0,
  0x7F, 0xE0, 0x1F, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xC0,
  0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x80, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x20, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x3C, 0x00, 0x7F, 0xC7, 0xFF, 0x01, 0xFE, 0x3F, 0xFF,
  0x0F, 0xF9, 0xFF, 0xFE, 0x3F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0xC0, 0x7F,
  0xF3, 0xFF, 0x01, 0xFF, 0x8F, 0xFF, 0xBF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xF0,
  0x3F, 0xF9, 0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xF8, 0x07,
  0xFE, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x03, 0xFF,
  0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xF7, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x1F, 0xF8, 0x0F,
  0xFE, 0xFF, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xD0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF,
  0x80, 0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0,
  0x0F, 0xFB, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0x7F, 0xF0, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF7, 0xFC, 0x7F,
  0xFF, 0x9F, 0xF0, 0x7F, 0xFC, 0x7F, 0x80, 0xFF, 0xE3, 0xFE, 0x00, 0x3C,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x06, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xF4, 0x00, 0x00, 0x1F, 0x0F,
  0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC7, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x7F, 0x8F, 0xFB, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x81, 0xC0, 0x0F, 0x83, 0xFE,
  0x3F, 0xE7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x3F, 0xE1, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x3F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0xC7, 0xFC,
  0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0xFF, 0xF1,
  0xE0, 0x07, 0xFF, 0x18, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xE0, 0x3F,
  0xC1, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xC7, 0xF8, 0x0F, 0xFF, 0xFC, 0x3F,
  0x8F, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0x3F, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F,
  0x7F, 0x03, 0xFF, 0xFF, 0xE0, 0xFE, 0xFE, 0x0F, 0xFC, 0x1F, 0xC1, 0xFF,
  0xFC, 0x3F, 0xE0, 0x3F, 0x83, 0xFF, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xFF,
  0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xFF, 0xC3, 0xFC, 0x01, 0xFC, 0x1F, 0xFF,
  0x87, 0xF8, 0x03, 0xF8, 0x3F, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0x7F, 0xFE,
  0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0xFC, 0x3F, 0x80, 0x3F, 0xC1, 0xFF, 0xF8,
  0x7F, 0x80, 0x7F, 0x83, 0xFF, 0xF0, 0xFF, 0x00, 0xFF, 0x07, 0xEF, 0xE1,
  0xFE, 0x03, 0xFE, 0x1F, 0xDF, 0xC1, 0xFE, 0x07, 0xFC, 0x3F, 0xBF, 0x83,
  0xFF, 0x3F, 0xFD, 0xFE, 0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x07, 0xFF, 0xF7, 0xFF, 0xC1, 0xFE, 0x07,
  0xFF, 0x87, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x00,
  0x3F, 0xE3, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xC0, 0x3F,
  0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFE, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1F,
  0xFC, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xC0, 0x3F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07,
  0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFE, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x1F, 0x07, 0xFF, 0x80, 0x01, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0x07, 0xFF, 0xE0,
  0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xC0, 0x7F, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xF3, 0xFF,
  0x00, 0x1F, 0xFE, 0x7F, 0xE0, 0x01, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xFD,
  0xFF, 0x80, 0x03, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xFD, 0xFF, 0x80,
  0x07, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x3F, 0xFC, 0xFF,
  0xC0, 0x1F, 0xFF, 0x1F, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xF8, 0x00, 0x78, 0x1F, 0xFF,
  0x00, 0x01, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x7F, 0xE0,
  0x3F, 0xFF, 0xF7, 0xFE, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xF7,
  0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x3F, 0xF3, 0xFF, 0x80, 0x03,
  0xFF, 0x3F, 0xFC, 0x00, 0x3F, 0xF3, 0xFF, 0xE0, 0x03, 0xFF, 0x1F, 0xFF,
  0x80, 0x3F, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0xB1, 0xFF, 0xF7,
  0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F,
  0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xE0, 0x03, 0xFF,
  0x8F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x1F, 0xFC, 0x3F, 0xF0, 0x07,
  0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F,
  0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x3F, 0xF1, 0xFF, 0xC0,
  0x07, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x1F, 0xFB, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x7F, 0xF0,
  0x03, 0xFF, 0x8F, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xF8, 0x1F, 0xF8, 0x07, 0xFF, 0x83,
  0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0xFF,
  0xF1, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0xE7, 0xFE, 0x00,
  0x1F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xFC, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xDF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0x80, 0x07, 0xFF, 0xFF,
  0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xFF, 0xFB, 0xFC, 0x00, 0xFF, 0x7F, 0xFF,
  0xEF, 0xF0, 0x03, 0xFD, 0xFF, 0xFF, 0xBF, 0xE0, 0x0F, 0xE7, 0xFF, 0xFE,
  0x7F, 0x80, 0x7F, 0x9F, 0xFF, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0xFF, 0xE7,
  0xF8, 0x07, 0xF1, 0xFF, 0xFF, 0x8F, 0xF0, 0x3F, 0xC7, 0xFF, 0xFE, 0x3F,
  0xC0, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0xFF, 0xE1, 0xFE,
  0x1F, 0xE1, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0x87, 0xFF, 0xFE, 0x1F, 0xE1,
  0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xC7, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0x3F,
  0xC1, 0xFF, 0xFF, 0x83, 0xFC, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF3, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFB, 0xFF, 0x00, 0x1F, 0xFF, 0xF7, 0xFF,
  0x00, 0x3F, 0xFF, 0xF7, 0xFE, 0x00, 0x7F, 0xFF, 0xEF, 0xFE, 0x00, 0xFF,
  0xFF, 0xCF, 0xFE, 0x01, 0xFF, 0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0xFF, 0x1F,
  0xFC, 0x07, 0xFF, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0xFC, 0x3F, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0xFF, 0xE3,
  0xFF, 0xFF, 0x00, 0xFF, 0xC7, 0xFF, 0xFE, 0x01, 0xFF, 0xCF, 0xFF, 0xFC,
  0x01, 0xFF, 0x9F, 0xFF, 0xF8, 0x03, 0xFF, 0xBF, 0xFF, 0xF0, 0x03, 0xFF,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x03,
  0xFF, 0xC7, 0xFF, 0x80, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xF9,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x00,
  0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xBF, 0xF8, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x3F, 0xF9, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0xFB, 0xFF, 0x00, 0xFF, 0xEF,
  0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0,
  0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xEF, 0xFC, 0x07, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x87, 0xFF, 0x80, 0x03,
  0xFF, 0xC7, 0xFF, 0x80, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x7F, 0xF9,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x00,
  0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xBF, 0xF8, 0x00, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x3F, 0xF9, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F,
  0xF8, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE,
  0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x07,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFF, 0x03, 0xFF, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC,
  0x1F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x7F, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00,
  0xFF, 0xE1, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0xC7, 0xFE,
  0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0xDF, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFE, 0x00, 0x78, 0xFF,
  0xC0, 0x01, 0x8F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xA0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xF7, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xCF, 0xFF,
  0x80, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x0B, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x1F,
  0xFC, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0xFF, 0x83,
  0xFF, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00,
  0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0x7F,
  0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x3F, 0xEF, 0xFC,
  0x00, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xF8, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFC,
  0x1F, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xBF, 0x80, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFE,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xDF, 0xE0, 0x3F, 0xF0, 0x07,
  0xFC, 0x07, 0xFB, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x3F, 0xC0,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xF0, 0x03, 0xFF, 0x07,
  0xF8, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x80,
  0x07, 0xFC, 0x3F, 0xE3, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xF8, 0x3F,
  0xC3, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0x07, 0xF8, 0xFF, 0xC0, 0x01, 0xFF,
  0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFC, 0x1F, 0xE3, 0xFE,
  0x00, 0x07, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0x9F, 0xE0,
  0x3F, 0xCF, 0xF8, 0x00, 0x0F, 0xFB, 0xFC, 0x07, 0xFB, 0xFE, 0x00, 0x01,
  0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xE0, 0x0F, 0xEF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFD, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x7F, 0xE0,
  0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x8F,
  0xFE, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0xFF,
  0xE0, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x03,
  0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x7F,
  0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x80, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFE, 0x0F, 0xFE, 0x03, 0x80, 0x1F, 0xFC, 0x08, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF0, 0xFF, 0xDF, 0xFC,
  0x03, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xCF, 0xF1, 0xFF, 0xFE, 0x3F, 0xC3, 0xFF, 0xF0, 0xFF, 0x07,
  0xFF, 0x01, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xC0, 0x1F, 0xF8, 0xFF,
  0xF0, 0x3F, 0xF3, 0xFF, 0xF0, 0x7F, 0xEF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0x83, 0xFF, 0xDF, 0xFE, 0x03, 0xFF, 0xBF, 0xF8, 0x03, 0xFF,
  0x7F, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xF7, 0xFF,
  0x00, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFE, 0x7F, 0xFF, 0x87, 0xFC, 0x7F, 0xFC, 0x0F, 0xF0, 0x3F,
  0xF0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F,
  0x0F, 0xFE, 0x00, 0x23, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x06, 0x7F, 0xF8, 0x03, 0xCF, 0xFF, 0xEF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0xFE,
  0x0F, 0xFC, 0x0F, 0xFE, 0x1F, 0xF0, 0x7F, 0xFE, 0x7F, 0xC3, 0xFF, 0xFD,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0xF3, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xDF, 0xF0, 0xFF, 0xFE, 0x3F, 0xC1, 0xFF, 0xF0, 0xFF, 0x01, 0xFF,
  0x01, 0xFC, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE,
  0x7F, 0xF0, 0x1F, 0xF9, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x11, 0xFF, 0xE0, 0x03, 0xC3, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0x3C, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFE, 0x3F, 0xC3, 0xFF,
  0xFD, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x3F, 0xFD, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0xF1, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xDF, 0xF0, 0xFF, 0xFE, 0x7F, 0xC1, 0xFF, 0xF1, 0xFF, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x40, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFD, 0x80, 0x00, 0x7F, 0xF7, 0xC0, 0x03,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xE0, 0x1F, 0xF8,
  0xFF, 0xF8, 0x3F, 0xF3, 0xFF, 0xF8, 0x7F, 0xEF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0x8F, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xF3, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xBF, 0xF7,
  0xFE, 0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE,
  0xFF, 0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF,
  0xDF, 0xFB, 0xFF, 0x7F, 0xEF, 0xFD, 0xFF, 0xBF, 0xF7, 0xFE, 0xFF, 0xDF,
  0xFB, 0xFF, 0x7F, 0xEF, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xBF, 0xF0, 0x01, 0xFF, 0xCF, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0x00,
  0x7F, 0xF0, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F,
  0xF0, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x3F, 0xF8, 0x00,
  0xFF, 0xCF, 0xFE, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFE, 0x7F, 0xF0, 0x0F, 0xFF, 0x1F, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFE,
  0x3F, 0xF0, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x1F,
  0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF,
  0xF0, 0x1F, 0xFF, 0x0F, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xFE, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x0F,
  0xFF, 0x83, 0xFC, 0x3F, 0xFF, 0x87, 0xFC, 0xFF, 0xFF, 0x8F, 0xFB, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xF0,
  0x1F, 0xFC, 0x7F, 0xE0, 0x0F, 0xFC, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xC0,
  0x07, 0xFE, 0xFF, 0xC0, 0x07, 0xFE, 0xFF, 0xE0, 0x07, 0xFE, 0x7F, 0xE0,
  0x0F, 0xFE, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x0F,
  0xFF, 0x03, 0xFE, 0x3F, 0xFF, 0x07, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xF8, 0x3F, 0xFD, 0xFF, 0xE0, 0x3F, 0xFB, 0xFF, 0x80, 0x3F,
  0xF7, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x7F,
  0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xF7, 0xFF, 0xF0, 0x7F, 0xE7, 0xFF, 0xC0, 0xFF, 0xC3,
  0xFF, 0x01, 0xFF, 0x80, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x0F, 0xF0, 0x7F, 0xFE, 0x7F, 0xC3, 0xFF, 0xFD, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x3F, 0xFD, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0x7F, 0xF0, 0x1F, 0xFD, 0xFF, 0xF0, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xDF, 0xF0, 0xFF, 0xFE, 0x7F, 0xC1, 0xFF, 0xF1, 0xFF, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x40, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x6F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF,
  0x81, 0xF8, 0xFF, 0x80, 0x0C, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x9A, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC7, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x01, 0x80, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xBF, 0xE3,
  0xFF, 0xFE, 0x7F, 0xC3, 0xFF, 0xF8, 0x7F, 0x81, 0xFF, 0xC0, 0xFF, 0x00,
  0x30, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0xC0, 0x03, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x07, 0xFC,
  0xFF, 0xC0, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x01,
  0xFF, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFE,
  0x7F, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0x9F, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xE3, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0xFC, 0x07,
  0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x1F, 0xCF, 0xE0,
  0xFF, 0xC1, 0xFF, 0x07, 0xF3, 0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFC, 0xFE,
  0x0F, 0xF8, 0x1F, 0xF8, 0xFF, 0x3F, 0xC7, 0xFE, 0x03, 0xFE, 0x3F, 0x8F,
  0xF1, 0xFF, 0x00, 0xFF, 0x8F, 0xE1, 0xFC, 0x7F, 0xC0, 0x3F, 0xE3, 0xF8,
  0x7F, 0x1F, 0xF0, 0x0F, 0xF8, 0xFE, 0x1F, 0xC7, 0xFC, 0x01, 0xFF, 0x7F,
  0x87, 0xFB, 0xFE, 0x00, 0x7F, 0xDF, 0xC1, 0xFE, 0xFF, 0x80, 0x1F, 0xF7,
  0xF0, 0x3F, 0xBF, 0xE0, 0x07, 0xFD, 0xFC, 0x0F, 0xEF, 0xF0, 0x00, 0xFF,
  0x7F, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0xFE, 0xFF, 0x00, 0x0F,
  0xF7, 0xE0, 0x1F, 0xBF, 0xC0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE7,
  0xFF, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0x1F, 0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0xC0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC0,
  0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xFF, 0x9F, 0xFC, 0x00, 0x7F, 0xF7, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x1F, 0xF9,
  0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F,
  0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF8, 0xFF,
  0xC0, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x03, 0xFC,
  0x7F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x00, 0xB0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x09, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0xC0, 0x07, 0xFF, 0xE4, 0x00, 0x0F, 0xFC, 0x00,
};

const GFXglyph NotoSans_ExtraBold59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 11, 43, 17, 3, -42 },
  { 61, 22, 15, 30, 4, -42 },
  { 103, 36, 42, 39, 1, -42 },
  { 292, 30, 48, 34, 2, -45 },
  { 472, 52, 43, 54, 1, -43 },
  { 752, 44, 44, 46, 2, -43 },
  { 994, 9, 15, 16, 4, -42 },
  { 1011, 17, 52, 21, 2, -43 },
  { 1122, 16, 52, 21, 2, -43 },
  { 1226, 28, 28, 32, 2, -45 },
  { 1324, 29, 28, 34, 3, -35 },
  { 1426, 12, 16, 17, 2, -8 },
  { 1450, 16, 8, 19, 1, -20 },
  { 1466, 11, 11, 17, 3, -10 },
  { 1482, 25, 43, 25, 0, -43 },
  { 1617, 30, 44, 34, 2, -43 },
  { 1782, 23, 42, 34, 3, -42 },
  { 1903, 30, 43, 34, 2, -43 },
  { 2065, 30, 44, 34, 2, -43 },
  { 2230, 32, 42, 34, 1, -42 },
  { 2398, 28, 43, 34, 3, -42 },
  { 2549, 30, 44, 34, 2, -43 },
  { 2714, 30, 42, 34, 2, -42 },
  { 2872, 30, 44, 34, 2, -43 },
  { 3037, 30, 44, 34, 2, -43 },
  { 3202, 11, 34, 17, 3, -33 },
  { 3249, 12, 41, 17, 2, -33 },
  { 3311, 28, 32, 34, 3, -37 },
  { 3423, 29, 19, 34, 3, -30 },
  { 3492, 28, 32, 34, 3, -37 },
  { 3604, 28, 44, 29, 0, -43 },
  { 3758, 47, 48, 53, 3, -43 },
  { 4040, 42, 42, 42, 0, -42 },
  { 4261, 32, 42, 39, 5, -42 },
  { 4429, 33, 44, 38, 3, -43 },
  { 4611, 35, 42, 43, 5, -42 },
  { 4795, 25, 42, 33, 5, -42 },
  { 4927, 24, 42, 32, 5, -42 },
  { 5053, 36, 44, 43, 3, -43 },
  { 5251, 35, 42, 45, 5, -42 },
  { 5435, 20, 42, 24, 2, -42 },
  { 5540, 19, 55, 20, -4, -42 },
  { 5671, 35, 42, 40, 5, -42 },
  { 5855, 27, 42, 34, 5, -42 },
  { 5997, 46, 42, 56, 5, -42 },
  { 6239, 39, 42, 49, 5, -42 },
  { 6444, 41, 44, 47, 3, -43 },
  { 6670, 30, 42, 37, 5, -42 },
  { 6828, 41, 53, 47, 3, -43 },
  { 7100, 35, 42, 39, 5, -42 },
  { 7284, 28, 44, 33, 3, -43 },
  { 7438, 32, 42, 34, 1, -42 },
  { 7606, 35, 43, 45, 5, -42 },
  { 7795, 40, 42, 40, 0, -42 },
  { 8005, 59, 42, 59, 0, -42 },
  { 8315, 41, 42, 41, 0, -42 },
  { 8531, 38, 42, 38, 0, -42 },
  { 8731, 32, 42, 35, 2, -42 },
  { 8899, 14, 53, 19, 4, -43 },
  { 8992, 25, 43, 25, 0, -43 },
  { 9127, 15, 53, 19, 1, -43 },
  { 9227, 31, 27, 32, 1, -42 },
  { 9332, 27, 5, 27, 0, 5 },
  { 9349, 19, 9, 23, 2, -45 },
  { 9371, 30, 34, 36, 2, -33 },
  { 9499, 31, 46, 38, 4, -45 },
  { 9678, 27, 34, 31, 3, -33 },
  { 9793, 30, 46, 38, 3, -45 },
  { 9966, 30, 34, 36, 3, -33 },
  { 10094, 25, 45, 24, 1, -45 },
  { 10235, 30, 47, 38, 3, -33 },
  { 10412, 31, 45, 39, 4, -45 },
  { 10587, 11, 45, 18, 4, -45 },
  { 10649, 18, 59, 18, -3, -45 },
  { 10782, 34, 45, 38, 4, -45 },
  { 10974, 10, 45, 18, 4, -45 },
  { 11031, 50, 33, 58, 4, -33 },
  { 11238, 31, 33, 39, 4, -33 },
  { 11366, 32, 34, 37, 3, -33 },
  { 11502, 31, 47, 38, 4, -33 },
  { 11685, 30, 47, 38, 3, -33 },
  { 11862, 22, 33, 27, 4, -33 },
  { 11953, 25, 34, 30, 3, -33 },
  { 12060, 23, 40, 26, 1, -39 },
  { 12175, 31, 33, 39, 4, -32 },
  { 12303, 35, 32, 35, 0, -32 },
  { 12443, 50, 32, 52, 1, -32 },
  { 12643, 35, 32, 36, 0, -32 },
  { 12783, 35, 46, 35, 0, -32 },
  { 12985, 26, 32, 29, 2, -32 },
  { 13089, 21, 52, 24, 1, -42 },
  { 13226, 7, 58, 31, 12, -45 },
  { 13277, 21, 52, 24, 2, -42 },
  { 13414, 29, 10, 34, 3, -26 },
};

const GFXfont NotoSans_ExtraBold59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold59pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_EXTRABOLD59PT7B_H_
