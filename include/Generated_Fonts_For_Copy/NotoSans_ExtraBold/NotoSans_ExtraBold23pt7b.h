#ifndef _NOTOSANS_EXTRABOLD23PT7B_H_
#define _NOTOSANS_EXTRABOLD23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x00, 0x6F, 0xFF, 0xF7, 0xB9, 0xDC,
  0xEE, 0x77, 0x3B, 0x9C, 0x07, 0x38, 0x0E, 0x60, 0x18, 0xC0, 0x33, 0x87,
  0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x87, 0x30, 0x0C, 0xE1, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xE1, 0xCC, 0x03, 0x38, 0x06, 0x70, 0x1C, 0xE0, 0x06, 0x03,
  0xF1, 0xFF, 0xFF, 0xFF, 0x65, 0xCC, 0x3D, 0x87, 0xF0, 0x7F, 0xC3, 0xFC,
  0x1F, 0x83, 0x78, 0x6F, 0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0xC0, 0x38,
  0x01, 0x07, 0xC0, 0xE0, 0xFE, 0x0E, 0x0E, 0xE1, 0xC0, 0xE7, 0x38, 0x0E,
  0x73, 0x80, 0xE7, 0x70, 0x0E, 0xE7, 0x7C, 0xFE, 0xEF, 0xE7, 0xCE, 0xEE,
  0x39, 0xCE, 0x70, 0x1C, 0xE7, 0x03, 0x8E, 0x70, 0x70, 0xE7, 0x07, 0x0E,
  0xE0, 0xE0, 0xFE, 0x0E, 0x07, 0xC0, 0x07, 0x00, 0x0F, 0xE0, 0x0F, 0xF8,
  0x0F, 0x3C, 0x07, 0x8E, 0x01, 0xCF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x3F,
  0x0F, 0x3F, 0xC7, 0xBF, 0xF7, 0x9E, 0x7F, 0xCF, 0x1F, 0xC7, 0x87, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0x9F, 0x80, 0xF7, 0x77, 0x77, 0x1C, 0xF3,
  0x9E, 0x71, 0xCF, 0x3C, 0xE3, 0x8E, 0x38, 0xE3, 0xCF, 0x1C, 0x71, 0xE3,
  0x8F, 0x1C, 0xE3, 0xC7, 0x1E, 0x38, 0xE3, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x73, 0xCF, 0x39, 0xE7, 0x3C, 0xE0, 0x0E, 0x01, 0xC2, 0x30, 0xFE, 0xFF,
  0xFF, 0xFF, 0xC7, 0xC1, 0xF8, 0x7B, 0xC6, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00,
  0x77, 0xFE, 0xEE, 0xFF, 0xFF, 0xC0, 0x6F, 0xFF, 0x03, 0xC0, 0xE0, 0x78,
  0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x38,
  0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0xF1, 0xFF, 0x3D, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0xFF, 0x1F,
  0xE3, 0xDF, 0xF1, 0xFE, 0x1F, 0x80, 0x0F, 0x8F, 0xCF, 0xEF, 0xFF, 0x7B,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x0E, 0x0F, 0xFB, 0xFF, 0x7F, 0xF6, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1E, 0x0F, 0xFB, 0xFF, 0x3F, 0xF4, 0x1E, 0x03, 0xC0, 0xF1, 0xFC, 0x3F,
  0x07, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0x80,
  0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0x77, 0x87,
  0x3C, 0x79, 0xE3, 0x8F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x07,
  0x80, 0x3C, 0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xEC, 0x1F, 0xF7,
  0xFE, 0x77, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0xFF, 0xFF, 0xF7, 0xF8,
  0x03, 0xC1, 0xFC, 0x3F, 0xC7, 0xE2, 0x78, 0x0F, 0x00, 0xF7, 0x8E, 0xFC,
  0xFF, 0xEF, 0x9E, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x1E, 0x7F, 0xE3, 0xFC,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C,
  0x07, 0xC0, 0x0E, 0x03, 0xFC, 0x7F, 0xEF, 0x9E, 0xF1, 0xEF, 0x1E, 0x7B,
  0xC3, 0xF8, 0x1F, 0x07, 0xFC, 0xFB, 0xEF, 0x1E, 0xE0, 0xFF, 0x0E, 0xFF,
  0xE7, 0xFC, 0x3F, 0x80, 0x0E, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0x1F, 0xE1,
  0xFC, 0x3F, 0x8F, 0xFF, 0xEF, 0xFD, 0xFB, 0x80, 0x70, 0x1E, 0x07, 0x9F,
  0xF3, 0xFC, 0x7E, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x06, 0xFF, 0xF0, 0x7F,
  0xF7, 0x00, 0x00, 0x00, 0x77, 0xFE, 0xEE, 0x00, 0x20, 0x0C, 0x07, 0x83,
  0xF1, 0xF8, 0xFC, 0x3E, 0x07, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0x80, 0x70,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x18, 0x03, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x78, 0x1F, 0x1F,
  0xCF, 0xE3, 0xE0, 0x70, 0x08, 0x00, 0x0E, 0x0F, 0xF3, 0xFF, 0x3D, 0xF4,
  0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x00,
  0x18, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x1E, 0x03, 0xC3, 0x80, 0x1C, 0xE3, 0xFB, 0x9C, 0xFF, 0x37, 0x38,
  0xE7, 0xE7, 0x1C, 0xFD, 0xC3, 0x9F, 0x98, 0x73, 0x73, 0x9E, 0xEE, 0x7F,
  0xFC, 0xC7, 0xDF, 0x1C, 0x00, 0x01, 0xC0, 0x10, 0x3F, 0xFE, 0x01, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x78, 0x1E, 0x78, 0x0F, 0xF0, 0x0F,
  0xFF, 0xCF, 0xFE, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x1F, 0xFF, 0xEF, 0xFC,
  0xFF, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8,
  0x03, 0xC0, 0x7F, 0xCF, 0xFE, 0x7F, 0xE7, 0xC1, 0x3C, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x08, 0xFF,
  0xC3, 0xFE, 0x0F, 0xF0, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3C, 0x3E, 0xF0,
  0x7B, 0xC1, 0xEF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0xBC,
  0x3E, 0xF1, 0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x3C, 0x0F, 0xFB, 0xFE, 0xFF, 0xBC, 0x0F, 0x03, 0xC0, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x01, 0xE0,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFE, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xF1, 0xFF, 0xC7, 0xFF, 0x1F, 0xDE, 0x0F, 0x78, 0x3D, 0xF0, 0xF3, 0xFF,
  0xC7, 0xFF, 0x0F, 0xF8, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x7C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0xFE, 0xFF, 0xFF,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0xFE, 0xFC, 0xF8, 0xF0, 0x7F, 0xC3,
  0xCF, 0x1E, 0x3C, 0xF8, 0xF3, 0xC3, 0xDE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x83, 0xFF, 0x0F, 0x3C, 0x3C, 0xF8, 0xF1, 0xE3, 0xC3, 0xCF, 0x0F, 0xBC,
  0x1F, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xEE, 0x1F, 0xFB, 0x87, 0xFE, 0xE1,
  0xFF, 0xBC, 0xEF, 0xE7, 0x3B, 0xF9, 0xCE, 0xFE, 0x7F, 0x3F, 0x8F, 0xCF,
  0xE3, 0xF3, 0xF8, 0xF8, 0xFE, 0x1E, 0x3F, 0x87, 0x8F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF8, 0x7F, 0xF0, 0xFE, 0xF1, 0xFD, 0xE3, 0xF9, 0xE7, 0xF3, 0xCF,
  0xE3, 0xCF, 0xC7, 0x9F, 0x87, 0xBF, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x1F, 0x03, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C,
  0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F,
  0xF0, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0xFF,
  0xFF, 0xDF, 0xF3, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x03,
  0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x1E, 0x78, 0x1F, 0xF8,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78,
  0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0x3F, 0xF9, 0xE3, 0xEF,
  0x0F, 0x78, 0xF3, 0xC7, 0x9F, 0xF8, 0xFF, 0x87, 0xFC, 0x3C, 0xF1, 0xE7,
  0x8F, 0x1E, 0x78, 0x7B, 0xC3, 0xDE, 0x0F, 0x0F, 0x07, 0xFD, 0xFF, 0xFF,
  0xEF, 0x05, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x80, 0xF0,
  0x1F, 0x83, 0xFF, 0xFF, 0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x1E, 0xF8, 0x79, 0xFF, 0xE3, 0xFF, 0x07,
  0xF0, 0xF0, 0x1E, 0xF0, 0x3D, 0xE0, 0xF3, 0xC1, 0xE3, 0xC3, 0xC7, 0x8F,
  0x0F, 0x1E, 0x0F, 0x3C, 0x1E, 0x70, 0x3D, 0xE0, 0x3B, 0xC0, 0x7F, 0x00,
  0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0xF0, 0x7C, 0x1E, 0xE0, 0xF8,
  0x39, 0xE1, 0xF0, 0xF3, 0xC3, 0xE1, 0xE7, 0x8E, 0xE3, 0xC7, 0x1D, 0xC7,
  0x0F, 0x3B, 0x9E, 0x1E, 0x77, 0x3C, 0x3D, 0xEF, 0x78, 0x3B, 0x8E, 0xE0,
  0x77, 0x1D, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0xF8, 0x1F, 0x3C, 0x3C, 0x3C, 0x7C, 0x1E,
  0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x1E, 0x78, 0x3E, 0x7C, 0x3C, 0x3C, 0x78, 0x3E, 0xF8,
  0x1F, 0xF8, 0x3E, 0xF0, 0x78, 0xF1, 0xE1, 0xE3, 0xC1, 0xEF, 0x03, 0xDE,
  0x03, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07,
  0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFC, 0xF0,
  0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80,
  0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0xFF, 0xFE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xFF, 0xFF, 0x80, 0x06,
  0x00, 0x30, 0x03, 0xC0, 0x1E, 0x01, 0xF8, 0x0E, 0xE0, 0xE7, 0x07, 0x1C,
  0x70, 0xE3, 0x83, 0xB8, 0x1E, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0x70,
  0x1F, 0x8F, 0xF8, 0xFF, 0x90, 0xF0, 0x0E, 0x3F, 0xDF, 0xFF, 0xC7, 0xF0,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF7, 0xE6, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0x1E, 0xF1, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF1, 0xEF, 0x1E, 0xFF, 0xEF, 0xFC, 0xEF, 0x80, 0x0F, 0x87, 0xFD, 0xFF,
  0x3C, 0x6F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x09, 0xFF, 0x1F,
  0xE1, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x1E, 0xF3, 0xFF, 0x7F,
  0xFF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x7F,
  0xF7, 0xFF, 0x3E, 0x70, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0x8F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x81, 0x7F, 0xE3, 0xFE, 0x1F, 0xE0,
  0x07, 0x07, 0xF1, 0xF8, 0xFA, 0x3C, 0x0F, 0xEF, 0xFB, 0xFE, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x1E,
  0x73, 0xFF, 0x7F, 0xFF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x8F, 0x7F, 0xF7, 0xFF, 0x3E, 0xF0, 0x0F, 0x80, 0xF7, 0xFF, 0x7F,
  0xE7, 0xFC, 0x04, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE7, 0x8E,
  0xFE, 0xFF, 0xEF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x33, 0xFE, 0xE0, 0x3D, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0, 0x0C, 0x3C, 0xF8, 0xE0, 0x03, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x79, 0xEF,
  0xDF, 0xBE, 0x20, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x0F, 0x78,
  0xF3, 0xCF, 0x9E, 0xF8, 0xEF, 0x87, 0x78, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC,
  0x79, 0xE3, 0xC7, 0x9E, 0x3E, 0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x87, 0x9D, 0xFB, 0xFB, 0xFF, 0xFF, 0xFC,
  0xF9, 0xFF, 0x1F, 0x1F, 0xE3, 0xC3, 0xFC, 0x78, 0x7F, 0x8F, 0x0F, 0xF1,
  0xE1, 0xFE, 0x3C, 0x3F, 0xC7, 0x87, 0xF8, 0xF0, 0xFF, 0x1E, 0x1E, 0xE7,
  0x8E, 0xFE, 0xFF, 0xEF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF0, 0x0F, 0x83, 0xFC, 0x7F, 0xE7,
  0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0x8F, 0x7F, 0xF3,
  0xFE, 0x1F, 0x80, 0xE7, 0x8E, 0xFC, 0xFF, 0xEF, 0x1E, 0xF1, 0xEF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF1, 0xEF, 0x1E, 0xFF, 0xEF, 0xFC, 0xEF, 0x8E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x73, 0xFF, 0x7F,
  0xFF, 0x9F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x7F,
  0xF7, 0xFF, 0x3E, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0xE7, 0xEF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0x1F, 0x1F, 0xFF, 0xFB, 0xC2, 0xF8, 0x3F, 0x87, 0xF8, 0x7E,
  0x07, 0xE0, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x38, 0x1C, 0x1F, 0xDF, 0xEF,
  0xF3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xF9, 0xFC, 0xFE,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xF1, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x7E, 0xF0, 0xF0, 0x7F, 0xC1, 0xE7,
  0x87, 0x9E, 0x1C, 0x38, 0xF0, 0xF3, 0xC3, 0xCE, 0x07, 0x78, 0x1F, 0xC0,
  0x7F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0xF0, 0xF7, 0x0F, 0x8F,
  0x78, 0xF8, 0xE7, 0x9F, 0x9E, 0x79, 0xF9, 0xE3, 0x9D, 0x9E, 0x3D, 0x9D,
  0xC3, 0xF9, 0xDC, 0x1F, 0x9F, 0xC1, 0xF9, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x0F, 0x0F, 0x80, 0xF8, 0x7D, 0xE3, 0xE3, 0xCF, 0x0F, 0xFC, 0x1F,
  0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0xFF, 0x83, 0xCF, 0x1E,
  0x3E, 0xF8, 0x7C, 0xF0, 0x3F, 0xC1, 0xE7, 0x87, 0x9E, 0x1C, 0x38, 0xF0,
  0xF3, 0xC3, 0xCE, 0x07, 0x78, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x02, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x78,
  0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x87, 0xC3, 0xE3, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x7E, 0x3C, 0x1F, 0x83, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0xE1, 0xF0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0xF0, 0xF8, 0x78, 0x38, 0x38, 0x38, 0x38, 0x3C, 0x3F, 0x0F, 0x1F,
  0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF8, 0xE0, 0x7C, 0x3F, 0xFF,
  0xFF, 0xC1, 0xE0,
};

const GFXglyph NotoSans_ExtraBold23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 16, 7, 1, -16 },
  { 9, 9, 6, 12, 1, -16 },
  { 16, 15, 16, 15, 0, -16 },
  { 46, 11, 18, 13, 1, -17 },
  { 71, 20, 17, 21, 1, -17 },
  { 114, 17, 17, 18, 1, -17 },
  { 151, 4, 6, 6, 1, -16 },
  { 154, 6, 21, 8, 1, -17 },
  { 170, 6, 21, 8, 1, -17 },
  { 186, 11, 10, 12, 1, -17 },
  { 200, 11, 11, 13, 1, -14 },
  { 216, 4, 6, 7, 1, -3 },
  { 219, 6, 3, 7, 1, -8 },
  { 222, 4, 4, 7, 1, -4 },
  { 224, 10, 17, 10, 0, -17 },
  { 246, 11, 17, 13, 1, -17 },
  { 270, 9, 16, 13, 1, -16 },
  { 288, 11, 17, 13, 1, -17 },
  { 312, 11, 17, 13, 1, -17 },
  { 336, 13, 16, 13, 0, -16 },
  { 362, 11, 16, 13, 1, -16 },
  { 384, 12, 17, 13, 1, -17 },
  { 410, 12, 16, 13, 1, -16 },
  { 434, 12, 17, 13, 1, -17 },
  { 460, 11, 17, 13, 1, -17 },
  { 484, 4, 13, 7, 1, -13 },
  { 491, 4, 16, 7, 1, -13 },
  { 499, 11, 13, 13, 1, -15 },
  { 517, 11, 8, 13, 1, -12 },
  { 528, 11, 13, 13, 1, -15 },
  { 546, 11, 17, 11, 0, -17 },
  { 570, 19, 19, 21, 1, -17 },
  { 616, 16, 16, 16, 0, -16 },
  { 648, 12, 16, 15, 2, -16 },
  { 672, 13, 17, 15, 1, -17 },
  { 700, 14, 16, 17, 2, -16 },
  { 728, 10, 16, 13, 2, -16 },
  { 748, 9, 16, 13, 2, -16 },
  { 766, 14, 17, 17, 1, -17 },
  { 796, 14, 16, 18, 2, -16 },
  { 824, 8, 16, 10, 1, -16 },
  { 840, 8, 21, 8, -2, -16 },
  { 861, 14, 16, 16, 2, -16 },
  { 889, 10, 16, 13, 2, -16 },
  { 909, 18, 16, 22, 2, -16 },
  { 945, 15, 16, 19, 2, -16 },
  { 975, 16, 17, 18, 1, -17 },
  { 1009, 11, 16, 14, 2, -16 },
  { 1031, 16, 21, 18, 1, -17 },
  { 1073, 13, 16, 15, 2, -16 },
  { 1099, 11, 17, 13, 1, -17 },
  { 1123, 13, 16, 13, 0, -16 },
  { 1149, 14, 16, 17, 2, -16 },
  { 1177, 15, 16, 15, 0, -16 },
  { 1207, 23, 16, 23, 0, -16 },
  { 1253, 16, 16, 16, 0, -16 },
  { 1285, 15, 16, 15, 0, -16 },
  { 1315, 12, 16, 14, 1, -16 },
  { 1339, 6, 21, 8, 1, -17 },
  { 1355, 10, 17, 10, 0, -17 },
  { 1377, 5, 21, 8, 1, -17 },
  { 1391, 13, 11, 13, 0, -17 },
  { 1409, 10, 2, 10, 0, 2 },
  { 1412, 7, 4, 9, 1, -18 },
  { 1416, 11, 13, 14, 1, -13 },
  { 1434, 12, 17, 15, 2, -17 },
  { 1460, 11, 13, 12, 1, -13 },
  { 1478, 12, 17, 15, 1, -17 },
  { 1504, 12, 13, 14, 1, -13 },
  { 1524, 10, 18, 9, 0, -18 },
  { 1547, 12, 19, 15, 1, -13 },
  { 1576, 12, 17, 15, 2, -17 },
  { 1602, 5, 18, 7, 1, -18 },
  { 1614, 7, 24, 7, -1, -18 },
  { 1635, 13, 17, 15, 2, -17 },
  { 1663, 4, 17, 7, 2, -17 },
  { 1672, 19, 13, 23, 2, -13 },
  { 1703, 12, 13, 15, 2, -13 },
  { 1723, 12, 13, 14, 1, -13 },
  { 1743, 12, 19, 15, 2, -13 },
  { 1772, 12, 19, 15, 1, -13 },
  { 1801, 8, 13, 11, 2, -13 },
  { 1814, 10, 13, 12, 1, -13 },
  { 1831, 9, 15, 10, 1, -15 },
  { 1848, 12, 13, 15, 2, -13 },
  { 1868, 14, 13, 14, 0, -13 },
  { 1891, 20, 13, 20, 0, -13 },
  { 1924, 14, 13, 14, 0, -13 },
  { 1947, 14, 19, 14, 0, -13 },
  { 1981, 10, 13, 11, 1, -13 },
  { 1998, 9, 21, 9, 0, -17 },
  { 2022, 2, 22, 12, 5, -17 },
  { 2028, 8, 21, 9, 1, -17 },
  { 2049, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_ExtraBold23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold23pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_EXTRABOLD23PT7B_H_
