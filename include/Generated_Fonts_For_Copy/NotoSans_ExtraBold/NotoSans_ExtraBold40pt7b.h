#ifndef _NOTOSANS_EXTRABOLD40PT7B_H_
#define _NOTOSANS_EXTRABOLD40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00, 0x00, 0x18,
  0x7E, 0xFE, 0xFE, 0xFE, 0xFE, 0x7C, 0xFE, 0x7F, 0xFE, 0x7F, 0x7E, 0x7E,
  0x7E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF0, 0xF8, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF1,
  0xF0, 0x01, 0xF1, 0xF0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xE3, 0xE0, 0x03, 0xC3,
  0xE0, 0x07, 0xC3, 0xC0, 0x07, 0xC7, 0xC0, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x0F, 0x8F, 0x80, 0x0F, 0x8F,
  0x80, 0x0F, 0x8F, 0x80, 0x0F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x1F, 0x0F,
  0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xFE, 0x70, 0xE7, 0xF3, 0x80, 0x3F, 0x9C, 0x00,
  0xFE, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xEF, 0xF0,
  0x07, 0x3F, 0xC0, 0x39, 0xFD, 0x81, 0xCF, 0xEF, 0xEF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x03,
  0xFC, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x3F, 0xFC, 0x03, 0xE0,
  0x07, 0xEF, 0x80, 0xFC, 0x01, 0xF9, 0xF8, 0x1F, 0x00, 0x3E, 0x1F, 0x07,
  0xE0, 0x07, 0xC3, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x3E, 0x00, 0x1F, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x3E, 0x0C, 0x0F,
  0xCF, 0xCF, 0x8F, 0xF0, 0xF9, 0xF3, 0xF3, 0xFF, 0x1F, 0xFE, 0x7C, 0xFF,
  0xF1, 0xFF, 0x9F, 0x9F, 0xFE, 0x1F, 0xE3, 0xE7, 0xE7, 0xC1, 0xF8, 0xF8,
  0xF8, 0xFC, 0x00, 0x1F, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE1, 0xF0, 0x00,
  0xF8, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0x87, 0xC0, 0x0F, 0xC1, 0xF0, 0xF8,
  0x01, 0xF0, 0x3E, 0x3F, 0x00, 0x7E, 0x07, 0xE7, 0xC0, 0x0F, 0x80, 0x7F,
  0xF8, 0x03, 0xE0, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x1F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x03, 0xF8, 0x7F, 0xF0, 0x3F, 0x87, 0xFF, 0xC1, 0xFC,
  0x7F, 0xFF, 0x0F, 0xE7, 0xFB, 0xFC, 0xFE, 0x3F, 0x8F, 0xF7, 0xF1, 0xFC,
  0x3F, 0xFF, 0x0F, 0xE0, 0xFF, 0xF8, 0x7F, 0x03, 0xFF, 0x83, 0xF8, 0x0F,
  0xF8, 0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x3F, 0xC0, 0x7F, 0xE0, 0xFF, 0x80,
  0xFF, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x07, 0xE1,
  0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7C,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F,
  0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x07, 0x0F, 0x0E, 0x7E, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFB, 0xF0, 0x1F,
  0x9F, 0x03, 0xF9, 0xF8, 0x1F, 0x0F, 0x80, 0x70, 0xE0, 0x01, 0x08, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x3F, 0x3F, 0x3F, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFE, 0x1F, 0x8F, 0xE0, 0xFE, 0x7F,
  0x07, 0xF3, 0xF8, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFB, 0xF0,
  0x1F, 0xDF, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9,
  0xFC, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7E,
  0xFC, 0xFC, 0xF1, 0xF8, 0x83, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xF8, 0x3F, 0xC3, 0x80, 0xFE, 0x10,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x60,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFA, 0x00, 0x1F, 0xDE, 0x03, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0,
  0x1F, 0x7E, 0x01, 0xFB, 0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x10, 0x3F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x87,
  0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFE, 0x30, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0xFC, 0xFF, 0x07, 0xEF, 0xFE,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0xFE, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xBF, 0x81, 0xFD,
  0xFC, 0x0F, 0xC7, 0xF0, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x3F, 0xC7, 0xF9, 0xFC, 0x1F, 0xCF, 0xE0, 0x7E, 0x7F, 0x07, 0xF1,
  0xF8, 0x3F, 0x0F, 0xF3, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xE3, 0xFC, 0xFF, 0x1F,
  0xC1, 0xFC, 0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xEF, 0xE0, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFC, 0x1F, 0xDF,
  0xC0, 0xFE, 0xFE, 0x03, 0xF7, 0xF0, 0x1F, 0xBF, 0x80, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xBF, 0x87, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xDF, 0x81, 0xFC, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x7D, 0xFF,
  0xFF, 0xFF, 0xEF, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x3E, 0x3F, 0x9F, 0xCF, 0xF7, 0xF1,
  0xF8, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3E,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xC0,
  0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0x7E, 0x7F, 0xCC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x40, 0x7E, 0x3E, 0x0F, 0xFF, 0x3E, 0x7C, 0x1F, 0xFF,
  0x1E, 0x7C, 0x3F, 0xFF, 0x1F, 0x7C, 0x7F, 0x1F, 0x1F, 0xF8, 0xFC, 0x1F,
  0x1F, 0xF8, 0xF8, 0x1F, 0x1F, 0xF8, 0xF8, 0x1F, 0x1F, 0xF8, 0xF8, 0x1F,
  0x1F, 0xF8, 0xF8, 0x1F, 0x1F, 0xF8, 0xF8, 0x3F, 0x1F, 0xF8, 0xF8, 0x3F,
  0x1F, 0xF8, 0xF8, 0x3F, 0x3E, 0xF8, 0xFE, 0xFF, 0xFE, 0xF8, 0x7F, 0xFF,
  0xFC, 0xFC, 0x7F, 0xE7, 0xF8, 0x7C, 0x1F, 0xC3, 0xF0, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x80, 0x1F, 0xE0, 0x07,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xF9, 0xF8,
  0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03,
  0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFE,
  0x7F, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0xBF, 0x80, 0xFE, 0xFE, 0x03, 0xFB,
  0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xBF, 0x87, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xF8, 0x1F,
  0xEF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x0F, 0xF8, 0x0E, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x02, 0x1F, 0xF8, 0x7C, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFE, 0x07, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xEF,
  0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xE0, 0x0C, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0x7F,
  0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x80, 0x3F, 0x3F, 0xC0, 0x3F, 0x3F,
  0xF0, 0x7F, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xF8, 0x3F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0xFF, 0xFF, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x8F, 0xF8, 0x3C,
  0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x03,
  0xFC, 0xFE, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F,
  0xE0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFF,
  0x00, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x3F, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFD, 0xF0, 0x0F, 0xBF, 0xFD, 0xF0,
  0x0F, 0xBF, 0xFD, 0xF8, 0x1F, 0xBF, 0xFD, 0xF8, 0x1F, 0x3F, 0xFC, 0xF8,
  0x1F, 0x3F, 0xFC, 0xFC, 0x1F, 0x7F, 0xFC, 0xFC, 0x3E, 0x7F, 0xFC, 0x7C,
  0x3E, 0x7F, 0xFC, 0x7C, 0x3E, 0x7F, 0xFC, 0x7E, 0x7E, 0x7F, 0xFC, 0x7E,
  0x7C, 0x7F, 0xFC, 0x3E, 0x7C, 0x7F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFC, 0x3F,
  0xF8, 0x7F, 0xFC, 0x1F, 0xF8, 0x7F, 0xFC, 0x1F, 0xF8, 0x7F, 0xFC, 0x1F,
  0xF0, 0x7F, 0xFC, 0x0F, 0xF0, 0x7F, 0xFC, 0x0F, 0xF0, 0x7F, 0xFC, 0x0F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xBF, 0x81, 0xFF, 0xF3, 0xF8, 0x3F, 0xFE, 0x7F, 0x07, 0xFF, 0xC7,
  0xF0, 0xFF, 0xF8, 0xFE, 0x1F, 0xFF, 0x0F, 0xE3, 0xFF, 0xE1, 0xFC, 0x7F,
  0xFC, 0x1F, 0xC7, 0xFF, 0x83, 0xFC, 0xFF, 0xF0, 0x3F, 0x9F, 0xFE, 0x03,
  0xFB, 0xFF, 0xC0, 0x7F, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xC7, 0xF8, 0x03, 0xFC,
  0x7F, 0x80, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0xFF,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF8, 0x01,
  0xFE, 0x3F, 0xC0, 0x3F, 0xC3, 0xFF, 0x9F, 0xFC, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07,
  0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF,
  0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0x3F, 0xE0, 0x7F, 0xC7, 0xF8, 0x03, 0xFC, 0x7F, 0x80, 0x1F, 0xE7, 0xF0,
  0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC3,
  0xFF, 0x9F, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF8,
  0xFE, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF,
  0x03, 0xFC, 0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xFD,
  0xFF, 0xFF, 0xBF, 0x80, 0x67, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0xFE, 0x7F,
  0xE3, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xF9,
  0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC1, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07,
  0xF1, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFD, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x7F, 0x00,
  0xFF, 0x00, 0xFE, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x3F, 0x00, 0xFF, 0x00,
  0xFC, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x3F, 0x81, 0xFF, 0x81, 0xFC, 0x3F,
  0x81, 0xFF, 0x81, 0xFC, 0x1F, 0x81, 0xFF, 0x81, 0xF8, 0x1F, 0x83, 0xFF,
  0xC1, 0xF8, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x1F, 0xC3, 0xE7, 0xC3, 0xF8,
  0x0F, 0xC3, 0xE7, 0xC3, 0xF0, 0x0F, 0xC7, 0xE7, 0xE3, 0xF0, 0x0F, 0xC7,
  0xE7, 0xE3, 0xF0, 0x0F, 0xE7, 0xC3, 0xE7, 0xF0, 0x07, 0xE7, 0xC3, 0xE7,
  0xE0, 0x07, 0xEF, 0xC3, 0xF7, 0xE0, 0x07, 0xEF, 0xC3, 0xF7, 0xE0, 0x07,
  0xEF, 0x81, 0xF7, 0xE0, 0x03, 0xEF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xE7,
  0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x1F,
  0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x83,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0xFF, 0x00,
  0x1F, 0xF0, 0xFE, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF0, 0x07, 0xF8,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F,
  0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F,
  0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0xC0, 0x07,
  0xDF, 0x00, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x1F, 0x07,
  0xC0, 0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1,
  0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x3E,
  0x01, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFF,
  0xF1, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBF, 0x7F, 0xF3, 0xF3, 0xFE, 0x1F, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x7F, 0x07, 0xE7, 0xFC, 0x3F,
  0x7F, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0x87, 0xFB, 0xF8, 0x1F,
  0xDF, 0xC0, 0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE,
  0xFF, 0x0F, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xDF,
  0xF8, 0x7C, 0x3F, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFF, 0x9F, 0xE0, 0xCF, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xFC, 0x01, 0x7F, 0x83, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xF3, 0xF8, 0xFF, 0xDF, 0xCF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0x7F, 0x87, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0x9F, 0x87, 0xF0,
  0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7,
  0xFC, 0xFE, 0x3F, 0x83, 0xFB, 0xF8, 0x0F, 0xDF, 0xC0, 0x7E, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x23, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0x78, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x0F, 0xF1, 0xF8, 0xFF, 0xCF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xBF, 0x87, 0xF9, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF3, 0x00, 0x7F, 0x9F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x1E,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x7F,
  0x87, 0xE7, 0xFE, 0x3F, 0x7F, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0xC7, 0xFB, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x39, 0xFB, 0xFF, 0xFF,
  0xFF, 0x84, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x0F, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0xCF, 0xF0,
  0x3C, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x03, 0xFD, 0xFC, 0x0F, 0xF3, 0xF8, 0x3F, 0xC7, 0xF0, 0xFF,
  0x0F, 0xE1, 0xFC, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0x7F, 0x80,
  0xFD, 0xFE, 0x01, 0xFB, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F, 0x1F, 0xE0, 0xFE,
  0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xC7, 0xF0, 0x3F, 0xCF, 0xE0,
  0x3F, 0x9F, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7F, 0x83, 0xFC,
  0x3E, 0x7F, 0xF1, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0x83, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0x81,
  0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F, 0xFE,
  0x07, 0xF0, 0x1F, 0xFF, 0x81, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x01, 0xFF,
  0xF8, 0x1F, 0xC0, 0x7F, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0x81, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0x01, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F, 0xFE, 0x07, 0xF0,
  0x1F, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0xF8, 0x7F, 0x87, 0xCF, 0xFF, 0x3F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xC7, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x83, 0xFB, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0x7F, 0x07,
  0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x01,
  0xFF, 0x00, 0xF8, 0x7F, 0x07, 0xE7, 0xFE, 0x3F, 0x7F, 0xF1, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x7F, 0x87, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFF, 0x0F, 0xF7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xDF, 0xF8, 0x7E, 0x3F, 0x83,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF1, 0xF8, 0xFF, 0xCF, 0xCF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xBF, 0x87, 0xF9, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xF8, 0x7F, 0xF1, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xDF,
  0xFF, 0xBF, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x1F, 0xFF,
  0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xF3, 0xE7, 0xE0, 0x13, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC1, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x03,
  0xFE, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xF3, 0xFF, 0x9F, 0x8F, 0xF8, 0xFC, 0xFE,
  0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFC, 0x3F,
  0x01, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x83, 0xF8, 0x1F, 0x83, 0xF8, 0x1F,
  0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE7, 0xE0, 0x07,
  0xE7, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F,
  0x81, 0xF9, 0xFC, 0x1F, 0xF0, 0x3F, 0x3F, 0x83, 0xFE, 0x0F, 0xE3, 0xF0,
  0x7F, 0xC1, 0xFC, 0x7E, 0x0F, 0x7C, 0x3F, 0x0F, 0xE3, 0xEF, 0x87, 0xE0,
  0xFC, 0x7D, 0xF1, 0xFC, 0x1F, 0x8F, 0xBE, 0x3F, 0x03, 0xF1, 0xF3, 0xE7,
  0xE0, 0x7F, 0x7C, 0x7C, 0xFC, 0x07, 0xEF, 0x8F, 0xBF, 0x80, 0xFD, 0xF1,
  0xF7, 0xE0, 0x1F, 0xBE, 0x3E, 0xFC, 0x03, 0xF7, 0xC3, 0xDF, 0x80, 0x3E,
  0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80,
  0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x3F, 0x81, 0xFE,
  0x3F, 0xC3, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xE7, 0xF0,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xE7, 0xF0, 0x1F, 0xE3, 0xF8,
  0x3F, 0xC3, 0xFC, 0x3F, 0x81, 0xFC, 0x7F, 0x81, 0xFE, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x01, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8,
  0x1F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7, 0xF0, 0x07, 0xE7, 0xE0,
  0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3C, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xC0, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x01, 0xFC, 0x3F, 0xF0, 0xFF, 0x83, 0xF8, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xFF,
  0x07, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x3F, 0xF0, 0xFF, 0xE1, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xF8, 0x06,
  0x00, 0x00, 0x1C, 0x00, 0x2F, 0xF8, 0x07, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xE0, 0x0F, 0xF0,
};

const GFXglyph NotoSans_ExtraBold40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 8, 29, 11, 2, -29 },
  { 30, 16, 11, 20, 2, -29 },
  { 52, 24, 29, 26, 1, -29 },
  { 139, 21, 32, 23, 1, -30 },
  { 223, 35, 29, 37, 1, -29 },
  { 350, 29, 29, 31, 2, -29 },
  { 456, 7, 11, 11, 2, -29 },
  { 466, 11, 35, 14, 2, -29 },
  { 515, 11, 35, 14, 1, -29 },
  { 564, 20, 19, 22, 1, -30 },
  { 612, 19, 20, 23, 2, -24 },
  { 660, 8, 10, 12, 1, -5 },
  { 670, 11, 5, 13, 1, -13 },
  { 677, 7, 7, 11, 2, -7 },
  { 684, 17, 29, 17, 0, -29 },
  { 746, 21, 29, 23, 1, -29 },
  { 823, 15, 29, 23, 2, -29 },
  { 878, 21, 29, 23, 1, -29 },
  { 955, 21, 29, 23, 1, -29 },
  { 1032, 21, 29, 23, 1, -29 },
  { 1109, 19, 29, 23, 2, -29 },
  { 1178, 21, 29, 23, 1, -29 },
  { 1255, 21, 29, 23, 1, -29 },
  { 1332, 21, 29, 23, 1, -29 },
  { 1409, 21, 29, 23, 1, -29 },
  { 1486, 7, 22, 11, 2, -22 },
  { 1506, 9, 27, 12, 1, -22 },
  { 1537, 19, 21, 23, 2, -25 },
  { 1587, 19, 13, 23, 2, -21 },
  { 1618, 19, 21, 23, 2, -25 },
  { 1668, 19, 29, 20, 0, -29 },
  { 1737, 32, 32, 36, 2, -29 },
  { 1865, 28, 29, 28, 0, -29 },
  { 1967, 22, 29, 27, 3, -29 },
  { 2047, 23, 29, 26, 2, -29 },
  { 2131, 24, 29, 29, 3, -29 },
  { 2218, 17, 29, 22, 3, -29 },
  { 2280, 17, 29, 22, 3, -29 },
  { 2342, 24, 29, 29, 2, -29 },
  { 2429, 24, 29, 31, 3, -29 },
  { 2516, 14, 29, 17, 1, -29 },
  { 2567, 13, 38, 14, -3, -29 },
  { 2629, 24, 29, 27, 3, -29 },
  { 2716, 18, 29, 23, 3, -29 },
  { 2782, 32, 29, 38, 3, -29 },
  { 2898, 27, 29, 33, 3, -29 },
  { 2996, 28, 29, 32, 2, -29 },
  { 3098, 20, 29, 25, 3, -29 },
  { 3171, 28, 36, 32, 2, -29 },
  { 3297, 24, 29, 27, 3, -29 },
  { 3384, 19, 29, 23, 2, -29 },
  { 3453, 21, 29, 23, 1, -29 },
  { 3530, 24, 29, 30, 3, -29 },
  { 3617, 27, 29, 27, 0, -29 },
  { 3715, 40, 29, 40, 0, -29 },
  { 3860, 28, 29, 28, 0, -29 },
  { 3962, 26, 29, 26, 0, -29 },
  { 4057, 22, 29, 24, 1, -29 },
  { 4137, 9, 36, 13, 3, -29 },
  { 4178, 17, 29, 17, 0, -29 },
  { 4240, 10, 36, 13, 1, -29 },
  { 4285, 22, 19, 22, 0, -29 },
  { 4338, 18, 4, 18, 0, 3 },
  { 4347, 12, 7, 16, 2, -31 },
  { 4358, 20, 22, 24, 2, -22 },
  { 4413, 21, 30, 25, 3, -30 },
  { 4492, 18, 22, 21, 2, -22 },
  { 4542, 21, 30, 25, 2, -30 },
  { 4621, 21, 22, 24, 2, -22 },
  { 4679, 16, 31, 16, 1, -31 },
  { 4741, 21, 32, 25, 2, -22 },
  { 4825, 21, 30, 26, 3, -30 },
  { 4904, 7, 31, 12, 3, -31 },
  { 4932, 12, 41, 12, -2, -31 },
  { 4994, 23, 30, 26, 3, -30 },
  { 5081, 7, 30, 12, 3, -30 },
  { 5108, 34, 22, 39, 3, -22 },
  { 5202, 21, 22, 26, 3, -22 },
  { 5260, 21, 22, 25, 2, -22 },
  { 5318, 21, 32, 25, 3, -22 },
  { 5402, 21, 32, 25, 2, -22 },
  { 5486, 15, 22, 18, 3, -22 },
  { 5528, 17, 22, 20, 2, -22 },
  { 5575, 16, 27, 18, 1, -27 },
  { 5629, 21, 22, 26, 3, -22 },
  { 5687, 24, 22, 24, 0, -22 },
  { 5753, 35, 22, 35, 0, -22 },
  { 5850, 24, 22, 24, 0, -22 },
  { 5916, 24, 32, 24, 0, -22 },
  { 6012, 18, 22, 20, 1, -22 },
  { 6062, 14, 36, 16, 1, -29 },
  { 6125, 5, 39, 21, 8, -30 },
  { 6150, 15, 36, 16, 1, -29 },
  { 6218, 19, 7, 23, 2, -18 },
};

const GFXfont NotoSans_ExtraBold40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold40pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_EXTRABOLD40PT7B_H_
