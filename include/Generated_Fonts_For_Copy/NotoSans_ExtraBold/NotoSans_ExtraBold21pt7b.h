#ifndef _NOTOSANS_EXTRABOLD21PT7B_H_
#define _NOTOSANS_EXTRABOLD21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold21pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0x00, 0xFF, 0xF0, 0xF7, 0xE7, 0xE7,
  0x67, 0x67, 0x06, 0x70, 0x33, 0x03, 0x98, 0x1C, 0xC7, 0xFF, 0xBF, 0xFD,
  0xFF, 0xE3, 0x98, 0x1C, 0xC7, 0xFF, 0xFF, 0xFE, 0x33, 0x81, 0x98, 0x1C,
  0xC0, 0xEE, 0x00, 0x0C, 0x03, 0x07, 0xFF, 0xFF, 0xED, 0xBB, 0x0F, 0xC3,
  0xF8, 0x7F, 0x83, 0xF0, 0xFC, 0x37, 0xEF, 0xFF, 0xFF, 0xF8, 0x30, 0x0C,
  0x00, 0x78, 0x1C, 0x3F, 0x06, 0x0E, 0xE3, 0x83, 0x39, 0xC0, 0xCE, 0x70,
  0x33, 0xB8, 0x0E, 0xEE, 0xF3, 0xF7, 0x7E, 0x79, 0x99, 0xC0, 0xEE, 0x70,
  0x33, 0x9C, 0x1C, 0x67, 0x0E, 0x1D, 0xC3, 0x87, 0xE1, 0xC0, 0xF0, 0x1F,
  0x80, 0x7F, 0x81, 0xEF, 0x03, 0x8E, 0x07, 0xBC, 0x07, 0xF0, 0x0F, 0xC0,
  0xBF, 0x0E, 0xFF, 0xBD, 0xEF, 0xFB, 0x8F, 0xE7, 0x8F, 0x8F, 0xFF, 0x8F,
  0xFF, 0x8F, 0xEF, 0x80, 0xFE, 0xE6, 0x60, 0x3C, 0xE7, 0x1C, 0xF3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x87, 0x1C, 0x38, 0xF0, 0xE1, 0xC7, 0x0E,
  0x38, 0xE3, 0x8E, 0x3C, 0xF3, 0x8E, 0x38, 0xE3, 0x9C, 0x73, 0x80, 0x1C,
  0x07, 0x01, 0xC3, 0xB7, 0xFF, 0xFF, 0xF3, 0xE0, 0xDC, 0x77, 0x88, 0x80,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x7F, 0xEE, 0xEC, 0xFF, 0xFE, 0xFF, 0xF0, 0x07, 0x83, 0x81,
  0xC1, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x0F, 0x07, 0x03,
  0x83, 0xC0, 0x3F, 0x1F, 0xE7, 0xFB, 0xCF, 0xF1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7F, 0x1F, 0xCF, 0x7F, 0xDF, 0xE3, 0xF0, 0x0F, 0x1F, 0x3F,
  0x7F, 0xF7, 0x67, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x3F, 0x3F, 0xEF, 0xFD, 0x8F, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0x3F, 0xE7, 0xFD, 0x0F,
  0x03, 0xC0, 0xE3, 0xF0, 0xFC, 0x3F, 0xC0, 0xF0, 0x1E, 0x0F, 0xFF, 0xFF,
  0xEF, 0xF0, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0xFC, 0x0F, 0xC1, 0xDC, 0x39,
  0xC3, 0x9C, 0x71, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x7F, 0x9F, 0xE7, 0xF9, 0xC0, 0x70, 0x3F, 0x8F, 0xFB, 0xFF, 0x03,
  0xC0, 0xF0, 0x1E, 0x0F, 0xFF, 0xFF, 0xEF, 0xF0, 0x0F, 0x8F, 0xE7, 0xF9,
  0xC0, 0xF0, 0x3B, 0xCF, 0xFB, 0xFF, 0xF1, 0xF8, 0x7E, 0x1F, 0xC7, 0x7F,
  0xDF, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0x80, 0xE0, 0x78,
  0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x07, 0x80, 0x3F, 0x1F,
  0xEF, 0x3F, 0xC7, 0xF3, 0xDF, 0xE3, 0xF0, 0xFC, 0x7F, 0xBC, 0xFE, 0x1F,
  0x87, 0xF3, 0xFF, 0xF3, 0xF0, 0x3F, 0x1F, 0xEF, 0xFF, 0x8F, 0xE1, 0xF8,
  0x7E, 0x3F, 0xFF, 0x7F, 0xCF, 0x70, 0x1C, 0x0E, 0x7F, 0x9F, 0xC7, 0xC0,
  0x6F, 0xF6, 0x00, 0x00, 0x0F, 0xFF, 0x6F, 0xF6, 0x00, 0x00, 0x07, 0xFE,
  0xEE, 0xC0, 0x00, 0x40, 0x70, 0x7C, 0x7C, 0x7C, 0x3C, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x70, 0x04, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x80, 0x38, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0xFC, 0xFC, 0xFC,
  0x38, 0x08, 0x00, 0x7F, 0x3F, 0xE7, 0xFD, 0x0F, 0x03, 0xC1, 0xE0, 0xF8,
  0x78, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x07, 0x01, 0xC0, 0x07, 0xF8,
  0x0F, 0xFE, 0x0F, 0x03, 0x8E, 0x00, 0xE7, 0x3F, 0xB7, 0x3F, 0xDF, 0xB8,
  0xEF, 0xDC, 0x77, 0xCE, 0x33, 0xE7, 0x19, 0xFB, 0xDF, 0xDC, 0xFB, 0xE6,
  0x18, 0xC3, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x77, 0x00, 0xEE, 0x03, 0xDE, 0x07, 0x1C,
  0x0E, 0x38, 0x3C, 0x78, 0x7F, 0xF0, 0xFF, 0xE3, 0xFF, 0xE7, 0x83, 0xCE,
  0x07, 0xBC, 0x07, 0x80, 0xFF, 0x1F, 0xFB, 0xFF, 0x70, 0xFE, 0x1F, 0xC7,
  0xBF, 0xE7, 0xFC, 0xFF, 0xDC, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0xFF, 0xBF,
  0xC0, 0x0F, 0xE3, 0xFF, 0x3F, 0xE7, 0x82, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0x7F, 0xE3, 0xFE, 0x0F, 0xE0,
  0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0xFD, 0xFE, 0xFF, 0x70, 0x38, 0x1C,
  0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x0F, 0xF8, 0xFF, 0x8F, 0xFC,
  0xF8, 0x27, 0x80, 0x78, 0x03, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x83, 0xDC,
  0x1E, 0xF0, 0xF7, 0xFF, 0x9F, 0xFC, 0x3F, 0xC0, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xFF, 0xFD, 0xF1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0xDF, 0xFF, 0x80, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x9F,
  0xFF, 0xF1, 0x00, 0xE0, 0xFE, 0x1E, 0xE3, 0xCE, 0x3C, 0xE7, 0x8E, 0xF0,
  0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0x78, 0xE3, 0x8E, 0x3C, 0xE1, 0xEE, 0x1E,
  0xE0, 0xF0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFF, 0xFE, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x37, 0xEE, 0x77, 0xEE, 0x77, 0xEE,
  0x77, 0xE6, 0x67, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xC7, 0xE3, 0xC7, 0xE3,
  0xC7, 0xF8, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFE, 0x3F, 0xB8, 0xFE,
  0xF3, 0xF9, 0xEF, 0xE7, 0xBF, 0x8F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF,
  0x83, 0xFE, 0x07, 0xC0, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xC1, 0xEF,
  0x03, 0xDE, 0x03, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3B, 0xC0,
  0xF3, 0xC3, 0xE7, 0xFF, 0x87, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x3F, 0xEF,
  0xFF, 0x8F, 0xE1, 0xF8, 0x7E, 0x3F, 0xFF, 0xFF, 0xBF, 0x8E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x00, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xC1, 0xEF,
  0x03, 0xDE, 0x03, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3B, 0xC0,
  0xF3, 0xC3, 0xE7, 0xFF, 0x87, 0xFE, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0xFF, 0x0F, 0xF8, 0xFF, 0xCE, 0x3C, 0xE1, 0xCE,
  0x1C, 0xE7, 0xCF, 0xF8, 0xFF, 0x0E, 0x70, 0xE7, 0x8E, 0x3C, 0xE1, 0xCE,
  0x1E, 0xE0, 0xF0, 0x3F, 0x9F, 0xFF, 0xFB, 0xC2, 0xF0, 0x3E, 0x07, 0xE0,
  0xFE, 0x1F, 0xC1, 0xF0, 0x3E, 0x0F, 0xFF, 0xFF, 0xEF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0xFF, 0x0F, 0xFF, 0xE7, 0xFE, 0x3F, 0x80, 0xF0, 0x3F, 0xC0, 0xF7,
  0x83, 0x9E, 0x1E, 0x78, 0x78, 0xE1, 0xC3, 0xCF, 0x0F, 0x3C, 0x1C, 0xE0,
  0x7F, 0x81, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0xF0,
  0x70, 0x7B, 0x87, 0xC3, 0x9C, 0x3E, 0x1C, 0xE1, 0xF0, 0xE7, 0x8D, 0x8F,
  0x1C, 0xEE, 0x70, 0xE7, 0x73, 0x87, 0x3B, 0x9C, 0x3D, 0xDD, 0xE0, 0xEC,
  0x6E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0x83, 0xC0,
  0x3C, 0x1E, 0x00, 0xF8, 0x3C, 0xF0, 0xF0, 0xF1, 0xE0, 0xE7, 0x81, 0xFE,
  0x01, 0xFC, 0x03, 0xF0, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7B, 0x81,
  0xE7, 0x83, 0xC7, 0x8F, 0x0F, 0x3C, 0x0F, 0x80, 0xF0, 0x7D, 0xE1, 0xE7,
  0x8F, 0x0F, 0x3C, 0x3D, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF0, 0x1C, 0x07,
  0x81, 0xE0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF9, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xC0, 0xF0, 0x38, 0x1C, 0x0F,
  0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x38,
  0x1E, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x0F, 0x81, 0xB8, 0x73, 0x0C,
  0x73, 0x86, 0x60, 0xFC, 0x0C, 0xFF, 0xFF, 0xF0, 0xF0, 0xE1, 0xC0, 0x1F,
  0x1F, 0xE3, 0xFC, 0x87, 0x01, 0xCF, 0xFF, 0xFF, 0xC7, 0xE1, 0xFC, 0xFF,
  0xFD, 0xF3, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x39, 0xFF, 0xBF, 0xFF,
  0xCF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xFF, 0xFF, 0xF7, 0x3C,
  0x0F, 0x0F, 0xF7, 0xFB, 0xE2, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x5F,
  0xE7, 0xF8, 0xFE, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF1, 0xDE, 0xFF, 0xDF,
  0xFF, 0x8F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xFF, 0xDF, 0xF9,
  0xE7, 0x0E, 0x07, 0xF1, 0xFF, 0x78, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x0F, 0x19, 0xFF, 0x0F, 0xE0, 0x0F, 0x8F, 0xCF, 0xC7, 0x83, 0xF7,
  0xFB, 0xFC, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x1C, 0xEF, 0xDD, 0xFF, 0xF8, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1,
  0xFF, 0xFD, 0xFF, 0x9E, 0xF0, 0x1F, 0x03, 0xDF, 0xF3, 0xFE, 0x7F, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x39, 0xFF, 0xBF, 0xFF, 0xCF, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0x7F, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0xF1, 0xC0, 0x3C, 0xF3, 0xCF,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xFF, 0xFE, 0xF0, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x1F, 0xC7, 0xB9, 0xE7, 0x38, 0xEF, 0x1F, 0xC3,
  0xFC, 0x7F, 0x8E, 0x79, 0xC7, 0xB8, 0xF7, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0x87, 0x3F, 0xF7, 0xEF, 0xFF, 0xFF, 0xE7,
  0xCF, 0xF0, 0xE1, 0xFC, 0x38, 0x7F, 0x0E, 0x1F, 0xC3, 0x87, 0xF0, 0xE1,
  0xFC, 0x38, 0x7F, 0x0E, 0x1F, 0xC3, 0x87, 0xE3, 0x9D, 0xFF, 0xFF, 0xFC,
  0xFF, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x70,
  0x0E, 0x07, 0xF1, 0xFF, 0x78, 0xFF, 0x1F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1,
  0xEF, 0x7D, 0xFF, 0x0F, 0xC0, 0xE3, 0x9F, 0xFB, 0xFF, 0xFC, 0xFF, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFF, 0xFF, 0xFF, 0x7B, 0xCF, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x00, 0x1C, 0xEF, 0xDD, 0xFF, 0xF8, 0xFF, 0x1F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xFF, 0xFD, 0xFF, 0x9E, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0xE3, 0xEF, 0xFF, 0xFF, 0xF8, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x1E, 0x3F, 0xFF, 0xDC, 0x2F, 0x87, 0xF0,
  0xFC, 0x1F, 0x07, 0xF3, 0xFF, 0xDF, 0xC0, 0x1C, 0x0E, 0x0F, 0xEF, 0xFF,
  0xF9, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xF3, 0xF8, 0xFC, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xEF,
  0xFD, 0xFF, 0x9F, 0x30, 0xF0, 0x7F, 0x0F, 0x70, 0xF7, 0x8E, 0x39, 0xE3,
  0x9C, 0x3D, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF0, 0xF1, 0xE1,
  0xDC, 0x78, 0x77, 0x1F, 0x3D, 0xC7, 0xCE, 0x7B, 0xB3, 0x8E, 0xEC, 0xE3,
  0xB3, 0xF8, 0xEC, 0xFC, 0x3B, 0x3F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x78,
  0x78, 0xF0, 0xF3, 0xC7, 0x8E, 0x78, 0x7B, 0x81, 0xFC, 0x07, 0xC0, 0x3E,
  0x03, 0xF8, 0x3F, 0xC1, 0xEF, 0x1E, 0x3D, 0xE1, 0xF0, 0xF0, 0x7F, 0x0F,
  0x70, 0xF7, 0x8E, 0x39, 0xE3, 0x9C, 0x3D, 0xC1, 0xDC, 0x1F, 0x80, 0xF8,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x7E, 0x07, 0xC0, 0x78, 0x00, 0xFF,
  0xFF, 0xFF, 0xE1, 0xE0, 0xE0, 0xF0, 0xF0, 0xF0, 0x70, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0x1F, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0xF8, 0xF8, 0xFC,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xE1, 0xE3, 0xE1, 0xC3, 0x87, 0x0E, 0x1E, 0x3E, 0x3C,
  0xF9, 0xC3, 0x87, 0x0E, 0x3C, 0xF1, 0xE0, 0xFC, 0x7F, 0xF8, 0xFC,
};

const GFXglyph NotoSans_ExtraBold21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 15, 6, 1, -15 },
  { 9, 8, 5, 11, 1, -15 },
  { 14, 13, 15, 14, 0, -15 },
  { 39, 10, 17, 12, 1, -16 },
  { 61, 18, 15, 19, 1, -15 },
  { 95, 15, 15, 16, 1, -15 },
  { 124, 4, 5, 6, 1, -15 },
  { 127, 6, 18, 7, 1, -15 },
  { 141, 6, 18, 7, 1, -15 },
  { 155, 10, 10, 11, 1, -16 },
  { 168, 10, 11, 12, 1, -13 },
  { 182, 4, 6, 6, 1, -3 },
  { 185, 5, 3, 7, 1, -7 },
  { 187, 4, 3, 6, 1, -3 },
  { 189, 9, 15, 9, 0, -15 },
  { 206, 10, 15, 12, 1, -15 },
  { 225, 8, 15, 12, 1, -15 },
  { 240, 10, 15, 12, 1, -15 },
  { 259, 10, 15, 12, 1, -15 },
  { 278, 12, 15, 12, 0, -15 },
  { 301, 10, 15, 12, 1, -15 },
  { 320, 10, 15, 12, 1, -15 },
  { 339, 10, 15, 12, 1, -15 },
  { 358, 10, 15, 12, 1, -15 },
  { 377, 10, 15, 12, 1, -15 },
  { 396, 4, 12, 6, 1, -12 },
  { 402, 4, 15, 6, 1, -12 },
  { 410, 10, 11, 12, 1, -13 },
  { 424, 10, 7, 12, 1, -11 },
  { 433, 10, 11, 12, 1, -13 },
  { 447, 10, 15, 10, 0, -15 },
  { 466, 17, 17, 19, 1, -15 },
  { 503, 15, 15, 15, 0, -15 },
  { 532, 11, 15, 14, 2, -15 },
  { 553, 12, 15, 14, 1, -15 },
  { 576, 12, 15, 15, 2, -15 },
  { 599, 9, 15, 12, 2, -15 },
  { 616, 8, 15, 11, 2, -15 },
  { 631, 13, 15, 15, 1, -15 },
  { 656, 12, 15, 16, 2, -15 },
  { 679, 7, 15, 9, 1, -15 },
  { 693, 7, 20, 7, -2, -15 },
  { 711, 12, 15, 14, 2, -15 },
  { 734, 9, 15, 12, 2, -15 },
  { 751, 16, 15, 20, 2, -15 },
  { 781, 14, 15, 17, 2, -15 },
  { 808, 15, 15, 17, 1, -15 },
  { 837, 10, 15, 13, 2, -15 },
  { 856, 15, 19, 17, 1, -15 },
  { 892, 12, 15, 14, 2, -15 },
  { 915, 10, 15, 12, 1, -15 },
  { 934, 12, 15, 12, 0, -15 },
  { 957, 12, 15, 16, 2, -15 },
  { 980, 14, 15, 14, 0, -15 },
  { 1007, 21, 15, 21, 0, -15 },
  { 1047, 15, 15, 15, 0, -15 },
  { 1076, 14, 15, 14, 0, -15 },
  { 1103, 11, 15, 12, 1, -15 },
  { 1124, 5, 18, 7, 1, -15 },
  { 1136, 9, 15, 9, 0, -15 },
  { 1153, 6, 18, 7, 0, -15 },
  { 1167, 11, 10, 12, 0, -15 },
  { 1181, 10, 2, 9, 0, 2 },
  { 1184, 6, 3, 8, 1, -16 },
  { 1187, 10, 12, 13, 1, -12 },
  { 1202, 11, 16, 13, 1, -16 },
  { 1224, 10, 12, 11, 1, -12 },
  { 1239, 11, 16, 13, 1, -16 },
  { 1261, 11, 12, 13, 1, -12 },
  { 1278, 9, 16, 8, 0, -16 },
  { 1296, 11, 17, 13, 1, -12 },
  { 1320, 11, 16, 14, 1, -16 },
  { 1342, 4, 16, 7, 1, -16 },
  { 1350, 6, 21, 7, -1, -16 },
  { 1366, 11, 16, 13, 2, -16 },
  { 1388, 4, 16, 6, 1, -16 },
  { 1396, 18, 12, 21, 1, -12 },
  { 1423, 11, 12, 14, 1, -12 },
  { 1440, 11, 12, 13, 1, -12 },
  { 1457, 11, 17, 13, 1, -12 },
  { 1481, 11, 17, 13, 1, -12 },
  { 1505, 8, 12, 10, 1, -12 },
  { 1517, 9, 12, 11, 1, -12 },
  { 1531, 9, 14, 9, 0, -14 },
  { 1547, 11, 12, 14, 1, -12 },
  { 1564, 12, 12, 12, 0, -12 },
  { 1582, 18, 12, 19, 0, -12 },
  { 1609, 13, 12, 13, 0, -12 },
  { 1629, 12, 17, 12, 0, -12 },
  { 1655, 9, 12, 10, 1, -12 },
  { 1669, 8, 18, 9, 0, -15 },
  { 1687, 3, 21, 11, 4, -16 },
  { 1695, 7, 18, 9, 1, -15 },
  { 1711, 10, 3, 12, 1, -9 },
};

const GFXfont NotoSans_ExtraBold21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold21pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_EXTRABOLD21PT7B_H_
