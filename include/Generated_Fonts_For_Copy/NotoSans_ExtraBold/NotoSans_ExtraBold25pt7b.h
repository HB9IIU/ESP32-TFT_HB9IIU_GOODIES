#ifndef _NOTOSANS_EXTRABOLD25PT7B_H_
#define _NOTOSANS_EXTRABOLD25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0x9C, 0xE0, 0x01, 0xDF, 0xFB,
  0xC0, 0xF3, 0xDC, 0xF7, 0x3D, 0xCF, 0x73, 0xDC, 0xF7, 0x18, 0x03, 0x9C,
  0x03, 0x1C, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38, 0x7F, 0xFF, 0x7F, 0xFF,
  0x7F, 0xFF, 0x0E, 0x70, 0x0E, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x06, 0x00,
  0x30, 0x0F, 0xF8, 0xFF, 0xEF, 0xFF, 0x7B, 0x13, 0xD8, 0x1F, 0xC0, 0xFF,
  0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x6F, 0x83, 0x3F, 0x1B, 0xDF, 0xFE,
  0xFF, 0xE3, 0xFE, 0x01, 0x80, 0x0C, 0x00, 0x3C, 0x03, 0x83, 0xF0, 0x38,
  0x3F, 0xC3, 0xC1, 0xCE, 0x1C, 0x0E, 0x71, 0xE0, 0x73, 0x8E, 0x03, 0x9C,
  0xF0, 0x1C, 0xE7, 0x3C, 0xFF, 0x73, 0xF3, 0xF3, 0xBF, 0xCF, 0x39, 0xCE,
  0x03, 0xCE, 0x70, 0x1C, 0x73, 0x81, 0xE3, 0x9C, 0x0E, 0x1C, 0xE0, 0xF0,
  0xFF, 0x07, 0x03, 0xF0, 0x70, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0xF3, 0xC0, 0x38, 0xF0, 0x0F, 0x3C, 0x03, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0x87, 0xDF, 0xF1, 0xE7, 0xFE, 0xFB, 0xE7, 0xFC, 0xF0, 0xFF,
  0x3C, 0x1F, 0x8F, 0x8F, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xF1, 0xF0,
  0xF7, 0x77, 0x77, 0x70, 0x1E, 0x78, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xF1, 0xE1, 0xC3, 0xC3, 0xC0,
  0xF0, 0xE1, 0xE1, 0xC3, 0xC7, 0x87, 0x0E, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x0E, 0x3C, 0x78, 0xE3, 0xC7, 0x1E, 0x00, 0x0E, 0x00, 0xE0, 0x0E,
  0x08, 0xE2, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF0, 0x3F, 0x83, 0xBC, 0x79,
  0xE1, 0x10, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x7B, 0xBD, 0xEE, 0x70,
  0xFF, 0xFF, 0xC0, 0x77, 0xFE, 0xF0, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0x1F, 0x81, 0xFE, 0x1F, 0xF8,
  0xF3, 0xEF, 0x8F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xEF, 0x0F, 0x7C, 0x79, 0xE7, 0xCF, 0xFC, 0x3F, 0xE0, 0xFC,
  0x00, 0x03, 0xC1, 0xF1, 0xFC, 0xFF, 0xFF, 0xDE, 0xF3, 0x3C, 0x8F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x1F, 0x83, 0xFF, 0x3F, 0xFC, 0xFF, 0xE6, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x8F, 0xFE, 0xFF, 0xF7, 0x3F,
  0x40, 0xF0, 0x0F, 0x01, 0xE1, 0xFC, 0x1F, 0x01, 0xFE, 0x0F, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xC1, 0xFF, 0xFF, 0xFF, 0xE7, 0xF8, 0x00, 0xF0, 0x07,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xEF, 0x07, 0xBC, 0x3C,
  0xF0, 0xE3, 0xC7, 0x8F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x78,
  0x07, 0x80, 0x7A, 0x07, 0xFC, 0x7F, 0xE7, 0xFF, 0x01, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0xC1, 0xFF, 0xFE, 0xFF, 0xE7, 0xF8, 0x07, 0xE0, 0xFF, 0x0F,
  0xF8, 0xFC, 0x07, 0x80, 0x38, 0x03, 0xCE, 0x1F, 0xFC, 0xFF, 0xF7, 0xFF,
  0xBE, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7D, 0xE3, 0xCF, 0xFE, 0x3F, 0xE0,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x00, 0x1F, 0x83, 0xFF, 0x1F,
  0xFD, 0xF1, 0xEF, 0x0F, 0x3C, 0x79, 0xF7, 0x87, 0xFC, 0x1F, 0x81, 0xFE,
  0x1F, 0xFD, 0xF1, 0xEF, 0x0F, 0xF8, 0x3F, 0xC3, 0xDF, 0xFE, 0x7F, 0xE1,
  0xFE, 0x00, 0x1F, 0x81, 0xFE, 0x1F, 0xF9, 0xF3, 0xEF, 0x0F, 0x78, 0x7B,
  0xC3, 0xFE, 0x1F, 0xF9, 0xFB, 0xFF, 0xDF, 0xDC, 0x3D, 0xE0, 0x0F, 0x00,
  0x78, 0x0F, 0x8F, 0xF8, 0x7F, 0x83, 0xF8, 0x00, 0x77, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x1D, 0xFF, 0xBC, 0x77, 0xFE, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xF7, 0x7B, 0xDC, 0xE0, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x0F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x00, 0x30,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF0,
  0x1F, 0x07, 0xF3, 0xFC, 0xFE, 0x0F, 0x80, 0xE0, 0x08, 0x00, 0x3F, 0x8F,
  0xFE, 0x7F, 0xE7, 0x1F, 0x40, 0xF0, 0x0F, 0x01, 0xE0, 0x7E, 0x0F, 0xC0,
  0xF0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xE0, 0x1E, 0x38,
  0x00, 0xE7, 0x9F, 0xE7, 0x73, 0xFE, 0x7F, 0x38, 0xE7, 0xE7, 0x0E, 0x7E,
  0x70, 0xE7, 0xE7, 0x0E, 0x7E, 0x70, 0xE7, 0xE7, 0x9E, 0xFF, 0x3F, 0xFE,
  0x71, 0xF3, 0xC7, 0x80, 0x00, 0x3C, 0x01, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x07, 0x78, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC7, 0xC0,
  0xF9, 0xE0, 0x3E, 0xF8, 0x07, 0xBE, 0x01, 0xF0, 0xFF, 0xC3, 0xFF, 0xCF,
  0xFF, 0xBC, 0xFE, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0xBF, 0xFC, 0xFF, 0xC3,
  0xFF, 0xCF, 0x1F, 0xBC, 0x1E, 0xF0, 0x7F, 0xC1, 0xEF, 0x0F, 0xBF, 0xFE,
  0xFF, 0xF3, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0xFE, 0x7C,
  0x05, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xF1, 0xCF, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0,
  0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF, 0xEF, 0x07, 0xDE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xDE, 0x0F, 0xBF, 0xFE, 0x7F, 0xFC, 0xFF, 0xE1, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0xFE, 0xFF, 0xDF, 0xFB,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x03, 0xFC,
  0x1F, 0xFC, 0x7F, 0xF9, 0xFD, 0xE7, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0xFF, 0xF1, 0xFF, 0xE3, 0xFB, 0xC0, 0xF7, 0x81, 0xEF, 0x83,
  0xCF, 0xC7, 0x9F, 0xFF, 0x1F, 0xFE, 0x0F, 0xF8, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xE7, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF1, 0xFE,
  0xFF, 0xFF, 0xC0, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0xFF,
  0xFE, 0xFC, 0xF0, 0x3F, 0xE0, 0xFB, 0xC3, 0xE7, 0x87, 0x8F, 0x1F, 0x1E,
  0x7C, 0x3D, 0xF0, 0x7B, 0xC0, 0xFF, 0x81, 0xFF, 0x83, 0xFF, 0x07, 0xDF,
  0x0F, 0x1F, 0x1E, 0x3E, 0x3C, 0x3E, 0x78, 0x3C, 0xF0, 0x7D, 0xE0, 0x7C,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0E, 0xFF, 0x70, 0xEF, 0xF7, 0x1E, 0xFF,
  0x79, 0xCF, 0xF3, 0x9C, 0xFF, 0x3B, 0xCF, 0xF3, 0xF8, 0xFF, 0x3F, 0x8F,
  0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF1, 0xF0, 0xFF, 0x0F, 0x0F, 0xFC, 0x07,
  0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x87, 0xF7, 0x87,
  0xF7, 0xC7, 0xF3, 0xC7, 0xF3, 0xE7, 0xF1, 0xE7, 0xF1, 0xF7, 0xF0, 0xF7,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0x07, 0xF8,
  0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFD, 0xFC, 0x7C, 0x0F, 0x9E, 0x03, 0xE7,
  0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xFF, 0x80, 0x79, 0xE0,
  0x1E, 0x78, 0x0F, 0x9F, 0x03, 0xE3, 0xF3, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xFF, 0xEF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1E, 0xFF, 0xF7, 0xFF, 0xBF, 0xF9, 0xFE, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xF0, 0xFD, 0xFC, 0x7C, 0x0F, 0x9E, 0x03, 0xE7, 0x80,
  0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBE, 0x01, 0xFF, 0x80, 0x79, 0xE0, 0x1E,
  0x78, 0x0F, 0x9F, 0x03, 0xE3, 0xF3, 0xF0, 0xFF, 0xFC, 0x1F, 0xFE, 0x01,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0xFF,
  0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x9F, 0x8F, 0x0F, 0x9E, 0x1F, 0x3C, 0x3E,
  0x78, 0x78, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x07, 0x9F, 0x0F, 0x1E, 0x1E,
  0x3E, 0x3C, 0x3E, 0x78, 0x7C, 0xF0, 0x7D, 0xE0, 0x7C, 0x1F, 0xC3, 0xFF,
  0x7F, 0xFF, 0xDE, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFE,
  0x07, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xF1, 0xFF, 0xFE, 0xFF, 0xE7, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFF, 0x07, 0xDF, 0x3F, 0x3F, 0xFE,
  0x3F, 0xF8, 0x3F, 0xC0, 0xF8, 0x0F, 0xFC, 0x07, 0x9E, 0x07, 0xCF, 0x83,
  0xE7, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0xF8, 0x7C, 0x78, 0x1E, 0x3C, 0x0F,
  0x3E, 0x07, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x3E, 0x07, 0xBC, 0x1F,
  0x07, 0x9E, 0x0F, 0x83, 0xCF, 0x07, 0xC1, 0xE7, 0x87, 0xF0, 0xF1, 0xE3,
  0xB8, 0xF0, 0xF1, 0xDC, 0x78, 0x78, 0xEE, 0x3C, 0x3C, 0xF7, 0x9E, 0x0E,
  0x7B, 0xCE, 0x07, 0xB8, 0xEF, 0x03, 0xDC, 0x77, 0x81, 0xEE, 0x3B, 0xC0,
  0x7F, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x0F, 0xBE, 0x0F, 0x8F, 0x87, 0x83, 0xC7,
  0xC1, 0xF7, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xF7, 0xC0, 0xF9, 0xE0, 0xF8, 0xF8,
  0x78, 0x3E, 0x7C, 0x1F, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x78, 0x1E, 0x7C,
  0x3E, 0x3C, 0x3C, 0x3E, 0x7C, 0x1E, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x3F, 0xFF, 0xF0, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70,
  0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xFF, 0xFF, 0xF0,
  0x07, 0x00, 0x1C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x77, 0x01, 0xCE,
  0x0E, 0x38, 0x38, 0x71, 0xC1, 0xC7, 0x03, 0xBC, 0x0F, 0xFF, 0xFF, 0xFC,
  0xF8, 0x3C, 0x1E, 0x0F, 0x1F, 0xC3, 0xFF, 0x0F, 0xFC, 0x61, 0xE0, 0x0F,
  0x83, 0xFC, 0xFF, 0xEF, 0xFF, 0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xF7,
  0xF7, 0x9F, 0x3C, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x79,
  0xE3, 0xFF, 0x9F, 0xFE, 0xFD, 0xF7, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x7F, 0xC3, 0xFF, 0x3E, 0xFF, 0xF7, 0xFF, 0x39, 0xF0, 0x0F, 0xC3,
  0xFF, 0x7F, 0xE7, 0xEE, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x67, 0xFE, 0x3F, 0xE1, 0xFC, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x8F, 0x3C, 0xFF, 0xEF, 0xFF, 0x7F, 0xFF, 0xC3, 0xFE,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xEF, 0x9F, 0x7F, 0xF9, 0xFF,
  0xC7, 0xCE, 0x0F, 0xC1, 0xFF, 0x1F, 0xFC, 0xF1, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x1E, 0x04, 0xFF, 0xE3, 0xFF, 0x07,
  0xF8, 0x1F, 0xCF, 0xF3, 0xF8, 0xF0, 0x3C, 0x1F, 0xEF, 0xFB, 0xFE, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC0, 0x1E, 0x79, 0xFF, 0xDF, 0xFE, 0xFB, 0xFF, 0x87, 0xFC, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xDE, 0x3E, 0xFF, 0xF3, 0xFF, 0x8F, 0xBC,
  0x01, 0xE0, 0x0F, 0x71, 0xFB, 0xFF, 0x9F, 0xF8, 0x7F, 0x80, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x79, 0xE3, 0xFF, 0xDF, 0xFE, 0xFD,
  0xFF, 0xC7, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1E, 0xFF, 0xF6, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1E, 0x3C, 0x78, 0x60, 0x03, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xF7, 0xFF, 0xFE,
  0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC1, 0xFF,
  0x0F, 0xBC, 0x7C, 0xF3, 0xE3, 0xDF, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFF, 0x0F, 0xBE, 0x3C, 0x7C, 0xF1, 0xF3, 0xC3, 0xEF, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0xC3, 0xE7,
  0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFB, 0xFB, 0xFF, 0x8F, 0x8F, 0xF8, 0x7C,
  0x3F, 0xC3, 0xE1, 0xFE, 0x1E, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83, 0xFC,
  0x3C, 0x1F, 0xE1, 0xE0, 0xFF, 0x0F, 0x07, 0xF8, 0x78, 0x3C, 0xE3, 0xC7,
  0x7F, 0xBF, 0xFD, 0xFB, 0xFF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3C, 0x0F, 0xC0, 0xFF,
  0x87, 0xFF, 0x1F, 0x3E, 0xF8, 0x7B, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xF8,
  0x7F, 0xE1, 0xE7, 0x8F, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0xE3, 0xC7,
  0xFF, 0x3F, 0xFD, 0xFB, 0xEF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0x87, 0xFE, 0x7D, 0xFF, 0xEF, 0xFE, 0x7B, 0xE3, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x79, 0xFF, 0xDF, 0xFE,
  0xF9, 0xFF, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0xC3, 0xDE,
  0x3E, 0xFF, 0xF3, 0xFF, 0x8F, 0xBC, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0xE3, 0xF7, 0xFF, 0xFF, 0xFF, 0x87, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x1F, 0x8F, 0xFF, 0xFF,
  0x78, 0x6F, 0x81, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xFF,
  0xEF, 0xFD, 0xFF, 0x00, 0x1C, 0x1E, 0x0F, 0x0F, 0xFF, 0xFF, 0xFD, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE4, 0xFE, 0x7F, 0x1F, 0x80,
  0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0x9F, 0x3C, 0xF0,
  0x3F, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xE3, 0xC7, 0x87, 0x8F, 0x0F, 0x3C,
  0x0F, 0x78, 0x1E, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF0, 0x78, 0x3D, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x9E, 0x3F,
  0x1E, 0x78, 0xFC, 0x78, 0xF7, 0xFB, 0xC3, 0xDC, 0xEF, 0x0F, 0x73, 0xBC,
  0x1D, 0xCE, 0xE0, 0x77, 0x3B, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x0F,
  0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0xF8, 0xF8, 0xF1, 0xE1, 0xF7,
  0xC1, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xE0,
  0xFB, 0xE1, 0xE3, 0xC7, 0xC7, 0xDF, 0x07, 0xC0, 0xF8, 0x3F, 0xF0, 0x79,
  0xE0, 0xF3, 0xC3, 0xE3, 0xC7, 0x87, 0x8F, 0x0F, 0x3C, 0x0F, 0x78, 0x1E,
  0xF0, 0x1D, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x5F, 0x80, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x83,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x1F, 0x1F, 0x1E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x3C, 0xFC, 0xF8, 0xF8, 0xFC, 0x3C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1E, 0x1F, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x7C, 0x3F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1F, 0xC7, 0xE1, 0xF3, 0xF9, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x1F,
  0x8F, 0x87, 0x80, 0x7C, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F,
};

const GFXglyph NotoSans_ExtraBold25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 18, 7, 1, -18 },
  { 13, 10, 7, 13, 1, -18 },
  { 22, 16, 18, 16, 0, -18 },
  { 58, 13, 20, 14, 1, -19 },
  { 91, 21, 18, 23, 1, -18 },
  { 139, 18, 18, 19, 1, -18 },
  { 180, 4, 7, 7, 1, -18 },
  { 184, 7, 22, 9, 1, -18 },
  { 204, 7, 22, 9, 1, -18 },
  { 224, 12, 12, 14, 1, -19 },
  { 242, 12, 12, 14, 1, -15 },
  { 260, 5, 6, 7, 1, -3 },
  { 264, 6, 3, 8, 1, -8 },
  { 267, 5, 4, 7, 1, -4 },
  { 270, 11, 18, 11, 0, -18 },
  { 295, 13, 18, 14, 1, -18 },
  { 325, 10, 18, 14, 1, -18 },
  { 348, 13, 18, 14, 1, -18 },
  { 378, 12, 18, 14, 1, -18 },
  { 405, 14, 18, 14, 0, -18 },
  { 437, 12, 18, 14, 1, -18 },
  { 464, 13, 18, 14, 1, -18 },
  { 494, 13, 18, 14, 1, -18 },
  { 524, 13, 18, 14, 1, -18 },
  { 554, 13, 18, 14, 1, -18 },
  { 584, 5, 14, 7, 1, -14 },
  { 593, 5, 17, 7, 1, -14 },
  { 604, 12, 14, 14, 1, -16 },
  { 625, 12, 8, 14, 1, -13 },
  { 637, 12, 14, 14, 1, -16 },
  { 658, 12, 18, 12, 0, -18 },
  { 685, 20, 20, 22, 1, -18 },
  { 735, 18, 18, 18, 0, -18 },
  { 776, 14, 18, 17, 2, -18 },
  { 808, 14, 18, 16, 1, -18 },
  { 840, 15, 18, 18, 2, -18 },
  { 874, 11, 18, 14, 2, -18 },
  { 899, 10, 18, 14, 2, -18 },
  { 922, 15, 18, 18, 1, -18 },
  { 956, 15, 18, 19, 2, -18 },
  { 990, 9, 18, 10, 1, -18 },
  { 1011, 8, 23, 9, -2, -18 },
  { 1034, 15, 18, 17, 2, -18 },
  { 1068, 11, 18, 14, 2, -18 },
  { 1093, 20, 18, 24, 2, -18 },
  { 1138, 16, 18, 21, 2, -18 },
  { 1174, 18, 18, 20, 1, -18 },
  { 1215, 13, 18, 16, 2, -18 },
  { 1245, 18, 22, 20, 1, -18 },
  { 1295, 15, 18, 17, 2, -18 },
  { 1329, 12, 18, 14, 1, -18 },
  { 1356, 13, 18, 15, 1, -18 },
  { 1386, 15, 18, 19, 2, -18 },
  { 1420, 17, 18, 17, 0, -18 },
  { 1459, 25, 18, 25, 0, -18 },
  { 1516, 17, 18, 17, 0, -18 },
  { 1555, 16, 18, 16, 0, -18 },
  { 1591, 13, 18, 15, 1, -18 },
  { 1621, 6, 22, 8, 2, -18 },
  { 1638, 11, 18, 11, 0, -18 },
  { 1663, 6, 22, 8, 1, -18 },
  { 1680, 14, 12, 14, 0, -18 },
  { 1701, 11, 2, 11, 0, 2 },
  { 1704, 8, 4, 10, 1, -19 },
  { 1708, 13, 14, 15, 1, -14 },
  { 1731, 13, 19, 16, 2, -19 },
  { 1762, 12, 14, 13, 1, -14 },
  { 1783, 13, 19, 16, 1, -19 },
  { 1814, 13, 14, 15, 1, -14 },
  { 1837, 10, 19, 10, 1, -19 },
  { 1861, 13, 20, 16, 1, -14 },
  { 1894, 13, 19, 16, 2, -19 },
  { 1925, 4, 19, 8, 2, -19 },
  { 1935, 7, 25, 8, -1, -19 },
  { 1957, 14, 19, 16, 2, -19 },
  { 1991, 4, 19, 8, 2, -19 },
  { 2001, 21, 14, 25, 2, -14 },
  { 2038, 13, 14, 16, 2, -14 },
  { 2061, 14, 14, 16, 1, -14 },
  { 2086, 13, 20, 16, 2, -14 },
  { 2119, 13, 20, 16, 1, -14 },
  { 2152, 9, 14, 11, 2, -14 },
  { 2168, 11, 14, 13, 1, -14 },
  { 2188, 9, 17, 11, 1, -17 },
  { 2208, 13, 14, 16, 2, -14 },
  { 2231, 15, 14, 15, 0, -14 },
  { 2258, 22, 14, 22, 0, -14 },
  { 2297, 15, 14, 15, 0, -14 },
  { 2324, 15, 20, 15, 0, -14 },
  { 2362, 11, 14, 12, 1, -14 },
  { 2382, 8, 22, 10, 1, -18 },
  { 2404, 3, 25, 13, 5, -19 },
  { 2414, 9, 22, 10, 1, -18 },
  { 2439, 12, 4, 14, 1, -11 },
};

const GFXfont NotoSans_ExtraBold25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold25pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_EXTRABOLD25PT7B_H_
