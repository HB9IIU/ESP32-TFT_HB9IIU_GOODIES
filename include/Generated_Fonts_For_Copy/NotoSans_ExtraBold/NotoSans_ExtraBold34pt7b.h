#ifndef _NOTOSANS_EXTRABOLD34PT7B_H_
#define _NOTOSANS_EXTRABOLD34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFB, 0xEF,
  0xBE, 0x00, 0x02, 0x3E, 0xFF, 0xFF, 0xFE, 0xF8, 0xFF, 0xC7, 0xFE, 0x3F,
  0xF1, 0xFF, 0x8F, 0xFC, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xF0, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01,
  0xE3, 0xC1, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC1, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x03, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0xF1, 0xF0, 0x07, 0x8F, 0x00,
  0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x01, 0xFF, 0xC3, 0xFF, 0xFB,
  0xFF, 0xF9, 0xFF, 0xFD, 0xFB, 0x8E, 0xF9, 0xC0, 0x7E, 0xE0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0xE7, 0xC0, 0x73, 0xF8, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x01, 0x00, 0xFE, 0x00, 0x78, 0x07, 0xFC, 0x03, 0xE0,
  0x1F, 0xF8, 0x0F, 0x00, 0xF9, 0xE0, 0x78, 0x03, 0xE7, 0xC3, 0xE0, 0x0F,
  0x1F, 0x0F, 0x00, 0x3C, 0x7C, 0x7C, 0x00, 0xF1, 0xF1, 0xE0, 0x03, 0xC7,
  0xCF, 0x80, 0x0F, 0x9F, 0x3C, 0x7C, 0x3E, 0x79, 0xF3, 0xF8, 0x7F, 0xE7,
  0x9F, 0xF1, 0xFF, 0x3E, 0xFF, 0xE3, 0xF9, 0xF3, 0xC7, 0x83, 0x87, 0x8F,
  0x1E, 0x00, 0x3E, 0x3C, 0x78, 0x00, 0xF0, 0xF1, 0xF0, 0x07, 0xC3, 0xC7,
  0xC0, 0x1E, 0x0F, 0x1E, 0x00, 0xF8, 0x3C, 0x78, 0x03, 0xC0, 0xFB, 0xE0,
  0x1F, 0x01, 0xFF, 0x00, 0xF8, 0x07, 0xFC, 0x03, 0xC0, 0x07, 0xE0, 0x00,
  0x60, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x3F, 0x00,
  0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x03, 0xF1, 0xFF, 0xC1, 0xF9, 0xFF, 0xF1, 0xF8, 0xFC, 0xFE,
  0xFC, 0xFE, 0x3F, 0xFC, 0x7E, 0x0F, 0xFE, 0x3F, 0x03, 0xFE, 0x1F, 0xC0,
  0xFF, 0x07, 0xF1, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFE, 0xFE, 0x0F, 0xFC, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x78,
  0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F,
  0x83, 0xF0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7C,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x0F, 0xC3,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xE0,
  0xF8, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x83, 0xC1, 0xF3, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78, 0x3E, 0x7C, 0x3E, 0x3E, 0x0C, 0x30,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x3E, 0xFD,
  0xF3, 0xE7, 0xCF, 0x3E, 0x7C, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x23,
  0xEF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x00,
  0x00, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF3, 0xF1,
  0xF9, 0xF8, 0x7E, 0xF8, 0x3F, 0x7C, 0x1F, 0xFE, 0x07, 0xFF, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xBE, 0x0F, 0xDF, 0x07, 0xEF, 0xC3, 0xF7, 0xF3, 0xF1, 0xFF, 0xF8, 0x7F,
  0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xC3, 0xFE, 0x3F,
  0xF3, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0x3F, 0x31, 0xF9, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xC0, 0x07,
  0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xFF, 0xF3, 0xF1, 0xFC, 0xE0, 0x7E,
  0x20, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0x80, 0x0F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xFF, 0xF1, 0xC1, 0xFC, 0x80, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x83, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xFF, 0x87, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x1E, 0xF8, 0x0F, 0xBE, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0xF8, 0xF8,
  0x7C, 0x3E, 0x1E, 0x0F, 0x8F, 0x83, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFC, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x7F, 0xF1, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF,
  0xF8, 0x7F, 0xE0, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3F, 0xFC,
  0x1F, 0xFF, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x3E, 0x0F, 0xDF, 0xE3, 0xEF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xE1,
  0xFB, 0xF0, 0x3E, 0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0xF9, 0xF8, 0x7E,
  0x7F, 0x3F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xC0, 0x03, 0xFF, 0x03, 0xFF,
  0xE0, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x87, 0xE7, 0xC1, 0xF9, 0xF0, 0x7E,
  0x7E, 0x1F, 0x0F, 0xDF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xF1, 0xF8, 0xFE, 0xFC, 0x1F, 0xBF, 0x03, 0xEF, 0xC0,
  0xFF, 0xF0, 0x3E, 0xFE, 0x1F, 0x9F, 0xFF, 0xE7, 0xFF, 0xF0, 0xFF, 0xF8,
  0x0F, 0xFC, 0x00, 0x01, 0x80, 0x07, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC7,
  0xFF, 0xF3, 0xF1, 0xFB, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xFE, 0x07,
  0xFF, 0x07, 0xFF, 0xC3, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F,
  0xDF, 0x07, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0xE1,
  0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x7B, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x8F, 0xBF, 0xFF, 0xFF, 0x80,
  0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x7E, 0xF9, 0xF3, 0xE7, 0x9F, 0x3E, 0x78, 0x00, 0x01, 0x80,
  0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x87, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x00,
  0x40, 0x00, 0x00, 0x03, 0x80, 0x3F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x7F,
  0xFF, 0x38, 0x3F, 0x20, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE3, 0xE1, 0xFF, 0x9E, 0x3C, 0x3F, 0xF9,
  0xE7, 0xC7, 0xFF, 0x8F, 0x78, 0xF8, 0x78, 0xF7, 0x8F, 0x07, 0x8F, 0x79,
  0xF0, 0x78, 0xF7, 0x9E, 0x07, 0x8F, 0xF9, 0xE0, 0xF8, 0xFF, 0x9E, 0x0F,
  0x8F, 0x79, 0xF0, 0xF9, 0xE7, 0x8F, 0x9F, 0x9E, 0x78, 0xFF, 0xFF, 0xC7,
  0x87, 0xFB, 0xFC, 0x7C, 0x3F, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xFC, 0x01, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE3,
  0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0x81,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFC, 0x3F, 0xBF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7E, 0xFC, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xFF,
  0x3F, 0xFF, 0xEF, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF,
  0xE0, 0x00, 0x38, 0x00, 0x7F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0x87, 0x9F, 0xC0, 0x23, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0x23, 0xFE, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFC,
  0xFF, 0xCF, 0xC0, 0xFE, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x1F,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB,
  0xFF, 0xEF, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0x0C, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFC, 0x1E, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0x7E, 0x01,
  0xF7, 0xF0, 0x1F, 0x3F, 0xE7, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x7F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x8F, 0xEF, 0xFE, 0xFF, 0xCF,
  0xF8, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0xFE, 0xFC, 0x1F, 0xCF, 0xC1,
  0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xF0, 0xFC, 0xFE, 0x0F, 0xCF, 0xC0, 0xFD,
  0xF8, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xE0, 0xFC, 0x7E, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F,
  0xEF, 0xC0, 0x7F, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFB, 0xC0, 0xF7, 0xFF, 0x7C, 0x1E, 0xFF, 0xEF, 0x87,
  0xDF, 0xFC, 0xF0, 0xFB, 0xFF, 0x9F, 0x1E, 0x7F, 0xF3, 0xE7, 0xCF, 0xFE,
  0x7C, 0xF9, 0xFF, 0xC7, 0x9E, 0x3F, 0xF8, 0xFB, 0xC7, 0xFF, 0x1F, 0xF8,
  0xFF, 0xE1, 0xFE, 0x1F, 0xFC, 0x3F, 0xC3, 0xFF, 0x87, 0xF8, 0x7F, 0xF0,
  0x7E, 0x0F, 0xFE, 0x0F, 0xC1, 0xFF, 0xC1, 0xF8, 0x3F, 0xFF, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x07, 0xFE, 0xFC, 0x1F, 0xFB, 0xF0, 0x7F, 0xE7, 0xE1,
  0xFF, 0x9F, 0x87, 0xFE, 0x3F, 0x1F, 0xF8, 0xFC, 0x7F, 0xE1, 0xF9, 0xFF,
  0x87, 0xF7, 0xFE, 0x0F, 0xDF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x9F, 0xC0, 0x7F, 0x3F,
  0x00, 0x7E, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFD, 0xF8, 0x03, 0xF3, 0xF8, 0x0F,
  0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF,
  0xCF, 0xF7, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x1F, 0xDF, 0xFF, 0xEF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xE1, 0xFF,
  0x80, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x9F,
  0xC0, 0x7F, 0x3F, 0x00, 0x7E, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFD, 0xF8, 0x03,
  0xF3, 0xF8, 0x0F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFC, 0x7F,
  0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0x7E, 0x0F, 0xC7, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC1, 0xF8, 0xFC, 0x1F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F,
  0x01, 0x80, 0x1F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFC, 0x1C,
  0xFC, 0x04, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0xC0, 0x3F, 0xFD, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8,
  0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xFC, 0x00, 0xFE, 0xFC,
  0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xE3, 0xF0, 0x1F, 0x87, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07,
  0xE0, 0x3E, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xF9, 0xF8,
  0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xDF, 0x00, 0xFC,
  0x03, 0xE7, 0xE0, 0x3F, 0x01, 0xF9, 0xF8, 0x1F, 0xE0, 0x7E, 0x7E, 0x07,
  0xF8, 0x1F, 0x8F, 0x81, 0xFE, 0x07, 0xC3, 0xE0, 0x7F, 0x81, 0xF0, 0xFC,
  0x3F, 0xF0, 0xFC, 0x3F, 0x0F, 0xFC, 0x3F, 0x07, 0xC3, 0xEF, 0x0F, 0x81,
  0xF0, 0xF3, 0xC3, 0xE0, 0x7E, 0x7C, 0xF9, 0xF8, 0x1F, 0x9F, 0x3E, 0x7E,
  0x03, 0xE7, 0xCF, 0x9F, 0x00, 0xF9, 0xE1, 0xE7, 0xC0, 0x3E, 0xF8, 0x79,
  0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC0,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F,
  0x00, 0xFE, 0x3F, 0x01, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x0F,
  0xC3, 0xF0, 0x0F, 0xC7, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07,
  0xEF, 0xC0, 0x0F, 0xE7, 0xE0, 0x0F, 0xC7, 0xF0, 0x1F, 0x83, 0xF0, 0x3F,
  0x81, 0xF8, 0x3F, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFD, 0xF8, 0x07, 0xE7, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x87,
  0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03,
  0xEF, 0x00, 0x79, 0xE0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x1E,
  0x07, 0x83, 0xC0, 0x78, 0xF0, 0x0F, 0x1E, 0x00, 0xF7, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3E,
  0x07, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF1, 0xE1, 0xF8, 0x80,
  0xFC, 0x00, 0x3E, 0x03, 0xFF, 0x1F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF,
  0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF,
  0x9F, 0xF3, 0xC7, 0xF1, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF1, 0xF0, 0xFD,
  0xFE, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFE, 0x1F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0xCF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFD,
  0xFF, 0x3E, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0xFC, 0xFF, 0xFB, 0xFF, 0xE7,
  0xFF, 0xDF, 0xC0, 0xBF, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0xC7, 0x3F, 0xFE, 0x3F, 0xFC,
  0x3F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x1F, 0x1F, 0x3F, 0xEF, 0xBF,
  0xF7, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xC1,
  0xFF, 0xF1, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xEF, 0x8F, 0xE3, 0xC0,
  0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7, 0xE3, 0xF7, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x0C, 0xFF, 0xFE, 0x3F, 0xFF,
  0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0x87, 0xFE,
  0x1F, 0x98, 0xFC, 0x03, 0xF0, 0x0F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF,
  0x3F, 0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x00, 0x0F, 0x8F, 0x9F, 0xF7, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFE, 0xFF,
  0xFF, 0x7F, 0xFF, 0x9F, 0xF7, 0xC7, 0xF3, 0xE0, 0x01, 0xF0, 0x01, 0xFC,
  0x00, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFE, 0x0F, 0xFC,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF1, 0xF0, 0xFD, 0xFF, 0x3F, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF0,
  0x7F, 0xFF, 0xFF, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC3, 0xF0, 0xFC,
  0x3F, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xF7, 0xFF, 0xFF, 0xFE,
  0xFF, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0xFC,
  0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xC7, 0xF0, 0xFC, 0xFE, 0x0F,
  0xCF, 0xC0, 0xFD, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x0F, 0xF7, 0xE0, 0xFC, 0x7F, 0x0F, 0xC3, 0xF8, 0xFC, 0x1F,
  0x8F, 0xC1, 0xFC, 0xFC, 0x0F, 0xEF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0xFC, 0x0F, 0xC7, 0xCF, 0xF9, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xF0, 0xFF, 0xF8, 0x3F, 0x07, 0xFF, 0x81, 0xF8, 0x3F, 0xFC, 0x0F, 0xC1,
  0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0x03, 0xF0, 0x7F, 0xF8, 0x1F, 0x83, 0xFF,
  0xC0, 0xFC, 0x1F, 0xFE, 0x07, 0xE0, 0xFF, 0xF0, 0x3F, 0x07, 0xFF, 0x81,
  0xF8, 0x3F, 0xFC, 0x0F, 0xC1, 0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0x03, 0xF0,
  0x7E, 0xF8, 0x7E, 0x3E, 0x7F, 0xCF, 0xBF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0,
  0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFC, 0x07, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x3F, 0xBF, 0x07, 0xEF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x07, 0xE7, 0xE3, 0xF9, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0x80, 0xF8, 0x7C, 0x3E, 0x7F, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xF3,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xCF, 0xC3, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x8F, 0x9F, 0xF7, 0xDF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0x9F, 0xF7, 0xC7, 0xF3, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0xF8, 0x7F, 0xCF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7,
  0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xF0, 0x7F,
  0xFD, 0xFF, 0xF3, 0xFF, 0xE7, 0xC1, 0x9F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x0F, 0xD8,
  0x1F, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xE2, 0x7F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xF3, 0xFD, 0xFF, 0xFF, 0x7F,
  0xFF, 0xCF, 0xFD, 0xF1, 0xFE, 0x7C, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1,
  0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xF9, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0xFD, 0xF0, 0x3F,
  0x03, 0xE7, 0xE1, 0xFE, 0x1F, 0x9F, 0x87, 0xF8, 0x7E, 0x3E, 0x1F, 0xE1,
  0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xF3, 0xFF, 0x3F, 0x0F, 0xCF, 0x3C, 0xFC,
  0x1F, 0x3C, 0xF3, 0xE0, 0x7C, 0xF3, 0xCF, 0x81, 0xF7, 0xCF, 0x3E, 0x07,
  0xDE, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF,
  0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0,
  0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xF7, 0xF0, 0x7E, 0x3F,
  0x0F, 0xE3, 0xF8, 0xFC, 0x1F, 0x9F, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x00, 0xFD, 0xF8, 0x1F, 0x9F, 0x83, 0xF8, 0xFC, 0x3F, 0x0F,
  0xE7, 0xF0, 0x7E, 0xFE, 0x07, 0xF0, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x7E,
  0x07, 0xE7, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1,
  0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF9, 0xF8, 0x0F, 0x9F, 0x00, 0xFD, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x4F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0xFF, 0x0F, 0xF0, 0xF8,
  0x0F, 0xE0, 0xFF, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xFF, 0x0F, 0xF0, 0x7F, 0x03, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xF0,
  0x7F, 0x01, 0xF0, 0x7F, 0x0F, 0xF1, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFC, 0x08,
  0x00, 0x3F, 0x00, 0xBF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFC,
  0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraBold34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 24, 10, 2, -24 },
  { 19, 13, 9, 17, 2, -24 },
  { 34, 21, 24, 22, 1, -24 },
  { 97, 17, 28, 20, 1, -26 },
  { 157, 30, 25, 31, 1, -25 },
  { 251, 25, 25, 26, 1, -25 },
  { 330, 5, 9, 9, 2, -24 },
  { 336, 10, 30, 12, 1, -25 },
  { 374, 10, 30, 12, 1, -25 },
  { 412, 16, 16, 18, 1, -26 },
  { 444, 17, 16, 20, 1, -20 },
  { 478, 7, 9, 10, 1, -4 },
  { 486, 9, 4, 11, 1, -11 },
  { 491, 6, 6, 10, 2, -6 },
  { 496, 14, 25, 15, 0, -25 },
  { 540, 17, 25, 20, 1, -25 },
  { 594, 13, 24, 20, 2, -24 },
  { 633, 17, 25, 20, 1, -25 },
  { 687, 17, 25, 20, 1, -25 },
  { 741, 18, 24, 20, 1, -24 },
  { 795, 16, 24, 20, 2, -24 },
  { 843, 18, 25, 20, 1, -25 },
  { 900, 18, 24, 20, 1, -24 },
  { 954, 18, 25, 20, 1, -25 },
  { 1011, 17, 25, 20, 1, -25 },
  { 1065, 6, 19, 10, 2, -19 },
  { 1080, 7, 24, 10, 1, -19 },
  { 1101, 17, 18, 20, 1, -21 },
  { 1140, 17, 11, 20, 1, -17 },
  { 1164, 17, 18, 20, 1, -21 },
  { 1203, 16, 25, 17, 0, -25 },
  { 1253, 28, 28, 31, 1, -25 },
  { 1351, 24, 24, 24, 0, -24 },
  { 1423, 18, 24, 23, 3, -24 },
  { 1477, 19, 25, 22, 2, -25 },
  { 1537, 20, 24, 25, 3, -24 },
  { 1597, 14, 24, 19, 3, -24 },
  { 1639, 14, 24, 19, 3, -24 },
  { 1681, 20, 25, 25, 2, -25 },
  { 1744, 20, 24, 26, 3, -24 },
  { 1804, 12, 24, 14, 1, -24 },
  { 1840, 12, 31, 12, -3, -24 },
  { 1887, 20, 24, 23, 3, -24 },
  { 1947, 15, 24, 19, 3, -24 },
  { 1992, 27, 24, 32, 3, -24 },
  { 2073, 22, 24, 28, 3, -24 },
  { 2139, 23, 25, 27, 2, -25 },
  { 2211, 17, 24, 21, 3, -24 },
  { 2262, 23, 31, 27, 2, -25 },
  { 2352, 20, 24, 23, 3, -24 },
  { 2412, 16, 25, 19, 2, -25 },
  { 2462, 18, 24, 20, 1, -24 },
  { 2516, 20, 24, 26, 3, -24 },
  { 2576, 23, 24, 23, 0, -24 },
  { 2645, 34, 24, 34, 0, -24 },
  { 2747, 24, 24, 24, 0, -24 },
  { 2819, 22, 24, 22, 0, -24 },
  { 2885, 18, 24, 20, 1, -24 },
  { 2939, 8, 31, 11, 2, -25 },
  { 2970, 14, 25, 15, 0, -25 },
  { 3014, 8, 31, 11, 1, -25 },
  { 3045, 19, 16, 19, 0, -24 },
  { 3083, 15, 3, 15, 0, 3 },
  { 3089, 11, 5, 13, 1, -26 },
  { 3096, 17, 19, 21, 1, -19 },
  { 3137, 18, 26, 22, 2, -26 },
  { 3196, 15, 19, 18, 2, -19 },
  { 3232, 17, 26, 22, 2, -26 },
  { 3288, 17, 19, 21, 2, -19 },
  { 3329, 14, 26, 14, 1, -26 },
  { 3375, 17, 27, 22, 2, -19 },
  { 3433, 18, 26, 22, 2, -26 },
  { 3492, 6, 26, 11, 2, -26 },
  { 3512, 10, 34, 11, -2, -26 },
  { 3555, 20, 26, 22, 2, -26 },
  { 3620, 6, 26, 11, 2, -26 },
  { 3640, 29, 19, 34, 2, -19 },
  { 3709, 18, 19, 22, 2, -19 },
  { 3752, 18, 19, 21, 2, -19 },
  { 3795, 18, 27, 22, 2, -19 },
  { 3856, 17, 27, 22, 2, -19 },
  { 3914, 13, 19, 16, 2, -19 },
  { 3945, 15, 19, 17, 1, -19 },
  { 3981, 13, 23, 15, 1, -23 },
  { 4019, 18, 19, 22, 2, -19 },
  { 4062, 20, 19, 20, 0, -19 },
  { 4110, 30, 19, 30, 0, -19 },
  { 4182, 20, 19, 20, 0, -19 },
  { 4230, 20, 27, 20, 0, -19 },
  { 4298, 15, 19, 17, 1, -19 },
  { 4334, 12, 30, 14, 1, -24 },
  { 4379, 4, 34, 18, 7, -26 },
  { 4396, 12, 30, 14, 1, -24 },
  { 4441, 17, 6, 20, 1, -15 },
};

const GFXfont NotoSans_ExtraBold34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold34pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_EXTRABOLD34PT7B_H_
