#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_ExtraBold
// Headers: 67

#include "NotoSans_ExtraBold6pt7b.h"
#include "NotoSans_ExtraBold7pt7b.h"
#include "NotoSans_ExtraBold8pt7b.h"
#include "NotoSans_ExtraBold9pt7b.h"
#include "NotoSans_ExtraBold10pt7b.h"
#include "NotoSans_ExtraBold11pt7b.h"
#include "NotoSans_ExtraBold12pt7b.h"
#include "NotoSans_ExtraBold13pt7b.h"
#include "NotoSans_ExtraBold14pt7b.h"
#include "NotoSans_ExtraBold15pt7b.h"
#include "NotoSans_ExtraBold16pt7b.h"
#include "NotoSans_ExtraBold17pt7b.h"
#include "NotoSans_ExtraBold18pt7b.h"
#include "NotoSans_ExtraBold19pt7b.h"
#include "NotoSans_ExtraBold20pt7b.h"
#include "NotoSans_ExtraBold21pt7b.h"
#include "NotoSans_ExtraBold22pt7b.h"
#include "NotoSans_ExtraBold23pt7b.h"
#include "NotoSans_ExtraBold24pt7b.h"
#include "NotoSans_ExtraBold25pt7b.h"
#include "NotoSans_ExtraBold26pt7b.h"
#include "NotoSans_ExtraBold27pt7b.h"
#include "NotoSans_ExtraBold28pt7b.h"
#include "NotoSans_ExtraBold29pt7b.h"
#include "NotoSans_ExtraBold30pt7b.h"
#include "NotoSans_ExtraBold31pt7b.h"
#include "NotoSans_ExtraBold32pt7b.h"
#include "NotoSans_ExtraBold33pt7b.h"
#include "NotoSans_ExtraBold34pt7b.h"
#include "NotoSans_ExtraBold35pt7b.h"
#include "NotoSans_ExtraBold36pt7b.h"
#include "NotoSans_ExtraBold37pt7b.h"
#include "NotoSans_ExtraBold38pt7b.h"
#include "NotoSans_ExtraBold39pt7b.h"
#include "NotoSans_ExtraBold40pt7b.h"
#include "NotoSans_ExtraBold41pt7b.h"
#include "NotoSans_ExtraBold42pt7b.h"
#include "NotoSans_ExtraBold43pt7b.h"
#include "NotoSans_ExtraBold44pt7b.h"
#include "NotoSans_ExtraBold45pt7b.h"
#include "NotoSans_ExtraBold46pt7b.h"
#include "NotoSans_ExtraBold47pt7b.h"
#include "NotoSans_ExtraBold48pt7b.h"
#include "NotoSans_ExtraBold49pt7b.h"
#include "NotoSans_ExtraBold50pt7b.h"
#include "NotoSans_ExtraBold51pt7b.h"
#include "NotoSans_ExtraBold52pt7b.h"
#include "NotoSans_ExtraBold53pt7b.h"
#include "NotoSans_ExtraBold54pt7b.h"
#include "NotoSans_ExtraBold55pt7b.h"
#include "NotoSans_ExtraBold56pt7b.h"
#include "NotoSans_ExtraBold57pt7b.h"
#include "NotoSans_ExtraBold58pt7b.h"
#include "NotoSans_ExtraBold59pt7b.h"
#include "NotoSans_ExtraBold60pt7b.h"
#include "NotoSans_ExtraBold61pt7b.h"
#include "NotoSans_ExtraBold62pt7b.h"
#include "NotoSans_ExtraBold63pt7b.h"
#include "NotoSans_ExtraBold64pt7b.h"
#include "NotoSans_ExtraBold65pt7b.h"
#include "NotoSans_ExtraBold66pt7b.h"
#include "NotoSans_ExtraBold67pt7b.h"
#include "NotoSans_ExtraBold68pt7b.h"
#include "NotoSans_ExtraBold69pt7b.h"
#include "NotoSans_ExtraBold70pt7b.h"
#include "NotoSans_ExtraBold71pt7b.h"
#include "NotoSans_ExtraBold72pt7b.h"
