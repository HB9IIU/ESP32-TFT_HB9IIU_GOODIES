#ifndef _NOTOSANS_EXTRABOLD28PT7B_H_
#define _NOTOSANS_EXTRABOLD28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00,
  0x0C, 0x7B, 0xFF, 0xDE, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF,
  0x3C, 0x07, 0x9E, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x73, 0xC3,
  0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x3C, 0x03, 0x9E,
  0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x39, 0xE0, 0x3C,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x3C, 0x00, 0x03, 0x00, 0x0C, 0x01,
  0xFF, 0x1F, 0xFF, 0x7F, 0xFB, 0xFD, 0xEF, 0x30, 0x3E, 0xC0, 0xFF, 0x01,
  0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0x0D, 0xF0, 0x33, 0xE0, 0xCF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x0F, 0xF8, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x3E, 0x01, 0xE0, 0x7F, 0x01, 0xC0, 0xFF, 0x83, 0xC0, 0xF3, 0x83,
  0x80, 0xE3, 0x87, 0x80, 0xE3, 0xC7, 0x00, 0xE3, 0xCF, 0x00, 0xE3, 0x9E,
  0x00, 0xF3, 0x9E, 0xFC, 0xFF, 0xBD, 0xFE, 0x7F, 0x39, 0xFE, 0x3E, 0x7B,
  0xCF, 0x00, 0x73, 0xCF, 0x00, 0xF3, 0xCF, 0x00, 0xE3, 0xCF, 0x01, 0xE3,
  0xCF, 0x03, 0xC1, 0xCF, 0x03, 0xC1, 0xFE, 0x07, 0x80, 0xFE, 0x0F, 0x00,
  0x7C, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7C, 0xF8, 0x03,
  0xC7, 0xC0, 0x1E, 0x3E, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFE, 0x0F, 0x8F, 0xF8, 0xF8, 0xFF, 0xE7, 0xCF, 0xDF, 0xBE, 0x7C,
  0x7F, 0xE3, 0xE1, 0xFE, 0x1F, 0x07, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xC7, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x1E,
  0x3C, 0x3C, 0x78, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1F, 0xF0, 0x78,
  0x7C, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x0F, 0x0F, 0x1F,
  0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0xF0, 0x07, 0x00,
  0x38, 0x01, 0xC1, 0x0E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0x1F,
  0xC0, 0xEF, 0x0F, 0x78, 0xF1, 0xE0, 0x88, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7D, 0xE7, 0x9E,
  0xF3, 0xCF, 0x38, 0xFF, 0xFF, 0xF8, 0x31, 0xEF, 0xFF, 0x78, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0x0F, 0xC0, 0xFF, 0xC3, 0xFF, 0x1F, 0xFE, 0x7C,
  0x7B, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xDF, 0x1F, 0x7F, 0xF8, 0xFF, 0xE3,
  0xFF, 0x03, 0xF8, 0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xF7, 0xFF, 0xFF, 0xDE,
  0xF9, 0x9F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0xE1, 0xFF, 0xCF, 0xFF,
  0x9F, 0xFE, 0x70, 0x7C, 0x81, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xE3, 0xFF, 0xC7, 0xFF, 0x9F,
  0xFE, 0x20, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x7C, 0x1F, 0xE0, 0x7E, 0x01,
  0xFF, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0x78, 0x0F, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x3C, 0x78, 0x78, 0x78, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x7F, 0xF9, 0xFF,
  0xE7, 0xFF, 0x9F, 0xFE, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xF0, 0x7F,
  0xF1, 0xFF, 0xE7, 0xFF, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0,
  0x3F, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF0, 0x03, 0xF8, 0x3F, 0xE1,
  0xFF, 0x8F, 0xFE, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0xF8, 0xF7, 0xFB,
  0xFF, 0xEF, 0xFF, 0xFE, 0x1F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xDE, 0x1F,
  0x7F, 0xFC, 0xFF, 0xE3, 0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0xE0, 0xFF, 0xC7, 0xFF, 0x9F,
  0x3F, 0x78, 0x7D, 0xE1, 0xF7, 0xCF, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x03,
  0xFF, 0x1F, 0xFE, 0xF8, 0xFF, 0xE1, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x7D,
  0xFF, 0xF7, 0xFF, 0x87, 0xF8, 0x1F, 0xC0, 0xFF, 0xC7, 0xFF, 0xBF, 0xFE,
  0xF8, 0x7F, 0xE1, 0xFF, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xF7, 0xFF,
  0xDF, 0xEF, 0x1F, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x6F, 0xF1, 0xFF,
  0xC7, 0xFC, 0x1F, 0xE0, 0x31, 0xEF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x7B, 0xFF, 0xDE, 0x31, 0xEF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7D, 0xE7, 0x9E, 0xF3, 0xCF, 0x38, 0x00, 0x04, 0x00, 0x30, 0x03,
  0xC0, 0x3F, 0x03, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0xFC, 0x0F, 0xF1, 0xFE, 0x1F, 0xE0, 0xFE,
  0x03, 0xE0, 0x0C, 0x00, 0x00, 0x3F, 0xE7, 0xFF, 0x9F, 0xFE, 0xFF, 0xF2,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0x00, 0xFC, 0x07, 0xE0,
  0x1E, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xF8,
  0x07, 0xC3, 0xE0, 0x03, 0xC7, 0x8F, 0xF3, 0x9E, 0x3F, 0xE7, 0x38, 0xFF,
  0xCF, 0x73, 0xC3, 0x8F, 0xE7, 0x87, 0x1F, 0xCE, 0x1E, 0x3F, 0x9C, 0x3C,
  0xFF, 0x38, 0x79, 0xFE, 0x78, 0xF3, 0xBC, 0xFF, 0xFF, 0x38, 0xFE, 0xFC,
  0x78, 0x78, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x01, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7B, 0xE0, 0x07, 0x9E, 0x00,
  0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xFF, 0xE1, 0xFF, 0xF3,
  0xFF, 0xF7, 0xFF, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x3E, 0xFF,
  0xF9, 0xFF, 0xE3, 0xFF, 0xF7, 0xC7, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0x00, 0x03, 0xFE,
  0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0x02, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x02, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFE, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0x83,
  0xF7, 0xC0, 0xFB, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x7D, 0xF0, 0xFE,
  0xFF, 0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x07, 0xFE, 0x1F,
  0xFF, 0x3F, 0xFF, 0x7F, 0xFE, 0x7E, 0x02, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0xF8,
  0x0F, 0xFC, 0x0F, 0x7E, 0x0F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x07,
  0xFE, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7F, 0xFF, 0xFE,
  0xFE, 0x7E, 0x00, 0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x0F, 0x9F, 0x0F, 0x8F,
  0x8F, 0xC7, 0xC7, 0xC3, 0xE7, 0xC1, 0xF7, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xFE, 0x0F, 0xDF, 0x07, 0xC7, 0xC3, 0xE3, 0xF1, 0xF0,
  0xF8, 0xF8, 0x7E, 0x7C, 0x1F, 0x3E, 0x07, 0xDF, 0x03, 0xF0, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xDC, 0x0F, 0xFF,
  0x78, 0x3F, 0xFD, 0xE0, 0xEF, 0xFF, 0x87, 0xBF, 0xEF, 0x1E, 0xFF, 0xBC,
  0x73, 0xFE, 0xF3, 0xCF, 0xF9, 0xEF, 0x3F, 0xE7, 0xB8, 0xFF, 0x9F, 0xE3,
  0xFE, 0x3F, 0x8F, 0xF8, 0xFC, 0x3F, 0xE3, 0xF0, 0xFF, 0x8F, 0xC3, 0xFE,
  0x1F, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF,
  0xF8, 0x3F, 0xEF, 0x87, 0xFD, 0xF0, 0xFF, 0x9F, 0x1F, 0xF3, 0xE3, 0xFF,
  0x3E, 0x7F, 0xE7, 0xCF, 0xFC, 0x7D, 0xFF, 0x8F, 0x9F, 0xF0, 0xFB, 0xFE,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x3E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3F, 0x7C, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xC0,
  0x3E, 0x7E, 0x03, 0xE3, 0xE0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0xF8,
  0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFC, 0xFF, 0xE3, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3F, 0x7C,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7,
  0xC0, 0x3E, 0x7E, 0x03, 0xE3, 0xE0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8F, 0x87, 0xC7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0xF8, 0xF8,
  0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0x07, 0xC7, 0xC3,
  0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7E, 0x7C, 0x1F, 0x3E, 0x0F, 0xDF, 0x03,
  0xF0, 0x0F, 0xF0, 0xFF, 0xF7, 0xFF, 0x9F, 0xFE, 0x78, 0x13, 0xE0, 0x07,
  0xC0, 0x1F, 0x80, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x01, 0xFC,
  0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E, 0xF8, 0x3E,
  0x7F, 0xFF, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xF8, 0x07, 0xFF,
  0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0xF8, 0x7C, 0x1F, 0x0F,
  0x83, 0xE1, 0xF0, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x78, 0x07,
  0x9F, 0x00, 0xFB, 0xE0, 0x1F, 0x78, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x0F, 0x01,
  0xF7, 0x81, 0xF8, 0x1E, 0x78, 0x1F, 0x81, 0xE7, 0xC1, 0xF8, 0x3E, 0x7C,
  0x1F, 0x83, 0xE3, 0xC3, 0xFC, 0x3C, 0x3C, 0x3F, 0xC3, 0xC3, 0xE3, 0xFC,
  0x7C, 0x3E, 0x3D, 0xC7, 0xC1, 0xE7, 0x9E, 0x78, 0x1E, 0x79, 0xE7, 0x81,
  0xE7, 0x9E, 0x78, 0x1F, 0x79, 0xEF, 0x80, 0xF7, 0x0E, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xEF, 0xC0, 0xF8,
  0xF8, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x1F, 0x7C, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0x7C, 0x03, 0xEF, 0xC0, 0xF8, 0xF8, 0x3F, 0x0F, 0x87,
  0xC1, 0xF9, 0xF0, 0x1F, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xDF, 0x03, 0xE7,
  0xC0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x3F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1F, 0xFF, 0xFF, 0xFE, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80,
  0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0xFF, 0xFF,
  0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0xFE, 0x01, 0xDC, 0x07, 0xBC, 0x0E, 0x38, 0x3C, 0x78, 0x70, 0x71,
  0xE0, 0xF3, 0x80, 0xEF, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC,
  0x1F, 0x07, 0xC0, 0xF0, 0x01, 0x80, 0xFF, 0xC3, 0xFF, 0x8F, 0xFF, 0x10,
  0x7C, 0x01, 0xF0, 0x3F, 0xCF, 0xFF, 0x7F, 0xFF, 0xF1, 0xFF, 0x87, 0xFE,
  0x1F, 0xFC, 0xFF, 0xFF, 0xF7, 0xFB, 0xCF, 0xC7, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x18, 0x3E, 0xFC, 0x7F, 0xFC, 0xFF,
  0xFD, 0xF8, 0xFB, 0xE1, 0xF7, 0xC1, 0xEF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x3E, 0xF8, 0x7D, 0xFF, 0xFB, 0xFF, 0xE7, 0xBF, 0xCF, 0x3F, 0x00,
  0x01, 0xC0, 0x7F, 0xCF, 0xFE, 0xFF, 0xE7, 0xE3, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x17, 0xFF, 0x9F, 0xFC, 0xFF,
  0xE1, 0xFE, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0xC7, 0xC7, 0xEF, 0x9F, 0xFF, 0x7F, 0xFE, 0xFC, 0xFF, 0xF0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0x7C, 0x3E, 0xFF, 0xFD,
  0xFF, 0xF9, 0xFE, 0xF1, 0xF9, 0xE0, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3,
  0xFF, 0xE7, 0xC3, 0xCF, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0xC7, 0xFF, 0x87, 0xFF, 0x07, 0xFC,
  0x1F, 0xE3, 0xFC, 0xFF, 0x1F, 0x13, 0xE0, 0x78, 0x3F, 0xF7, 0xFE, 0xFF,
  0xC7, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x07, 0x00, 0x3F, 0x3C, 0xFF, 0xFB, 0xFF,
  0xF7, 0xC7, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFB, 0xE1, 0xF7, 0xEF, 0xEF, 0xFF, 0xCF, 0xFF, 0x8F, 0xDF, 0x00,
  0x3E, 0x00, 0x7D, 0x81, 0xFB, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x03, 0xF0,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x1C,
  0x3E, 0xFE, 0x7F, 0xFE, 0xFF, 0xFD, 0xF8, 0xFB, 0xE0, 0xFF, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xC1, 0xFF, 0x83, 0xE0, 0x27, 0xFF, 0xF7, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x04, 0x1F, 0x1F, 0x1F, 0x0E,
  0x00, 0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x3F, 0xFE, 0xFE, 0xFC, 0xF0,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x7E, 0xF8, 0x7C, 0xF8, 0xF8, 0xF9, 0xF0, 0xFB, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFD, 0xF0, 0xF9, 0xF8, 0xF8, 0xF8,
  0xF8, 0x7C, 0xF8, 0x7E, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x60, 0xF7,
  0xF9, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0x7E, 0x3F, 0xF8,
  0x7E, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0x00, 0xC1, 0xEF, 0xF3,
  0xDF, 0xF7, 0xFF, 0xEF, 0xC7, 0xDF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE7, 0xC7, 0xEF,
  0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFB, 0xE1,
  0xF7, 0xE7, 0xE7, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x00, 0xC1, 0xE7, 0xE3,
  0xDF, 0xE7, 0xFF, 0xEF, 0xC7, 0xDF, 0x0F, 0xBE, 0x0F, 0x7C, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE1, 0xF7, 0xC3, 0xEF, 0xFF, 0xDF, 0xFF, 0x3F, 0xFE,
  0x7D, 0xF8, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x00, 0x06, 0x00, 0x3F, 0x3C, 0xFF, 0xFB, 0xFF, 0xF7,
  0xC7, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFB, 0xE1, 0xF7, 0xEF, 0xEF, 0xFF, 0xCF, 0xFF, 0x8F, 0xDF, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x00, 0xFC, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x07, 0x03, 0xFF, 0x7F,
  0xFF, 0xFE, 0xF8, 0x2F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x03,
  0xF0, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xE7, 0xFC, 0x1C, 0x03, 0x80, 0xF0,
  0x1E, 0x07, 0xFD, 0xFF, 0xBF, 0xF1, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xFF, 0x3F, 0xE7, 0xFC, 0x7F, 0x80, 0xF8,
  0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xF3,
  0xF1, 0xC0, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x7C, 0x3E, 0x3C, 0x3E,
  0x3E, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x78,
  0x7E, 0x1F, 0x7C, 0x7F, 0x1F, 0x7C, 0x7F, 0x1E, 0x3C, 0x77, 0x1E, 0x3C,
  0xF7, 0x3E, 0x3E, 0xF7, 0xBC, 0x1E, 0xE7, 0xBC, 0x1E, 0xE7, 0xBC, 0x1E,
  0xE3, 0xBC, 0x1F, 0xE3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF8, 0x0F,
  0xC1, 0xF0, 0x0F, 0xC1, 0xF0, 0xFC, 0x1F, 0x1F, 0x1F, 0x0F, 0x9F, 0x83,
  0xEF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xFC, 0x07, 0xDF, 0x07, 0xEF, 0x83, 0xE3, 0xE3, 0xE1, 0xFB, 0xF0,
  0x7E, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7E, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC3, 0xF1, 0xFC,
  0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x8F, 0xE3, 0xF0, 0xF8,
  0x3F, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xF1,
  0xFC, 0x3F, 0x01, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF8, 0x3F, 0x0F, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3E, 0x07, 0x81, 0xFC, 0x3F, 0x07, 0xC7, 0xF1, 0xF0, 0xF8, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x3F, 0x0F, 0xC3, 0xE0, 0x80, 0x00, 0x7F,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x60,
};

const GFXglyph NotoSans_ExtraBold28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 6, 20, 8, 1, -20 },
  { 16, 10, 7, 14, 2, -20 },
  { 25, 17, 20, 18, 1, -20 },
  { 68, 14, 23, 16, 1, -21 },
  { 109, 24, 20, 26, 1, -20 },
  { 169, 21, 20, 22, 1, -20 },
  { 222, 4, 7, 8, 2, -20 },
  { 226, 8, 24, 10, 1, -20 },
  { 250, 8, 24, 10, 1, -20 },
  { 274, 13, 13, 15, 1, -21 },
  { 296, 14, 14, 16, 1, -17 },
  { 321, 6, 8, 8, 1, -4 },
  { 327, 7, 3, 9, 1, -9 },
  { 330, 6, 5, 8, 1, -5 },
  { 334, 12, 20, 12, 0, -20 },
  { 364, 14, 20, 16, 1, -20 },
  { 399, 11, 20, 16, 1, -20 },
  { 427, 14, 20, 16, 1, -20 },
  { 462, 14, 20, 16, 1, -20 },
  { 497, 16, 20, 16, 0, -20 },
  { 537, 14, 20, 16, 1, -20 },
  { 572, 14, 20, 16, 1, -20 },
  { 607, 14, 20, 16, 1, -20 },
  { 642, 14, 20, 16, 1, -20 },
  { 677, 14, 20, 16, 1, -20 },
  { 712, 6, 16, 8, 1, -16 },
  { 724, 6, 20, 8, 1, -16 },
  { 739, 14, 15, 16, 1, -18 },
  { 766, 14, 9, 16, 1, -14 },
  { 782, 14, 15, 16, 1, -18 },
  { 809, 13, 20, 14, 0, -20 },
  { 842, 23, 22, 25, 1, -20 },
  { 906, 20, 20, 20, 0, -20 },
  { 956, 15, 20, 19, 2, -20 },
  { 994, 16, 20, 18, 1, -20 },
  { 1034, 17, 20, 21, 2, -20 },
  { 1077, 12, 20, 16, 2, -20 },
  { 1107, 12, 20, 15, 2, -20 },
  { 1137, 16, 20, 20, 2, -20 },
  { 1177, 17, 20, 21, 2, -20 },
  { 1220, 10, 20, 12, 1, -20 },
  { 1245, 9, 26, 10, -2, -20 },
  { 1275, 17, 20, 19, 2, -20 },
  { 1318, 13, 20, 16, 2, -20 },
  { 1351, 22, 20, 27, 2, -20 },
  { 1406, 19, 20, 23, 2, -20 },
  { 1454, 20, 20, 22, 1, -20 },
  { 1504, 14, 20, 18, 2, -20 },
  { 1539, 20, 25, 22, 1, -20 },
  { 1602, 17, 20, 19, 2, -20 },
  { 1645, 14, 20, 16, 1, -20 },
  { 1680, 15, 20, 16, 1, -20 },
  { 1718, 17, 20, 21, 2, -20 },
  { 1761, 19, 20, 19, 0, -20 },
  { 1809, 28, 20, 28, 0, -20 },
  { 1879, 19, 20, 19, 0, -20 },
  { 1927, 18, 20, 18, 0, -20 },
  { 1972, 15, 20, 17, 1, -20 },
  { 2010, 7, 25, 9, 2, -20 },
  { 2032, 12, 20, 12, 0, -20 },
  { 2062, 6, 25, 9, 1, -20 },
  { 2081, 15, 13, 15, 0, -20 },
  { 2106, 13, 3, 13, 0, 2 },
  { 2111, 9, 4, 11, 1, -21 },
  { 2116, 14, 16, 17, 1, -16 },
  { 2144, 15, 21, 18, 2, -21 },
  { 2184, 13, 16, 15, 1, -16 },
  { 2210, 15, 21, 18, 1, -21 },
  { 2250, 15, 16, 17, 1, -16 },
  { 2280, 11, 21, 11, 1, -21 },
  { 2309, 15, 23, 18, 1, -16 },
  { 2353, 15, 21, 18, 2, -21 },
  { 2393, 5, 22, 9, 2, -22 },
  { 2407, 8, 29, 9, -1, -22 },
  { 2436, 16, 21, 18, 2, -21 },
  { 2478, 5, 21, 9, 2, -21 },
  { 2492, 24, 16, 28, 2, -16 },
  { 2540, 15, 16, 18, 2, -16 },
  { 2570, 15, 16, 18, 1, -16 },
  { 2600, 15, 23, 18, 2, -16 },
  { 2644, 15, 23, 18, 1, -16 },
  { 2688, 10, 16, 13, 2, -16 },
  { 2708, 12, 16, 14, 1, -16 },
  { 2732, 11, 19, 12, 1, -19 },
  { 2759, 14, 15, 18, 2, -15 },
  { 2786, 16, 15, 16, 0, -15 },
  { 2816, 24, 15, 25, 0, -15 },
  { 2861, 17, 15, 17, 0, -15 },
  { 2893, 16, 22, 16, 0, -15 },
  { 2937, 12, 15, 14, 1, -15 },
  { 2960, 10, 25, 12, 1, -20 },
  { 2992, 3, 27, 15, 6, -21 },
  { 3003, 10, 25, 12, 1, -20 },
  { 3035, 14, 5, 16, 1, -12 },
};

const GFXfont NotoSans_ExtraBold28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold28pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_EXTRABOLD28PT7B_H_
