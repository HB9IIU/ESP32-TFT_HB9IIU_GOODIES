#ifndef _NOTOSANS_EXTRABOLD52PT7B_H_
#define _NOTOSANS_EXTRABOLD52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold52pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xFF, 0xF7, 0xFD, 0xFF, 0x3F, 0x81,
  0x00, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7,
  0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0,
  0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xF9,
  0xE3, 0xF3, 0xFC, 0x78, 0x08, 0xFF, 0x1E, 0x00, 0x3F, 0xC7, 0x80, 0x0F,
  0xF9, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xBF, 0xF0, 0x01, 0xE3, 0xFC, 0x00, 0x78, 0xFF, 0xC0, 0x1E, 0x3F,
  0xFE, 0x07, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0x00, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xF8,
  0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83,
  0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0x87, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x87, 0xF0,
  0xFC, 0x0F, 0x80, 0x7F, 0x1F, 0xC7, 0xF1, 0xFF, 0x81, 0xFC, 0x7F, 0x1F,
  0x8F, 0xFF, 0x87, 0xFF, 0xF8, 0xFE, 0x7F, 0xFE, 0x0F, 0xFF, 0xE7, 0xF1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x1F, 0xCF, 0xFF, 0xF8, 0x3F, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE0, 0x7F, 0xC3, 0xF8, 0xFE, 0x3F, 0x80, 0x38, 0x1F, 0xC3, 0xF0,
  0x7E, 0x00, 0x00, 0x7F, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x07,
  0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0xFE, 0x00,
  0x0F, 0xE0, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x00,
  0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x20,
  0x7F, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFC, 0x1F, 0xFF, 0xF0,
  0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFE, 0x1F,
  0xF9, 0xFF, 0x9F, 0xF8, 0xFF, 0xC3, 0xFF, 0x7F, 0xC3, 0xFE, 0x07, 0xFF,
  0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xE0, 0x1F, 0xFF, 0xE0, 0xFF,
  0x80, 0x3F, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xDF,
  0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x00,
  0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC,
  0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F,
  0xE0, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x01, 0x80, 0xFC, 0x06, 0x7E, 0x3F, 0x0F, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0xF3,
  0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x0F, 0x03, 0xC0, 0x00,
  0xC0, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFF, 0x7F, 0x9F, 0xE7, 0xF9, 0xFC, 0x7F,
  0x3F, 0xCF, 0xE3, 0xF8, 0xFC, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x04, 0x0F, 0xE7, 0xFD,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFD, 0xFF, 0x3F, 0x81, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xE1, 0xFF, 0x9F,
  0xF0, 0x3F, 0xE7, 0xFC, 0x0F, 0xF9, 0xFE, 0x01, 0xFE, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFD, 0xFE, 0x01,
  0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x3F, 0xE3, 0xFE, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xF7, 0xF9, 0xFF, 0x3F, 0x1F, 0xF1, 0xC1, 0xFF,
  0x18, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE,
  0x3F, 0x81, 0xFF, 0x87, 0x80, 0x3F, 0xE1, 0xC0, 0x0F, 0xF8, 0x20, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xBF, 0xFE, 0x1E, 0x01, 0xFF, 0x86, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFD, 0xFF, 0x00, 0x3F, 0xDF, 0xF0, 0x03, 0xF9,
  0xFF, 0x00, 0x7F, 0x9F, 0xF0, 0x0F, 0xF1, 0xFF, 0x00, 0xFE, 0x1F, 0xF0,
  0x1F, 0xE1, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x3F, 0x81, 0xFF, 0x07, 0xF8,
  0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x0C, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0xC0, 0x00, 0xFF, 0xBC, 0x00, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0C, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0xFF, 0x83,
  0xFC, 0xFF, 0xF0, 0xFF, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xDF, 0xF0, 0x1F,
  0xF7, 0xFE, 0x0F, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF9, 0xFF, 0x87, 0xFE, 0x7F, 0xC0, 0xFF,
  0x9F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0xC0,
  0xFF, 0x8F, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0xF1, 0xFF, 0x87,
  0xFE, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xC1, 0xFF, 0xBF, 0xE0, 0x3F, 0xEF, 0xF8,
  0x07, 0xFB, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFB, 0xFC, 0x3F, 0xFC, 0xFF, 0x07, 0xFC, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x58, 0x00, 0x00, 0x1F, 0x1F, 0xE7,
  0xFD, 0xFF, 0xFF, 0xDF, 0xF7, 0xFD, 0xFE, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x0F,
  0xE7, 0xFD, 0xFF, 0x7F, 0xFF, 0xF7, 0xFD, 0xFF, 0x3F, 0x81, 0x00, 0x1F,
  0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0xFF, 0x3F, 0xCF, 0xF7, 0xF9, 0xFE, 0x7F, 0x9F,
  0xC7, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x3F, 0xC7, 0xFF, 0x1E, 0x01, 0xFF, 0x10, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xE1, 0xFC, 0x0F, 0xFF, 0xF1,
  0xF8, 0xFE, 0x07, 0xFF, 0xFC, 0x7E, 0x3F, 0x83, 0xFF, 0xFF, 0x1F, 0xCF,
  0xC1, 0xFF, 0xFF, 0xC3, 0xF7, 0xF0, 0xFF, 0x87, 0xF0, 0xFD, 0xF8, 0x3F,
  0x81, 0xFC, 0x3F, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xDF, 0x87, 0xF0, 0x1F,
  0xC3, 0xFF, 0xE1, 0xF8, 0x07, 0xE0, 0xFF, 0xF8, 0xFE, 0x01, 0xF8, 0x3F,
  0xFE, 0x3F, 0x80, 0x7E, 0x0F, 0xFF, 0x8F, 0xE0, 0x1F, 0x83, 0xFF, 0xE3,
  0xF8, 0x0F, 0xE0, 0xFF, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0xFE, 0x1F, 0xC0,
  0xFE, 0x1F, 0x9F, 0x87, 0xF8, 0x7F, 0xCF, 0xE7, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF1, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0x07, 0xFF, 0xDF, 0xFE, 0x0F,
  0xC0, 0xFF, 0xE3, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x10, 0x00, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0x03, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x03, 0xFE, 0xFF,
  0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0xFF, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x01, 0xFF, 0x87, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0xE3,
  0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00,
  0x3F, 0xEF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x07, 0xFE, 0xFF,
  0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03,
  0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x0F, 0xFE,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC,
  0x01, 0xE1, 0xFF, 0xC0, 0x02, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x10, 0xFF, 0xF0, 0x07, 0x83, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x7F, 0xFC, 0xFF, 0x80,
  0x3F, 0xF9, 0xFF, 0x00, 0x3F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7,
  0xFC, 0x00, 0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0x9F, 0xF0, 0x7F, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFE,
  0x00, 0x70, 0x7F, 0xF0, 0x00, 0x20, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFD, 0xFF, 0x00, 0x07, 0xFB,
  0xFF, 0x00, 0x0F, 0xF7, 0xFF, 0x00, 0x1F, 0xE7, 0xFF, 0x00, 0x3F, 0xCF,
  0xFF, 0x00, 0x7F, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xC1, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF,
  0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x1F,
  0xFB, 0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFF,
  0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x07,
  0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF3, 0xFF, 0x00, 0x3F,
  0xEF, 0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x03, 0xFE, 0x07,
  0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xF0, 0x0F,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0x80, 0x3F,
  0xF1, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xEF, 0xE0, 0x07, 0xEF, 0xFF, 0xF7, 0xF0,
  0x07, 0xF7, 0xFF, 0xFB, 0xF8, 0x03, 0xFB, 0xFF, 0xFC, 0xFE, 0x01, 0xFD,
  0xFF, 0xFE, 0x7F, 0x01, 0xFC, 0xFF, 0xFF, 0x3F, 0x80, 0xFE, 0x7F, 0xFF,
  0x9F, 0xE0, 0x7F, 0x3F, 0xFF, 0xC7, 0xF0, 0x3F, 0x1F, 0xFF, 0xE3, 0xF8,
  0x3F, 0x8F, 0xFF, 0xF1, 0xFE, 0x1F, 0xC7, 0xFF, 0xF8, 0x7F, 0x0F, 0xC3,
  0xFF, 0xFC, 0x3F, 0x8F, 0xE1, 0xFF, 0xFE, 0x1F, 0xC7, 0xF0, 0xFF, 0xFF,
  0x07, 0xF3, 0xF0, 0x7F, 0xFF, 0x83, 0xFB, 0xF8, 0x3F, 0xFF, 0xC1, 0xFD,
  0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0x7F, 0xE0,
  0x3F, 0xFF, 0xCF, 0xF8, 0x0F, 0xFF, 0xF1, 0xFF, 0x03, 0xFF, 0xFC, 0x7F,
  0xC0, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0x0F, 0xFF, 0xF0,
  0x7F, 0xC1, 0xFF, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF, 0x03, 0xFE, 0x1F, 0xFF,
  0xC0, 0xFF, 0xC7, 0xFF, 0xF0, 0x1F, 0xF1, 0xFF, 0xFC, 0x03, 0xFE, 0x7F,
  0xFF, 0x00, 0xFF, 0x9F, 0xFF, 0xC0, 0x1F, 0xF7, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x03, 0xFF, 0x87,
  0xFE, 0x00, 0x3F, 0xF9, 0xFF, 0x80, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF, 0x8F, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00,
  0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xEF, 0xFC,
  0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE,
  0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x03, 0xFE,
  0xFF, 0xC0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00,
  0x7F, 0xE7, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF,
  0x80, 0x1F, 0xFC, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x00, 0xFF, 0xC3, 0xFE,
  0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xE0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x07, 0xFC,
  0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0,
  0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x7F, 0xE7,
  0xFC, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x1E,
  0x3F, 0xE0, 0x01, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0xFF,
  0xCF, 0xFE, 0x03, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x01,
  0xFF, 0x3F, 0xF0, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x1F,
  0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0xBF,
  0xE0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xF7, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x0F,
  0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFC, 0x1F, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF8, 0x1F,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x03, 0xF9, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0x3F, 0x9F, 0xC0, 0xFF, 0x00, 0xFF, 0x83, 0xF9, 0xFC,
  0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0x9F, 0xC1, 0xFE, 0x00, 0x7F, 0x87, 0xF9,
  0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x87,
  0xF0, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x0F, 0xE3, 0xFC, 0x00, 0x3F,
  0xC7, 0xF0, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x07, 0xF3, 0xFC, 0x00,
  0x3F, 0xCF, 0xE0, 0x7F, 0x3F, 0xC0, 0x01, 0xFC, 0xFE, 0x07, 0xF3, 0xF8,
  0x00, 0x1F, 0xEF, 0xE0, 0x7F, 0x7F, 0x80, 0x01, 0xFE, 0xFE, 0x03, 0xF7,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE3,
  0xFF, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00,
  0x1F, 0xF1, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x3F, 0xF0, 0xFF,
  0x80, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07,
  0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xE0,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x7F, 0xC3, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x0F, 0xFB, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xF9, 0xF8, 0x00,
  0x3F, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xF8,
  0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0,
  0x00, 0xFE, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0x7E, 0x1F, 0xFC, 0x1C, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xF7, 0xF3, 0xFF, 0xF9, 0xFC, 0x7F, 0xFC, 0x7F, 0x0F,
  0xFC, 0x0F, 0xC0, 0x20, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x0F, 0xF1,
  0xFF, 0xC1, 0xFE, 0x7F, 0xFC, 0x3F, 0xDF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF, 0x87, 0xFF, 0x7F, 0xE0,
  0x7F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xBF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFE,
  0xFF, 0xFC, 0x3F, 0x8F, 0xFF, 0x07, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xF0,
  0x1C, 0x7F, 0xE0, 0x04, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x02, 0x7F, 0xF0, 0x0E, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x0F, 0xF0,
  0x3F, 0xF1, 0xFE, 0x1F, 0xFF, 0xBF, 0xC7, 0xFF, 0xF7, 0xF8, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0xC3, 0xFF, 0xBF,
  0xF0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x3F,
  0xDF, 0xF0, 0x07, 0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x7F, 0xE7, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0x9F, 0xC1, 0xFF, 0xE3, 0xF8, 0x1F, 0xF0, 0x3F, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x8F, 0xFC,
  0x1F, 0xF1, 0xFF, 0x01, 0xFE, 0x7F, 0xC0, 0x1F, 0xEF, 0xF8, 0x03, 0xFD,
  0xFF, 0x00, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x01, 0x8F, 0xFE, 0x01, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0x04, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x7F, 0xF1, 0xFC, 0x3F, 0xFF, 0x3F, 0x8F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0x83,
  0xFF, 0x7F, 0xE0, 0x3F, 0xEF, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFD, 0xFF,
  0x00, 0x7F, 0xBF, 0xE0, 0x0F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x7F,
  0xDF, 0xFE, 0x7F, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0x7F, 0x83, 0xFF, 0xCF, 0xF0, 0x3F, 0xE1, 0xFE,
  0x00, 0x60, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x40, 0x00,
  0x3F, 0xE7, 0x00, 0x0F, 0xFC, 0xFF, 0x9F, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x0F, 0xF1, 0xFF,
  0xE1, 0xFE, 0x7F, 0xFE, 0x3F, 0xDF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x1F, 0x1F, 0xE7, 0xFF,
  0xFF, 0xFF, 0xDF, 0xF7, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x00, 0x7C,
  0x01, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0x7F, 0xC0, 0x3F, 0xF3, 0xFE, 0x03, 0xFF,
  0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x3F, 0xF0, 0x3F,
  0xE1, 0xFF, 0x01, 0xFE, 0x1F, 0xF8, 0x0F, 0xF1, 0xFF, 0x80, 0x7F, 0x9F,
  0xF8, 0x03, 0xFD, 0xFF, 0x80, 0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF0,
  0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F,
  0xE1, 0xFF, 0x01, 0xFF, 0x8F, 0xF8, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xF3,
  0xFE, 0x00, 0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE3, 0xFF, 0xE0, 0xFF, 0xF0, 0xFE, 0x7F,
  0xFF, 0x1F, 0xFF, 0x8F, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0xFC, 0x07, 0xF8, 0x1F, 0xC3, 0xFF, 0xC3, 0xF9, 0xFF,
  0xFC, 0x7F, 0x7F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xF7, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE3, 0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x3F,
  0xE7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xF7,
  0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xF3, 0xFE, 0x03, 0xFE, 0x3F, 0xF0,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x30, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC3, 0xFF, 0x83, 0xF8, 0xFF, 0xF8,
  0x7F, 0xBF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0x0F, 0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xF0, 0x0F, 0xFB,
  0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xEF, 0xFC, 0x07,
  0xFD, 0xFF, 0x81, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFD, 0xFF, 0xF8, 0x7F, 0x9F, 0xFE,
  0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x01, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x7F, 0xF1, 0xFC, 0x3F, 0xFF, 0x3F, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0x83, 0xFF,
  0x7F, 0xE0, 0x3F, 0xEF, 0xF8, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFD, 0xFF, 0x00,
  0x7F, 0xBF, 0xE0, 0x0F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xDF,
  0xFE, 0x3F, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0x7F, 0x83, 0xFF, 0xCF, 0xF0, 0x3F, 0xE1, 0xFE, 0x00,
  0x60, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF,
  0x3F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xEF, 0xF8, 0x1F, 0x3F, 0xE0, 0x0C, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x02, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xFD, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x02, 0x00, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFC,
  0xFF, 0xFF, 0x7F, 0x8F, 0xFF, 0x8F, 0xF0, 0x7F, 0xE0, 0xFE, 0x00, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xF9, 0xFF, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x87, 0xFC, 0x01,
  0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0xC1, 0xFE,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xE0,
  0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFE, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0xF0, 0x1F, 0xE7, 0xF8,
  0x0F, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0xFF, 0xF0, 0x3F, 0xE3, 0xFC, 0x1F,
  0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFB, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xBF,
  0x87, 0xFC, 0x3F, 0xE1, 0xF9, 0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0x9F, 0x87,
  0xF8, 0x1F, 0xE3, 0xF9, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0x1F, 0xCF, 0xF8,
  0x1F, 0xF3, 0xF1, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0x0F, 0xCF, 0xF0, 0x0F,
  0xF7, 0xF0, 0xFC, 0xFF, 0x00, 0xFF, 0x7F, 0x0F, 0xEF, 0xE0, 0x07, 0xF7,
  0xE0, 0xFE, 0xFE, 0x00, 0x7F, 0x7E, 0x07, 0xFF, 0xE0, 0x07, 0xF7, 0xE0,
  0x7F, 0xFE, 0x00, 0x7F, 0x7E, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F,
  0xE0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF,
  0x80, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0x87, 0xFC, 0x01, 0xFF,
  0x1F, 0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0xFF, 0xCF, 0xF8,
  0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xE0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE3, 0xFF, 0x00, 0x7F, 0xEF,
  0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xF9,
  0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x87,
  0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F,
  0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF,
  0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFD,
  0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xFC,
  0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x3F, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F,
  0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x3F,
  0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x03,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x4F, 0xFF, 0x00, 0x37, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x80, 0x03, 0xFE, 0x00,
};

const GFXglyph NotoSans_ExtraBold52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 10, 38, 15, 2, -37 },
  { 49, 20, 13, 26, 3, -37 },
  { 82, 32, 37, 34, 1, -37 },
  { 230, 26, 42, 30, 2, -39 },
  { 367, 46, 38, 48, 1, -38 },
  { 586, 38, 39, 40, 2, -38 },
  { 772, 8, 13, 14, 3, -37 },
  { 785, 15, 46, 18, 2, -38 },
  { 872, 14, 46, 18, 2, -38 },
  { 953, 26, 25, 28, 1, -40 },
  { 1035, 26, 25, 30, 2, -31 },
  { 1117, 10, 14, 15, 2, -7 },
  { 1135, 14, 7, 17, 1, -17 },
  { 1148, 10, 10, 15, 2, -9 },
  { 1161, 22, 38, 22, 0, -38 },
  { 1266, 26, 39, 30, 2, -38 },
  { 1393, 20, 37, 30, 3, -37 },
  { 1486, 26, 38, 30, 2, -38 },
  { 1610, 26, 39, 30, 2, -38 },
  { 1737, 28, 37, 30, 1, -37 },
  { 1867, 26, 38, 30, 2, -37 },
  { 1991, 26, 39, 30, 2, -38 },
  { 2118, 26, 37, 30, 2, -37 },
  { 2239, 26, 39, 30, 2, -38 },
  { 2366, 26, 39, 30, 2, -38 },
  { 2493, 10, 30, 15, 2, -29 },
  { 2531, 10, 36, 15, 2, -29 },
  { 2576, 26, 28, 30, 2, -33 },
  { 2667, 26, 17, 30, 2, -27 },
  { 2723, 26, 28, 30, 2, -33 },
  { 2814, 24, 39, 25, 0, -38 },
  { 2931, 42, 41, 47, 2, -37 },
  { 3147, 37, 37, 37, 0, -37 },
  { 3319, 28, 37, 35, 4, -37 },
  { 3449, 29, 39, 34, 3, -38 },
  { 3591, 31, 37, 38, 4, -37 },
  { 3735, 22, 37, 29, 4, -37 },
  { 3837, 22, 37, 28, 4, -37 },
  { 3939, 31, 39, 38, 3, -38 },
  { 4091, 31, 37, 40, 4, -37 },
  { 4235, 18, 37, 21, 2, -37 },
  { 4319, 17, 48, 18, -4, -37 },
  { 4421, 31, 37, 35, 4, -37 },
  { 4565, 24, 37, 30, 4, -37 },
  { 4676, 41, 37, 50, 4, -37 },
  { 4866, 34, 37, 43, 4, -37 },
  { 5024, 35, 39, 41, 3, -38 },
  { 5195, 26, 37, 33, 4, -37 },
  { 5316, 36, 47, 41, 3, -38 },
  { 5528, 31, 37, 35, 4, -37 },
  { 5672, 25, 39, 29, 2, -38 },
  { 5794, 28, 37, 30, 1, -37 },
  { 5924, 31, 38, 39, 4, -37 },
  { 6072, 35, 37, 35, 0, -37 },
  { 6234, 52, 37, 52, 0, -37 },
  { 6475, 36, 37, 36, 0, -37 },
  { 6642, 33, 37, 33, 0, -37 },
  { 6795, 29, 37, 31, 1, -37 },
  { 6930, 13, 46, 17, 3, -38 },
  { 7005, 22, 38, 22, 0, -38 },
  { 7110, 13, 46, 17, 1, -38 },
  { 7185, 28, 24, 29, 0, -37 },
  { 7269, 24, 5, 24, 0, 4 },
  { 7284, 16, 8, 20, 2, -40 },
  { 7300, 26, 30, 32, 2, -29 },
  { 7398, 27, 41, 33, 4, -40 },
  { 7537, 24, 30, 27, 2, -29 },
  { 7627, 27, 41, 33, 2, -40 },
  { 7766, 27, 30, 32, 2, -29 },
  { 7868, 22, 40, 21, 1, -40 },
  { 7978, 27, 41, 33, 2, -29 },
  { 8117, 27, 40, 34, 4, -40 },
  { 8252, 10, 40, 16, 3, -40 },
  { 8302, 16, 52, 16, -3, -40 },
  { 8406, 29, 40, 33, 4, -40 },
  { 8551, 8, 40, 16, 4, -40 },
  { 8591, 44, 29, 51, 4, -29 },
  { 8751, 27, 29, 34, 4, -29 },
  { 8849, 28, 30, 33, 2, -29 },
  { 8954, 27, 41, 33, 4, -29 },
  { 9093, 27, 41, 33, 2, -29 },
  { 9232, 19, 29, 24, 4, -29 },
  { 9301, 22, 30, 26, 2, -29 },
  { 9384, 21, 35, 23, 1, -34 },
  { 9476, 27, 30, 34, 4, -29 },
  { 9578, 31, 29, 31, 0, -29 },
  { 9691, 44, 29, 46, 1, -29 },
  { 9851, 31, 29, 31, 0, -29 },
  { 9964, 31, 41, 31, 0, -29 },
  { 10123, 23, 29, 26, 1, -29 },
  { 10207, 19, 45, 21, 1, -37 },
  { 10314, 6, 51, 28, 11, -39 },
  { 10353, 18, 45, 21, 2, -37 },
  { 10455, 26, 9, 30, 2, -23 },
};

const GFXfont NotoSans_ExtraBold52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold52pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_EXTRABOLD52PT7B_H_
