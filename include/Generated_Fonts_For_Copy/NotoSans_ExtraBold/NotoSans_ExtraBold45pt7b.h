#ifndef _NOTOSANS_EXTRABOLD45PT7B_H_
#define _NOTOSANS_EXTRABOLD45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold45pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xDF, 0xEF, 0xFF, 0xFD, 0xFC,
  0xFC, 0x18, 0x00, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xEF,
  0xC3, 0xF7, 0xE1, 0xFB, 0xF0, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E, 0x1F,
  0x9F, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0,
  0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00,
  0x3E, 0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7C, 0x0F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7C, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xF8,
  0x00, 0x7C, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x3E, 0x1F, 0x80,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC3,
  0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xF9, 0xE3, 0xCF, 0xE7, 0x81, 0x3F, 0x9E, 0x00,
  0xFE, 0x78, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xBF, 0xC0, 0x1E, 0x7F, 0x80, 0x79, 0xFF,
  0x81, 0xE7, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0x80, 0x00,
  0x01, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xF8, 0x01,
  0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xCF, 0xC0,
  0x3F, 0x00, 0x1F, 0x8F, 0x80, 0x7C, 0x00, 0x7E, 0x1F, 0x81, 0xF8, 0x00,
  0xFC, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF1, 0xF8, 0x00,
  0x1F, 0x87, 0xE3, 0xF0, 0xF8, 0x1F, 0x8F, 0xCF, 0xC7, 0xFC, 0x3F, 0x3F,
  0x1F, 0x1F, 0xFC, 0x7F, 0xFE, 0x7E, 0x7F, 0xFC, 0x7F, 0xF9, 0xF8, 0xFF,
  0xF8, 0x7F, 0xE3, 0xF3, 0xF3, 0xF8, 0x7F, 0x8F, 0xC7, 0xE3, 0xF0, 0x18,
  0x1F, 0x8F, 0xC7, 0xE0, 0x00, 0x7E, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x3E,
  0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x3F, 0x00, 0x07, 0xC0, 0xF8, 0x7E, 0x00,
  0x1F, 0x81, 0xF8, 0xFC, 0x00, 0x7E, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x07,
  0xE3, 0xF0, 0x03, 0xF0, 0x0F, 0xEF, 0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0x80,
  0x1F, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0x01, 0xFE,
  0x1F, 0xFF, 0xC0, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F,
  0x8F, 0xF9, 0xFF, 0x3F, 0xC7, 0xF8, 0x7F, 0xFF, 0xC3, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0x80, 0x7F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE7, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xF9, 0xF0, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0xFE, 0x1F,
  0xC1, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F,
  0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x01,
  0x01, 0xF0, 0x17, 0x87, 0xC3, 0x9F, 0xDE, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x1F, 0x81,
  0xF8, 0x7F, 0x01, 0xE0, 0xE0, 0x01, 0x03, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xCF, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xC7, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xC3, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3F, 0xBF,
  0xDF, 0xFF, 0xFB, 0xF9, 0xFC, 0x30, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xE1, 0xFE, 0x7F, 0x03, 0xFB, 0xFC,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFD, 0xFC, 0x0F, 0xE7, 0xF8, 0x7F,
  0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xEF, 0xF3, 0xE3, 0xFC, 0x70, 0xFF, 0x08, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0x1F, 0xC1, 0xFE, 0x1E, 0x01, 0xFE, 0x10, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0x01, 0xFE, 0x10, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xF7, 0xF8, 0x03, 0xF7, 0xF8, 0x07,
  0xE7, 0xF8, 0x0F, 0xE7, 0xF8, 0x0F, 0xC7, 0xF8, 0x1F, 0x87, 0xF8, 0x3F,
  0x87, 0xF8, 0x3F, 0x07, 0xF8, 0x7E, 0x07, 0xF8, 0xFE, 0x07, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC7, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x70, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0x9C, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE3, 0xF8, 0x1F, 0xDF, 0xFC, 0x3F, 0xBF, 0xFC, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFB, 0xFE, 0x0F, 0xF7, 0xF8, 0x0F,
  0xEF, 0xE0, 0x1F, 0xDF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFD, 0xFE, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xF8, 0x7F, 0x9F, 0xC0, 0xFE,
  0x7F, 0x03, 0xFD, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F, 0xE1, 0xFE, 0x3F,
  0xCF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0x87, 0xFB,
  0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0x10, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xC1, 0xFE, 0x7F, 0x01, 0xFE, 0xFE,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xEF, 0xE0,
  0x1F, 0xDF, 0xC0, 0x7F, 0xBF, 0xC1, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xF7, 0xF0, 0xFF, 0xCF, 0xE0, 0x7F, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x3E, 0x3F, 0xBF, 0xDF,
  0xFF, 0xFF, 0xF9, 0xFC, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xEF, 0xF7, 0xFF, 0xFE, 0xFE, 0x7F,
  0x0C, 0x00, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0x7F, 0xCF, 0xE3, 0xF8, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x1F, 0xC7, 0xF1,
  0xF8, 0x7E, 0x1F, 0x0F, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0x80, 0xFF, 0x20, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x00, 0xFE, 0x1F, 0x81, 0xFF, 0x87, 0xE3, 0xF0, 0x7F, 0xFE, 0x3E, 0x3E,
  0x0F, 0xFF, 0xE3, 0xF7, 0xE1, 0xFF, 0xFE, 0x1F, 0x7C, 0x3F, 0xC3, 0xE1,
  0xF7, 0xC3, 0xF0, 0x3E, 0x1F, 0xFC, 0x7E, 0x07, 0xE1, 0xFF, 0xC7, 0xE0,
  0x7E, 0x1F, 0xF8, 0x7E, 0x07, 0xE1, 0xFF, 0x87, 0xC0, 0x7E, 0x1F, 0xF8,
  0x7C, 0x07, 0xE1, 0xFF, 0x87, 0xC0, 0x7E, 0x1F, 0xF8, 0x7E, 0x07, 0xE3,
  0xFF, 0xC7, 0xE0, 0xFE, 0x3E, 0xFC, 0x3F, 0xBF, 0xFF, 0xEF, 0xC3, 0xFF,
  0xFF, 0xFC, 0x7C, 0x1F, 0xFD, 0xFF, 0x87, 0xE0, 0xFF, 0x8F, 0xF0, 0x7E,
  0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0x80, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC,
  0x7F, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFE, 0x03,
  0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFE, 0x07,
  0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0x3C, 0x3F, 0xE0, 0x01, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x43, 0xFF, 0x80, 0x70, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE,
  0x3F, 0x81, 0xFF, 0xC7, 0xF0, 0x0F, 0xFC, 0xFE, 0x00, 0x7F, 0x9F, 0xC0,
  0x0F, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFD,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xEF,
  0xE0, 0x03, 0xFD, 0xFC, 0x00, 0xFF, 0xBF, 0x80, 0x1F, 0xE7, 0xF0, 0x07,
  0xFC, 0xFE, 0x01, 0xFF, 0x9F, 0xC1, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0x38,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xF7, 0xF8, 0x3F, 0xFF, 0x7F, 0x83, 0xFF, 0xF7, 0xF8, 0x00,
  0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF3,
  0xFE, 0x00, 0xFF, 0x3F, 0xF8, 0x0F, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFE, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xF6, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF,
  0x80, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xEF, 0xE0, 0x0F,
  0xF3, 0xF8, 0x07, 0xFC, 0xFE, 0x03, 0xFE, 0x3F, 0x80, 0xFF, 0x0F, 0xE0,
  0x7F, 0x83, 0xF8, 0x3F, 0xE0, 0xFE, 0x1F, 0xF0, 0x3F, 0x87, 0xF8, 0x0F,
  0xE3, 0xFC, 0x03, 0xF9, 0xFF, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xBF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x3F,
  0x83, 0xFC, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xFC,
  0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0xE3, 0xF8, 0x07, 0xFC, 0xFE, 0x00,
  0xFF, 0x3F, 0x80, 0x3F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFD, 0xF8, 0x03, 0xFF, 0xFF, 0xBF,
  0x00, 0x7F, 0xFF, 0xF7, 0xE0, 0x0F, 0xBF, 0xFE, 0xFE, 0x03, 0xF7, 0xFF,
  0xCF, 0xC0, 0x7E, 0xFF, 0xFD, 0xF8, 0x0F, 0x9F, 0xFF, 0xBF, 0x83, 0xF3,
  0xFF, 0xF3, 0xF0, 0x7E, 0x7F, 0xFE, 0x7E, 0x0F, 0xCF, 0xFF, 0xCF, 0xC3,
  0xF1, 0xFF, 0xF8, 0xFC, 0x7E, 0x3F, 0xFF, 0x1F, 0x8F, 0xC7, 0xFF, 0xE3,
  0xF3, 0xF0, 0xFF, 0xFC, 0x7F, 0x7E, 0x1F, 0xFF, 0x87, 0xEF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xC1,
  0xFF, 0xF8, 0x3F, 0xF0, 0x3F, 0xFF, 0x07, 0xFE, 0x07, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0x81, 0xFE, 0x03, 0xFF, 0xF0,
  0x3F, 0xC0, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF,
  0xEF, 0xF0, 0x1F, 0xFF, 0x3F, 0xC0, 0xFF, 0xF9, 0xFE, 0x07, 0xFF, 0xC7,
  0xF8, 0x3F, 0xFE, 0x3F, 0xC1, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xC7, 0xF8,
  0x7F, 0xFE, 0x1F, 0xE3, 0xFF, 0xF0, 0xFF, 0x1F, 0xFF, 0x83, 0xFC, 0xFF,
  0xFC, 0x1F, 0xF3, 0xFF, 0xE0, 0x7F, 0x9F, 0xFF, 0x01, 0xFE, 0xFF, 0xF8,
  0x0F, 0xF7, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0xFF, 0x80,
  0x07, 0xF9, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xF7, 0xF8, 0x00,
  0x1F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xFC,
  0x7F, 0xC0, 0x1F, 0xF8, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x7F,
  0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x7F,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xFE,
  0x3F, 0x80, 0x7F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE, 0x03,
  0xFC, 0x3F, 0x81, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F,
  0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F, 0xE3, 0xF8,
  0x07, 0xF8, 0xFE, 0x01, 0xFF, 0x3F, 0x80, 0x3F, 0xEF, 0xE0, 0x07, 0xFB,
  0xF8, 0x01, 0xFF, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xE0,
  0x3C, 0xFF, 0x00, 0x13, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x3F, 0xE7, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00,
  0x1F, 0xF7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x07,
  0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFE, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F,
  0x83, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xE1,
  0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFC, 0xFE,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFB,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xF8, 0x01, 0xFC, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xE7, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x1F, 0xC0,
  0x1F, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0x87, 0xF8, 0x0F,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xEF,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFB, 0xF0,
  0x3F, 0x81, 0xFE, 0x0F, 0xDF, 0x83, 0xFC, 0x07, 0xF0, 0x7E, 0xFE, 0x1F,
  0xC0, 0x3F, 0x87, 0xF3, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x1F, 0x87, 0xF0,
  0x07, 0xF1, 0xF8, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xC7, 0xE3, 0xF8, 0x01,
  0xFC, 0xFE, 0x3F, 0x9F, 0xC0, 0x0F, 0xE7, 0xE0, 0xFC, 0xFE, 0x00, 0x3F,
  0x3F, 0x07, 0xE7, 0xF0, 0x01, 0xFD, 0xF8, 0x3F, 0x7F, 0x00, 0x0F, 0xEF,
  0xC1, 0xFB, 0xF8, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0x80,
  0x0F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x01,
  0xFE, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x3F,
  0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xBF, 0xE0, 0x01,
  0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0xFF, 0x1F, 0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFB, 0xFC, 0x00, 0x7F, 0x9F, 0xF0, 0x07, 0xFC, 0x7F, 0x80, 0x3F,
  0xC3, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE, 0x01,
  0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE,
  0x7F, 0x80, 0x07, 0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xE0, 0x07, 0xE3,
  0xE0, 0x07, 0xC3, 0xF0, 0x0F, 0xC1, 0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0x80,
  0xF8, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3E, 0x1F, 0xF0, 0xC0,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xCF, 0xFF, 0x3F,
  0x1F, 0xF0, 0x7C, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0xFF, 0x3F, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xC3, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x00, 0xFE,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x81, 0xFE,
  0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFE, 0xFF, 0xF8, 0xFE, 0x7F, 0xF0, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF1, 0xFF, 0x03, 0x8F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x9F, 0xF0, 0x1C, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0xFF, 0x0F, 0xFC, 0xFF,
  0x1F, 0xFE, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xC3, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0x7F, 0xC1, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFE, 0xFF, 0x0F, 0xFC, 0x7F, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7,
  0xF8, 0x7F, 0x9F, 0xE0, 0x7F, 0xBF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x13, 0xFF, 0x01, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xE3, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x0F, 0xFC, 0x7F,
  0x1F, 0xFF, 0x7F, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xC1, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0x7F, 0x81, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFE, 0xFF, 0x0F, 0xFE, 0xFF, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x60, 0x01, 0xFE, 0x7E, 0x07, 0xFE,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xE0,
  0xFF, 0x7F, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC3, 0xFE, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x80, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xC0, 0x10,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xF3, 0xFF, 0xFF, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0xCF, 0xF8,
  0x3F, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xEF, 0xF0,
  0x0F, 0xF3, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0xFF, 0x83, 0xFC, 0x7F, 0xC0, 0xFF, 0x3F, 0xE0, 0x3F, 0xCF, 0xF0,
  0x0F, 0xF7, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xE7, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFC,
  0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0xFF, 0x00,
  0xFF, 0xBF, 0xC0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x3F, 0xC3, 0xF1, 0xFF, 0xC3, 0xFF,
  0xCF, 0xEF, 0xFF, 0x9F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8, 0x7F,
  0xFF, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x80, 0x7F,
  0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xF0, 0x1F,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xFF, 0x01, 0xFE, 0x01, 0xFF,
  0xFC, 0x07, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F,
  0x80, 0x7F, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xF8, 0x07, 0xFF,
  0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xFF, 0x01, 0xFE,
  0x01, 0xFC, 0xFC, 0x1F, 0xE0, 0xFC, 0x7F, 0xF8, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xC1, 0xFE, 0xFF,
  0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F,
  0xC1, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x7F,
  0x81, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0xFC, 0x1F, 0xC0, 0xFE,
  0x7F, 0xF0, 0xFE, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xC3, 0xFE, 0xFF, 0x81, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x81, 0xFE, 0xFF, 0x83, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFE, 0xFF, 0xF8, 0xFF, 0x7F, 0xF0, 0xFF, 0x3F, 0xC0, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x0F,
  0xFC, 0x7F, 0x1F, 0xFE, 0x7F, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFE, 0xFF, 0x0F, 0xFE, 0xFF, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x1F, 0xFE, 0x1F,
  0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFE, 0x1F, 0x3F, 0x80, 0x27, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0x7F,
  0xFE, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xE0, 0x03, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0x7F, 0x1F, 0xFE, 0x7F, 0x0F, 0xF8,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F,
  0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F,
  0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xFC, 0x1F, 0xC0, 0x3F,
  0x87, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE7, 0xF0,
  0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0xFE, 0x03, 0xFE, 0x03, 0xFD,
  0xFE, 0x07, 0xFE, 0x07, 0xFB, 0xFC, 0x0F, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F,
  0xF8, 0x1F, 0xC7, 0xF0, 0x7F, 0xF0, 0x7F, 0x8F, 0xE0, 0xFF, 0xE0, 0xFE,
  0x1F, 0xE1, 0xF7, 0xE1, 0xFC, 0x1F, 0xC3, 0xEF, 0xC3, 0xF8, 0x3F, 0x8F,
  0xCF, 0x8F, 0xF0, 0x7F, 0x1F, 0x9F, 0x1F, 0xC0, 0x7F, 0x3F, 0x3F, 0x3F,
  0x80, 0xFE, 0x7C, 0x7E, 0x7F, 0x01, 0xFC, 0xF8, 0xFC, 0xFC, 0x03, 0xFB,
  0xF0, 0xFB, 0xF8, 0x03, 0xF7, 0xE1, 0xF7, 0xF0, 0x07, 0xEF, 0x83, 0xFF,
  0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xEF, 0xF8, 0x0F, 0xF8, 0xFF,
  0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC,
  0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xDF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF8, 0x07, 0xF8, 0xFF, 0x01,
  0xFE, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F, 0xF0, 0x1F, 0xE3, 0xFE, 0x03,
  0xFE, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xF9,
  0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x80,
  0xFF, 0x0F, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x87, 0xF8, 0x07, 0xF8, 0xFE, 0x00, 0x7F, 0x1F,
  0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03,
  0xFB, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x47, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xFE, 0x07,
  0xFF, 0x03, 0xFF, 0x00, 0x7F, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x05, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xA0, 0x03, 0xF8,
};

const GFXglyph NotoSans_ExtraBold45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 33, 13, 2, -32 },
  { 39, 17, 11, 23, 3, -32 },
  { 63, 27, 32, 29, 1, -32 },
  { 171, 22, 37, 26, 2, -34 },
  { 273, 39, 33, 42, 1, -33 },
  { 434, 33, 33, 35, 2, -33 },
  { 571, 7, 11, 13, 3, -32 },
  { 581, 12, 40, 16, 2, -33 },
  { 641, 13, 40, 16, 1, -33 },
  { 706, 22, 21, 24, 1, -34 },
  { 764, 22, 22, 26, 2, -27 },
  { 825, 10, 12, 13, 1, -6 },
  { 840, 12, 6, 14, 1, -15 },
  { 849, 9, 8, 13, 2, -7 },
  { 858, 19, 32, 19, 0, -32 },
  { 934, 22, 33, 26, 2, -33 },
  { 1025, 18, 32, 26, 2, -32 },
  { 1097, 23, 33, 26, 1, -33 },
  { 1192, 22, 33, 26, 2, -33 },
  { 1283, 24, 32, 26, 1, -32 },
  { 1379, 22, 32, 26, 2, -32 },
  { 1467, 23, 33, 26, 2, -33 },
  { 1562, 24, 32, 26, 1, -32 },
  { 1658, 22, 33, 26, 2, -33 },
  { 1749, 23, 33, 26, 1, -33 },
  { 1844, 9, 26, 13, 2, -25 },
  { 1874, 10, 31, 13, 1, -25 },
  { 1913, 22, 24, 26, 2, -28 },
  { 1979, 22, 14, 26, 2, -23 },
  { 2018, 22, 24, 26, 2, -28 },
  { 2084, 21, 34, 22, 0, -33 },
  { 2174, 36, 36, 40, 2, -32 },
  { 2336, 32, 32, 32, 0, -32 },
  { 2464, 24, 32, 30, 4, -32 },
  { 2560, 26, 33, 29, 2, -33 },
  { 2668, 27, 32, 33, 4, -32 },
  { 2776, 19, 32, 25, 4, -32 },
  { 2852, 18, 32, 24, 4, -32 },
  { 2924, 28, 33, 33, 2, -33 },
  { 3040, 27, 32, 34, 4, -32 },
  { 3148, 16, 32, 19, 1, -32 },
  { 3212, 15, 42, 15, -3, -32 },
  { 3291, 26, 32, 30, 4, -32 },
  { 3395, 20, 32, 26, 4, -32 },
  { 3475, 35, 32, 43, 4, -32 },
  { 3615, 29, 32, 37, 4, -32 },
  { 3731, 31, 33, 36, 2, -33 },
  { 3859, 22, 32, 28, 4, -32 },
  { 3947, 32, 41, 36, 2, -33 },
  { 4111, 26, 32, 30, 4, -32 },
  { 4215, 22, 33, 25, 2, -33 },
  { 4306, 24, 32, 26, 1, -32 },
  { 4402, 26, 32, 34, 4, -32 },
  { 4506, 30, 32, 30, 0, -32 },
  { 4626, 45, 32, 45, 0, -32 },
  { 4806, 31, 32, 31, 0, -32 },
  { 4930, 29, 32, 29, 0, -32 },
  { 5046, 25, 32, 27, 1, -32 },
  { 5146, 11, 40, 15, 3, -33 },
  { 5201, 19, 32, 19, 0, -32 },
  { 5277, 11, 40, 15, 1, -33 },
  { 5332, 24, 21, 25, 0, -32 },
  { 5395, 20, 4, 20, 0, 4 },
  { 5405, 14, 7, 18, 2, -34 },
  { 5418, 22, 25, 27, 2, -25 },
  { 5487, 24, 34, 29, 3, -34 },
  { 5589, 21, 25, 24, 2, -25 },
  { 5655, 24, 34, 29, 2, -34 },
  { 5757, 23, 25, 27, 2, -25 },
  { 5829, 19, 34, 18, 1, -34 },
  { 5910, 24, 36, 29, 2, -25 },
  { 6018, 24, 34, 30, 3, -34 },
  { 6120, 8, 35, 14, 3, -35 },
  { 6155, 13, 46, 14, -2, -35 },
  { 6230, 26, 34, 29, 3, -34 },
  { 6341, 8, 34, 14, 3, -34 },
  { 6375, 38, 25, 44, 3, -25 },
  { 6494, 24, 25, 30, 3, -25 },
  { 6569, 24, 25, 28, 2, -25 },
  { 6644, 24, 36, 29, 3, -25 },
  { 6752, 24, 36, 29, 2, -25 },
  { 6860, 17, 25, 21, 3, -25 },
  { 6914, 19, 25, 23, 2, -25 },
  { 6974, 18, 30, 20, 1, -30 },
  { 7042, 24, 25, 30, 3, -25 },
  { 7117, 27, 25, 27, 0, -25 },
  { 7202, 39, 25, 40, 0, -25 },
  { 7324, 27, 25, 27, 0, -25 },
  { 7409, 27, 36, 27, 0, -25 },
  { 7531, 20, 25, 22, 1, -25 },
  { 7594, 16, 39, 19, 1, -32 },
  { 7672, 6, 44, 24, 9, -34 },
  { 7705, 16, 39, 19, 2, -32 },
  { 7783, 22, 8, 26, 2, -20 },
};

const GFXfont NotoSans_ExtraBold45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold45pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_EXTRABOLD45PT7B_H_
