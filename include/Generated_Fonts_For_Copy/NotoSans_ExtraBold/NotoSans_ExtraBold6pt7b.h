#ifndef _NOTOSANS_EXTRABOLD6PT7B_H_
#define _NOTOSANS_EXTRABOLD6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xA0, 0x6F, 0xF6, 0x5F, 0x3E, 0xD7, 0x4E, 0xB0, 0x63, 0x2D,
  0xF0, 0x80, 0x6A, 0x40, 0xD5, 0x80, 0x5F, 0x80, 0x5D, 0x00, 0xC0, 0xC0,
  0x80, 0x69, 0x40, 0xF6, 0xB0, 0x74, 0x90, 0xE5, 0x70, 0xEC, 0xF0, 0x6F,
  0x90, 0xFC, 0xF0, 0x7E, 0xB0, 0xE5, 0x20, 0xEE, 0xF0, 0xF5, 0xF0, 0xA0,
  0xB0, 0x39, 0x80, 0xFC, 0x8F, 0x00, 0xED, 0x20, 0x7D, 0xF6, 0xE0, 0x66,
  0x79, 0xFE, 0xDE, 0x78, 0x87, 0xFD, 0xDE, 0xFF, 0x70, 0xFF, 0x60, 0x7A,
  0x97, 0xDF, 0xDD, 0xD7, 0x55, 0x80, 0xFE, 0xED, 0xDB, 0x70, 0xCD, 0xEF,
  0x50, 0xDB, 0xB9, 0x79, 0x97, 0xEF, 0xCC, 0x79, 0x97, 0x10, 0xFE, 0xED,
  0xF8, 0xF0, 0xE9, 0x20, 0xDD, 0xD7, 0x96, 0x66, 0xB6, 0xD7, 0x92, 0xF6,
  0x69, 0xB6, 0x44, 0xED, 0x70, 0xEA, 0xC0, 0x89, 0x30, 0xD5, 0xC0, 0x56,
  0x80, 0xE0, 0xC0, 0xFF, 0x80, 0x88, 0xE9, 0xE0, 0xF1, 0x80, 0x27, 0xD6,
  0xFD, 0x80, 0x6B, 0x24, 0xF5, 0xF0, 0x88, 0xF9, 0x90, 0xB8, 0xBC, 0x89,
  0xAE, 0xB0, 0xF8, 0xFA, 0xBA, 0xC0, 0xF9, 0x90, 0xEB, 0x60, 0xE9, 0xE8,
  0xF5, 0x90, 0xF2, 0x00, 0xEF, 0x80, 0x75, 0x99, 0x70, 0xB6, 0x40, 0xAA,
  0xD4, 0xF6, 0xB0, 0xB6, 0x4C, 0xEB, 0x80, 0x59, 0x40, 0xFC, 0xD5, 0xC0,
  0xE0,
};

const GFXglyph NotoSans_ExtraBold6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 3, 1, 3, 0, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 6, 0, -4 },
  { 10, 5, 4, 5, 0, -4 },
  { 13, 1, 1, 2, 0, -4 },
  { 14, 2, 5, 2, 0, -4 },
  { 16, 2, 5, 2, 0, -4 },
  { 18, 3, 3, 3, 0, -5 },
  { 20, 3, 3, 3, 0, -4 },
  { 22, 1, 2, 2, 0, -1 },
  { 23, 2, 1, 2, 0, -2 },
  { 24, 1, 1, 2, 0, -1 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 3, 4, 3, 0, -4 },
  { 45, 3, 4, 3, 0, -4 },
  { 47, 1, 3, 2, 0, -3 },
  { 48, 1, 4, 2, 0, -3 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 3, 2, 3, 0, -3 },
  { 52, 3, 3, 3, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 5, 4, 5, 0, -4 },
  { 59, 4, 4, 4, 0, -4 },
  { 61, 4, 4, 4, 0, -4 },
  { 63, 4, 4, 4, 0, -4 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 3, 4, 3, 0, -4 },
  { 69, 3, 4, 3, 0, -4 },
  { 71, 4, 4, 4, 0, -4 },
  { 73, 4, 4, 5, 0, -4 },
  { 75, 2, 4, 2, 0, -4 },
  { 76, 2, 5, 2, 0, -4 },
  { 78, 4, 4, 4, 0, -4 },
  { 80, 3, 4, 3, 0, -4 },
  { 82, 5, 4, 6, 0, -4 },
  { 85, 4, 4, 5, 0, -4 },
  { 87, 4, 4, 5, 0, -4 },
  { 89, 4, 4, 4, 0, -4 },
  { 91, 4, 5, 5, 0, -4 },
  { 94, 4, 4, 4, 0, -4 },
  { 96, 3, 4, 3, 0, -4 },
  { 98, 3, 4, 4, 0, -4 },
  { 100, 4, 4, 5, 0, -4 },
  { 102, 4, 4, 4, 0, -4 },
  { 104, 6, 4, 6, 0, -4 },
  { 107, 4, 4, 4, 0, -4 },
  { 109, 4, 4, 4, 0, -4 },
  { 111, 3, 4, 4, 0, -4 },
  { 113, 2, 5, 2, 0, -4 },
  { 115, 3, 4, 3, 0, -4 },
  { 117, 2, 5, 2, 0, -4 },
  { 119, 3, 3, 3, 0, -4 },
  { 121, 3, 1, 3, 0, 0 },
  { 122, 2, 1, 2, 0, -5 },
  { 123, 3, 3, 4, 0, -3 },
  { 125, 4, 5, 4, 0, -5 },
  { 128, 3, 3, 3, 0, -3 },
  { 130, 3, 5, 4, 0, -5 },
  { 132, 3, 3, 4, 0, -3 },
  { 134, 3, 5, 2, 0, -5 },
  { 136, 3, 4, 4, 0, -3 },
  { 138, 4, 5, 4, 0, -5 },
  { 141, 1, 5, 2, 0, -5 },
  { 142, 1, 6, 2, 0, -5 },
  { 143, 4, 5, 4, 0, -5 },
  { 146, 1, 5, 2, 0, -5 },
  { 147, 6, 3, 6, 0, -3 },
  { 150, 4, 3, 4, 0, -3 },
  { 152, 4, 3, 4, 0, -3 },
  { 154, 4, 4, 4, 0, -3 },
  { 156, 3, 4, 4, 0, -3 },
  { 158, 3, 3, 3, 0, -3 },
  { 160, 3, 3, 3, 0, -3 },
  { 162, 2, 4, 3, 0, -4 },
  { 163, 4, 3, 4, 0, -3 },
  { 165, 4, 3, 4, 0, -3 },
  { 167, 5, 3, 5, 0, -3 },
  { 169, 4, 3, 4, 0, -3 },
  { 171, 4, 4, 4, 0, -3 },
  { 173, 3, 3, 3, 0, -3 },
  { 175, 2, 5, 2, 0, -4 },
  { 177, 1, 6, 3, 1, -5 },
  { 178, 2, 5, 2, 0, -4 },
  { 180, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_ExtraBold6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold6pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_EXTRABOLD6PT7B_H_
