#ifndef _NOTOSANS_EXTRABOLD66PT7B_H_
#define _NOTOSANS_EXTRABOLD66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold66pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF9, 0xFF,
  0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF9,
  0xFF, 0xCF, 0xFE, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0xC3, 0xFE,
  0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x1F, 0xF1, 0xFF, 0xCF, 0xFE, 0xFF, 0xF7, 0xFF, 0xBF, 0xFF, 0xFF,
  0xE7, 0xFF, 0x3F, 0xF8, 0xFF, 0x81, 0xE0, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x07, 0xFC, 0xFF, 0x83, 0xFE, 0x7F, 0xC1, 0xFF, 0x3F,
  0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xF8, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3,
  0xFC, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x81, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0xFC,
  0xFF, 0x8F, 0xFE, 0x3F, 0x01, 0xC3, 0xFF, 0x8F, 0xC0, 0x10, 0xFF, 0xC3,
  0xF0, 0x00, 0x3F, 0xF8, 0xFC, 0x00, 0x0F, 0xFE, 0x3F, 0x00, 0x01, 0xFF,
  0xEF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xF7, 0xFF, 0xC0, 0x00,
  0xFC, 0xFF, 0xF0, 0x00, 0x3F, 0x1F, 0xFC, 0x00, 0x0F, 0xC3, 0xFF, 0x40,
  0x03, 0xF0, 0xFF, 0xDE, 0x00, 0xFC, 0x7F, 0xF7, 0xF8, 0x3F, 0x3F, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xC3, 0xFC,
  0x07, 0xF0, 0x0F, 0xF8, 0x3F, 0xC3, 0xFE, 0x1F, 0xFE, 0x03, 0xFC, 0x3F,
  0xE1, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0x3F, 0xF1, 0xFF, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0x8F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xF8,
  0x7F, 0xC7, 0xFC, 0x7F, 0xC1, 0xFF, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xE0,
  0x3F, 0xF8, 0x3F, 0xC3, 0xFE, 0x0F, 0xF8, 0x07, 0xE0, 0x3F, 0xE1, 0xFF,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80,
  0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x0F, 0xFD, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xF0, 0x7F, 0xFD, 0xFF, 0xF0, 0xFF, 0xF0,
  0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFD, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0xDF,
  0xF7, 0xFD, 0xFF, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0x80, 0x1F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x40, 0x0F, 0xE0, 0x02, 0x7C, 0x0F, 0xE0, 0x3E,
  0x7F, 0x8F, 0xE3, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xE0,
  0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0,
  0x03, 0xF8, 0x1F, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x30, 0x0C, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x7F, 0xF1,
  0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0,
  0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0,
  0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xFF,
  0xFE, 0x7F, 0xF3, 0xFF, 0x8F, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xCF, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xE0, 0x1F, 0xFC, 0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF,
  0x9F, 0xFC, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x3F, 0xF9,
  0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF0, 0x03, 0xFF, 0x9F, 0xFC, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x3F, 0xF8, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x07,
  0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xFE,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xDF,
  0xFE, 0xFF, 0xF3, 0xFF, 0x3F, 0xFC, 0x7F, 0x8F, 0xFF, 0x0F, 0xC3, 0xFF,
  0xC3, 0xC0, 0xFF, 0xF0, 0x60, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0x00, 0x1F, 0xFE, 0x0F, 0x80, 0x07, 0xFF, 0x81, 0x80, 0x01,
  0xFF, 0xE0, 0x20, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x1F, 0xFF, 0xC0, 0xF8, 0x00, 0xFF,
  0xF0, 0x18, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xB0, 0x00, 0x03, 0xFF, 0xEF, 0x80, 0x01, 0xFF, 0xFB,
  0xFE, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xEF, 0xFE, 0x00, 0x03, 0xFE, 0xFF, 0xE0, 0x00, 0x7F, 0xCF, 0xFE, 0x00,
  0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0xE0, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xE0, 0x07, 0xFC,
  0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xF8, 0x0F, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x7F, 0xC0, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xE7, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0xF8, 0x00, 0x3F, 0xFE, 0xFF,
  0xC1, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x80, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0xE0, 0x07, 0xFE, 0x1F, 0xFE, 0x01,
  0xFF, 0x9F, 0xFF, 0xE0, 0x7F, 0xEF, 0xFF, 0xFC, 0x1F, 0xFB, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xC0, 0x7F, 0xFB, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xDF,
  0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x07, 0xFF,
  0x7F, 0xF8, 0x03, 0xFF, 0xCF, 0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x7F,
  0xF8, 0x7F, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0xE8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x7F, 0xF0, 0xFF, 0xC0, 0x0F, 0xFE, 0x3F, 0xF0, 0x03, 0xFF, 0x0F,
  0xFC, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC,
  0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0x3F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC7,
  0xFF, 0x80, 0x7F, 0xF9, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xE0, 0x01, 0xFF,
  0xBF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFD, 0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0x80, 0xFF, 0xF1, 0xFF, 0xC0, 0x1F, 0xFC,
  0xFF, 0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x3F,
  0xFB, 0xFF, 0x80, 0x07, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xEF, 0xFC, 0x7F, 0xFF, 0xFB, 0xFE, 0x0F, 0xFF, 0xFD, 0xFF,
  0x81, 0xFF, 0xFE, 0x7F, 0xE0, 0x1F, 0xFF, 0x1F, 0xF8, 0x01, 0xFE, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x60, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB,
  0xFF, 0xFF, 0xFE, 0x7F, 0xF3, 0xFF, 0x8F, 0xF8, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0xC7,
  0xFF, 0x3F, 0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0x9F, 0xFC, 0xFF,
  0xE3, 0xFE, 0x07, 0x80, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFE, 0x7F,
  0xFD, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0xF1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xFE,
  0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE,
  0x3F, 0xE0, 0x7F, 0xFC, 0x7C, 0x00, 0x3F, 0xF8, 0x60, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xC0, 0x03,
  0xFE, 0x07, 0xFC, 0x01, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xFF,
  0xFC, 0x7F, 0xC3, 0xFC, 0x07, 0xFF, 0xFF, 0xE1, 0xFE, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xF1, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xDF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC1, 0xFE, 0xFF, 0x03, 0xFF, 0x81, 0xFE, 0x0F, 0xF7,
  0xF8, 0x3F, 0xF0, 0x1F, 0xF0, 0x7F, 0xBF, 0xC1, 0xFF, 0x00, 0xFF, 0x81,
  0xFF, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xFF, 0xC1, 0xFE, 0x00, 0x7F, 0x81, 0xFF, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xFF,
  0x83, 0xFC, 0x00, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F,
  0xDF, 0xE0, 0xFF, 0x80, 0x7F, 0xC1, 0xFE, 0xFF, 0x07, 0xFC, 0x07, 0xFE,
  0x0F, 0xF7, 0xF8, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xF8, 0x1F,
  0xFF, 0xFB, 0xFF, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0x9F, 0xFF, 0xC0, 0xFF,
  0x01, 0xFF, 0xF8, 0x7F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x80, 0x00, 0x60, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFD, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE7, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x8F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE7, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xDF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xBF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x00, 0x7F,
  0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0,
  0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x01, 0xFF, 0xEF,
  0xFF, 0x00, 0x1F, 0xFC, 0xFF, 0xF0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x7F,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xFE, 0xFF, 0xF0,
  0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0x7E, 0x07, 0xFF, 0xE0, 0x00, 0x30, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xC1, 0xFF, 0xFE, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x07, 0xC1,
  0xFF, 0xFC, 0x00, 0x01, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0xFF,
  0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0xF0, 0x00, 0x1F, 0xFB, 0xFF, 0xE0, 0x00,
  0x3F, 0xF3, 0xFF, 0xE0, 0x00, 0x7F, 0xE7, 0xFF, 0xE0, 0x00, 0xFF, 0xC7,
  0xFF, 0xF0, 0x01, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF3, 0xFF, 0x80, 0x03,
  0xFF, 0xE7, 0xFF, 0x00, 0x0F, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFE, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xF0, 0x07,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x07,
  0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xFC, 0x00,
  0x7F, 0xF1, 0xFF, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x01, 0xFF, 0xCF,
  0xFF, 0x00, 0x03, 0xFF, 0xBF, 0xFE, 0x00, 0x07, 0xFF, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xDF, 0xFE, 0x00, 0x1F, 0xFF, 0x1F, 0xFE,
  0x00, 0x3F, 0xF8, 0x3F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0xFF,
  0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x7F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x03,
  0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0xFF, 0xC3,
  0xFF, 0x80, 0x07, 0xFF, 0xC7, 0xFF, 0x00, 0x07, 0xFF, 0x8F, 0xFE, 0x00,
  0x0F, 0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x7F, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xFF, 0xFD, 0xFF,
  0x00, 0x0F, 0xFB, 0xFF, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x7F, 0xFF, 0xF3,
  0xFE, 0x00, 0x3F, 0xCF, 0xFF, 0xFE, 0x7F, 0xC0, 0x07, 0xF9, 0xFF, 0xFF,
  0xC7, 0xFC, 0x01, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0x80, 0x3F, 0xC7, 0xFF,
  0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0x01, 0xFF, 0x1F,
  0xFF, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xFF, 0xFF, 0xC7, 0xFC, 0x07, 0xF8,
  0x7F, 0xFF, 0xF8, 0xFF, 0x81, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F,
  0xE1, 0xFF, 0xFF, 0xE1, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xE1,
  0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xC7, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xF9, 0xFF, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xBF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xF7, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFE, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x7F, 0xF8, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x9F, 0xFE, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xF8, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xF8,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xC7, 0xFF, 0xFF, 0x80,
  0x3F, 0xF8, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFB, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00, 0x00, 0x7F,
  0xF9, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x9F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFD,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFD, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFD, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x9F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x17, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0xEF,
  0xFF, 0x00, 0xFF, 0xFB, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xEF, 0xFF, 0x00,
  0x3F, 0xFB, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFF, 0xBF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x00,
  0x00, 0x7F, 0xF9, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFD, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFD, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xDF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFD,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x9F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x17, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xFF, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x3F,
  0xF8, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF,
  0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x1F,
  0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x1F, 0xFC, 0x00,
  0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xFF,
  0xE1, 0xFF, 0xE0, 0x03, 0xFF, 0xE3, 0xFF, 0xC0, 0x03, 0xFF, 0xC7, 0xFF,
  0x80, 0x07, 0xFF, 0xCF, 0xFF, 0x00, 0x07, 0xFF, 0xDF, 0xFE, 0x00, 0x07,
  0xFF, 0xBF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0xF8, 0x7F,
  0xF8, 0x01, 0xF8, 0x7F, 0xF0, 0x00, 0x30, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFE, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x7F, 0xF8, 0x00,
  0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF7, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE7,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE3, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x7F,
  0xF8, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x8F, 0xFC, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x9F, 0xFC, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xDF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xDF, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x3F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0x81, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x7F, 0xCF, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xF3, 0xFE,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFC, 0xFF, 0x80, 0xFF, 0xE0, 0x03,
  0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC7,
  0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x3F, 0xE1, 0xFF, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x0F, 0xF8, 0x7F, 0xC1, 0xFF, 0xC0, 0x01, 0xFF, 0x83, 0xFE,
  0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0xFF, 0x87, 0xFE, 0x00, 0x07, 0xFF, 0x1F,
  0xF0, 0x3F, 0xE3, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFC, 0x0F, 0xF8, 0xFF,
  0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC,
  0xFF, 0x80, 0x7F, 0xCF, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x1F, 0xF3,
  0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x1F,
  0xFB, 0xFE, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x3F,
  0xDF, 0xF8, 0x00, 0x01, 0xFF, 0xBF, 0xC0, 0x0F, 0xF7, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF3,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x87, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xF1, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x00, 0x01, 0xFF, 0xF7,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC7, 0xFF,
  0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F,
  0x8F, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00,
  0x7F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x07, 0xFD, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x01, 0xE0, 0x07, 0xFF, 0x80, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF,
  0xCF, 0xFF, 0xFC, 0x3F, 0xE3, 0xFF, 0xFC, 0x1F, 0xF0, 0x7F, 0xF8, 0x07,
  0xF8, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x1F, 0xC0, 0x0F, 0xFE, 0x1F, 0xFC, 0x03, 0xFF, 0x9F, 0xFF,
  0xC0, 0xFF, 0xEF, 0xFF, 0xF8, 0x3F, 0xF7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xC1, 0xFF, 0xFB, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF,
  0xF0, 0x07, 0xFF, 0xBF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x1F, 0xFE, 0xFF, 0xF8, 0x0F, 0xFF, 0xBF,
  0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0xFF,
  0xC3, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xE0, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0x87, 0xFF, 0xC0, 0x06, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0x9F,
  0xFF, 0x00, 0x1E, 0x3F, 0xFF, 0x87, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x0F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x0F, 0xFF, 0xE7,
  0xFF, 0x07, 0xFF, 0xFD, 0xFF, 0xC3, 0xFF, 0xFF, 0xBF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xF0, 0xFF, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x1F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xFC, 0x03, 0xFF, 0xDF,
  0xFF, 0xC3, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0xCF,
  0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0xF8,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x00, 0xFF,
  0xE7, 0xFF, 0x80, 0x1F, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x7F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0C, 0x3F, 0xFE, 0x00, 0x0F, 0x0F, 0xFF, 0xF9,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x5F, 0x80, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x80, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF,
  0x0F, 0xFF, 0xFE, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x81,
  0xFF, 0xF7, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x7F, 0xF7, 0xFF, 0x80,
  0x1F, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xFE, 0x0F, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F, 0xFF, 0xDF, 0xFC,
  0x0F, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0x80, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC8, 0x00, 0x00, 0xFF, 0xF3, 0x80, 0x00, 0x7F, 0xFC, 0xFE, 0x00,
  0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x0F, 0xE0, 0x0F, 0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x9F, 0xFF,
  0xE0, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x07, 0x03, 0xFE, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0x7F, 0xF3, 0xFE, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F,
  0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x00, 0x0E, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF,
  0xC7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xDF, 0xFC, 0x00, 0x7F,
  0xFC, 0xFF, 0xE0, 0x07, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xFC, 0x3F, 0xF8,
  0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0xFC, 0x3F,
  0xFE, 0x00, 0xFF, 0xE3, 0xFF, 0xE0, 0x07, 0xFF, 0x1F, 0xFE, 0x00, 0x3F,
  0xF9, 0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xFE, 0x00, 0x0F, 0xFD, 0xFF, 0xE0,
  0x00, 0x7F, 0xEF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0x1F,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x3F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xFF, 0x0F, 0xFE,
  0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0x03, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFF,
  0x9F, 0xFC, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xF7, 0xFF, 0x00,
  0x07, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0xFF, 0x87, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0x8F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFE, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x3F,
  0xC0, 0x7F, 0xFC, 0x0F, 0xF8, 0x7F, 0xFF, 0xC3, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xFC, 0x7F, 0xF8, 0x03, 0xFF, 0xC7, 0xFF,
  0x80, 0x1F, 0xFE, 0x7F, 0xF0, 0x01, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFE,
  0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFE,
  0xFF, 0xF0, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00,
  0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFE, 0x7F, 0xF8, 0x01, 0xFF, 0xC3, 0xFF,
  0xC0, 0x3F, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x7F, 0xF8, 0x0F, 0xF8, 0x7F, 0xFF,
  0x03, 0xFF, 0x3F, 0xFF, 0xE0, 0xFF, 0xDF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0x07, 0xFF, 0xEF, 0xFF, 0x80, 0x7F, 0xFB, 0xFF,
  0xC0, 0x1F, 0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x7F, 0xFB, 0xFF, 0xE0, 0x3F, 0xFE, 0xFF,
  0xFF, 0x3F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xF7, 0xFF, 0xFF,
  0x0F, 0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0x9F, 0xFF, 0x80, 0xFF, 0xE1, 0xFF,
  0xC0, 0x3F, 0xF8, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x1F, 0xF0, 0x3F, 0xFF, 0x8F, 0xFC, 0x1F,
  0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0xFE, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0x81, 0xFF, 0xF7, 0xFF, 0x80, 0x3F, 0xFD, 0xFF, 0xE0, 0x07,
  0xFF, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xDF, 0xFC, 0x00, 0x7F,
  0xF7, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xF0, 0x0F, 0xFF, 0x7F, 0xFE, 0x0F,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xFF, 0x7F, 0xF0, 0x7F,
  0xFF, 0xDF, 0xFC, 0x0F, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xC0,
  0x03, 0x80, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x1F, 0x8F, 0xFE, 0x00, 0x38, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x70, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xEF, 0xFF,
  0x00, 0x7F, 0xFD, 0xFF, 0xE0, 0x1F, 0xFF, 0xBF, 0xFF, 0x8F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xFF, 0x7F, 0xE1, 0xFF, 0xFF,
  0xC7, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xF8, 0x1F, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x00, 0x3F,
  0xF9, 0xFF, 0xE0, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x03, 0xFF, 0x87, 0xFF, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xFF, 0x83,
  0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x1F, 0xF9,
  0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF,
  0xE0, 0x07, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x7F, 0xF0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x3F, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFE,
  0x3F, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F,
  0xE7, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xF8, 0x0F, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F,
  0xF8, 0x0F, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x3F, 0xC3,
  0xFC, 0x3F, 0xF0, 0x0F, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0xF0, 0x07, 0xFE,
  0x3F, 0xC3, 0xFC, 0x7F, 0xE0, 0x07, 0xFE, 0x3F, 0xC3, 0xFE, 0x7F, 0xE0,
  0x07, 0xFE, 0x7F, 0x83, 0xFE, 0x7F, 0xE0, 0x07, 0xFE, 0x7F, 0x81, 0xFE,
  0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0x81, 0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0x7F,
  0x81, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0xC0, 0x01,
  0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xF8, 0x01,
  0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x01, 0xFF, 0xE1,
  0xFF, 0xE0, 0x01, 0xFF, 0xE7, 0xFF, 0x80, 0x03, 0xFF, 0xCF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x0F, 0xFF, 0x9F, 0xFE, 0x00, 0x1F,
  0xFE, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F,
  0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0x00, 0xFF, 0xF9, 0xFF, 0xF0, 0x00,
  0xFF, 0xF7, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0xFF, 0xE0, 0x00, 0x3F, 0xF9, 0xFF, 0xE0, 0x00, 0x7F, 0xF3, 0xFF, 0xC0,
  0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x07, 0xFF,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0xC1, 0xFF,
  0xC0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00,
  0x3F, 0xF7, 0xFE, 0x00, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x3F, 0xFF, 0x00,
  0x03, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x80, 0x00, 0x3F,
  0xF8, 0x80, 0x00, 0x01, 0x80,
};

const GFXglyph NotoSans_ExtraBold66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 13, 48, 19, 3, -47 },
  { 79, 25, 17, 33, 4, -47 },
  { 133, 41, 47, 43, 1, -47 },
  { 374, 34, 54, 38, 2, -50 },
  { 604, 57, 49, 61, 2, -48 },
  { 954, 48, 49, 51, 3, -48 },
  { 1248, 10, 17, 18, 4, -47 },
  { 1270, 18, 58, 23, 3, -48 },
  { 1401, 18, 58, 23, 2, -48 },
  { 1532, 32, 31, 36, 2, -50 },
  { 1656, 32, 32, 38, 3, -39 },
  { 1784, 14, 18, 20, 2, -9 },
  { 1816, 17, 9, 21, 2, -22 },
  { 1836, 13, 12, 19, 3, -11 },
  { 1856, 28, 49, 28, 0, -48 },
  { 2028, 34, 49, 38, 2, -48 },
  { 2237, 26, 47, 38, 3, -47 },
  { 2390, 34, 48, 38, 2, -48 },
  { 2594, 34, 49, 38, 2, -48 },
  { 2803, 36, 47, 38, 1, -47 },
  { 3015, 32, 48, 38, 3, -47 },
  { 3207, 34, 49, 38, 2, -48 },
  { 3416, 34, 47, 38, 2, -47 },
  { 3616, 34, 49, 38, 2, -48 },
  { 3825, 34, 49, 38, 2, -48 },
  { 4034, 13, 38, 19, 3, -37 },
  { 4096, 14, 46, 19, 2, -37 },
  { 4177, 32, 36, 38, 3, -42 },
  { 4321, 32, 21, 38, 3, -34 },
  { 4405, 32, 36, 38, 3, -42 },
  { 4549, 31, 49, 32, 0, -48 },
  { 4739, 53, 53, 59, 3, -48 },
  { 5091, 47, 47, 47, 0, -47 },
  { 5368, 36, 47, 44, 5, -47 },
  { 5580, 38, 49, 43, 3, -48 },
  { 5813, 40, 47, 48, 5, -47 },
  { 6048, 27, 47, 37, 6, -47 },
  { 6207, 27, 47, 36, 6, -47 },
  { 6366, 39, 49, 48, 4, -48 },
  { 6605, 39, 47, 50, 6, -47 },
  { 6835, 23, 47, 27, 2, -47 },
  { 6971, 22, 61, 23, -5, -47 },
  { 7139, 39, 47, 45, 6, -47 },
  { 7369, 30, 47, 38, 5, -47 },
  { 7546, 51, 47, 63, 6, -47 },
  { 7846, 43, 47, 54, 6, -47 },
  { 8099, 46, 49, 52, 3, -48 },
  { 8381, 34, 47, 41, 5, -47 },
  { 8581, 46, 59, 52, 3, -48 },
  { 8921, 39, 47, 44, 5, -47 },
  { 9151, 32, 49, 37, 3, -48 },
  { 9347, 36, 47, 39, 1, -47 },
  { 9559, 40, 48, 50, 5, -47 },
  { 9799, 44, 47, 44, 0, -47 },
  { 10058, 66, 47, 66, 0, -47 },
  { 10446, 46, 47, 46, 0, -47 },
  { 10717, 42, 47, 42, 0, -47 },
  { 10964, 36, 47, 39, 2, -47 },
  { 11176, 16, 59, 22, 4, -48 },
  { 11294, 28, 49, 28, 0, -48 },
  { 11466, 15, 59, 22, 2, -48 },
  { 11577, 35, 31, 36, 1, -47 },
  { 11713, 30, 6, 30, 0, 5 },
  { 11736, 20, 11, 26, 3, -51 },
  { 11764, 33, 38, 40, 3, -37 },
  { 11921, 34, 51, 42, 5, -50 },
  { 12138, 30, 38, 35, 3, -37 },
  { 12281, 34, 51, 42, 3, -50 },
  { 12498, 34, 38, 40, 3, -37 },
  { 12660, 28, 50, 26, 1, -50 },
  { 12835, 34, 53, 42, 3, -37 },
  { 13061, 34, 50, 44, 5, -50 },
  { 13274, 12, 51, 21, 4, -51 },
  { 13351, 19, 67, 20, -3, -51 },
  { 13511, 37, 50, 42, 5, -50 },
  { 13743, 11, 50, 20, 5, -50 },
  { 13812, 56, 37, 65, 5, -37 },
  { 14071, 34, 37, 44, 5, -37 },
  { 14229, 36, 38, 42, 3, -37 },
  { 14400, 34, 53, 42, 5, -37 },
  { 14626, 34, 53, 42, 3, -37 },
  { 14852, 24, 37, 30, 5, -37 },
  { 14963, 28, 38, 34, 3, -37 },
  { 15096, 25, 45, 29, 2, -44 },
  { 15237, 35, 37, 44, 4, -36 },
  { 15399, 39, 36, 39, 0, -36 },
  { 15575, 56, 36, 58, 1, -36 },
  { 15827, 39, 36, 40, 0, -36 },
  { 16003, 39, 52, 39, 0, -36 },
  { 16257, 29, 36, 33, 2, -36 },
  { 16388, 24, 58, 27, 1, -47 },
  { 16562, 7, 65, 35, 14, -50 },
  { 16619, 24, 58, 27, 2, -47 },
  { 16793, 32, 12, 38, 3, -29 },
};

const GFXfont NotoSans_ExtraBold66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold66pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_EXTRABOLD66PT7B_H_
