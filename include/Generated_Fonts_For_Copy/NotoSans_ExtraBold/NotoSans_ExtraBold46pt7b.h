#ifndef _NOTOSANS_EXTRABOLD46PT7B_H_
#define _NOTOSANS_EXTRABOLD46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFE, 0xFF, 0x7F, 0xBF,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7,
  0xF3, 0xF8, 0x00, 0x00, 0x00, 0x04, 0x1F, 0xCF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFE, 0x7F, 0x04, 0x00, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE3, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE,
  0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xE1,
  0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3F, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8,
  0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0xFC, 0x00, 0x1F,
  0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x07, 0xC3, 0xF0, 0x00, 0x7C, 0x3F,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xF7, 0xF3, 0xF9, 0xE0, 0x47, 0xF3, 0xC0,
  0x0F, 0xE7, 0x80, 0x1F, 0xEF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3C, 0xFF, 0x00,
  0x78, 0xFF, 0x00, 0xF1, 0xFF, 0xC1, 0xE7, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x3F,
  0x01, 0xF8, 0x00, 0xFC, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x0F, 0xE0, 0x00, 0xFC,
  0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x1F,
  0x8F, 0xF0, 0x7E, 0x3F, 0x3F, 0x1F, 0xF8, 0x7F, 0xFE, 0x3F, 0x3F, 0xFC,
  0x3F, 0xFE, 0x7E, 0x7F, 0xFE, 0x3F, 0xFC, 0x7E, 0x7F, 0xFE, 0x1F, 0xF8,
  0xFC, 0x7E, 0x7F, 0x07, 0xF1, 0xFC, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFC,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x00, 0x0F, 0xC0,
  0xFC, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0x1F, 0x80, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x03, 0xFC, 0x1F, 0xFF, 0x00,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0x87, 0xFF, 0xFE, 0x1F, 0xE1, 0xFF, 0xFF,
  0xCF, 0xF8, 0xFF, 0x9F, 0xFB, 0xFC, 0x3F, 0xC3, 0xFF, 0xFF, 0x0F, 0xF0,
  0x7F, 0xFF, 0x83, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xCF, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFD, 0xF9, 0xF3, 0xE0, 0x03, 0xF8, 0x3F,
  0x83, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F,
  0x80, 0x7F, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0,
  0x3F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F,
  0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x18, 0x1F, 0x03, 0x3F, 0x3E, 0x7E, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xE0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x1F, 0x8F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7C, 0x1F, 0x00, 0x38, 0x38, 0x00, 0x10, 0x40, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF1,
  0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x08, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFD, 0xFC,
  0xFE, 0x08, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xF1, 0xFE, 0x3F, 0xC1,
  0xFE, 0xFF, 0x03, 0xFD, 0xFE, 0x03, 0xFB, 0xFC, 0x07, 0xF7, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFE, 0x7F,
  0x03, 0xFC, 0xFF, 0x07, 0xF9, 0xFE, 0x1F, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0xC1, 0xFF, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xEF, 0xF3,
  0xF3, 0xFC, 0xF8, 0xFF, 0x1C, 0x3F, 0xC2, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xC7,
  0xFE, 0x1F, 0x01, 0xFE, 0x0C, 0x01, 0xFE, 0x08, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x7F, 0xFF,
  0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x8F, 0x83, 0xFF, 0x0C, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFF, 0x00, 0x7F, 0x7F, 0x80, 0x3F,
  0x3F, 0xC0, 0x3F, 0x9F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0x87, 0xF8, 0x1F,
  0xC3, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF1, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x78, 0x0F, 0xE7, 0xFE, 0x1F, 0xDF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xDF,
  0xFB, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFD,
  0xFE, 0x0F, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x8F, 0xFD, 0xFF, 0x9F, 0xE0, 0xFF, 0x3F, 0x80, 0xFE, 0x7F, 0x01,
  0xFC, 0xFE, 0x07, 0xF9, 0xFE, 0x0F, 0xF3, 0xFE, 0x3F, 0xC3, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFE, 0x7F, 0xCF, 0xF8, 0x7F, 0xDF,
  0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x00,
  0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x00,
  0xFF, 0x7F, 0x00, 0xFF, 0x7F, 0x81, 0xFF, 0x7F, 0xC7, 0xFF, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0x7F, 0x1F, 0xFF, 0x7F, 0x07, 0xFC,
  0x7E, 0x01, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x1C, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x0F, 0xE7,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0x3F, 0x82, 0x00, 0x0E, 0x0F, 0xE3, 0xFD,
  0xFF, 0x7F, 0xDF, 0xF3, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xF3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF1, 0xFC, 0x7E, 0x1F, 0x87, 0xE3, 0xF0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x02,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE3, 0xE0, 0x7F, 0xC4, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFE, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xF1,
  0xFC, 0x1F, 0xFF, 0x9F, 0x8F, 0xC1, 0xFF, 0xFC, 0x7C, 0xFC, 0x1F, 0xFF,
  0xE3, 0xF7, 0xE1, 0xFF, 0xFF, 0x1F, 0xBE, 0x1F, 0xC1, 0xF8, 0x7D, 0xF0,
  0xFC, 0x0F, 0xC3, 0xFF, 0x8F, 0xC0, 0x7E, 0x1F, 0xFC, 0x7E, 0x03, 0xF0,
  0xFF, 0xE3, 0xF0, 0x1F, 0x87, 0xFF, 0x1F, 0x80, 0xFC, 0x3F, 0xF8, 0xFC,
  0x07, 0xC1, 0xFF, 0xC7, 0xE0, 0x7E, 0x1F, 0xFE, 0x3F, 0x03, 0xF0, 0xFB,
  0xF0, 0xFC, 0x3F, 0xCF, 0xDF, 0x87, 0xFF, 0xFF, 0xFE, 0x7C, 0x3F, 0xFF,
  0xFF, 0xE3, 0xF0, 0xFF, 0xF7, 0xFE, 0x1F, 0x83, 0xFE, 0x1F, 0xE0, 0x7E,
  0x03, 0xE0, 0x3C, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x60, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00,
  0x7F, 0x3F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0xC7, 0xF0, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFC, 0x1F,
  0xFD, 0xFE, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0,
  0x3F, 0xDF, 0xE0, 0x3F, 0xCF, 0xF0, 0x3F, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x9F, 0xE0, 0x7F, 0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB,
  0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF,
  0xBF, 0xC0, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0xC1, 0xF0, 0xFF, 0xC0,
  0x0C, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x21,
  0xFF, 0xC0, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE7, 0xF8,
  0x0F, 0xFC, 0xFF, 0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xFB, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0xFF, 0xDF,
  0xE0, 0x3F, 0xF3, 0xFC, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0x07, 0xE1, 0xFF, 0x80, 0x0C, 0x7F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0x7F, 0xC0, 0x0F, 0xEF, 0xFC, 0x01, 0xFC, 0xFF, 0xE0, 0x3F,
  0x9F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x81, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0xC7, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xE0, 0x7F, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFB,
  0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xCF, 0xF0, 0x1F, 0xF1, 0xFE, 0x07,
  0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x0F, 0xF8, 0x1F,
  0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x9F, 0xF0, 0x0F, 0xF7, 0xFC,
  0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xF9, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFE, 0x07, 0xF8,
  0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF8,
  0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFF, 0x3F, 0xC0,
  0x1F, 0xF7, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFD, 0xF8, 0x01, 0xFF, 0xFF, 0xDF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xF7, 0xFF, 0xEF, 0xC0, 0x3F, 0x7F, 0xFE, 0xFC, 0x03, 0xF7, 0xFF, 0xEF,
  0xC0, 0x7E, 0x7F, 0xFE, 0xFE, 0x07, 0xE7, 0xFF, 0xE7, 0xE0, 0x7E, 0x7F,
  0xFE, 0x7E, 0x0F, 0xC7, 0xFF, 0xE7, 0xF0, 0xFC, 0x7F, 0xFE, 0x3F, 0x0F,
  0xC7, 0xFF, 0xE3, 0xF1, 0xF8, 0x7F, 0xFE, 0x3F, 0x9F, 0x87, 0xFF, 0xE1,
  0xF9, 0xF8, 0x7F, 0xFE, 0x1F, 0x9F, 0x87, 0xFF, 0xE1, 0xFB, 0xF0, 0x7F,
  0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xC0, 0x7F, 0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F,
  0xFE, 0x03, 0xF8, 0x07, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xF7, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xBF,
  0xC0, 0x7F, 0xFE, 0x7F, 0x81, 0xFF, 0xF9, 0xFE, 0x07, 0xFF, 0xE3, 0xFC,
  0x1F, 0xFF, 0x8F, 0xF0, 0x7F, 0xFE, 0x1F, 0xE1, 0xFF, 0xF8, 0x7F, 0xC7,
  0xFF, 0xE0, 0xFF, 0x1F, 0xFF, 0x83, 0xFE, 0x7F, 0xFE, 0x07, 0xF9, 0xFF,
  0xF8, 0x0F, 0xF7, 0xFF, 0xE0, 0x3F, 0xDF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x03,
  0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01,
  0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01,
  0xFF, 0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x03,
  0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFE,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC1, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x1F, 0xFC,
  0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x03, 0xFE,
  0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFF,
  0x7F, 0xC0, 0x01, 0xFE, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFE,
  0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x3F, 0xC3, 0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0,
  0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1,
  0xFE, 0x07, 0xFC, 0x3F, 0xC3, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F,
  0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x0F, 0xF8, 0x7F,
  0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xF1, 0xFE, 0x01, 0xFF, 0x3F, 0xC0, 0x3F,
  0xE7, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE7, 0xFC, 0x1F, 0x3F, 0xC0, 0x0C, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xF9, 0xFF, 0x83, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFF,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE7, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x9F, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x7F, 0x80,
  0x3F, 0xF0, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xC3, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F,
  0xF8, 0x0F, 0xF0, 0x7F, 0x01, 0xFF, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xFF,
  0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFC, 0xFC,
  0x1F, 0xE0, 0x3F, 0x83, 0xF3, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xCF, 0xC1,
  0xFC, 0x03, 0xF8, 0x3F, 0x3F, 0x87, 0xF0, 0x0F, 0xF1, 0xFC, 0xFE, 0x3F,
  0xC0, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0x87, 0xE3, 0xF8,
  0x01, 0xFC, 0x7E, 0x1F, 0x8F, 0xE0, 0x07, 0xFB, 0xF8, 0x7F, 0x7F, 0x80,
  0x0F, 0xEF, 0xC0, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x03, 0xF7, 0xF0, 0x00,
  0xFE, 0xFC, 0x0F, 0xDF, 0xC0, 0x03, 0xFB, 0xF0, 0x3F, 0x7F, 0x00, 0x07,
  0xEF, 0xC0, 0x7D, 0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x3F,
  0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x7F,
  0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07,
  0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFD, 0xFE, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x07, 0xFC,
  0x3F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x03,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xF7, 0xC0, 0x01, 0xF3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x01, 0xF8,
  0x1F, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0x8F, 0xC0, 0x07,
  0xE7, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x83, 0xC0, 0xFF, 0x84, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0x7F, 0x3F, 0xFC, 0x7E, 0x3F, 0xF0, 0xFC, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x07, 0x80, 0xFF, 0x3F, 0xE0, 0xFF, 0x7F, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFE, 0xFF,
  0xF8, 0xFE, 0x7F, 0xF0, 0xFC, 0x3F, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0xFF,
  0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF,
  0xFF, 0x8F, 0xF8, 0x04, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x04, 0xFF, 0x80, 0xE7,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xE0, 0xFF, 0x07, 0xFC,
  0xFF, 0x0F, 0xFE, 0xFF, 0x1F, 0xFF, 0x7F, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0x7F, 0x0F, 0xFE, 0x7F, 0x07, 0xF8,
  0x3F, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x7F, 0xC1, 0xFE, 0x7F, 0x80,
  0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x04, 0x3F, 0xF0, 0x7C, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFC,
  0x7F, 0x0F, 0xFE, 0x7F, 0x1F, 0xFF, 0x7F, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x7F, 0xE7, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80,
  0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x60, 0x01,
  0xFF, 0x7C, 0x07, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x03, 0xC0, 0xFF, 0x3F, 0xF0, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F,
  0xF0, 0x7F, 0x81, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFD, 0xFF, 0xCF, 0xFC, 0x7F, 0x80, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x0F, 0xFB, 0xFC, 0x03, 0xFC,
  0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x7F, 0xC3, 0xFC, 0x3F,
  0xE0, 0xFF, 0x1F, 0xF0, 0x3F, 0xCF, 0xF8, 0x0F, 0xF3, 0xFC, 0x03, 0xFD,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFC, 0xFF,
  0x03, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0,
  0x3F, 0xE3, 0xFC, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xEF,
  0xF0, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x0F, 0x81, 0xF8, 0x7F, 0xE0, 0x7F, 0xE3,
  0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xF7, 0xFF, 0xEF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xFF, 0x01,
  0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xF8, 0x0F,
  0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0,
  0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0x01,
  0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0xF8,
  0x07, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F, 0xE0,
  0x3F, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF,
  0x00, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xC0,
  0xFC, 0x3F, 0xF0, 0xFE, 0x7F, 0xFC, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF1, 0xFF, 0x8F,
  0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x7F, 0x9F,
  0xE0, 0x3F, 0xCF, 0xF8, 0x3F, 0xE3, 0xFF, 0x7F, 0xE1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0xFE, 0x3F, 0xE0, 0xFE, 0x7F, 0xF8, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x81,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0x7F, 0xF0, 0xFF, 0x3F, 0xE0, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x7F, 0x0F, 0xFE,
  0x7F, 0x1F, 0xFF, 0x7F, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0xF7,
  0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0x7F, 0x80,
  0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFE, 0xFF, 0x07, 0xFC, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFF,
  0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0x01, 0xCF, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0xFE, 0xFC, 0x3F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x43, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0x7F, 0x1F, 0xFE, 0x3F, 0x0F, 0xFC, 0x3F, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x07, 0xF9, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC,
  0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x03, 0xF8,
  0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF8,
  0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0xFF, 0x00,
  0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x7F, 0x81, 0xFF, 0x80,
  0xFE, 0x3F, 0x81, 0xFF, 0x80, 0xFE, 0x3F, 0x81, 0xFF, 0xC1, 0xFE, 0x3F,
  0xC1, 0xFF, 0xC1, 0xFC, 0x3F, 0xC3, 0xFF, 0xC1, 0xFC, 0x1F, 0xC3, 0xF7,
  0xC1, 0xFC, 0x1F, 0xC3, 0xF7, 0xE3, 0xFC, 0x1F, 0xE3, 0xE7, 0xE3, 0xF8,
  0x1F, 0xE7, 0xE7, 0xE3, 0xF8, 0x0F, 0xE7, 0xE3, 0xE3, 0xF8, 0x0F, 0xE7,
  0xE3, 0xF7, 0xF0, 0x0F, 0xE7, 0xC3, 0xF7, 0xF0, 0x07, 0xE7, 0xC3, 0xF7,
  0xF0, 0x07, 0xFF, 0xC3, 0xF7, 0xF0, 0x07, 0xFF, 0xC1, 0xF7, 0xE0, 0x07,
  0xFF, 0xC1, 0xF7, 0xE0, 0x03, 0xFF, 0x81, 0xF7, 0xE0, 0x03, 0xFF, 0x81,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE7, 0xF8, 0x0F, 0xF8, 0xFF, 0x81,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0xF3, 0xFC, 0x01,
  0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0x7F, 0xC0, 0x3F, 0xE7, 0xF8, 0x07, 0xF8, 0xFF, 0x81, 0xFF,
  0x0F, 0xF8, 0x7F, 0xC0, 0xFF, 0x0F, 0xF8, 0x1F, 0xF3, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x03, 0xF9, 0xFE,
  0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFF,
  0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xC0,
  0x0F, 0xF3, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFB,
  0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0xFF, 0xF0,
  0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x80, 0xFE, 0x00, 0x80,
  0x00, 0x3F, 0xC0, 0x02, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xB0, 0x07, 0xFE, 0x40, 0x01, 0xF0,
};

const GFXglyph NotoSans_ExtraBold46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 9, 34, 13, 2, -33 },
  { 40, 17, 12, 23, 3, -33 },
  { 66, 28, 33, 30, 1, -33 },
  { 182, 23, 38, 26, 2, -35 },
  { 292, 40, 33, 42, 1, -33 },
  { 457, 34, 33, 36, 2, -33 },
  { 598, 7, 12, 13, 3, -33 },
  { 609, 13, 40, 16, 2, -33 },
  { 674, 13, 40, 16, 1, -33 },
  { 739, 23, 22, 25, 1, -35 },
  { 803, 23, 22, 27, 2, -27 },
  { 867, 10, 12, 14, 1, -6 },
  { 882, 13, 6, 15, 1, -15 },
  { 892, 9, 9, 13, 2, -8 },
  { 903, 20, 33, 20, 0, -33 },
  { 986, 23, 33, 27, 2, -33 },
  { 1081, 18, 33, 27, 2, -33 },
  { 1156, 24, 33, 27, 1, -33 },
  { 1255, 23, 33, 27, 2, -33 },
  { 1350, 25, 33, 27, 1, -33 },
  { 1454, 22, 33, 27, 2, -33 },
  { 1545, 23, 33, 27, 2, -33 },
  { 1640, 24, 33, 27, 1, -33 },
  { 1739, 23, 33, 27, 2, -33 },
  { 1834, 24, 33, 27, 1, -33 },
  { 1933, 9, 27, 13, 2, -26 },
  { 1964, 10, 32, 13, 1, -26 },
  { 2004, 23, 25, 27, 2, -29 },
  { 2076, 23, 15, 27, 2, -24 },
  { 2120, 23, 25, 27, 2, -29 },
  { 2192, 22, 34, 23, 0, -33 },
  { 2286, 37, 37, 41, 2, -33 },
  { 2458, 33, 33, 33, 0, -33 },
  { 2595, 25, 33, 31, 4, -33 },
  { 2699, 26, 33, 30, 2, -33 },
  { 2807, 27, 33, 34, 4, -33 },
  { 2919, 19, 33, 26, 4, -33 },
  { 2998, 19, 33, 25, 4, -33 },
  { 3077, 27, 33, 34, 3, -33 },
  { 3189, 27, 33, 35, 4, -33 },
  { 3301, 15, 33, 19, 2, -33 },
  { 3363, 16, 43, 16, -4, -33 },
  { 3449, 27, 33, 31, 4, -33 },
  { 3561, 21, 33, 26, 4, -33 },
  { 3648, 36, 33, 44, 4, -33 },
  { 3797, 30, 33, 38, 4, -33 },
  { 3921, 32, 33, 37, 2, -33 },
  { 4053, 23, 33, 29, 4, -33 },
  { 4148, 32, 41, 37, 2, -33 },
  { 4312, 27, 33, 31, 4, -33 },
  { 4424, 22, 33, 26, 2, -33 },
  { 4515, 25, 33, 27, 1, -33 },
  { 4619, 27, 33, 35, 4, -33 },
  { 4731, 31, 33, 31, 0, -33 },
  { 4859, 46, 33, 46, 0, -33 },
  { 5049, 32, 33, 32, 0, -33 },
  { 5181, 30, 33, 30, 0, -33 },
  { 5305, 25, 33, 27, 1, -33 },
  { 5409, 11, 41, 15, 3, -33 },
  { 5466, 19, 33, 20, 0, -33 },
  { 5545, 11, 41, 15, 1, -33 },
  { 5602, 25, 22, 25, 0, -33 },
  { 5671, 21, 4, 21, 0, 4 },
  { 5682, 14, 7, 18, 2, -35 },
  { 5695, 23, 26, 28, 2, -26 },
  { 5770, 24, 35, 29, 3, -35 },
  { 5875, 21, 26, 24, 2, -26 },
  { 5944, 24, 35, 29, 2, -35 },
  { 6049, 24, 26, 28, 2, -26 },
  { 6127, 19, 35, 18, 1, -35 },
  { 6211, 24, 37, 29, 2, -26 },
  { 6322, 24, 35, 30, 3, -35 },
  { 6427, 8, 35, 14, 3, -35 },
  { 6462, 13, 46, 14, -2, -35 },
  { 6537, 26, 35, 29, 3, -35 },
  { 6651, 8, 35, 14, 3, -35 },
  { 6686, 39, 26, 45, 3, -26 },
  { 6813, 24, 26, 30, 3, -26 },
  { 6891, 25, 26, 29, 2, -26 },
  { 6973, 24, 37, 29, 3, -26 },
  { 7084, 24, 37, 29, 2, -26 },
  { 7195, 17, 26, 21, 3, -26 },
  { 7251, 20, 26, 23, 2, -26 },
  { 7316, 18, 31, 21, 1, -31 },
  { 7386, 24, 25, 30, 3, -25 },
  { 7461, 27, 25, 27, 0, -25 },
  { 7546, 40, 25, 41, 0, -25 },
  { 7671, 27, 25, 28, 0, -25 },
  { 7756, 27, 36, 27, 0, -25 },
  { 7878, 21, 25, 23, 1, -25 },
  { 7944, 16, 41, 19, 1, -33 },
  { 8026, 5, 45, 24, 10, -35 },
  { 8055, 16, 41, 19, 2, -33 },
  { 8137, 23, 8, 27, 2, -20 },
};

const GFXfont NotoSans_ExtraBold46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold46pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_EXTRABOLD46PT7B_H_
