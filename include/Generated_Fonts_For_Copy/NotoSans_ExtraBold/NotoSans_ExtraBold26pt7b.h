#ifndef _NOTOSANS_EXTRABOLD26PT7B_H_
#define _NOTOSANS_EXTRABOLD26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x0F, 0xFF,
  0xDE, 0xF7, 0xFB, 0xFD, 0xFC, 0x7E, 0x3F, 0x1F, 0x8E, 0x07, 0x38, 0x0E,
  0x70, 0x1C, 0xE0, 0x79, 0xC0, 0xE3, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0E, 0x70, 0x38, 0xE0, 0x73, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCE,
  0x38, 0x1C, 0x70, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x00, 0x06, 0x00, 0x30,
  0x07, 0xF0, 0xFF, 0xF7, 0xFF, 0x7F, 0x7B, 0xD8, 0x1E, 0xC0, 0xFE, 0x03,
  0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0x3E, 0x19, 0xFE, 0xDF, 0xFF,
  0xF7, 0xFF, 0x9F, 0xF0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x03, 0xC1,
  0xF8, 0x0E, 0x0F, 0xF0, 0x78, 0x39, 0xC1, 0xC0, 0xE7, 0x8F, 0x03, 0x9E,
  0x38, 0x0E, 0x79, 0xC0, 0x39, 0xEF, 0x00, 0xE7, 0x39, 0xF3, 0xFD, 0xEF,
  0xE7, 0xE7, 0x3B, 0xC7, 0x3D, 0xE7, 0x00, 0xE7, 0x9C, 0x07, 0x9E, 0x70,
  0x1C, 0x79, 0xC0, 0xE1, 0xE7, 0x07, 0x83, 0xFC, 0x1C, 0x0F, 0xE0, 0xF0,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0x7C, 0x03,
  0xC7, 0x80, 0x79, 0xF0, 0x0F, 0x3C, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x79, 0xFF, 0x1F, 0x7F, 0xF3, 0xCF, 0x9F, 0xF9, 0xF1, 0xFE, 0x3E,
  0x1F, 0xC7, 0xE7, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0x9F, 0x80,
  0xFF, 0xFE, 0xEE, 0xE0, 0x1E, 0x38, 0xF1, 0xC7, 0x8F, 0x1C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0xC3, 0x87,
  0x80, 0xF0, 0xE1, 0xE1, 0xC3, 0xC7, 0x87, 0x0F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x3C, 0x00, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x60, 0xF6, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0x83,
  0xFC, 0x79, 0xE3, 0x9C, 0x09, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x00, 0x7B, 0xDD, 0xEF, 0x70, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFE, 0xF0, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xFE, 0x0F, 0xF8, 0xFF,
  0xE7, 0x8F, 0x7C, 0x7F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xFC, 0x7D, 0xE3, 0xEF, 0xBE, 0x7F, 0xF1, 0xFF, 0x07,
  0xF0, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x7F, 0xFF, 0xF7, 0xBC, 0x8F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x81, 0xFF, 0x3F, 0xFD, 0xFF, 0xE7, 0x0F, 0x90, 0x7C, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x83, 0xFF, 0x3F,
  0xFC, 0xFF, 0xE2, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x1F, 0xC0, 0xFC,
  0x07, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xFC, 0x3F, 0xFF, 0xF7,
  0xFF, 0x1F, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x03, 0xFC, 0x07, 0x78, 0x1E, 0xF0, 0x79, 0xE0, 0xE3, 0xC3,
  0xC7, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0xFF, 0xE7, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0xF8, 0x7F, 0xE3, 0xFF, 0x9F, 0xFC, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xFE, 0x7E, 0xFF, 0xF7, 0xFF, 0x1F, 0xF0, 0x03, 0xF0,
  0x7F, 0x87, 0xFC, 0x7F, 0xE7, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0xFC, 0xFF,
  0xF7, 0xFF, 0xFF, 0x3F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xE1, 0xEF, 0x9F,
  0x7F, 0xF1, 0xFF, 0x87, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xFB, 0xEF, 0x8F, 0xBC, 0x7D, 0xE3, 0xCF,
  0xFE, 0x3F, 0xE0, 0xFE, 0x0F, 0xF8, 0xFB, 0xEF, 0x8F, 0xF8, 0x3F, 0xC1,
  0xFF, 0x1F, 0xFF, 0xFB, 0xFF, 0x87, 0xF0, 0x0F, 0x01, 0xFE, 0x1F, 0xF9,
  0xFF, 0xEF, 0x8F, 0x78, 0x7F, 0xC1, 0xFE, 0x0F, 0xF8, 0xFF, 0xFF, 0xDF,
  0xFE, 0x7E, 0xF1, 0xC7, 0x80, 0x78, 0x03, 0xC0, 0x7E, 0x7F, 0xE3, 0xFE,
  0x1F, 0xC0, 0x23, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFD, 0xE0,
  0x23, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x07, 0xBD, 0xDE, 0xF7, 0x00,
  0x00, 0x18, 0x03, 0xC0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F, 0x03, 0xE0, 0x1F,
  0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF0, 0x03, 0x80, 0x04, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x3F, 0x0F, 0xF1, 0xFC, 0x3F, 0x81, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x0F,
  0x87, 0xFE, 0xFF, 0xF7, 0xFF, 0x60, 0xF0, 0x0F, 0x00, 0xF0, 0x3E, 0x07,
  0xE0, 0xF8, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1F,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0,
  0x3E, 0x03, 0xC3, 0xC0, 0x0F, 0x1C, 0x3F, 0x39, 0xC7, 0xFC, 0xEE, 0x7F,
  0xE7, 0xF3, 0x87, 0x3F, 0x3C, 0x39, 0xF9, 0xE3, 0xCF, 0xCE, 0x1E, 0x7E,
  0x78, 0xF3, 0xF1, 0xEF, 0xB9, 0xCF, 0xFF, 0xCE, 0x3E, 0x7C, 0x78, 0x00,
  0x01, 0xE0, 0x04, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x1E, 0x07, 0xC7, 0x81, 0xE1,
  0xF0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xF9, 0xF0, 0x1E,
  0x7C, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7C, 0xFE, 0x03, 0xFF, 0xCF, 0xFF,
  0xBF, 0xFE, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x3E, 0xFF, 0xF3, 0xFF,
  0x8F, 0xFF, 0xBE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x7F, 0xFF,
  0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF,
  0xE3, 0xE0, 0xCF, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x9F, 0xDE, 0x3F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xF8, 0x7E, 0xF8, 0x3E, 0xF8, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x7E, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x02, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0x78,
  0xFF, 0x78, 0x0F, 0x7C, 0x0F, 0x7E, 0x0F, 0x3F, 0x9F, 0x3F, 0xFF, 0x1F,
  0xFF, 0x07, 0xFE, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xEF, 0xE3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF1, 0xF7, 0xFB, 0xF9, 0xF8, 0x70, 0x00, 0xF8, 0x1F, 0xF8, 0x3E,
  0xF8, 0x7C, 0xF8, 0xF8, 0xF8, 0xF8, 0xF9, 0xF0, 0xFB, 0xE0, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xF9, 0xF0, 0xF9, 0xF0,
  0xF8, 0xF8, 0xF8, 0x78, 0xF8, 0x7C, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xBF, 0xFC, 0x1D, 0xFE, 0xE1, 0xEF,
  0xF7, 0x8F, 0x7F, 0xBC, 0x73, 0xFC, 0xE3, 0x9F, 0xE7, 0x3C, 0xFF, 0x3D,
  0xC7, 0xF8, 0xEE, 0x3F, 0xC7, 0xF1, 0xFE, 0x3F, 0x0F, 0xF1, 0xF8, 0x7F,
  0x87, 0xC3, 0xFC, 0x3C, 0x1E, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0xE0, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xDE, 0x1F, 0xEF, 0x8F, 0xF3, 0xC7,
  0xF9, 0xF3, 0xFC, 0x79, 0xFE, 0x3E, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC1,
  0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x0F, 0x9F, 0x01, 0xF7,
  0xC0, 0x7D, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0x78, 0x07, 0xDF, 0x01, 0xF7, 0xE0, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFE, 0x07, 0xFF, 0x3F, 0xFD, 0xFF, 0xFF,
  0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xCF, 0xF0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x7E, 0x0F, 0x9F,
  0x01, 0xF7, 0xC0, 0x7D, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x01, 0xF7, 0xE0, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0xCF,
  0x8F, 0x9F, 0x0F, 0x3E, 0x1E, 0x7C, 0x3C, 0xF9, 0xF9, 0xFF, 0xE3, 0xFF,
  0x87, 0xFF, 0x0F, 0x9E, 0x1F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0x7D,
  0xF0, 0x7B, 0xE0, 0xF8, 0x0F, 0xC1, 0xFF, 0xDF, 0xFC, 0xFF, 0xEF, 0x82,
  0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x03, 0xFF, 0x3E, 0xFF, 0xF7, 0xFF, 0x1F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xF8,
  0x07, 0xFC, 0x07, 0xDE, 0x03, 0xEF, 0x81, 0xE7, 0xC1, 0xF1, 0xE0, 0xF8,
  0xF8, 0x78, 0x7C, 0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0xCF, 0x01, 0xEF,
  0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x1E, 0x07, 0xFE, 0x07, 0x81, 0xF7, 0x83,
  0xF0, 0x79, 0xE0, 0xFC, 0x1E, 0x78, 0x3F, 0x07, 0x9F, 0x0F, 0xC3, 0xE3,
  0xC7, 0xF8, 0xF0, 0xF1, 0xFE, 0x3C, 0x3C, 0x7B, 0x8F, 0x0F, 0x9C, 0xE7,
  0xC1, 0xEF, 0x3D, 0xE0, 0x7B, 0xCF, 0x78, 0x1E, 0xF3, 0xDE, 0x07, 0xB8,
  0x77, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0xDF, 0x03, 0xE3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x1F, 0x3E, 0x03, 0xCF, 0x00, 0xFF, 0xC0, 0x1F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03,
  0xDF, 0x01, 0xF3, 0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x03, 0xEF, 0x80,
  0xFC, 0xF8, 0x0F, 0xBC, 0x0F, 0x9F, 0x07, 0xC7, 0x87, 0xC3, 0xE3, 0xE0,
  0xF3, 0xE0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E,
  0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xFF, 0xFF, 0xC0, 0xF0, 0x0F,
  0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xFF, 0xFF, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3,
  0xCF, 0x3C, 0xF3, 0xCF, 0xFF, 0xFF, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x01, 0xCE, 0x07, 0x3C, 0x38, 0x70, 0xE1,
  0xE7, 0x03, 0x9C, 0x0F, 0xF0, 0x1C, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x1E,
  0x0F, 0x01, 0x03, 0xFF, 0x0F, 0xFC, 0x7F, 0xF2, 0x0F, 0x80, 0x3C, 0x7F,
  0xEF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0xF1, 0xFF, 0xFF, 0xBF, 0xFC,
  0xFC, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x43,
  0xDF, 0x9F, 0xFE, 0xFF, 0xFF, 0xC7, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFF, 0x1F, 0xFD, 0xFF, 0xFF, 0xBF, 0xFD, 0xCF, 0xC0, 0x01,
  0x01, 0xFF, 0x3F, 0xF7, 0xFE, 0x7C, 0x2F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x07, 0xE7, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x11, 0xF3, 0xFF, 0xCF, 0xEF,
  0x7F, 0xFD, 0xF1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83,
  0xFE, 0x1F, 0x7C, 0xFD, 0xFF, 0xF3, 0xFB, 0xC7, 0xCF, 0x03, 0x00, 0x7F,
  0x83, 0xFF, 0x1F, 0xFE, 0x78, 0x7B, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0x02, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x00,
  0x0F, 0xC7, 0xF3, 0xFC, 0xFA, 0x3C, 0x0F, 0x0F, 0xFB, 0xFE, 0xFF, 0x8F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x04, 0x00, 0xFE, 0xF3, 0xFF, 0xDF, 0xFF, 0x7C, 0x7F, 0xE1, 0xFF,
  0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87, 0xDF, 0x3F, 0x7F, 0xFC,
  0xFF, 0xF1, 0xF7, 0xC0, 0x1F, 0x00, 0x7D, 0x83, 0xE7, 0xFF, 0x9F, 0xFC,
  0x7F, 0xE0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x43,
  0xDF, 0xDF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x3C, 0x78,
  0xF0, 0x00, 0x07, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xEF, 0xFF, 0xFD, 0xF0, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x1F, 0x78, 0x7C, 0xF1,
  0xF1, 0xE7, 0xC3, 0xDF, 0x07, 0xBC, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8,
  0x7C, 0xF0, 0xF1, 0xF1, 0xE1, 0xF3, 0xC1, 0xF7, 0x83, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x80, 0xC3, 0x9F,
  0xCF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF8, 0xFC, 0x7F, 0xE3, 0xE1,
  0xFF, 0x07, 0x87, 0xFC, 0x1E, 0x1F, 0xF0, 0x78, 0x7F, 0xC1, 0xE1, 0xFF,
  0x07, 0x87, 0xFC, 0x1E, 0x1F, 0xF0, 0x78, 0x7F, 0xC1, 0xE1, 0xFF, 0x07,
  0x87, 0xC0, 0x00, 0x87, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xE0, 0x01, 0x00, 0x7F, 0x83, 0xFF, 0x1F, 0xFE, 0x78, 0x7F,
  0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xF7, 0x87, 0xDF, 0x1F,
  0x7F, 0xF8, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x87, 0xBF, 0x3F, 0xFD, 0xFF,
  0xFF, 0x8F, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFE, 0x3F,
  0xFB, 0xFF, 0xFF, 0x7F, 0xFB, 0xDF, 0x9E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x04, 0x00, 0xFE, 0xF3, 0xFB, 0xDF, 0xFF,
  0x7C, 0x7F, 0xE1, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x87,
  0xDF, 0x3F, 0x7F, 0xFC, 0xFF, 0xF1, 0xF7, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF9, 0xEF, 0xFB, 0xFE, 0xFF,
  0xBE, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x00, 0x04, 0x07, 0xFD, 0xFF, 0xFF, 0xEF, 0x05, 0xF8, 0x1F, 0xC3, 0xFE,
  0x1F, 0xE0, 0xFC, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xBF, 0xE0, 0x1C, 0x0F,
  0x03, 0xC1, 0xFF, 0xFF, 0xFF, 0xF7, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x93, 0xFC, 0xFF, 0x1F, 0xC0, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87,
  0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0x9F, 0x9C, 0xF8, 0x3E, 0xF0, 0x7D, 0xE0,
  0xF3, 0xE1, 0xE3, 0xC7, 0xC7, 0x8F, 0x07, 0x9E, 0x0F, 0x78, 0x1E, 0xF0,
  0x1D, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x7C,
  0x3E, 0xF0, 0xF8, 0x79, 0xE3, 0xF8, 0xF3, 0xE7, 0x73, 0xE3, 0xCE, 0xE7,
  0x87, 0x9D, 0xCF, 0x0F, 0x7B, 0x9E, 0x1E, 0xE7, 0xF8, 0x1F, 0xC7, 0xF0,
  0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x7C, 0x00, 0xFC, 0x3E, 0x7C, 0x7C, 0x3E, 0x7C, 0x1F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3E,
  0xF8, 0x3E, 0x7C, 0x7C, 0x3E, 0xF8, 0x3F, 0xF8, 0x1E, 0xF0, 0x7D, 0xF0,
  0xF3, 0xE1, 0xE3, 0xC7, 0xC7, 0x8F, 0x07, 0x9E, 0x0F, 0x78, 0x1E, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0x87, 0xC7, 0xE3, 0xF1, 0xE0, 0xE0,
  0x70, 0x38, 0x1C, 0x1E, 0x3F, 0x1E, 0x0F, 0x87, 0xE0, 0xF0, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0xC1, 0xF8, 0xFC, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x7C, 0x3F, 0x1F, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1F, 0x07, 0xE0, 0xF1, 0xF9, 0xFC, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x8F, 0xC7, 0xC3, 0xC0, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF,
  0x03, 0xE0,
};

const GFXglyph NotoSans_ExtraBold26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 5, 19, 7, 1, -19 },
  { 13, 9, 7, 13, 2, -19 },
  { 21, 15, 19, 17, 1, -19 },
  { 57, 13, 22, 15, 1, -20 },
  { 93, 22, 19, 24, 1, -19 },
  { 146, 19, 19, 20, 1, -19 },
  { 192, 4, 7, 7, 2, -19 },
  { 196, 7, 23, 9, 1, -19 },
  { 217, 7, 23, 9, 1, -19 },
  { 238, 12, 13, 14, 1, -20 },
  { 258, 13, 13, 15, 1, -16 },
  { 280, 5, 6, 8, 1, -3 },
  { 284, 7, 4, 8, 1, -9 },
  { 288, 5, 4, 7, 1, -4 },
  { 291, 11, 19, 11, 0, -19 },
  { 318, 13, 19, 15, 1, -19 },
  { 349, 10, 19, 15, 1, -19 },
  { 373, 13, 19, 15, 1, -19 },
  { 404, 13, 19, 15, 1, -19 },
  { 435, 15, 19, 15, 0, -19 },
  { 471, 13, 19, 15, 1, -19 },
  { 502, 13, 19, 15, 1, -19 },
  { 533, 13, 19, 15, 1, -19 },
  { 564, 13, 19, 15, 1, -19 },
  { 595, 13, 19, 15, 1, -19 },
  { 626, 5, 15, 7, 1, -15 },
  { 636, 5, 18, 8, 1, -15 },
  { 648, 13, 14, 15, 1, -16 },
  { 671, 13, 8, 15, 1, -13 },
  { 684, 13, 14, 15, 1, -16 },
  { 707, 12, 19, 13, 0, -19 },
  { 736, 21, 21, 23, 1, -19 },
  { 792, 18, 19, 18, 0, -19 },
  { 835, 14, 19, 17, 2, -19 },
  { 869, 15, 19, 17, 1, -19 },
  { 905, 16, 19, 19, 2, -19 },
  { 943, 11, 19, 14, 2, -19 },
  { 970, 11, 19, 14, 2, -19 },
  { 997, 16, 19, 19, 1, -19 },
  { 1035, 16, 19, 20, 2, -19 },
  { 1073, 9, 19, 11, 1, -19 },
  { 1095, 9, 25, 9, -2, -19 },
  { 1124, 16, 19, 18, 2, -19 },
  { 1162, 12, 19, 15, 2, -19 },
  { 1191, 21, 19, 25, 2, -19 },
  { 1241, 17, 19, 21, 2, -19 },
  { 1282, 18, 19, 21, 1, -19 },
  { 1325, 13, 19, 16, 2, -19 },
  { 1356, 18, 23, 21, 1, -19 },
  { 1408, 15, 19, 17, 2, -19 },
  { 1444, 13, 19, 15, 1, -19 },
  { 1475, 14, 19, 15, 1, -19 },
  { 1509, 16, 19, 20, 2, -19 },
  { 1547, 17, 19, 17, 0, -19 },
  { 1588, 26, 19, 26, 0, -19 },
  { 1650, 18, 19, 18, 0, -19 },
  { 1693, 17, 19, 17, 0, -19 },
  { 1734, 14, 19, 15, 1, -19 },
  { 1768, 6, 23, 9, 2, -19 },
  { 1786, 11, 19, 11, 0, -19 },
  { 1813, 6, 23, 9, 1, -19 },
  { 1831, 14, 13, 14, 0, -19 },
  { 1854, 12, 2, 12, 0, 2 },
  { 1857, 8, 4, 10, 1, -20 },
  { 1861, 13, 15, 16, 1, -15 },
  { 1886, 13, 20, 17, 2, -20 },
  { 1919, 12, 15, 14, 1, -15 },
  { 1942, 14, 20, 17, 1, -20 },
  { 1977, 14, 15, 16, 1, -15 },
  { 2004, 10, 20, 10, 1, -20 },
  { 2029, 14, 21, 17, 1, -15 },
  { 2066, 13, 20, 17, 2, -20 },
  { 2099, 4, 20, 8, 2, -20 },
  { 2109, 7, 26, 8, -1, -20 },
  { 2132, 15, 20, 17, 2, -20 },
  { 2170, 4, 20, 8, 2, -20 },
  { 2180, 22, 15, 26, 2, -15 },
  { 2222, 13, 15, 17, 2, -15 },
  { 2247, 14, 15, 16, 1, -15 },
  { 2274, 13, 21, 17, 2, -15 },
  { 2309, 14, 21, 17, 1, -15 },
  { 2346, 10, 15, 12, 2, -15 },
  { 2365, 11, 15, 13, 1, -15 },
  { 2386, 10, 17, 12, 1, -17 },
  { 2408, 13, 14, 17, 2, -14 },
  { 2431, 15, 14, 15, 0, -14 },
  { 2458, 23, 14, 23, 0, -14 },
  { 2499, 16, 14, 16, 0, -14 },
  { 2527, 15, 20, 15, 0, -14 },
  { 2565, 11, 14, 13, 1, -14 },
  { 2585, 9, 23, 11, 1, -19 },
  { 2611, 3, 26, 14, 5, -20 },
  { 2621, 9, 23, 11, 1, -19 },
  { 2647, 13, 4, 15, 1, -11 },
};

const GFXfont NotoSans_ExtraBold26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold26pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_EXTRABOLD26PT7B_H_
