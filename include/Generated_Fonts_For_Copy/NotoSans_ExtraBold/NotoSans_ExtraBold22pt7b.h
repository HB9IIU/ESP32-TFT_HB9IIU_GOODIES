#ifndef _NOTOSANS_EXTRABOLD22PT7B_H_
#define _NOTOSANS_EXTRABOLD22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x70, 0x6F, 0xFF, 0xF7, 0xFB, 0xFD,
  0xCE, 0xE6, 0x33, 0x18, 0x07, 0x30, 0x19, 0xC0, 0x67, 0x03, 0x9C, 0x0E,
  0x61, 0xFF, 0xF7, 0xFF, 0xC3, 0x38, 0x0C, 0xE3, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0x19, 0xC0, 0x67, 0x03, 0x9C, 0x0E, 0x60, 0x0C, 0x01, 0x80, 0xFF,
  0xBF, 0xEF, 0xFD, 0xD8, 0xBB, 0x07, 0xE0, 0x7F, 0x07, 0xF8, 0x3F, 0x86,
  0xF8, 0xCF, 0xFF, 0xFF, 0xF7, 0xFC, 0x0C, 0x01, 0x80, 0x38, 0x0E, 0x1F,
  0x83, 0x83, 0xB8, 0x70, 0x77, 0x1C, 0x0C, 0xE3, 0x81, 0x9C, 0xE0, 0x3B,
  0x98, 0xC7, 0x77, 0x7E, 0xFD, 0xDF, 0xC7, 0x3B, 0x9C, 0x0E, 0x73, 0x81,
  0xCE, 0x70, 0x71, 0xCE, 0x0E, 0x3B, 0x83, 0x83, 0xF0, 0xE0, 0x3C, 0x0F,
  0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x79, 0xE0, 0x79, 0xE0, 0x3B, 0xC0, 0x3F,
  0x80, 0x3F, 0x1E, 0x7F, 0x1E, 0xFF, 0x9E, 0xF3, 0xFC, 0xF1, 0xFC, 0xF0,
  0xF8, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x9F, 0xFF, 0xF7, 0x66, 0x1C, 0xE7,
  0x9C, 0x73, 0xCE, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8F, 0x1C, 0x70, 0xE3,
  0xC0, 0xE1, 0xC7, 0x1E, 0x38, 0xE3, 0xCF, 0x1C, 0x71, 0xC7, 0x3C, 0xE3,
  0x8E, 0x79, 0xCE, 0x00, 0x1C, 0x03, 0x00, 0xC3, 0x33, 0xFF, 0xFF, 0xF1,
  0xE0, 0xFC, 0x77, 0x9C, 0xE1, 0x20, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x77, 0xFE,
  0xEC, 0xFF, 0xFE, 0x6F, 0xFF, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x70,
  0x38, 0x3C, 0x1C, 0x0E, 0x0F, 0x07, 0x07, 0x83, 0x81, 0xC1, 0xE0, 0x1F,
  0x07, 0xF1, 0xFF, 0x79, 0xEF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1C, 0xFF, 0x9F, 0xE0, 0xF8, 0x07, 0x87, 0xC7,
  0xEF, 0xFF, 0xFB, 0xBC, 0x9E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x1F, 0x0F, 0xF3, 0xFF, 0x39, 0xE4, 0x1E, 0x03, 0x80,
  0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0x1F, 0xF3, 0xFF, 0x31, 0xE0, 0x1C, 0x07, 0x83, 0xE1, 0xF8,
  0x3F, 0x80, 0xF8, 0x07, 0x80, 0xF8, 0x3F, 0xFF, 0xBF, 0xF7, 0xF8, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x1D, 0xE3, 0x9E, 0x39,
  0xE7, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x7F,
  0xCF, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0, 0x3F, 0xC7, 0xFE, 0xFF, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x3D, 0xFF, 0xBF, 0xE7, 0xF8, 0x07, 0xC3, 0xF8,
  0xFF, 0x3C, 0x07, 0x01, 0xE0, 0x3B, 0xE7, 0xFE, 0xFF, 0xFE, 0x3F, 0x87,
  0xF8, 0xFF, 0x1E, 0xFF, 0x9F, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x1F, 0x0F, 0xFB, 0xFF, 0x78, 0xFF, 0x1C,
  0xE7, 0x9F, 0xE1, 0xF8, 0x3F, 0x8F, 0x7B, 0xC7, 0xF0, 0xFE, 0x1F, 0xFF,
  0xDF, 0xF1, 0xFC, 0x1E, 0x0F, 0xF3, 0xFF, 0x79, 0xEE, 0x1F, 0xC3, 0xF8,
  0x7F, 0x9F, 0xFF, 0xEF, 0xFC, 0x67, 0x80, 0xE0, 0x3C, 0xFF, 0x1F, 0xC3,
  0xF0, 0xFF, 0xF6, 0x00, 0x00, 0x6F, 0xFF, 0xFF, 0xF6, 0x00, 0x00, 0x07,
  0x7F, 0xEE, 0xC0, 0x00, 0x20, 0x1C, 0x0F, 0x87, 0xE3, 0xE1, 0xF0, 0x3C,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0x80, 0x10, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x1C, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0xF8, 0x7E, 0x7F, 0x1F, 0x83, 0x80, 0x40, 0x00, 0x3F,
  0x3F, 0xE7, 0xFD, 0x87, 0x01, 0xC0, 0xF0, 0x7C, 0x3E, 0x1E, 0x07, 0x01,
  0xC0, 0x00, 0x0C, 0x07, 0x81, 0xE0, 0x70, 0x01, 0xF0, 0x03, 0xFF, 0x81,
  0xF1, 0xF0, 0xE0, 0x1E, 0x71, 0xF3, 0x9C, 0xFE, 0x6E, 0x71, 0x9F, 0x98,
  0xE7, 0xEE, 0x39, 0xFB, 0x8E, 0x7E, 0xE3, 0x9B, 0x9F, 0xFE, 0xE7, 0xFF,
  0x1C, 0x21, 0x07, 0x80, 0x40, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x0E, 0xF0,
  0x1E, 0x70, 0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x38, 0x3F, 0xFC, 0x3F, 0xFC,
  0x7F, 0xFC, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x1F, 0xFF, 0x0F, 0xFC, 0xFF,
  0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xFF, 0xEF, 0xF8, 0xFF, 0xCF, 0x1E, 0xF0,
  0xFF, 0x0F, 0xF1, 0xFF, 0xFE, 0xFF, 0xCF, 0xF8, 0x07, 0xE0, 0xFF, 0xCF,
  0xFC, 0xF8, 0x67, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0xC1, 0x1F, 0xF8, 0xFF, 0xC1, 0xFE, 0xFE, 0x07,
  0xFE, 0x3F, 0xF9, 0xE7, 0xEF, 0x0F, 0x78, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xEF, 0x1F, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C,
  0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07,
  0x83, 0xC1, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0xFC, 0x27, 0x80, 0x3C, 0x03, 0xC0, 0x1E,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x0E, 0xF0, 0x77, 0xC3, 0x9F, 0xFC, 0xFF,
  0xE1, 0xFF, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0xF9, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x8F, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1E,
  0xFE, 0xFC, 0xF0, 0xF0, 0x7F, 0x87, 0xBC, 0x79, 0xE7, 0x8F, 0x3C, 0x7B,
  0xC3, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x3D, 0xF1, 0xE7, 0x8F, 0x1E,
  0x78, 0xF3, 0xC3, 0xDE, 0x1F, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE1, 0xDF, 0xB8, 0xEF, 0xDC, 0x77, 0xEE, 0x33, 0xF3, 0xB9, 0xF9, 0xDC,
  0xFC, 0xEC, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F, 0x8F, 0x8F, 0xC7, 0x87, 0xF8,
  0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F, 0xBC, 0x7E, 0xF1, 0xF9,
  0xE7, 0xE7, 0x9F, 0x8F, 0x7E, 0x3D, 0xF8, 0x7F, 0xE1, 0xFF, 0x83, 0xFE,
  0x07, 0xF8, 0x1F, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xE3, 0xE7, 0x83,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7B,
  0xC0, 0xF7, 0xC3, 0xC7, 0xFF, 0x8F, 0xFE, 0x07, 0xF0, 0xFE, 0x1F, 0xF3,
  0xFF, 0x79, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0xBE, 0xFF, 0xDF, 0xF3, 0xF0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x07, 0xE0, 0x3F, 0xF0, 0xFF,
  0xF3, 0xE3, 0xE7, 0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7B, 0xC0, 0xF7, 0xC3, 0xC7, 0xFF, 0x8F, 0xFE, 0x07,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xFE, 0x07, 0xFE,
  0x3F, 0xF1, 0xE7, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0x9F, 0xF8, 0xFF, 0x87,
  0xFC, 0x3D, 0xE1, 0xE7, 0x8F, 0x3C, 0x78, 0xF3, 0xC3, 0xDE, 0x1F, 0x1F,
  0x8F, 0xFD, 0xFF, 0x78, 0x6F, 0x01, 0xE0, 0x1F, 0x03, 0xF8, 0x3F, 0x81,
  0xF8, 0x0F, 0x80, 0xFC, 0x1D, 0xFF, 0xBF, 0xE3, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xBF, 0xF9, 0xFF, 0x83, 0xF8, 0xF0,
  0x1F, 0xE0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0x87, 0x8F, 0x0F, 0x1E,
  0x1E, 0x38, 0x1C, 0xF0, 0x3D, 0xE0, 0x7B, 0x80, 0x77, 0x00, 0xFE, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xF7, 0x07,
  0x83, 0x9E, 0x3F, 0x1E, 0x78, 0xFC, 0x79, 0xE3, 0xF1, 0xE3, 0x8F, 0xC7,
  0x0E, 0x7B, 0x9C, 0x3D, 0xCE, 0xF0, 0xF7, 0x3B, 0xC1, 0xDC, 0xEE, 0x07,
  0x73, 0xB8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x80, 0xF8, 0x7C, 0x03, 0xE1,
  0xF0, 0xF8, 0x3E, 0xF0, 0x78, 0xF1, 0xE1, 0xE3, 0xC1, 0xEF, 0x01, 0xFE,
  0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0xF7, 0x83,
  0xC7, 0x87, 0x8F, 0x1E, 0x0F, 0x7C, 0x0F, 0xF0, 0x3D, 0xE1, 0xE7, 0x87,
  0x8F, 0x1C, 0x3C, 0xF0, 0x7B, 0x81, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF,
  0xEF, 0xFE, 0xFF, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C,
  0x07, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0xFF, 0xFE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3F, 0xFF, 0xF0, 0x06, 0x00, 0xE0,
  0x0F, 0x01, 0xF0, 0x1F, 0x83, 0x98, 0x39, 0xC3, 0x0C, 0x70, 0xE6, 0x06,
  0xE0, 0x70, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x3F, 0x8F, 0xF8,
  0xCF, 0x80, 0xF0, 0xFE, 0xFF, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0xFF, 0xFB,
  0xBE, 0x70, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xDF, 0x3F, 0xF7,
  0xFE, 0xF1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xE3, 0xFF, 0xF7, 0xFE,
  0xEF, 0x80, 0x1F, 0xDF, 0xF7, 0xFB, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x5F, 0xF7, 0xFC, 0x7E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x7D, 0xDF, 0xFB, 0xFF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1,
  0xDF, 0xFB, 0xFF, 0x3E, 0xE0, 0x1F, 0x8F, 0xF9, 0xE7, 0xF8, 0x7F, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x0F, 0xBC, 0xFF, 0x8F, 0xE0, 0x0F, 0xC7,
  0xE3, 0xF8, 0xF0, 0x3C, 0x1F, 0xEF, 0xFB, 0xFE, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x3E, 0xEF, 0xFD, 0xFF,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xEF, 0xFD, 0xFF, 0x9F,
  0x70, 0x0F, 0x03, 0xDF, 0xFB, 0xFE, 0x7F, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xDF, 0x3F, 0xF7, 0xFF, 0xF1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xE0, 0x7F, 0x72, 0x07, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x70, 0x1C, 0xF1, 0xC2, 0x00, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x73, 0xFF, 0xFF, 0xE0, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x1F, 0xE3, 0xCE, 0x7C, 0xE7, 0x8E,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x8E, 0x7C, 0xE3, 0xCE, 0x1E, 0xE1, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xEF, 0x9F, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC7, 0x8F, 0xE1, 0xE3, 0xF8, 0x78, 0xFE, 0x1E, 0x3F, 0x87,
  0x8F, 0xE1, 0xE3, 0xF8, 0x78, 0xFE, 0x1E, 0x3F, 0x87, 0x8F, 0xEF, 0xDF,
  0xFB, 0xFF, 0xF8, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0xF0, 0x1F, 0x87, 0xFC, 0x7F, 0xEF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xF7, 0xFE, 0x3F, 0xC1, 0xF8, 0xEF, 0x9F, 0xFB,
  0xFF, 0x78, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF1, 0xFF, 0xFB, 0xFF,
  0x77, 0xCE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x3E, 0xEF, 0xFD,
  0xFF, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xEF, 0xFD, 0xFF,
  0x9F, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0xCF, 0xFF, 0xFF,
  0xF8, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x7F, 0xFF, 0xFC,
  0xDE, 0x0F, 0xC3, 0xF8, 0xFE, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x38,
  0x38, 0x38, 0x7F, 0xFF, 0xFF, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x7F,
  0x3F, 0x3F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0x78, 0xF7, 0xFF, 0x7F, 0x73, 0xE7, 0xF0, 0x7B, 0x83, 0x9E,
  0x3C, 0xF1, 0xE3, 0x8E, 0x1E, 0xF0, 0x77, 0x03, 0xB8, 0x1F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0xF1, 0xEE, 0x3E, 0x3D, 0xE7, 0xC7, 0x3C,
  0xDC, 0xE3, 0x9B, 0xBC, 0x77, 0x77, 0x8E, 0xEE, 0xE1, 0xFC, 0xDC, 0x1F,
  0x1F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x87, 0x80, 0xF8, 0xFB, 0xC7,
  0x8F, 0x78, 0x3F, 0xC1, 0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xF8, 0x3D, 0xE1,
  0xEF, 0x9E, 0x3D, 0xF0, 0xF0, 0xF0, 0x7B, 0x83, 0x9E, 0x3C, 0xF1, 0xE3,
  0x8E, 0x1E, 0xF0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0xFF, 0xFF, 0xFF,
  0xE1, 0xE0, 0xE0, 0xF0, 0xF0, 0xF0, 0x70, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0x0F, 0x1F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFC, 0xF8, 0xF8, 0x3C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1E, 0x1F, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0xF0, 0xF8, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0x1F, 0x1F,
  0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF8, 0xF0, 0xC0, 0x70, 0x3F, 0xCF,
  0xFF, 0xC3, 0xE0,
};

const GFXglyph NotoSans_ExtraBold22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 9, 6, 11, 1, -16 },
  { 16, 14, 16, 14, 0, -16 },
  { 44, 11, 18, 13, 1, -17 },
  { 69, 19, 16, 20, 1, -16 },
  { 107, 16, 16, 17, 1, -16 },
  { 139, 4, 6, 6, 1, -16 },
  { 142, 6, 19, 8, 1, -16 },
  { 157, 6, 19, 8, 1, -16 },
  { 172, 10, 11, 12, 1, -17 },
  { 186, 11, 11, 13, 1, -13 },
  { 202, 4, 6, 7, 1, -3 },
  { 205, 5, 3, 7, 1, -7 },
  { 207, 4, 4, 6, 1, -4 },
  { 209, 9, 16, 9, 0, -16 },
  { 227, 11, 16, 13, 1, -16 },
  { 249, 9, 16, 13, 1, -16 },
  { 267, 11, 16, 13, 1, -16 },
  { 289, 11, 16, 13, 1, -16 },
  { 311, 12, 16, 13, 0, -16 },
  { 335, 11, 16, 13, 1, -16 },
  { 357, 11, 16, 13, 1, -16 },
  { 379, 11, 16, 13, 1, -16 },
  { 401, 11, 16, 13, 1, -16 },
  { 423, 11, 16, 13, 1, -16 },
  { 445, 4, 12, 6, 1, -12 },
  { 451, 4, 15, 6, 1, -12 },
  { 459, 11, 12, 13, 1, -14 },
  { 476, 11, 7, 13, 1, -11 },
  { 486, 11, 12, 13, 1, -14 },
  { 503, 10, 16, 11, 0, -16 },
  { 523, 18, 18, 20, 1, -16 },
  { 564, 16, 16, 16, 0, -16 },
  { 596, 12, 16, 15, 2, -16 },
  { 620, 13, 16, 14, 1, -16 },
  { 646, 13, 16, 16, 2, -16 },
  { 672, 9, 16, 12, 2, -16 },
  { 690, 9, 16, 12, 2, -16 },
  { 708, 13, 16, 16, 1, -16 },
  { 734, 13, 16, 17, 2, -16 },
  { 760, 7, 16, 9, 1, -16 },
  { 774, 8, 21, 8, -2, -16 },
  { 795, 13, 16, 15, 2, -16 },
  { 821, 10, 16, 13, 2, -16 },
  { 841, 17, 16, 21, 2, -16 },
  { 875, 14, 16, 18, 2, -16 },
  { 903, 15, 16, 17, 1, -16 },
  { 933, 11, 16, 14, 2, -16 },
  { 955, 15, 20, 17, 1, -16 },
  { 993, 13, 16, 15, 2, -16 },
  { 1019, 11, 16, 12, 1, -16 },
  { 1041, 12, 16, 13, 0, -16 },
  { 1065, 13, 16, 17, 2, -16 },
  { 1091, 15, 16, 15, 0, -16 },
  { 1121, 22, 16, 22, 0, -16 },
  { 1165, 15, 16, 15, 0, -16 },
  { 1195, 14, 16, 14, 0, -16 },
  { 1223, 12, 16, 13, 1, -16 },
  { 1247, 6, 20, 7, 1, -16 },
  { 1262, 9, 16, 9, 0, -16 },
  { 1280, 5, 20, 7, 1, -16 },
  { 1293, 12, 11, 12, 0, -16 },
  { 1310, 10, 2, 10, 0, 2 },
  { 1313, 7, 4, 9, 1, -17 },
  { 1317, 11, 12, 13, 1, -12 },
  { 1334, 11, 17, 14, 2, -17 },
  { 1358, 10, 12, 12, 1, -12 },
  { 1373, 11, 17, 14, 1, -17 },
  { 1397, 11, 12, 13, 1, -12 },
  { 1414, 10, 17, 9, 0, -17 },
  { 1436, 11, 17, 14, 1, -12 },
  { 1460, 11, 17, 15, 2, -17 },
  { 1484, 4, 17, 7, 1, -17 },
  { 1493, 6, 22, 7, -1, -17 },
  { 1510, 12, 17, 14, 2, -17 },
  { 1536, 3, 17, 7, 2, -17 },
  { 1543, 18, 12, 22, 2, -12 },
  { 1570, 11, 12, 15, 2, -12 },
  { 1587, 12, 12, 14, 1, -12 },
  { 1605, 11, 17, 14, 2, -12 },
  { 1629, 11, 17, 14, 1, -12 },
  { 1653, 8, 12, 10, 2, -12 },
  { 1665, 9, 12, 11, 1, -12 },
  { 1679, 8, 15, 10, 1, -15 },
  { 1694, 12, 12, 15, 1, -12 },
  { 1712, 13, 12, 13, 0, -12 },
  { 1732, 19, 12, 19, 0, -12 },
  { 1761, 13, 12, 13, 0, -12 },
  { 1781, 13, 17, 13, 0, -12 },
  { 1809, 9, 12, 11, 1, -12 },
  { 1823, 8, 20, 9, 0, -16 },
  { 1843, 2, 22, 12, 5, -17 },
  { 1849, 8, 20, 9, 1, -16 },
  { 1869, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_ExtraBold22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold22pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_EXTRABOLD22PT7B_H_
