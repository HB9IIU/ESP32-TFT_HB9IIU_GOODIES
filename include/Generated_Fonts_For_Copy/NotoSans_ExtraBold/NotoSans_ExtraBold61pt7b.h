#ifndef _NOTOSANS_EXTRABOLD61PT7B_H_
#define _NOTOSANS_EXTRABOLD61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold61pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7,
  0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xFC, 0x7F, 0xEF, 0xFE, 0xFF, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFE, 0x7F, 0xE3, 0xFC, 0x0E, 0x00, 0xFF, 0x87, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xDF,
  0xF0, 0x7F, 0xBF, 0xE0, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0x83, 0xFD, 0xFF,
  0x07, 0xFB, 0xFE, 0x0F, 0xF3, 0xF8, 0x1F, 0xE7, 0xF0, 0x3F, 0xCF, 0xE0,
  0x7F, 0x9F, 0xC0, 0xFF, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xFE,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFE,
  0x7C, 0x3F, 0x1F, 0xF8, 0xF8, 0x0E, 0x3F, 0xF1, 0xF0, 0x00, 0x7F, 0xE3,
  0xE0, 0x00, 0xFF, 0xC7, 0xC0, 0x01, 0xFF, 0xCF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xF3, 0xFF,
  0x80, 0x03, 0xE3, 0xFF, 0x00, 0x07, 0xC3, 0xFE, 0x80, 0x0F, 0x87, 0xFD,
  0xE0, 0x1F, 0x1F, 0xFB, 0xF8, 0x3E, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F,
  0x81, 0xFE, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F,
  0xC0, 0x3F, 0xC3, 0xFC, 0x3F, 0xC3, 0xFF, 0x81, 0xFE, 0x1F, 0xE1, 0xFE,
  0x3F, 0xFF, 0x07, 0xFD, 0xFF, 0x1F, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xF1, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0xFF, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0x87, 0xF8, 0xFF, 0x0F, 0xF0,
  0x7F, 0xF8, 0x7F, 0x87, 0xF8, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x3F, 0xC3,
  0xFC, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE3,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xEF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF,
  0x81, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x1F, 0xFE, 0x7F, 0xF8,
  0xFF, 0xE0, 0xFF, 0xE1, 0xFF, 0xE7, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x08, 0x03, 0xF8, 0x01, 0x78, 0x1F, 0xC0, 0xF7, 0xF8, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xDF, 0xE0, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFF,
  0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFC, 0x00, 0xF8, 0x0F,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x02, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF1,
  0xFF, 0x3F, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0xFC, 0x7F, 0xC7,
  0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0x8F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xF8, 0x38, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0xFF, 0xC0,
  0x7F, 0xF3, 0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x00, 0xFF, 0xCF, 0xFC, 0x01,
  0xFF, 0x9F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xF7, 0xFE, 0x00, 0xFF, 0xEF,
  0xFC, 0x01, 0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x3F, 0xF0, 0x07, 0xFE, 0x7F,
  0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xF8, 0xFF, 0xC0, 0x7F, 0xE1, 0xFF,
  0xC1, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x7F, 0xE7, 0xFF, 0x3F, 0xC7, 0xFF, 0x1F,
  0x87, 0xFF, 0x0F, 0x07, 0xFF, 0x0E, 0x07, 0xFF, 0x04, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xC0, 0x7F, 0xF8, 0x7E, 0x00, 0x7F, 0xF0, 0x78, 0x00, 0x7F,
  0xE0, 0x40, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xE0, 0xFF, 0xF8, 0x1E, 0x00, 0x7F, 0xF8, 0x30, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xF7, 0xC0, 0x03, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFE,
  0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0x3F, 0xF0, 0x00, 0xFF,
  0x9F, 0xF8, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x7F, 0x87, 0xFE, 0x00, 0x7F,
  0xC3, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xC0, 0x3F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xF0, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x0E, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x08, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x38, 0x00,
  0x7F, 0xC3, 0xFF, 0x80, 0xFF, 0x9F, 0xFF, 0x81, 0xFF, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xBF, 0xF0,
  0x03, 0xFF, 0x7F, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0,
  0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x1A, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0x7F, 0xFE, 0x3F, 0xF0, 0x1F, 0xFC, 0xFF, 0xE0, 0x1F, 0xF9, 0xFF,
  0x80, 0x3F, 0xF3, 0xFF, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0xFF, 0xC7, 0xFE,
  0x01, 0xFF, 0x0F, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0xFC, 0x1F, 0xFE,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0x81, 0xFF, 0xE7, 0xFE, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xF7, 0xFF, 0x81, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC,
  0x7F, 0xF8, 0xFF, 0xE0, 0x3F, 0xF3, 0xFF, 0x80, 0x7F, 0xF7, 0xFE, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0x03, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFB, 0xFE, 0x3F, 0xFF, 0xE7, 0xFC, 0x3F, 0xFF, 0xDF, 0xF8,
  0x1F, 0xFE, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x0F,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xF8,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xF8, 0x38, 0x00, 0x0F,
  0xC1, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xFD, 0xFF, 0xCF, 0xFE,
  0x3F, 0xF0, 0xFF, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x3F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F,
  0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFE, 0x1F, 0xE0, 0x7F, 0xF0, 0xF0, 0x01, 0xFF, 0xC2, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0xFF, 0x0F, 0xE1,
  0xFE, 0x03, 0xFF, 0xFF, 0xC7, 0xF8, 0xFF, 0x03, 0xFF, 0xFF, 0xE1, 0xFC,
  0x7F, 0x03, 0xFF, 0xFF, 0xF0, 0xFE, 0x7F, 0x83, 0xFF, 0xFF, 0xF8, 0x7F,
  0xBF, 0x81, 0xFF, 0x83, 0xFC, 0x1F, 0xDF, 0xC1, 0xFF, 0x01, 0xFC, 0x0F,
  0xFF, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0x03,
  0xFF, 0xF0, 0x7F, 0x80, 0x3F, 0x81, 0xFF, 0xF8, 0x3F, 0xC0, 0x1F, 0xC0,
  0xFF, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0,
  0x3F, 0xFF, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xFF, 0x83, 0xF8, 0x03, 0xFC,
  0x1F, 0xFF, 0xC1, 0xFC, 0x01, 0xFE, 0x0F, 0xEF, 0xE0, 0xFF, 0x00, 0xFF,
  0x07, 0xF7, 0xF0, 0x7F, 0x80, 0xFF, 0x87, 0xFB, 0xF8, 0x3F, 0xE0, 0xFF,
  0xE3, 0xF9, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0x81, 0xFF, 0xFE, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0xFE,
  0x3F, 0xFC, 0x0F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x01, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE1, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00,
  0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xDF,
  0xF8, 0x00, 0xFF, 0xEF, 0xFC, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x3F, 0xFB,
  0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFE,
  0x7F, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE0, 0x1F,
  0xFF, 0x3F, 0xF0, 0x03, 0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xEF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFB, 0xFF, 0x07, 0xFF, 0xE0, 0x07, 0xC1, 0xFF,
  0xE0, 0x00, 0x20, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x21, 0xFF, 0xF0, 0x00, 0x38, 0x7F, 0xFF, 0x00,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFC, 0x01, 0xFF,
  0xFC, 0xFF, 0xC0, 0x07, 0xFF, 0xCF, 0xFC, 0x00, 0x3F, 0xFE, 0xFF, 0xC0,
  0x01, 0xFF, 0xEF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xC0, 0x00, 0xFF, 0xEF,
  0xFC, 0x00, 0x1F, 0xFE, 0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFC, 0x00, 0x7F,
  0xFC, 0xFF, 0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0xFE, 0x00,
  0x1E, 0x07, 0xFF, 0xC0, 0x00, 0x10, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFE, 0xFF, 0xE0, 0x00, 0x3F,
  0xF7, 0xFF, 0x00, 0x01, 0xFF, 0xBF, 0xF8, 0x00, 0x0F, 0xFD, 0xFF, 0xE0,
  0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xFC, 0x00, 0x1F, 0xF9,
  0xFF, 0xF0, 0x00, 0xFF, 0xC7, 0xFF, 0xC0, 0x07, 0xFE, 0x3F, 0xFF, 0x80,
  0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0xC1, 0xFF,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xEF,
  0xFE, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x7F,
  0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xE0,
  0x1F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC,
  0x00, 0xFF, 0xE3, 0xFF, 0xC0, 0x0F, 0xFE, 0x7F, 0xF8, 0x00, 0xFF, 0xE7,
  0xFF, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0x9F, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0xFF, 0xE0, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x3F, 0xF8, 0xFF, 0xE0,
  0x03, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xEF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFD, 0xFF, 0xFF, 0xBF, 0xC0, 0x03,
  0xFD, 0xFF, 0xFF, 0xBF, 0xC0, 0x03, 0xFD, 0xFF, 0xFF, 0xBF, 0xE0, 0x07,
  0xF9, 0xFF, 0xFF, 0x9F, 0xE0, 0x07, 0xF9, 0xFF, 0xFF, 0x9F, 0xE0, 0x07,
  0xF9, 0xFF, 0xFF, 0x9F, 0xF0, 0x0F, 0xF1, 0xFF, 0xFF, 0x8F, 0xF0, 0x0F,
  0xF1, 0xFF, 0xFF, 0x8F, 0xF0, 0x0F, 0xF3, 0xFF, 0xFF, 0x8F, 0xF8, 0x0F,
  0xE3, 0xFF, 0xFF, 0x8F, 0xF8, 0x1F, 0xE3, 0xFF, 0xFF, 0x87, 0xF8, 0x1F,
  0xE3, 0xFF, 0xFF, 0x87, 0xF8, 0x1F, 0xE3, 0xFF, 0xFF, 0x87, 0xFC, 0x3F,
  0xC3, 0xFF, 0xFF, 0x83, 0xFC, 0x3F, 0xC3, 0xFF, 0xFF, 0x83, 0xFC, 0x3F,
  0xC3, 0xFF, 0xFF, 0x83, 0xFE, 0x7F, 0x83, 0xFF, 0xFF, 0x83, 0xFE, 0x7F,
  0x83, 0xFF, 0xFF, 0x81, 0xFE, 0x7F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xBF, 0xF8, 0x01, 0xFF,
  0xFF, 0xBF, 0xF8, 0x01, 0xFF, 0xFF, 0x9F, 0xFC, 0x01, 0xFF, 0xFF, 0x8F,
  0xFC, 0x01, 0xFF, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xFF, 0x87, 0xFF, 0x01,
  0xFF, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xFF,
  0x83, 0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0xFF, 0xE1, 0xFF,
  0xFF, 0x80, 0x7F, 0xF1, 0xFF, 0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xFF, 0x80,
  0x3F, 0xF9, 0xFF, 0xFF, 0x80, 0x1F, 0xFD, 0xFF, 0xFF, 0x80, 0x1F, 0xFD,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xC3, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00, 0x3F,
  0xF9, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x8F,
  0xFF, 0x80, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0x00, 0x7F, 0xF7, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFB, 0xFF, 0x00, 0x7F, 0xF7, 0xFE, 0x01, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x83, 0xFF,
  0x80, 0x00, 0x7F, 0xF8, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x3F, 0xFB, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0x00, 0x1F, 0xFD, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x00, 0x7F, 0xF7, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x00,
  0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE7, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x87, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFD, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x0F,
  0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xF0,
  0xFF, 0xC0, 0x07, 0xFF, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xC0, 0x03,
  0xFF, 0xCF, 0xFC, 0x00, 0x1F, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0xEF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xE7,
  0xFF, 0x00, 0x1E, 0x3F, 0xF8, 0x00, 0x31, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xD0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x0F, 0xFF, 0x7F, 0xF8,
  0x01, 0xFF, 0xE7, 0xFF, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xDF, 0xFC,
  0x00, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x00,
  0x7F, 0xF1, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00,
  0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0x83, 0xFF, 0x00, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x7F, 0xE1, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xDF, 0xF8, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x00, 0x1F, 0xF7, 0xFC,
  0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x9F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFC, 0x07, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xF7, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xEF,
  0xF8, 0x0F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x3F, 0xC0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0x8F, 0xF0,
  0x3F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x00, 0x0F, 0xFC,
  0x3F, 0xE3, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF,
  0xC0, 0x03, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xFE, 0x00, 0x0F, 0xF8, 0xFF,
  0x83, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x00,
  0x03, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xF8, 0x00, 0x1F, 0xF9, 0xFE, 0x03,
  0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xCF, 0xF0, 0x1F, 0xE7, 0xFC, 0x00, 0x03,
  0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF7, 0xF8, 0x03, 0xFD,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x87, 0xFF,
  0x00, 0x00, 0x7F, 0xF3, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0xFF,
  0xE1, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC7, 0xFF, 0x80, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x3F, 0xFD, 0xFF,
  0xC0, 0x00, 0x7F, 0xF1, 0xFF, 0xC0, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x03,
  0xFF, 0x83, 0xFF, 0x80, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01,
  0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00,
  0x3F, 0xF8, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xF1,
  0xFF, 0xC0, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFE,
  0x00, 0x01, 0xFC, 0xFF, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x1F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03,
  0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x1F, 0xFE, 0x03, 0xC0,
  0x0F, 0xFE, 0x02, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0, 0x3F, 0xF7, 0xFF, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xE1, 0xFE, 0x0F,
  0xFF, 0x01, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0x00, 0xFF,
  0xE3, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF,
  0xDF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF,
  0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF,
  0xF8, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0x87, 0xFF,
  0x80, 0x18, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x47, 0xFF, 0xC0, 0x3C, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0x05, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0x07, 0xFF, 0x03, 0xFF,
  0xC7, 0xFF, 0x07, 0xFF, 0xF7, 0xFF, 0x0F, 0xFF, 0xFB, 0xFF, 0x1F, 0xFF,
  0xFB, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFC, 0x3F, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF8,
  0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFB, 0xFF, 0x0F, 0xFF,
  0xF3, 0xFF, 0x07, 0xFF, 0xE1, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFE, 0x0F, 0xFE, 0x7F, 0xF0, 0x0F,
  0xFC, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x30, 0xFF, 0xF8, 0x03, 0xE1, 0xFF,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0B, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0x86, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC1, 0xFF, 0x07,
  0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFC, 0x1F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF, 0x07,
  0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x18, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x60,
  0x00, 0x0F, 0xFE, 0x7C, 0x00, 0x1F, 0xFE, 0x7F, 0xFB, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0xFF,
  0xC3, 0xFF, 0xE0, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xDF, 0xFF, 0xF8, 0xFF,
  0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x1F,
  0x0F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xC1,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x03, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x05, 0xFF, 0xC0, 0x07,
  0xFF, 0x3F, 0xF8, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xF8, 0xFF, 0xE0,
  0x1F, 0xFE, 0x1F, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0xE0, 0x7F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x80,
  0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFF, 0x3F, 0xFC, 0x00, 0xFF, 0xCF, 0xFF,
  0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xBF, 0xF8, 0x03, 0xFF, 0xE7, 0xFF, 0x80, 0x7F, 0xF8, 0x7F,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0xFE, 0x1F,
  0xFC, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF0, 0x03, 0xFF,
  0xCF, 0xFE, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xF9, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0x03, 0xFF, 0xE0, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF,
  0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xFE,
  0x3F, 0xF8, 0x07, 0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0xFF,
  0xEF, 0xFE, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xF7, 0xFF, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0,
  0x0F, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x0F, 0xFF,
  0x0F, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xCF, 0xFF, 0xF0, 0xFF, 0xDF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x3F, 0xFE,
  0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE,
  0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0xF8, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xDF, 0xFF, 0xE0, 0xFF, 0xC7, 0xFF, 0xC0,
  0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xE0, 0x38, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xC1, 0xFF,
  0x07, 0xFF, 0xF3, 0xFF, 0x0F, 0xFF, 0xFB, 0xFF, 0x1F, 0xFF, 0xFB, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFC, 0x1F, 0xFF, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0x7F, 0xF8, 0x0F, 0xFF,
  0x7F, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFB, 0xFF, 0x0F, 0xFF, 0xF7, 0xFF,
  0x07, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0x00, 0x18, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0x81, 0xF8,
  0xFF, 0xC0, 0x0E, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xE0,
  0x3F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0x01, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0xFF,
  0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80,
  0x1F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0,
  0x7F, 0xE0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03,
  0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFB,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xE7,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFE, 0x7F, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xE7, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xFF, 0x80,
  0xFF, 0xC3, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x3F, 0xBF,
  0xC0, 0xFF, 0xC3, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F,
  0x9F, 0xC1, 0xFF, 0x81, 0xFF, 0x87, 0xF9, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x7F, 0x9F, 0xE1, 0xFF, 0x00, 0xFF, 0x87, 0xF1, 0xFE, 0x1F, 0xF0, 0x0F,
  0xF8, 0x7F, 0x1F, 0xE3, 0xFF, 0x00, 0xFF, 0xCF, 0xF0, 0xFE, 0x3F, 0xF0,
  0x0F, 0xFC, 0xFF, 0x0F, 0xE3, 0xFE, 0x00, 0x7F, 0xCF, 0xF0, 0xFF, 0x3F,
  0xE0, 0x07, 0xFC, 0xFE, 0x0F, 0xF3, 0xFE, 0x00, 0x7F, 0xCF, 0xE0, 0xFF,
  0x7F, 0xC0, 0x03, 0xFD, 0xFE, 0x07, 0xF7, 0xFC, 0x00, 0x3F, 0xFF, 0xE0,
  0x7F, 0x7F, 0xC0, 0x03, 0xFF, 0xFC, 0x07, 0xF7, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0xFE,
  0x1F, 0xFC, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07,
  0xFF, 0x80, 0x7F, 0xF0, 0x7F, 0xF0, 0x07, 0xFF, 0x8F, 0xFE, 0x00, 0x3F,
  0xF8, 0xFF, 0xE0, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xDF, 0xFC, 0x00, 0x3F,
  0xFD, 0xFF, 0xC0, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x7F, 0xF0, 0xFF, 0xF0,
  0x07, 0xFF, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xE7, 0xFF,
  0x80, 0x0F, 0xFE, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x7F,
  0xF7, 0xFE, 0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0x00,
  0x0F, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x1F, 0xFC, 0x1F,
  0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x03,
  0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x04, 0xFF, 0xF8, 0x00, 0x37, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFA, 0x00, 0x07, 0xFF, 0x88, 0x00, 0x03, 0xF8, 0x00,
};

const GFXglyph NotoSans_ExtraBold61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 12, 45, 17, 3, -44 },
  { 69, 23, 16, 31, 4, -44 },
  { 115, 38, 44, 40, 1, -44 },
  { 324, 31, 50, 35, 2, -46 },
  { 518, 53, 44, 56, 2, -44 },
  { 810, 45, 45, 47, 2, -44 },
  { 1064, 9, 16, 17, 4, -44 },
  { 1082, 18, 54, 21, 2, -44 },
  { 1204, 17, 54, 21, 2, -44 },
  { 1319, 29, 29, 33, 2, -46 },
  { 1425, 30, 29, 35, 3, -36 },
  { 1534, 12, 16, 18, 2, -8 },
  { 1558, 16, 9, 19, 2, -21 },
  { 1576, 11, 11, 17, 3, -10 },
  { 1592, 26, 44, 26, 0, -44 },
  { 1735, 31, 45, 35, 2, -44 },
  { 1910, 24, 44, 35, 3, -44 },
  { 2042, 31, 44, 35, 2, -44 },
  { 2213, 31, 45, 35, 2, -44 },
  { 2388, 33, 44, 35, 1, -44 },
  { 2570, 29, 45, 35, 3, -44 },
  { 2734, 31, 45, 35, 2, -44 },
  { 2909, 31, 44, 35, 2, -44 },
  { 3080, 31, 45, 35, 2, -44 },
  { 3255, 31, 45, 35, 2, -44 },
  { 3430, 11, 35, 17, 3, -34 },
  { 3479, 13, 42, 18, 2, -34 },
  { 3548, 30, 32, 35, 3, -38 },
  { 3668, 30, 19, 35, 3, -31 },
  { 3740, 30, 32, 35, 3, -38 },
  { 3860, 29, 45, 30, 0, -44 },
  { 4024, 49, 49, 55, 3, -44 },
  { 4325, 43, 44, 43, 0, -44 },
  { 4562, 33, 44, 41, 5, -44 },
  { 4744, 34, 45, 39, 3, -44 },
  { 4936, 36, 44, 45, 5, -44 },
  { 5134, 26, 44, 34, 5, -44 },
  { 5277, 25, 44, 33, 5, -44 },
  { 5415, 37, 45, 45, 3, -44 },
  { 5624, 37, 44, 47, 5, -44 },
  { 5828, 21, 44, 25, 2, -44 },
  { 5944, 21, 57, 21, -5, -44 },
  { 6094, 36, 44, 41, 5, -44 },
  { 6292, 28, 44, 35, 5, -44 },
  { 6446, 48, 44, 58, 5, -44 },
  { 6710, 40, 44, 50, 5, -44 },
  { 6930, 42, 45, 48, 3, -44 },
  { 7167, 31, 44, 38, 5, -44 },
  { 7338, 43, 54, 48, 3, -44 },
  { 7629, 36, 44, 41, 5, -44 },
  { 7827, 29, 45, 34, 3, -44 },
  { 7991, 33, 44, 36, 1, -44 },
  { 8173, 36, 45, 46, 5, -44 },
  { 8376, 41, 44, 41, 0, -44 },
  { 8602, 61, 44, 61, 0, -44 },
  { 8938, 42, 44, 42, 0, -44 },
  { 9169, 39, 44, 39, 0, -44 },
  { 9384, 33, 44, 36, 2, -44 },
  { 9566, 15, 54, 20, 4, -44 },
  { 9668, 26, 44, 26, 0, -44 },
  { 9811, 15, 54, 20, 1, -44 },
  { 9913, 32, 29, 34, 1, -44 },
  { 10029, 28, 5, 28, 0, 5 },
  { 10047, 19, 10, 24, 2, -47 },
  { 10071, 31, 35, 37, 2, -34 },
  { 10207, 32, 47, 39, 4, -46 },
  { 10395, 28, 35, 32, 3, -34 },
  { 10518, 32, 47, 39, 3, -46 },
  { 10706, 31, 35, 37, 3, -34 },
  { 10842, 26, 47, 24, 1, -47 },
  { 10995, 32, 49, 39, 3, -34 },
  { 11191, 32, 46, 40, 4, -46 },
  { 11375, 11, 47, 19, 4, -47 },
  { 11440, 18, 62, 19, -3, -47 },
  { 11580, 35, 46, 39, 4, -46 },
  { 11782, 11, 46, 19, 4, -46 },
  { 11846, 52, 34, 60, 4, -34 },
  { 12067, 32, 34, 40, 4, -34 },
  { 12203, 33, 35, 38, 3, -34 },
  { 12348, 32, 49, 39, 4, -34 },
  { 12544, 32, 49, 39, 3, -34 },
  { 12740, 23, 34, 28, 4, -34 },
  { 12838, 26, 35, 31, 3, -34 },
  { 12952, 24, 41, 27, 1, -40 },
  { 13075, 32, 34, 40, 4, -33 },
  { 13211, 36, 33, 36, 0, -33 },
  { 13360, 52, 33, 54, 1, -33 },
  { 13575, 36, 33, 37, 0, -33 },
  { 13724, 36, 48, 36, 0, -33 },
  { 13940, 27, 33, 30, 2, -33 },
  { 14052, 22, 54, 25, 1, -44 },
  { 14201, 7, 60, 32, 13, -46 },
  { 14254, 22, 54, 25, 2, -44 },
  { 14403, 30, 11, 35, 3, -27 },
};

const GFXfont NotoSans_ExtraBold61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold61pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_EXTRABOLD61PT7B_H_
