#ifndef _NOTOSANS_EXTRABOLD8PT7B_H_
#define _NOTOSANS_EXTRABOLD8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF5, 0x30, 0xF6, 0x31, 0xBF, 0xF5, 0x30, 0x2F, 0xE3, 0xB7, 0x45,
  0x52, 0xB2, 0xF2, 0xA4, 0xC0, 0x71, 0x47, 0x1F, 0xD9, 0xF0, 0xD0, 0x6B,
  0x4C, 0x98, 0xD5, 0x5C, 0x2F, 0x67, 0x22, 0xF2, 0x60, 0xC0, 0xC0, 0x25,
  0xA5, 0x00, 0x6D, 0xDD, 0xD7, 0x3D, 0x92, 0x40, 0x7D, 0x12, 0x4F, 0xF5,
  0x37, 0x1F, 0x31, 0x95, 0xEF, 0x98, 0x74, 0x6F, 0x1F, 0x34, 0xFD, 0xD7,
  0xF1, 0x32, 0x24, 0x7D, 0x77, 0xD7, 0x6D, 0xD7, 0x16, 0xC3, 0xC1, 0x80,
  0x16, 0xE1, 0xFF, 0x86, 0x3C, 0xEB, 0x24, 0x04, 0x38, 0x89, 0xED, 0x5B,
  0xC8, 0x8E, 0x00, 0x30, 0xC7, 0x16, 0x7B, 0x30, 0xEB, 0xBF, 0x9E, 0x3B,
  0x71, 0x84, 0x3C, 0xEB, 0x99, 0x9E, 0xF3, 0xF9, 0xC0, 0xF2, 0x79, 0x00,
  0x3B, 0x71, 0xB4, 0xBC, 0x99, 0xFF, 0x99, 0xE9, 0x25, 0xC0, 0x24, 0x92,
  0x5E, 0x9A, 0xEE, 0xB9, 0x92, 0x49, 0xC0, 0xCF, 0x3D, 0x75, 0xB6, 0xD0,
  0xCE, 0x7B, 0x5B, 0xCC, 0x39, 0x3C, 0xF3, 0x4D, 0xE0, 0xEB, 0xBE, 0x88,
  0x39, 0x3C, 0xF3, 0x4D, 0xE0, 0xC0, 0xEB, 0xBE, 0xA9, 0x7D, 0x63, 0x9F,
  0xF9, 0x08, 0x42, 0x10, 0x99, 0x99, 0x9F, 0xCE, 0x56, 0xA7, 0x18, 0x99,
  0xDB, 0x5A, 0x5A, 0x66, 0x66, 0xC9, 0x63, 0x0C, 0x5B, 0x30, 0xCA, 0x9C,
  0x42, 0x10, 0xF0, 0x8C, 0xC4, 0x7C, 0xFE, 0x99, 0x22, 0x40, 0xD5, 0x5C,
  0x26, 0x59, 0xF0, 0xE0, 0x77, 0xDF, 0x88, 0xFB, 0xBE, 0x7C, 0xC7, 0x18,
  0xDF, 0xBD, 0xBC, 0x77, 0xF0, 0xE0, 0x6B, 0xA4, 0x80, 0x7E, 0xF6, 0xF1,
  0x38, 0x88, 0xFB, 0xBB, 0xBC, 0x45, 0x57, 0x89, 0xAC, 0xAB, 0xFC, 0xFE,
  0xDB, 0x6D, 0xFB, 0xBB, 0x76, 0xF6, 0xE0, 0xFB, 0xBE, 0x88, 0x7E, 0xF6,
  0xF1, 0x8C, 0xF2, 0x40, 0xF6, 0x3E, 0x5D, 0x26, 0xBB, 0xBD, 0xDA, 0x9C,
  0xC0, 0xD6, 0xD9, 0xB3, 0x60, 0xDB, 0x1D, 0xB0, 0xDA, 0x9C, 0x46, 0x60,
  0xF2, 0x4F, 0x29, 0x64, 0x98, 0xFF, 0xC9, 0x34, 0xB0, 0x5B,
};

const GFXglyph NotoSans_ExtraBold8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 4, 2, 4, 0, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 6, 5, 0, -6 },
  { 11, 7, 6, 7, 0, -6 },
  { 17, 6, 6, 6, 0, -6 },
  { 22, 2, 2, 2, 0, -6 },
  { 23, 3, 7, 3, 0, -6 },
  { 26, 2, 7, 3, 0, -6 },
  { 28, 4, 4, 4, 0, -6 },
  { 30, 4, 4, 5, 0, -5 },
  { 32, 2, 2, 2, 0, -1 },
  { 33, 2, 1, 3, 0, -3 },
  { 34, 2, 1, 2, 0, -1 },
  { 35, 3, 6, 3, 0, -6 },
  { 38, 4, 6, 5, 0, -6 },
  { 41, 3, 6, 5, 0, -6 },
  { 44, 4, 6, 5, 0, -6 },
  { 47, 4, 6, 5, 0, -6 },
  { 50, 5, 6, 5, 0, -6 },
  { 54, 4, 6, 5, 0, -6 },
  { 57, 4, 6, 5, 0, -6 },
  { 60, 4, 6, 5, 0, -6 },
  { 63, 4, 6, 5, 0, -6 },
  { 66, 4, 6, 5, 0, -6 },
  { 69, 2, 4, 2, 0, -4 },
  { 70, 2, 5, 2, 0, -4 },
  { 72, 4, 4, 5, 0, -5 },
  { 74, 4, 2, 5, 0, -4 },
  { 75, 4, 4, 5, 0, -5 },
  { 77, 4, 6, 4, 0, -6 },
  { 80, 7, 7, 7, 0, -6 },
  { 87, 6, 6, 6, 0, -6 },
  { 92, 4, 6, 5, 1, -6 },
  { 95, 5, 6, 5, 0, -6 },
  { 99, 4, 6, 6, 1, -6 },
  { 102, 3, 6, 4, 1, -6 },
  { 105, 3, 6, 4, 1, -6 },
  { 108, 5, 6, 6, 0, -6 },
  { 112, 4, 6, 6, 1, -6 },
  { 115, 3, 6, 3, 0, -6 },
  { 118, 3, 8, 3, -1, -6 },
  { 121, 4, 6, 5, 1, -6 },
  { 124, 3, 6, 5, 1, -6 },
  { 127, 6, 6, 8, 1, -6 },
  { 132, 5, 6, 7, 1, -6 },
  { 136, 6, 6, 6, 0, -6 },
  { 141, 4, 6, 5, 1, -6 },
  { 144, 6, 7, 6, 0, -6 },
  { 150, 4, 6, 5, 1, -6 },
  { 153, 4, 6, 5, 0, -6 },
  { 156, 5, 6, 5, 0, -6 },
  { 160, 4, 6, 6, 1, -6 },
  { 163, 5, 6, 5, 0, -6 },
  { 167, 8, 6, 8, 0, -6 },
  { 173, 6, 6, 6, 0, -6 },
  { 178, 5, 6, 5, 0, -6 },
  { 182, 5, 6, 5, 0, -6 },
  { 186, 1, 7, 3, 1, -6 },
  { 187, 3, 6, 3, 0, -6 },
  { 190, 2, 7, 3, 0, -6 },
  { 192, 4, 4, 4, 0, -6 },
  { 194, 4, 1, 4, 0, 0 },
  { 195, 3, 1, 3, 0, -6 },
  { 196, 4, 4, 5, 0, -4 },
  { 198, 4, 6, 5, 1, -6 },
  { 201, 4, 4, 4, 0, -4 },
  { 203, 5, 6, 5, 0, -6 },
  { 207, 5, 4, 5, 0, -4 },
  { 210, 3, 6, 3, 0, -6 },
  { 213, 5, 6, 5, 0, -4 },
  { 217, 4, 6, 5, 1, -6 },
  { 220, 1, 6, 2, 1, -6 },
  { 221, 2, 8, 2, 0, -6 },
  { 223, 4, 6, 5, 1, -6 },
  { 226, 1, 6, 2, 1, -6 },
  { 227, 6, 4, 8, 1, -4 },
  { 230, 4, 4, 5, 1, -4 },
  { 232, 5, 4, 5, 0, -4 },
  { 235, 4, 6, 5, 1, -4 },
  { 238, 5, 6, 5, 0, -4 },
  { 242, 3, 4, 4, 1, -4 },
  { 244, 4, 4, 4, 0, -4 },
  { 246, 3, 5, 4, 0, -5 },
  { 248, 4, 4, 5, 1, -4 },
  { 250, 5, 4, 5, 0, -4 },
  { 253, 7, 4, 7, 0, -4 },
  { 257, 5, 4, 5, 0, -4 },
  { 260, 5, 6, 5, 0, -4 },
  { 264, 4, 4, 4, 0, -4 },
  { 266, 3, 7, 3, 0, -6 },
  { 269, 1, 8, 4, 2, -6 },
  { 270, 3, 7, 3, 0, -6 },
  { 273, 4, 2, 5, 0, -4 },
};

const GFXfont NotoSans_ExtraBold8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold8pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_EXTRABOLD8PT7B_H_
