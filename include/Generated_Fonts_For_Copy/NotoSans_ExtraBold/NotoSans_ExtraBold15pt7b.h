#ifndef _NOTOSANS_EXTRABOLD15PT7B_H_
#define _NOTOSANS_EXTRABOLD15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0x6D, 0xB0, 0x1F, 0x00, 0xDF, 0x6D, 0xB6, 0x19, 0x06, 0xC1,
  0xB1, 0xFF, 0x7F, 0xCC, 0x8F, 0xFB, 0xFE, 0x36, 0x09, 0x86, 0x40, 0x11,
  0xFF, 0xFE, 0x8F, 0x0F, 0x87, 0x8B, 0xDF, 0xF8, 0xC0, 0x80, 0x30, 0x63,
  0xC6, 0x33, 0x31, 0x9B, 0x0C, 0xDB, 0x3D, 0xBC, 0xDB, 0x60, 0xDB, 0x0C,
  0xD8, 0x67, 0xC6, 0x1E, 0x3C, 0x0F, 0xC1, 0x98, 0x37, 0x07, 0xC0, 0xF3,
  0xBF, 0x76, 0x7C, 0xC7, 0x9F, 0xF1, 0xF7, 0x80, 0xFF, 0x76, 0xEC, 0xCC,
  0xCC, 0xCC, 0xC6, 0x70, 0xE3, 0x0C, 0x63, 0x1C, 0xE7, 0x39, 0x8C, 0x6E,
  0x00, 0x18, 0x99, 0x7F, 0xFE, 0x3C, 0x76, 0x24, 0x30, 0x60, 0xC7, 0xFF,
  0xE6, 0x0C, 0x00, 0x76, 0x6C, 0xFF, 0xF8, 0x0C, 0x31, 0xC6, 0x18, 0xC3,
  0x1C, 0x61, 0x8E, 0x00, 0x39, 0xFB, 0xBE, 0x7C, 0x78, 0xF1, 0xE7, 0xCF,
  0xF9, 0xF0, 0x1C, 0xF7, 0xFF, 0x5C, 0x71, 0xC7, 0x1C, 0x71, 0xC0, 0x3C,
  0xFE, 0x67, 0x07, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0x7F, 0x7F, 0x79, 0xFB,
  0x38, 0x71, 0xCF, 0x07, 0x87, 0x8F, 0xFF, 0xF0, 0x06, 0x0E, 0x1E, 0x1E,
  0x36, 0x66, 0x66, 0xFF, 0xFF, 0x06, 0x06, 0xFD, 0xFB, 0x86, 0x0F, 0x9F,
  0x83, 0x87, 0x8F, 0xFB, 0xE0, 0x1C, 0xFB, 0x86, 0x0F, 0xDF, 0xF1, 0xE3,
  0xC7, 0xFD, 0xF0, 0xFF, 0xFF, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x18,
  0x38, 0x30, 0x79, 0xFF, 0x3E, 0x7F, 0xCF, 0x3F, 0xE3, 0xC7, 0xFD, 0xF0,
  0x3C, 0x7E, 0x67, 0xE3, 0x63, 0x7F, 0x7B, 0x03, 0x06, 0x7E, 0x7C, 0xF8,
  0x00, 0x3E, 0x76, 0x00, 0x00, 0x76, 0x6C, 0x06, 0x3D, 0xE7, 0x0F, 0x07,
  0xC1, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0xC1, 0xE0, 0xF0, 0x73, 0xFE,
  0x30, 0x40, 0x7D, 0xFD, 0x38, 0x30, 0xE7, 0x0C, 0x00, 0x00, 0x70, 0xE0,
  0x0F, 0x03, 0xFC, 0x60, 0x6C, 0xFA, 0xDD, 0xBD, 0x9B, 0x91, 0xBD, 0xBA,
  0xDF, 0xEC, 0x00, 0x71, 0x83, 0xF8, 0x0E, 0x03, 0xC0, 0x7C, 0x0D, 0x83,
  0xB0, 0x67, 0x0C, 0x63, 0xFC, 0x7F, 0xCC, 0x3B, 0x83, 0x80, 0xFC, 0xFF,
  0xE7, 0xE7, 0xFF, 0xFE, 0xE7, 0xE3, 0xE7, 0xFF, 0xFE, 0x1E, 0x7F, 0x73,
  0xE0, 0xE0, 0xC0, 0xC0, 0xE0, 0xE1, 0x7F, 0x3F, 0xFC, 0x7F, 0xB9, 0xFC,
  0x7E, 0x3F, 0x0F, 0x8F, 0xC7, 0xE7, 0xFF, 0xBF, 0x00, 0xFF, 0xFF, 0x87,
  0x0F, 0xDF, 0xB8, 0x70, 0xE1, 0xFF, 0xF8, 0xFF, 0xFE, 0x38, 0xE3, 0xFF,
  0xF8, 0xE3, 0x8E, 0x00, 0x1F, 0x3F, 0xDC, 0x5C, 0x0E, 0x06, 0x7F, 0xBF,
  0xC7, 0xE3, 0xBF, 0xCF, 0xE0, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xE1, 0xF0, 0xF8, 0x60, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C,
  0x31, 0xFF, 0xC0, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x7F, 0x78,
  0xE3, 0xF3, 0xB9, 0x9D, 0xCF, 0xC7, 0xE3, 0xF1, 0xDC, 0xE7, 0x73, 0xB8,
  0xE0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF, 0xF8, 0xF0,
  0x7F, 0x0F, 0xF0, 0xFD, 0x8F, 0xD9, 0xBF, 0x9B, 0xED, 0xBE, 0xF3, 0xEF,
  0x3E, 0xF3, 0xE6, 0x30, 0xF0, 0xFC, 0x3F, 0x8F, 0x63, 0xDC, 0xFB, 0x3E,
  0xEF, 0x9F, 0xE7, 0xF8, 0xFE, 0x1C, 0x1E, 0x1F, 0xEF, 0x3B, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xDF, 0xE3, 0xF0, 0xF8, 0xFE, 0xEF, 0xE7,
  0xE7, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0x1E, 0x1F, 0xEF, 0x3B, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xDF, 0xE3, 0xF0, 0x1C, 0x03, 0x80,
  0x70, 0xFC, 0x7F, 0x39, 0xDC, 0xEE, 0x77, 0xF3, 0xF1, 0xDC, 0xE6, 0x73,
  0xB8, 0xE0, 0x3D, 0xFF, 0x96, 0x0F, 0x0F, 0x8F, 0x87, 0x8F, 0xFB, 0xE0,
  0xFF, 0xFF, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE3, 0xBF, 0x8F, 0x80,
  0xE1, 0xF8, 0x76, 0x19, 0xCE, 0x73, 0x8C, 0xC3, 0xF0, 0xFC, 0x1E, 0x07,
  0x81, 0xE0, 0xE3, 0x8F, 0xC7, 0x1D, 0x8E, 0x33, 0x14, 0x67, 0x6D, 0xCE,
  0xDB, 0x8D, 0xB6, 0x1B, 0x6C, 0x3C, 0x78, 0x78, 0xF0, 0x71, 0xC0, 0xE1,
  0xDC, 0x63, 0x38, 0xFC, 0x1E, 0x03, 0x81, 0xE0, 0xFC, 0x33, 0x9C, 0xEE,
  0x1C, 0xE1, 0xD8, 0xE7, 0x30, 0xDC, 0x3E, 0x07, 0x81, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x7F, 0x3F, 0x81, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0x70,
  0x70, 0x7F, 0xFF, 0xE0, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xF0, 0xC1,
  0x86, 0x1C, 0x30, 0xC3, 0x86, 0x18, 0x70, 0xC0, 0xFF, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xF0, 0x18, 0x18, 0x3C, 0x3C, 0x66, 0x66, 0xC3, 0xFF, 0xFC,
  0xE3, 0xFC, 0xDC, 0x1B, 0xFE, 0x79, 0xFF, 0xFB, 0xE0, 0xE0, 0xE0, 0xFE,
  0xFE, 0xE7, 0xE7, 0xE7, 0xE7, 0xFE, 0xDE, 0x7F, 0xFB, 0x86, 0x0C, 0x1C,
  0x7F, 0x3E, 0x07, 0x07, 0x07, 0x7F, 0xFF, 0xC7, 0xC7, 0xC7, 0xE7, 0xFF,
  0x77, 0x7D, 0xDF, 0x1F, 0xFF, 0xFC, 0x3F, 0xBF, 0x3E, 0x68, 0xC7, 0xEF,
  0xCE, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x7F, 0xFF, 0xC7, 0xC7, 0xC7, 0xE7,
  0xFF, 0x7F, 0x06, 0xCE, 0xFE, 0x38, 0xE0, 0xE0, 0xE0, 0xFE, 0xFF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x5F, 0x0F, 0xFF, 0xFF, 0xF0, 0x11, 0xCC,
  0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xDF, 0xCC, 0xE0, 0x70, 0x38, 0x1C,
  0xEE, 0xE7, 0xE3, 0xE1, 0xF8, 0xEE, 0x73, 0xB9, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xDE, 0xF7, 0xFF, 0xF9, 0xCF, 0xCE, 0x7E, 0x73, 0xF3, 0x9F,
  0x9C, 0xFC, 0xE7, 0xDE, 0xFF, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0x7C,
  0xFE, 0xC7, 0xC7, 0xC7, 0xE7, 0xFE, 0x7C, 0xDE, 0xFF, 0xE7, 0xE7, 0xE7,
  0xE7, 0xFE, 0xFE, 0xE0, 0xE0, 0xE0, 0xE0, 0x7F, 0xFF, 0xC7, 0xC7, 0xC7,
  0xE7, 0xFF, 0x7F, 0x07, 0x07, 0x07, 0x07, 0xDF, 0xFE, 0x38, 0xE3, 0x8E,
  0x38, 0xFF, 0x2E, 0x3E, 0x3C, 0x3F, 0xFE, 0x30, 0xC7, 0xFF, 0x71, 0xC7,
  0x1C, 0x3C, 0xF0, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xFF, 0x7B, 0xE3,
  0xB1, 0x99, 0xCE, 0xC3, 0x61, 0xF0, 0x70, 0x38, 0xE7, 0x3B, 0x39, 0xD9,
  0x6C, 0xFB, 0x67, 0xDF, 0x1E, 0xF0, 0xE3, 0x87, 0x1C, 0xF3, 0xBB, 0x8F,
  0x83, 0x83, 0xE1, 0xB1, 0xDD, 0xC7, 0xE3, 0xB1, 0x9D, 0xCE, 0xC3, 0x61,
  0xF0, 0x70, 0x38, 0x1C, 0x5C, 0x1C, 0x0C, 0x00, 0x7E, 0xFC, 0x70, 0xC3,
  0x8E, 0x3F, 0xFF, 0x1C, 0xF3, 0x0C, 0x30, 0xCF, 0x3C, 0x30, 0xC3, 0x0E,
  0x3C, 0xFF, 0xFF, 0xFF, 0xF0, 0xC7, 0x18, 0xC6, 0x30, 0xEF, 0x63, 0x19,
  0xCE, 0x00, 0x63, 0xFE, 0x78,
};

const GFXglyph NotoSans_ExtraBold15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 11, 4, 1, -11 },
  { 6, 6, 4, 8, 1, -11 },
  { 9, 10, 11, 10, 0, -11 },
  { 23, 7, 12, 9, 1, -11 },
  { 34, 13, 11, 14, 0, -11 },
  { 52, 11, 11, 12, 1, -11 },
  { 68, 2, 4, 4, 1, -11 },
  { 69, 4, 13, 5, 1, -11 },
  { 76, 5, 13, 5, 0, -11 },
  { 85, 8, 7, 8, 0, -11 },
  { 92, 7, 7, 9, 1, -9 },
  { 99, 4, 4, 4, 0, -2 },
  { 101, 4, 2, 5, 0, -5 },
  { 102, 3, 2, 4, 1, -2 },
  { 103, 6, 11, 6, 0, -11 },
  { 112, 7, 11, 9, 1, -11 },
  { 122, 6, 11, 9, 1, -11 },
  { 131, 8, 11, 9, 0, -11 },
  { 142, 7, 11, 9, 1, -11 },
  { 152, 8, 11, 9, 0, -11 },
  { 163, 7, 11, 9, 1, -11 },
  { 173, 7, 11, 9, 1, -11 },
  { 183, 8, 11, 9, 0, -11 },
  { 194, 7, 11, 9, 1, -11 },
  { 204, 8, 11, 9, 0, -11 },
  { 215, 3, 8, 4, 1, -8 },
  { 218, 4, 10, 4, 0, -8 },
  { 223, 7, 8, 9, 1, -9 },
  { 230, 7, 5, 9, 1, -8 },
  { 235, 7, 8, 9, 1, -9 },
  { 242, 7, 11, 7, 0, -11 },
  { 252, 12, 12, 13, 1, -11 },
  { 270, 11, 11, 11, 0, -11 },
  { 286, 8, 11, 10, 1, -11 },
  { 297, 8, 11, 10, 1, -11 },
  { 308, 9, 11, 11, 1, -11 },
  { 321, 7, 11, 8, 1, -11 },
  { 331, 6, 11, 8, 1, -11 },
  { 340, 9, 11, 11, 1, -11 },
  { 353, 9, 11, 11, 1, -11 },
  { 366, 6, 11, 6, 0, -11 },
  { 375, 5, 14, 5, -1, -11 },
  { 384, 9, 11, 10, 1, -11 },
  { 397, 7, 11, 9, 1, -11 },
  { 407, 12, 11, 14, 1, -11 },
  { 424, 10, 11, 12, 1, -11 },
  { 438, 10, 11, 12, 1, -11 },
  { 452, 8, 11, 9, 1, -11 },
  { 463, 10, 14, 12, 1, -11 },
  { 481, 9, 11, 10, 1, -11 },
  { 494, 7, 11, 8, 1, -11 },
  { 504, 8, 11, 9, 0, -11 },
  { 515, 9, 11, 11, 1, -11 },
  { 528, 10, 11, 10, 0, -11 },
  { 542, 15, 11, 15, 0, -11 },
  { 563, 10, 11, 10, 0, -11 },
  { 577, 10, 11, 10, 0, -11 },
  { 591, 9, 11, 9, 0, -11 },
  { 604, 4, 13, 5, 1, -11 },
  { 611, 6, 11, 6, 0, -11 },
  { 620, 4, 13, 5, 0, -11 },
  { 627, 8, 7, 8, 0, -11 },
  { 634, 7, 2, 7, 0, 1 },
  { 636, 4, 2, 6, 1, -11 },
  { 637, 7, 8, 9, 1, -8 },
  { 644, 8, 11, 10, 1, -11 },
  { 655, 7, 8, 8, 1, -8 },
  { 662, 8, 11, 10, 1, -11 },
  { 673, 7, 8, 9, 1, -8 },
  { 680, 7, 11, 6, 0, -11 },
  { 690, 8, 12, 10, 1, -8 },
  { 702, 8, 11, 10, 1, -11 },
  { 713, 3, 12, 5, 1, -12 },
  { 718, 5, 16, 5, -1, -12 },
  { 728, 9, 11, 10, 1, -11 },
  { 741, 3, 11, 5, 1, -11 },
  { 746, 13, 8, 15, 1, -8 },
  { 759, 8, 8, 10, 1, -8 },
  { 767, 8, 8, 9, 1, -8 },
  { 775, 8, 12, 10, 1, -8 },
  { 787, 8, 12, 10, 1, -8 },
  { 799, 6, 8, 7, 1, -8 },
  { 805, 6, 8, 8, 1, -8 },
  { 811, 6, 10, 7, 0, -10 },
  { 819, 8, 8, 10, 1, -8 },
  { 827, 9, 8, 9, 0, -8 },
  { 836, 13, 8, 13, 0, -8 },
  { 849, 9, 8, 9, 0, -8 },
  { 858, 9, 12, 9, 0, -8 },
  { 872, 7, 8, 7, 0, -8 },
  { 879, 6, 13, 6, 0, -11 },
  { 889, 2, 14, 8, 3, -11 },
  { 893, 5, 13, 6, 1, -11 },
  { 902, 7, 3, 9, 1, -7 },
};

const GFXfont NotoSans_ExtraBold15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold15pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_EXTRABOLD15PT7B_H_
