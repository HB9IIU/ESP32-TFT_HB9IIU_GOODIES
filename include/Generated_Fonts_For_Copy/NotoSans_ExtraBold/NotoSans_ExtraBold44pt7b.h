#ifndef _NOTOSANS_EXTRABOLD44PT7B_H_
#define _NOTOSANS_EXTRABOLD44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0xFE, 0x7F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0x87, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x0F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x03, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFC, 0xFF, 0xF7, 0xF3, 0xF9, 0xC0, 0x8F, 0xC7, 0x00, 0x3F, 0x9C,
  0x00, 0xFF, 0x70, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFC, 0x01, 0xCF, 0xF0, 0x07, 0x1F, 0xC0, 0x1C, 0x7F, 0xC0, 0x71,
  0xFF, 0xF1, 0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0x02, 0x00,
  0x3F, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0xE0,
  0x0F, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x7E, 0x00,
  0x3F, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x1F, 0x03, 0xF0, 0x00, 0xFC, 0x3F,
  0x07, 0xC0, 0x01, 0xF8, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x3E, 0x00,
  0x07, 0xE1, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xE3, 0xF0, 0x00, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF8, 0x1F, 0x9F, 0x9F, 0x8F, 0xFC, 0x3F, 0xFF, 0x3F, 0x3F,
  0xFC, 0x3F, 0xFC, 0xFC, 0xFF, 0xF8, 0x7F, 0xF1, 0xF1, 0xFB, 0xF8, 0x7F,
  0xC7, 0xE7, 0xE3, 0xF0, 0x3E, 0x0F, 0x8F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F,
  0x87, 0xC0, 0x00, 0xFC, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0x7E, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x7C, 0x00, 0x3F, 0x03,
  0xF1, 0xF8, 0x00, 0x7C, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x07, 0xEF, 0xE0,
  0x03, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00,
  0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x01, 0xFE, 0x1F,
  0xFF, 0x03, 0xFC, 0x3F, 0xFF, 0x83, 0xFC, 0x7F, 0xFF, 0xC3, 0xF8, 0xFF,
  0xBF, 0xE7, 0xF8, 0xFF, 0x1F, 0xF7, 0xF8, 0xFF, 0x0F, 0xFF, 0xF0, 0xFE,
  0x07, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0xC0, 0xFF,
  0x81, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xE7, 0xFE, 0x07,
  0xFF, 0x83, 0xFF, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF0, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83,
  0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x03,
  0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01,
  0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF0,
  0x3F, 0x83, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x01, 0x01, 0xE0, 0x67, 0xC7, 0x8F, 0x9F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xF3, 0xF0,
  0x1F, 0xCF, 0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x7C, 0x00, 0xC0, 0xC0, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x9F, 0xCF,
  0xE7, 0xF3, 0xF1, 0xF9, 0xFC, 0xFC, 0x7E, 0x3F, 0x1F, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC7, 0xF8, 0xFF, 0x1F, 0xC1, 0xFE, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0xEF,
  0xE0, 0x3F, 0xBF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xBF,
  0xC0, 0xFE, 0x7F, 0x07, 0xF9, 0xFE, 0x1F, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0xFF,
  0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xBF, 0x9F, 0xCF, 0x8F, 0xE3,
  0x07, 0xF0, 0x83, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F,
  0xFB, 0xFF, 0x0F, 0x81, 0xFE, 0x1C, 0x01, 0xFC, 0x10, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xE1, 0xFF, 0x8C, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x3F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xF7, 0xF0,
  0x03, 0xF7, 0xF0, 0x07, 0xE7, 0xF0, 0x0F, 0xE7, 0xF0, 0x0F, 0xC7, 0xF0,
  0x1F, 0x87, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xF0,
  0xFE, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0x80, 0xFE, 0x7F,
  0xC3, 0xF3, 0xFF, 0x8F, 0xDF, 0xFF, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB,
  0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFD, 0xFE, 0x1F,
  0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xE0, 0xFF, 0x3F, 0xC0, 0xFE, 0x7F, 0x81,
  0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xF1, 0xFE, 0x3F, 0xC1, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFE, 0x3F, 0xE7, 0xF8, 0x3F, 0xCF,
  0xE0, 0x3F, 0xDF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0xFE, 0xFE,
  0x03, 0xFD, 0xFE, 0x0F, 0xFB, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x1F, 0xF1, 0xFE, 0x3F, 0xC1, 0xFE, 0x7F, 0x01, 0xFD, 0xFE, 0x03, 0xFB,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0xDF,
  0xE0, 0xFF, 0xBF, 0xF7, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFB, 0xF8, 0x7F, 0xE7, 0xE0, 0x7F, 0x8F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x63, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x08, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x04, 0x1F, 0x8F, 0xEF, 0xF7, 0xFB, 0xFC,
  0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF3, 0xF9, 0xFC, 0xFE, 0x7E, 0x3F, 0x3F, 0x9F, 0x8F,
  0xC7, 0xE3, 0xE3, 0xF0, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xE0,
  0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0x80,
  0x00, 0x10, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xF8, 0x3F, 0xE6, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x78, 0x0F, 0xC3,
  0xF0, 0x3F, 0xFC, 0x7C, 0x3E, 0x0F, 0xFF, 0xE7, 0xE7, 0xE1, 0xFF, 0xFE,
  0x3E, 0x7C, 0x3F, 0xFF, 0xE3, 0xE7, 0xC3, 0xF0, 0x7C, 0x3E, 0xFC, 0x7E,
  0x07, 0xC3, 0xFF, 0xC7, 0xE0, 0x7C, 0x3F, 0xF8, 0x7C, 0x07, 0xC3, 0xFF,
  0x87, 0xC0, 0x7C, 0x3E, 0xF8, 0x7C, 0x07, 0xC3, 0xEF, 0x87, 0xC0, 0xFC,
  0x3E, 0xF8, 0x7C, 0x0F, 0xC3, 0xEF, 0x87, 0xE0, 0xFC, 0x7E, 0xFC, 0x7F,
  0x3F, 0xEF, 0xCF, 0xC3, 0xFF, 0xFF, 0xFC, 0x7C, 0x3F, 0xFD, 0xFF, 0x87,
  0xE1, 0xFF, 0x9F, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0x00, 0x0F, 0xF8,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x7F, 0x87, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x07,
  0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0x80,
  0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0xC3, 0xFF, 0xBF, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x0F, 0xF7, 0xF0, 0x3F, 0xEF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF9, 0xFC, 0x3F, 0xFB, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xF1, 0xF8, 0x7F, 0xE0, 0x0C, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x01, 0x1F, 0xF8, 0x03, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xE0, 0x3F, 0xF3, 0xF8, 0x03,
  0xFE, 0xFE, 0x00, 0xFF, 0xBF, 0x80, 0x1F, 0xEF, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x1F, 0xEF, 0xE0,
  0x0F, 0xF3, 0xF8, 0x07, 0xFC, 0xFE, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xCF, 0xE1,
  0xFF, 0x80, 0x08, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xBF, 0x81, 0xFF, 0xF7, 0xF8, 0x00, 0xFE, 0xFF,
  0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xFE, 0x00, 0x7F, 0x3F, 0xE0, 0x0F,
  0xE7, 0xFE, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3,
  0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0x10, 0x00, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xCF, 0xE0, 0x1F, 0xF3, 0xF8, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0x3F,
  0x81, 0xFE, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0,
  0x3F, 0x8F, 0xF0, 0x0F, 0xE7, 0xFC, 0x03, 0xF9, 0xFE, 0x00, 0xFE, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFC, 0x7F, 0x80,
  0xFE, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0xFF, 0x83, 0xF8, 0x1F,
  0xE0, 0xFE, 0x07, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xE3, 0xF8,
  0x07, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x3F, 0xEF, 0xE0, 0x07, 0xFC,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xBF, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0x7E, 0x01, 0xFB,
  0xFF, 0xDF, 0x80, 0x7F, 0xFF, 0xF7, 0xE0, 0x3F, 0x7F, 0xFC, 0xFC, 0x0F,
  0xDF, 0xFF, 0x3F, 0x03, 0xF7, 0xFF, 0xCF, 0xC0, 0xF9, 0xFF, 0xF1, 0xF8,
  0x7E, 0x7F, 0xFC, 0x7E, 0x1F, 0x9F, 0xFF, 0x1F, 0x87, 0xC7, 0xFF, 0xC7,
  0xF3, 0xF1, 0xFF, 0xF0, 0xFC, 0xFC, 0x7F, 0xFC, 0x3F, 0x3E, 0x1F, 0xFF,
  0x0F, 0xDF, 0x87, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x7F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xC1,
  0xFF, 0xF0, 0x3F, 0xE0, 0x7F, 0xFC, 0x0F, 0xF8, 0x1F, 0xFF, 0x01, 0xFE,
  0x07, 0xFF, 0xC0, 0x7F, 0x01, 0xFC, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0x3F, 0x80, 0xFF, 0xF9, 0xFE,
  0x07, 0xFF, 0xC7, 0xF8, 0x3F, 0xFE, 0x3F, 0xC1, 0xFF, 0xF0, 0xFF, 0x0F,
  0xFF, 0x87, 0xF8, 0x7F, 0xFC, 0x1F, 0xE3, 0xFF, 0xE0, 0xFF, 0x1F, 0xFF,
  0x03, 0xFC, 0xFF, 0xF8, 0x1F, 0xE7, 0xFF, 0xC0, 0x7F, 0xBF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0x1F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x80,
  0x0F, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F,
  0x9F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0xBF, 0x80,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFB, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x1F, 0xFC, 0x1F, 0xF0, 0x07, 0xFC,
  0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF9, 0xFE, 0x00, 0x0F, 0xF3,
  0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0,
  0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0x8F, 0xFF, 0x0F, 0xE0, 0x7F, 0xC3,
  0xF8, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x3F,
  0xC3, 0xF8, 0x0F, 0xF0, 0xFE, 0x07, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0x87, 0xF8,
  0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x80,
  0xFF, 0x0F, 0xE0, 0x3F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x00, 0xFF, 0x3F,
  0x80, 0x3F, 0xEF, 0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x07,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0x0F,
  0x9F, 0xE0, 0x0C, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0,
  0x01, 0xFE, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x07, 0xF3, 0xFC, 0x01, 0xFE,
  0x7F, 0xE0, 0x7F, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x3F, 0xDF, 0xE0, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x00,
  0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x03, 0xF8, 0x03,
  0xF8, 0x3F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8,
  0xFF, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xF9, 0xFC,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF7, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE7, 0xF8, 0x03,
  0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xFE,
  0x01, 0xFC, 0x3F, 0x80, 0x7F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xFF, 0x01,
  0xFC, 0x1F, 0xC0, 0xFF, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xFF, 0x03, 0xF8,
  0x1F, 0xC0, 0xFF, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0x9F, 0x83, 0xF8, 0x0F,
  0xE1, 0xF9, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x9F, 0x87, 0xF0, 0x0F, 0xE1,
  0xF9, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x9F, 0x87, 0xF0, 0x07, 0xE3, 0xF0,
  0xFC, 0x7E, 0x00, 0x7F, 0x3F, 0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xF0, 0xFC,
  0xFE, 0x00, 0x7F, 0x3F, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xE0, 0x7C, 0xFC,
  0x00, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFC,
  0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFF,
  0x1F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFF, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF8, 0x01, 0xFE,
  0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x81, 0xFE, 0x01,
  0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x1F,
  0xEF, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x0F, 0xF7, 0xF8, 0x01, 0xFE,
  0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFE,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x03, 0xEF, 0x80, 0x03, 0xEF, 0xC0, 0x07, 0xE7, 0xC0, 0x07,
  0xC7, 0xE0, 0x0F, 0xC3, 0xE0, 0x0F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x1F,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xE0, 0x7F, 0xC2, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0xFF, 0xC7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xCF, 0xCF, 0xFE, 0x3F, 0x1F, 0xF0, 0xFC,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x06, 0x01, 0xFC, 0x7F, 0x83, 0xF9, 0xFF, 0xC7, 0xF7, 0xFF, 0xCF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xF3, 0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x3F, 0xBF, 0xFC, 0x7F, 0x3F, 0xF0, 0xFC, 0x3F, 0xC0, 0x00,
  0x18, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x7F, 0xE3, 0xC7, 0xF8, 0x04, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0x7F, 0x80, 0x67, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0xE0, 0xFE, 0x0F, 0xF1, 0xFC, 0x7F, 0xFB, 0xF8, 0xFF, 0xF7,
  0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFB, 0xFF, 0xBF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x03, 0xFD, 0xFE, 0x07, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xBF, 0x87, 0xFE, 0x3F, 0x07, 0xF8,
  0x7E, 0x00, 0x1C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x9F, 0xE0, 0xFF, 0x3F, 0x80, 0xFE,
  0xFF, 0x00, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x23, 0xFE, 0x01, 0xC3, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0x08, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xF1, 0xFC,
  0x7F, 0xFB, 0xF8, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xF1, 0xFF, 0xBF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFD, 0xFE, 0x07,
  0xFB, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xBF,
  0x87, 0xFE, 0x7F, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF6, 0x00, 0x3F, 0xEF, 0xE1, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x01,
  0x40, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x02, 0x01, 0xFC, 0x7F, 0xC3, 0xF9, 0xFF, 0xE7, 0xF7, 0xFF,
  0xCF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xF9, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFE, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xFA, 0x7F, 0xDF, 0xFE, 0xFF, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF, 0x03, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x7F, 0x9F,
  0xE0, 0x7F, 0x8F, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x83, 0xFC, 0x7F, 0xC1,
  0xFE, 0x7F, 0xC0, 0xFF, 0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0x3F, 0xBF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xC3,
  0xFE, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xF3, 0xFC,
  0x07, 0xF9, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x0E, 0x07, 0xE1,
  0xFF, 0x07, 0xFE, 0x3F, 0x3F, 0xFC, 0x7F, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFF, 0xF0, 0x7F, 0xE0, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFF,
  0xF8, 0x0F, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xFE, 0x03, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0x80, 0xFE, 0x01, 0xFF, 0xFC,
  0x07, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0x01, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0xFE, 0x03,
  0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0x80, 0xFE, 0x01, 0xFF,
  0xFC, 0x07, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xFF, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x03, 0x01, 0xF8, 0x7F, 0xC3, 0xF3, 0xFF, 0xE7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFE, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFC, 0x7F,
  0x81, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFE, 0x7F, 0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0xC3, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0x01, 0xF8, 0x7F, 0x83, 0xF9,
  0xFF, 0xC7, 0xF7, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xBF, 0xF3,
  0xFF, 0x7F, 0xC1, 0xFE, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F, 0xBF, 0xFC, 0x7F,
  0x7F, 0xF0, 0xFE, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF1, 0xFC, 0x7F, 0xFB, 0xF8, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xF1, 0xFF, 0xBF, 0xC0, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x03, 0xFD, 0xFE, 0x07, 0xFB, 0xFF, 0x3F, 0xF7, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0xBF, 0x87, 0xFE, 0x7F, 0x07, 0xF8,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x7E,
  0x1F, 0xFF, 0x1F, 0xDF, 0x9F, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD,
  0xFF, 0xE2, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x70, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0x80, 0xE7, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x01, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x0F, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8,
  0x7F, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xF7, 0x1F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC7, 0xFF, 0x9F, 0x87,
  0xFC, 0x3F, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xF9,
  0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFF, 0x01,
  0xFD, 0xFC, 0x07, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xF0, 0x3F, 0xDF, 0xE0,
  0xFF, 0xC0, 0xFE, 0x3F, 0x83, 0xFF, 0x83, 0xF8, 0xFE, 0x0F, 0xFE, 0x0F,
  0xE3, 0xF8, 0x3E, 0xF8, 0x7F, 0x07, 0xF1, 0xFB, 0xE1, 0xFC, 0x1F, 0xC7,
  0xEF, 0xC7, 0xF0, 0x7F, 0x1F, 0x3F, 0x1F, 0xC1, 0xFC, 0x7C, 0xFC, 0xFE,
  0x03, 0xF9, 0xF1, 0xF3, 0xF8, 0x0F, 0xEF, 0xC7, 0xCF, 0xE0, 0x3F, 0xBF,
  0x1F, 0xBF, 0x00, 0x7E, 0xF8, 0x7E, 0xFC, 0x01, 0xFB, 0xE0, 0xFB, 0xF0,
  0x07, 0xEF, 0x83, 0xFF, 0xC0, 0x1F, 0xBE, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xCF, 0xF0, 0x1F, 0xE3, 0xFE, 0x0F, 0xF0,
  0x7F, 0x87, 0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xBF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFC, 0xFF,
  0x00, 0xFF, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0,
  0x3F, 0xE7, 0xFC, 0x07, 0xFB, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xDF,
  0xC0, 0x0F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F,
  0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0,
  0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07,
  0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x23, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x07, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xE0,
  0xFF, 0xE0, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0,
  0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0x1F, 0xF8, 0x07,
  0xF0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x87, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xE8, 0x01, 0xFF, 0x00,
};

const GFXglyph NotoSans_ExtraBold44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 32, 13, 2, -31 },
  { 33, 16, 11, 22, 3, -31 },
  { 55, 27, 31, 29, 1, -31 },
  { 160, 22, 36, 25, 2, -33 },
  { 259, 39, 32, 41, 1, -32 },
  { 415, 32, 32, 34, 2, -32 },
  { 543, 7, 11, 12, 3, -31 },
  { 553, 12, 39, 15, 2, -32 },
  { 612, 13, 39, 15, 1, -32 },
  { 676, 22, 20, 24, 1, -33 },
  { 731, 22, 21, 25, 2, -26 },
  { 789, 9, 12, 13, 1, -6 },
  { 803, 12, 6, 14, 1, -15 },
  { 812, 8, 8, 13, 2, -7 },
  { 820, 19, 32, 19, 0, -32 },
  { 896, 22, 32, 25, 2, -32 },
  { 984, 17, 31, 25, 2, -31 },
  { 1050, 23, 32, 25, 1, -32 },
  { 1142, 22, 32, 25, 2, -32 },
  { 1230, 24, 31, 25, 1, -31 },
  { 1323, 21, 31, 25, 2, -31 },
  { 1405, 22, 32, 25, 2, -32 },
  { 1493, 23, 31, 25, 1, -31 },
  { 1583, 23, 32, 25, 1, -32 },
  { 1675, 23, 32, 25, 1, -32 },
  { 1767, 8, 26, 13, 2, -25 },
  { 1793, 9, 31, 13, 1, -25 },
  { 1828, 21, 24, 25, 2, -28 },
  { 1891, 22, 15, 25, 2, -23 },
  { 1933, 21, 24, 25, 2, -28 },
  { 1996, 21, 33, 22, 0, -32 },
  { 2083, 36, 35, 39, 2, -32 },
  { 2241, 31, 32, 31, 0, -32 },
  { 2365, 23, 31, 29, 4, -31 },
  { 2455, 25, 32, 28, 2, -32 },
  { 2555, 26, 31, 32, 4, -31 },
  { 2656, 18, 31, 24, 4, -31 },
  { 2726, 18, 31, 24, 4, -31 },
  { 2796, 27, 32, 32, 2, -32 },
  { 2904, 26, 31, 34, 4, -31 },
  { 3005, 16, 31, 18, 1, -31 },
  { 3067, 14, 41, 15, -3, -31 },
  { 3139, 26, 31, 30, 4, -31 },
  { 3240, 20, 31, 25, 4, -31 },
  { 3318, 34, 31, 42, 4, -31 },
  { 3450, 29, 31, 36, 4, -31 },
  { 3563, 31, 32, 35, 2, -32 },
  { 3687, 22, 31, 28, 4, -31 },
  { 3773, 31, 39, 35, 2, -32 },
  { 3925, 26, 31, 29, 4, -31 },
  { 4026, 21, 32, 25, 2, -32 },
  { 4110, 24, 31, 26, 1, -31 },
  { 4203, 27, 31, 33, 3, -31 },
  { 4308, 29, 31, 29, 0, -31 },
  { 4421, 44, 31, 44, 0, -31 },
  { 4592, 30, 31, 31, 0, -31 },
  { 4709, 28, 31, 28, 0, -31 },
  { 4818, 24, 31, 26, 1, -31 },
  { 4911, 10, 39, 14, 3, -32 },
  { 4960, 19, 32, 19, 0, -32 },
  { 5036, 11, 39, 14, 1, -32 },
  { 5090, 24, 21, 24, 0, -32 },
  { 5153, 20, 4, 20, 0, 3 },
  { 5163, 13, 7, 17, 2, -34 },
  { 5175, 22, 25, 27, 2, -25 },
  { 5244, 23, 33, 28, 3, -33 },
  { 5339, 20, 25, 23, 2, -25 },
  { 5402, 23, 33, 28, 2, -33 },
  { 5497, 23, 25, 27, 2, -25 },
  { 5569, 18, 34, 18, 1, -34 },
  { 5646, 23, 36, 28, 2, -25 },
  { 5750, 23, 33, 29, 3, -33 },
  { 5845, 8, 34, 14, 3, -34 },
  { 5879, 13, 45, 14, -2, -34 },
  { 5953, 25, 33, 28, 3, -33 },
  { 6057, 8, 33, 14, 3, -33 },
  { 6090, 37, 25, 43, 3, -25 },
  { 6206, 23, 25, 29, 3, -25 },
  { 6278, 24, 25, 28, 2, -25 },
  { 6353, 23, 36, 28, 3, -25 },
  { 6457, 23, 36, 28, 2, -25 },
  { 6561, 17, 25, 20, 3, -25 },
  { 6615, 19, 25, 22, 2, -25 },
  { 6675, 17, 29, 20, 1, -29 },
  { 6737, 23, 24, 29, 3, -24 },
  { 6806, 26, 24, 26, 0, -24 },
  { 6884, 38, 24, 39, 0, -24 },
  { 6998, 26, 24, 26, 0, -24 },
  { 7076, 26, 35, 26, 0, -24 },
  { 7190, 20, 24, 22, 1, -24 },
  { 7250, 16, 39, 18, 1, -32 },
  { 7328, 5, 43, 23, 9, -33 },
  { 7355, 15, 39, 18, 2, -32 },
  { 7429, 22, 7, 25, 2, -19 },
};

const GFXfont NotoSans_ExtraBold44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold44pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_EXTRABOLD44PT7B_H_
