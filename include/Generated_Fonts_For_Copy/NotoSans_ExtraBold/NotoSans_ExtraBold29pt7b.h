#ifndef _NOTOSANS_EXTRABOLD29PT7B_H_
#define _NOTOSANS_EXTRABOLD29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE0,
  0x00, 0x31, 0xFF, 0xFF, 0x78, 0xF3, 0xFE, 0x7F, 0xCF, 0xF9, 0xFF, 0x1D,
  0xE3, 0xBC, 0x77, 0x8E, 0x03, 0x8E, 0x03, 0xC7, 0x01, 0xE7, 0x80, 0xF3,
  0xC0, 0x71, 0xC0, 0x38, 0xE1, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x87,
  0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC,
  0x38, 0xE0, 0x1C, 0x70, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x1C, 0x03, 0x8E,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x3F, 0xC1, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF,
  0xBE, 0xC2, 0x7D, 0x80, 0xFB, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xC0, 0x7F, 0x80, 0xDF, 0x81, 0x9F, 0xC3, 0x3F, 0xFF, 0xFB, 0xFF,
  0xF7, 0xFF, 0xC3, 0xFE, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x3E, 0x00,
  0xF0, 0x3F, 0x80, 0xF0, 0x3F, 0xE0, 0x78, 0x1E, 0x70, 0x78, 0x0F, 0x3C,
  0x3C, 0x07, 0x9E, 0x3C, 0x03, 0xCF, 0x1E, 0x01, 0xE7, 0x9E, 0x00, 0xF3,
  0xCE, 0x18, 0x79, 0xEF, 0x7F, 0x1F, 0xE7, 0x3F, 0xCF, 0xE7, 0xBF, 0xF1,
  0xE7, 0x9E, 0x78, 0x03, 0xCF, 0x3C, 0x03, 0xC7, 0x9E, 0x01, 0xE3, 0xCF,
  0x01, 0xE1, 0xE7, 0x80, 0xE0, 0xF3, 0xC0, 0xF0, 0x3F, 0xC0, 0x70, 0x1F,
  0xE0, 0x78, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x7F, 0xF8, 0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF9, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x7C, 0xFF, 0xE3, 0xE7,
  0xFF, 0xBF, 0x7E, 0x7F, 0xF3, 0xE1, 0xFF, 0x9F, 0x07, 0xF8, 0xFC, 0x1F,
  0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x7C, 0x78, 0x78,
  0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0x78, 0x78, 0x78,
  0x7C, 0x3C, 0x3C, 0x1E, 0x1F, 0x0F, 0xF0, 0x78, 0x7C, 0x3C, 0x3E, 0x1E,
  0x1E, 0x1E, 0x1F, 0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1F,
  0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0xF7, 0x3F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x0F, 0xC0,
  0x7F, 0x83, 0xDE, 0x1F, 0x3C, 0x18, 0xE0, 0x21, 0x00, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x7D, 0xF7,
  0x9E, 0x7B, 0xCF, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x31, 0xFF, 0xFF, 0x78,
  0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xC7, 0xC7, 0xCF, 0x0F, 0xBE, 0x1F, 0x7C, 0x1F, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0x3C, 0x3E, 0x7C, 0x7C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00,
  0x01, 0xF0, 0x3F, 0x07, 0xF1, 0xFF, 0x3F, 0xFF, 0xFF, 0x7D, 0xF3, 0x9F,
  0x11, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xE1,
  0xFF, 0xE7, 0xFF, 0xE7, 0x8F, 0xC6, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xE0, 0xFF, 0xE3, 0xFF, 0xE3, 0xFF, 0xE3, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x1F, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0xC0, 0x1F,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x7D, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xC7, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0x7C, 0x0F, 0x7C, 0x1E, 0x7C,
  0x3E, 0x7C, 0x3C, 0x7C, 0x78, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x3F, 0xF9,
  0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7F, 0xF1, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x7F, 0xE0, 0x01,
  0xF8, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xE0, 0x0F, 0x80, 0x1E, 0x00,
  0x7C, 0x60, 0xFB, 0xF9, 0xFF, 0xFB, 0xFF, 0xF7, 0xF3, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0x7C, 0x7E, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF,
  0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0xE1, 0xFF,
  0xE3, 0xFF, 0xE7, 0xC7, 0xCF, 0x07, 0x9F, 0x1F, 0x3F, 0x7E, 0x3F, 0xF8,
  0x3F, 0xE0, 0x7F, 0x81, 0xFF, 0xC7, 0xEF, 0xDF, 0x0F, 0xBE, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF8, 0xF9, 0xFF, 0xF1, 0xFF, 0xC1, 0xFF, 0x00, 0x0F,
  0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xFF, 0xCF, 0xC7, 0xDF, 0x0F, 0xBE, 0x0F,
  0x7C, 0x1F, 0xF8, 0x3F, 0xF0, 0xFF, 0xFF, 0xFB, 0xFF, 0xF3, 0xFB, 0xE3,
  0xE7, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF,
  0x07, 0xF8, 0x00, 0x7B, 0xFF, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x7F, 0xFF, 0xDE, 0x79, 0xFF, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7D, 0xF7, 0x9E, 0x7B, 0xCF, 0x3C, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x3F, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x40, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xC0, 0x03, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x00, 0xFC, 0x1F, 0xE1, 0xFE, 0x3F, 0xE0, 0xFE, 0x03,
  0xC0, 0x0C, 0x00, 0x00, 0x1F, 0xC1, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x70,
  0x7C, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x1F, 0xC0, 0x7C, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x0F, 0x80, 0xF8, 0x1E, 0x00, 0x3C, 0x3C, 0x0C, 0x1E, 0x38,
  0x7F, 0xCE, 0x78, 0xFF, 0xCE, 0x71, 0xF3, 0xCF, 0x73, 0xC3, 0xCF, 0xF3,
  0xC3, 0xCF, 0xF3, 0xC3, 0xCF, 0xF3, 0xC3, 0xCF, 0xF3, 0xC3, 0xCE, 0xF3,
  0xC7, 0xDE, 0x71, 0xFF, 0xFC, 0x78, 0xFC, 0xFC, 0x78, 0x38, 0x70, 0x3C,
  0x00, 0x00, 0x3F, 0x00, 0x60, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xEF, 0x00, 0x1F, 0x7C, 0x00, 0xF3, 0xE0, 0x0F,
  0x8F, 0x00, 0x7C, 0x7C, 0x03, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xE0,
  0x1F, 0x1F, 0x00, 0xFD, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x80, 0xFF, 0xC0,
  0xFF, 0xF8, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x7E, 0xF8, 0x3F, 0xF8, 0x3E,
  0xF8, 0x3E, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xFE, 0xF8, 0x3E,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF0, 0x03, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE,
  0x7F, 0x0E, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x02, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0xFF, 0xC0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x7F, 0x3E, 0x07, 0xEF,
  0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7E, 0xF8, 0x7F,
  0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFF,
  0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xC7,
  0xFF, 0xE7, 0xF0, 0x73, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF8, 0x1F, 0x7E, 0x0F, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0,
  0x7F, 0xF0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F,
  0xCF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0xFF, 0xFF, 0x7F, 0xBF, 0x00,
  0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0x83, 0xF3, 0xE0, 0xF8, 0xF8, 0x7C, 0x3E,
  0x3F, 0x0F, 0x9F, 0x83, 0xE7, 0xC0, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x3E, 0x0F, 0x8F, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7E, 0x3E, 0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x7E, 0xF8, 0x0F, 0xC0,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x77, 0xFF, 0xC1, 0xEF,
  0xFB, 0xC3, 0xDF, 0xF7, 0x87, 0x3F, 0xEF, 0x1E, 0x7F, 0xDE, 0x3C, 0xFF,
  0x9E, 0x79, 0xFF, 0x3D, 0xE3, 0xFE, 0x7B, 0xC7, 0xFC, 0x7F, 0x8F, 0xF8,
  0xFE, 0x1F, 0xF1, 0xFC, 0x3F, 0xE1, 0xF8, 0x7F, 0xC3, 0xE0, 0xFF, 0x87,
  0xC1, 0xE0, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xDF, 0x0F, 0xFB, 0xE1, 0xFF,
  0x3E, 0x3F, 0xE7, 0xC7, 0xFC, 0x7C, 0xFF, 0x8F, 0xDF, 0xF0, 0xFB, 0xFE,
  0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x7E, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE7, 0xE0, 0xFD, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0x7E, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xF7,
  0xFF, 0xEF, 0x8F, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF1,
  0xFF, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF, 0x1F, 0xF8, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x7E, 0x0F, 0xCF, 0xC0,
  0x7E, 0xFC, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF,
  0xC0, 0x7E, 0x7E, 0x0F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x81, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF,
  0x87, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7F, 0xFE,
  0x3F, 0xFF, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xCF, 0xC3, 0xE3, 0xE1, 0xF0,
  0xF8, 0xF8, 0x7E, 0x7C, 0x1F, 0x3E, 0x0F, 0xDF, 0x03, 0xFF, 0x80, 0xF8,
  0x07, 0xF0, 0x7F, 0xF3, 0xFF, 0xDF, 0xFE, 0x7C, 0x39, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFC, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x3E, 0x7E, 0x1F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF0,
  0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x1F,
  0xBE, 0x03, 0xE7, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xE1, 0xF0, 0x7C,
  0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xE0,
  0x1F, 0x7C, 0x01, 0xEF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xFB, 0xC0,
  0x7C, 0x07, 0xDF, 0x03, 0xE0, 0x7C, 0xF8, 0x3F, 0x83, 0xE7, 0xC1, 0xFC,
  0x1F, 0x1E, 0x0F, 0xE0, 0xF8, 0xF0, 0x77, 0x07, 0x87, 0xC7, 0xBC, 0x7C,
  0x3E, 0x3D, 0xE3, 0xE0, 0xF1, 0xEF, 0x1F, 0x07, 0x8F, 0x78, 0xF0, 0x3E,
  0xF1, 0xEF, 0x81, 0xF7, 0x8F, 0x7C, 0x07, 0xBC, 0x7B, 0xE0, 0x3D, 0xE3,
  0xDE, 0x01, 0xEE, 0x0E, 0xF0, 0x0F, 0xF0, 0x77, 0x80, 0x3F, 0x83, 0xFC,
  0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0xFC, 0x03, 0xF7, 0xE0, 0x7E, 0x3E, 0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x1F,
  0x80, 0xF9, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x00, 0xF9, 0xF0, 0x1F, 0x1F, 0x83, 0xF0, 0xFC, 0x3E, 0x07, 0xC7,
  0xE0, 0x7E, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xEF, 0x80, 0xF9, 0xF0, 0x3E,
  0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0x3E, 0x3E, 0x07, 0xCF, 0x80, 0x7D, 0xF0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3F, 0xFF, 0xFF, 0xFC,
  0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0xFF, 0xFF, 0xF8, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x03, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x1E, 0x78, 0x1C,
  0x78, 0x3C, 0x3C, 0x38, 0x3C, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0x07, 0xC0, 0xF0, 0x0F, 0xF0, 0x7F,
  0xF0, 0xFF, 0xF0, 0xE3, 0xE0, 0x03, 0xE0, 0x07, 0xC3, 0xFF, 0x9F, 0xFF,
  0x7F, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF,
  0xF7, 0x9F, 0x8F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x7C, 0x7F, 0xFC, 0xFF, 0xFD, 0xFF, 0xFB, 0xF1, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8,
  0xFF, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0x9E, 0x7E, 0x00, 0x07, 0xFC, 0x7F,
  0xE3, 0xFF, 0x9F, 0xFC, 0x7C, 0x11, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x02, 0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x83,
  0xFC, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC3, 0xE7, 0x9F, 0xEF, 0x7F, 0xFE, 0xFF, 0xFD, 0xF0, 0xFF, 0xE0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x1E, 0xF8, 0x7D, 0xFF,
  0xFB, 0xFF, 0xF3, 0xFD, 0xE3, 0xF3, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xF3, 0xF3, 0xF7, 0xC3, 0xEF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xF1, 0xC7, 0xFF, 0x87, 0xFF, 0x07,
  0xFC, 0x0F, 0xF1, 0xFE, 0x3F, 0xE3, 0xFE, 0x3E, 0x03, 0xE0, 0x7F, 0xCF,
  0xFC, 0xFF, 0xCF, 0xFC, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0F, 0x9E,
  0x7F, 0xBC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC3, 0xFF, 0x83, 0xFE, 0x07, 0xFC,
  0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7B, 0xE1, 0xF7, 0xFF, 0xEF, 0xFF,
  0xCF, 0xF7, 0x8F, 0xCF, 0x00, 0x1E, 0x00, 0x7D, 0x81, 0xFB, 0xFF, 0xF7,
  0xFF, 0xCF, 0xFF, 0x07, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x7E, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xC0,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xFF, 0xFF, 0xDF, 0xEF, 0xC0, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0xFD, 0xF0, 0xFC, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x7C, 0x1F, 0x7C,
  0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFD, 0xF8, 0x7C,
  0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0xCF, 0x83, 0xE7, 0xC0, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF3, 0xF8, 0xFC, 0x7B, 0xFE, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xC7, 0xF1, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0, 0x7C,
  0x1F, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07,
  0xC1, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0,
  0x7C, 0x1F, 0xF3, 0xF9, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0x0F, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7F, 0x7E, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF0, 0xF1, 0xF1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF,
  0xC7, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFF, 0xE3, 0xFF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFE, 0x7D, 0xF8, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x9E, 0x7F, 0xBC, 0xFF, 0xFB, 0xFF, 0xF7, 0xC3, 0xFF, 0x83, 0xFE,
  0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xF0, 0x7B, 0xE1, 0xF7, 0xFF,
  0xEF, 0xFF, 0xCF, 0xF7, 0x8F, 0xCF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0xF1, 0xFE, 0x7F, 0xDF,
  0xFF, 0xFF, 0xF3, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x1F, 0xE3, 0xFF, 0x9F, 0xFD, 0xF0,
  0xCF, 0x80, 0x7F, 0x01, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F, 0x80, 0x7F,
  0x01, 0xFF, 0x1F, 0x7F, 0xFB, 0xFF, 0x8F, 0xF8, 0x1E, 0x03, 0xC0, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xFF, 0x3F, 0xE3, 0xFC, 0x3F, 0x80, 0xF8,
  0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC3, 0xFF, 0xFF, 0xEF,
  0xFF, 0xDF, 0xF7, 0x9F, 0xCF, 0xF8, 0x0F, 0xBE, 0x0F, 0xDF, 0x07, 0xCF,
  0x83, 0xE3, 0xC1, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x3C, 0x78, 0x1F, 0x7C,
  0x07, 0xBE, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x07, 0xC0, 0xF8, 0x3F, 0x0F, 0xBC, 0x1F, 0x87, 0xDF, 0x0F, 0xC3,
  0xEF, 0x8F, 0xE1, 0xE3, 0xC7, 0xF9, 0xF1, 0xE3, 0xBC, 0xF8, 0xF9, 0xDE,
  0x78, 0x7D, 0xE7, 0x3C, 0x1E, 0xF3, 0xBE, 0x0F, 0x71, 0xFF, 0x07, 0xB8,
  0xFF, 0x03, 0xDC, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x3F,
  0x07, 0xE0, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0xBF, 0x0F, 0x8F, 0x8F, 0xC3,
  0xE7, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xFC, 0x03, 0xFF, 0x03, 0xEF, 0x83, 0xF3, 0xE1, 0xF1, 0xF9, 0xF8,
  0x7D, 0xF8, 0x3F, 0xF8, 0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xCF, 0x83, 0xE3,
  0xE1, 0xE1, 0xF1, 0xF0, 0x78, 0xF8, 0x3E, 0x78, 0x1F, 0x7C, 0x07, 0xBE,
  0x03, 0xDE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03,
  0xF8, 0x01, 0xF0, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x3E,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC3, 0xF0, 0xFC, 0x7F, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE3, 0xF8, 0xF8, 0x3F, 0x0F,
  0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xFC, 0x3F,
  0x0F, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x3F, 0x0F, 0xC3, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xF0, 0x7F, 0x07, 0xC3, 0xF1, 0xFC, 0x7C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x8F, 0xE3, 0xF0, 0xFC, 0x30, 0x00, 0x3C,
  0x05, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFC,
};

const GFXglyph NotoSans_ExtraBold29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 21, 8, 1, -21 },
  { 17, 11, 8, 15, 2, -21 },
  { 28, 17, 21, 19, 1, -21 },
  { 73, 15, 24, 17, 1, -22 },
  { 118, 25, 21, 27, 1, -21 },
  { 184, 21, 21, 22, 1, -21 },
  { 240, 4, 8, 8, 2, -21 },
  { 244, 8, 26, 10, 1, -21 },
  { 270, 8, 26, 10, 1, -21 },
  { 296, 14, 14, 16, 1, -22 },
  { 321, 14, 14, 17, 1, -17 },
  { 346, 6, 8, 9, 1, -4 },
  { 352, 8, 4, 9, 1, -10 },
  { 356, 6, 5, 8, 1, -5 },
  { 360, 12, 21, 12, 0, -21 },
  { 392, 15, 21, 17, 1, -21 },
  { 432, 12, 21, 17, 1, -21 },
  { 464, 15, 21, 17, 1, -21 },
  { 504, 15, 21, 17, 1, -21 },
  { 544, 16, 21, 17, 0, -21 },
  { 586, 14, 21, 17, 1, -21 },
  { 623, 15, 21, 17, 1, -21 },
  { 663, 15, 21, 17, 1, -21 },
  { 703, 15, 21, 17, 1, -21 },
  { 743, 15, 21, 17, 1, -21 },
  { 783, 6, 16, 8, 1, -16 },
  { 795, 6, 20, 8, 1, -16 },
  { 810, 14, 15, 17, 1, -18 },
  { 837, 14, 9, 17, 1, -15 },
  { 853, 14, 15, 17, 1, -18 },
  { 880, 14, 21, 14, 0, -21 },
  { 917, 24, 23, 26, 1, -21 },
  { 986, 21, 21, 21, 0, -21 },
  { 1042, 16, 21, 19, 2, -21 },
  { 1084, 16, 21, 19, 2, -21 },
  { 1126, 18, 21, 21, 2, -21 },
  { 1174, 13, 21, 16, 2, -21 },
  { 1209, 12, 21, 16, 2, -21 },
  { 1241, 17, 21, 21, 2, -21 },
  { 1286, 18, 21, 22, 2, -21 },
  { 1334, 10, 21, 12, 1, -21 },
  { 1361, 9, 27, 10, -2, -21 },
  { 1392, 18, 21, 20, 2, -21 },
  { 1440, 14, 21, 17, 2, -21 },
  { 1477, 23, 21, 28, 2, -21 },
  { 1538, 19, 21, 24, 2, -21 },
  { 1588, 19, 21, 23, 2, -21 },
  { 1638, 15, 21, 18, 2, -21 },
  { 1678, 20, 26, 23, 2, -21 },
  { 1743, 17, 21, 19, 2, -21 },
  { 1788, 14, 21, 16, 1, -21 },
  { 1825, 15, 21, 17, 1, -21 },
  { 1865, 18, 21, 22, 2, -21 },
  { 1913, 19, 21, 19, 0, -21 },
  { 1963, 29, 21, 29, 0, -21 },
  { 2040, 20, 21, 20, 0, -21 },
  { 2093, 19, 21, 19, 0, -21 },
  { 2143, 16, 21, 17, 1, -21 },
  { 2185, 7, 26, 10, 2, -21 },
  { 2208, 12, 21, 12, 0, -21 },
  { 2240, 7, 26, 10, 1, -21 },
  { 2263, 16, 14, 16, 0, -21 },
  { 2291, 13, 3, 13, 0, 2 },
  { 2296, 9, 4, 11, 1, -22 },
  { 2301, 15, 16, 18, 1, -16 },
  { 2331, 15, 22, 18, 2, -22 },
  { 2373, 14, 16, 15, 1, -16 },
  { 2401, 15, 22, 18, 1, -22 },
  { 2443, 15, 16, 18, 1, -16 },
  { 2473, 12, 22, 12, 1, -22 },
  { 2506, 15, 23, 18, 1, -16 },
  { 2550, 15, 22, 19, 2, -22 },
  { 2592, 5, 22, 9, 2, -22 },
  { 2606, 9, 29, 9, -2, -22 },
  { 2639, 17, 22, 19, 2, -22 },
  { 2686, 5, 22, 9, 2, -22 },
  { 2700, 25, 16, 29, 2, -16 },
  { 2750, 15, 16, 19, 2, -16 },
  { 2780, 16, 16, 18, 1, -16 },
  { 2812, 15, 23, 18, 2, -16 },
  { 2856, 15, 23, 18, 1, -16 },
  { 2900, 11, 16, 13, 2, -16 },
  { 2922, 13, 16, 15, 1, -16 },
  { 2948, 11, 19, 13, 1, -19 },
  { 2975, 15, 16, 19, 2, -16 },
  { 3005, 17, 16, 17, 0, -16 },
  { 3039, 25, 16, 26, 0, -16 },
  { 3089, 17, 16, 17, 0, -16 },
  { 3123, 17, 23, 17, 0, -16 },
  { 3172, 13, 16, 14, 1, -16 },
  { 3198, 10, 26, 12, 1, -21 },
  { 3231, 3, 28, 15, 6, -22 },
  { 3242, 10, 26, 12, 1, -21 },
  { 3275, 14, 5, 17, 1, -13 },
};

const GFXfont NotoSans_ExtraBold29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold29pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_EXTRABOLD29PT7B_H_
