#ifndef _NOTOSANS_EXTRABOLD20PT7B_H_
#define _NOTOSANS_EXTRABOLD20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xEE, 0xE0, 0x0E, 0xFE, 0xE7, 0xE7, 0xE7, 0xE6,
  0x66, 0x0E, 0x60, 0x77, 0x03, 0x38, 0x19, 0x87, 0xFF, 0xBF, 0xFC, 0x77,
  0x03, 0xB8, 0xFF, 0xF7, 0xFF, 0x86, 0x60, 0x73, 0x03, 0xB8, 0x19, 0xC0,
  0x0C, 0x07, 0xC7, 0xFF, 0xFE, 0xEC, 0xBB, 0x0F, 0xC1, 0xFC, 0x1F, 0x83,
  0xF0, 0xDF, 0x3F, 0xFF, 0xBF, 0xC0, 0xC0, 0x30, 0x3C, 0x1C, 0x1F, 0x86,
  0x06, 0x63, 0x83, 0x9C, 0xC0, 0x67, 0x70, 0x19, 0x99, 0xC7, 0xEE, 0xF8,
  0xF3, 0x77, 0x01, 0xDD, 0xC0, 0xE7, 0x70, 0x31, 0xDC, 0x1C, 0x77, 0x06,
  0x0F, 0x83, 0x83, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xCF, 0x03, 0x9C, 0x07,
  0xF8, 0x07, 0xE0, 0x0F, 0x8F, 0x3F, 0x9C, 0xF7, 0xF9, 0xC7, 0xF3, 0x87,
  0xC7, 0xFF, 0x87, 0xFF, 0x87, 0xE7, 0xC0, 0xFF, 0xF6, 0x3B, 0x9D, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x39, 0xCE, 0x38, 0xE3, 0x9C, 0x63, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0xB9, 0xCE, 0xE0, 0x1C, 0x0E, 0x26, 0x3F, 0xFF,
  0xF9, 0xE0, 0xF8, 0xEE, 0x26, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF,
  0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x7E, 0xEE, 0xCC, 0xFF, 0xFF,
  0xC0, 0xEF, 0xE0, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0x70, 0xE0, 0x08, 0x0F, 0xC7, 0xFB, 0xCE, 0xE3, 0xB8,
  0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0xCE, 0x7F, 0x9F, 0xE3, 0xE0,
  0x0F, 0x1F, 0x7F, 0xFF, 0x6F, 0x4F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x7F, 0x3F, 0xEF, 0x79, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x3F, 0xE6, 0x78,
  0x0E, 0x03, 0x8F, 0xC3, 0xC0, 0xFE, 0x03, 0xC0, 0xF0, 0x3F, 0xFE, 0xFF,
  0xBF, 0xC0, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xE1, 0xFC, 0x37, 0x8E, 0xF3,
  0x9E, 0xE3, 0xDF, 0xFF, 0xFF, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0x7F, 0x9F,
  0xE7, 0xFB, 0xC0, 0xE0, 0x3F, 0xCF, 0xF9, 0xBE, 0x03, 0xC0, 0xF0, 0x3F,
  0xFE, 0xFF, 0xBF, 0x80, 0x1F, 0x8F, 0xE7, 0x83, 0xC0, 0xE0, 0x3F, 0xEF,
  0xFB, 0xCF, 0xE1, 0xF8, 0x7E, 0x3F, 0xFF, 0x7F, 0x8F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x81, 0xC0,
  0xF0, 0x38, 0x1E, 0x00, 0x7F, 0x3F, 0xEF, 0x3B, 0x8E, 0xF3, 0x9F, 0xC3,
  0xE1, 0xFC, 0xF3, 0xB8, 0x7E, 0x1F, 0xCF, 0xFF, 0x8F, 0xC0, 0x7F, 0x3F,
  0xEF, 0x3B, 0x8F, 0xE3, 0xF8, 0xFF, 0x7F, 0xFF, 0x7D, 0xC0, 0xE0, 0x39,
  0x7E, 0x7F, 0x1F, 0x00, 0xEF, 0xF0, 0x00, 0x00, 0xEF, 0xE0, 0xEF, 0xF0,
  0x00, 0x00, 0x7E, 0xEE, 0xCC, 0x00, 0x40, 0x70, 0x7C, 0x7E, 0x7C, 0x3C,
  0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0xF0, 0x0C, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x80, 0x30, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x7C,
  0xFC, 0xFC, 0x3C, 0x08, 0x00, 0x7F, 0x7F, 0xD8, 0xE0, 0x70, 0x38, 0x7C,
  0x78, 0x38, 0x1C, 0x00, 0x00, 0x03, 0x83, 0xC0, 0xE0, 0x0F, 0xF8, 0x1F,
  0xFC, 0x38, 0x0E, 0x71, 0xE6, 0x67, 0xF7, 0xEE, 0x73, 0xCE, 0x73, 0xCC,
  0x73, 0xCC, 0x73, 0xCE, 0x76, 0xE7, 0xFE, 0x63, 0x9C, 0x70, 0x00, 0x3E,
  0xF8, 0x1F, 0xF8, 0x01, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8,
  0x1C, 0xE0, 0x73, 0x81, 0xCF, 0x0F, 0x1C, 0x3F, 0xF0, 0xFF, 0xE7, 0xFF,
  0x9C, 0x0E, 0x70, 0x3F, 0xC0, 0xF0, 0xFF, 0xBF, 0xFE, 0x3F, 0x87, 0xE3,
  0xFF, 0xEF, 0xF3, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0xFF, 0xFF, 0xBF, 0xC0,
  0x1F, 0xE7, 0xFD, 0xF3, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x01, 0xE0, 0x3F, 0xF3, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF,
  0xEE, 0x1E, 0xE0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x1E, 0xE1,
  0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xE0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1F, 0xF3, 0xFF,
  0x7C, 0x67, 0x80, 0xF0, 0x0F, 0x00, 0xF3, 0xFF, 0x3F, 0xF3, 0xFF, 0x07,
  0x78, 0x77, 0xFF, 0x3F, 0xF1, 0xFF, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xFF, 0xFD, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0xCF, 0xFF, 0xC0, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xCF, 0xFD, 0xF0, 0xE1, 0xFE, 0x3C, 0xE3,
  0x8E, 0x78, 0xEF, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0E, 0x78, 0xE3,
  0x8E, 0x3C, 0xE1, 0xEE, 0x1F, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1F, 0xFF, 0xFF, 0xFC, 0xF8, 0x1F, 0xF0,
  0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC7, 0xFF, 0x8F, 0xFB, 0x1B, 0xF7, 0x77,
  0xEE, 0xEF, 0xDD, 0x9F, 0x9F, 0x3F, 0x3E, 0x7E, 0x78, 0xFC, 0x71, 0xC0,
  0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8, 0x7F, 0xE3, 0xF7, 0x1F, 0xBC, 0xFC,
  0xE7, 0xE7, 0xBF, 0x1D, 0xF8, 0xFF, 0xC3, 0xFE, 0x0F, 0xF0, 0x7C, 0x02,
  0x00, 0x7F, 0x83, 0xFF, 0x1F, 0x3E, 0x70, 0x7B, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0x9E, 0x1E, 0x7F, 0xF8, 0xFF, 0xC1,
  0xFC, 0x00, 0xFF, 0x3F, 0xEF, 0xFB, 0x8F, 0xE3, 0xF8, 0xFF, 0xFB, 0xFE,
  0xFE, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x02, 0x00, 0x7F, 0x83,
  0xFF, 0x1F, 0x3E, 0x70, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0x9E, 0x1E, 0x7F, 0xF8, 0xFF, 0xC1, 0xFC, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0xFF, 0x1F, 0xF3, 0x9F, 0x71, 0xEE, 0x3D, 0xC7,
  0xBF, 0xE7, 0xF8, 0xFF, 0x1C, 0xE3, 0x9E, 0x71, 0xEE, 0x1D, 0xC3, 0xC0,
  0x3F, 0xDF, 0xEF, 0x1B, 0x80, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0x80,
  0xF8, 0x3B, 0xFE, 0xFF, 0xBF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x00, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xF0, 0xEF, 0xFE, 0x7F, 0xC3, 0xF8, 0xF0,
  0x3B, 0x83, 0xDC, 0x1C, 0xF0, 0xE3, 0x8F, 0x1C, 0x70, 0xF3, 0x83, 0xBC,
  0x1D, 0xC0, 0xEE, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0xF0, 0xF0,
  0xF7, 0x0F, 0x0E, 0x70, 0xF0, 0xE7, 0x1F, 0x8E, 0x79, 0xF9, 0xE3, 0x9F,
  0x9C, 0x39, 0x99, 0xC3, 0xB9, 0xDC, 0x3B, 0x9D, 0xC1, 0xF9, 0xF8, 0x1F,
  0x9F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0xF8, 0x79, 0xE1,
  0xC3, 0xCF, 0x07, 0x78, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0xC0, 0x7F, 0x83, 0xCE, 0x0E, 0x3C, 0x78, 0x7B, 0xC0, 0xF0, 0xF0, 0x7B,
  0xC7, 0x9E, 0x38, 0x7B, 0xC1, 0xDC, 0x0F, 0xE0, 0x3E, 0x01, 0xF0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9F, 0xF8, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x0E,
  0x0E, 0x0E, 0x07, 0x07, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xFF, 0xF8, 0x0C, 0x01, 0xC0, 0x78, 0x0D, 0x83, 0xB8, 0x63, 0x1C,
  0x73, 0x06, 0xE0, 0xE0, 0xFF, 0x80, 0xF0, 0xE1, 0xC0, 0x3F, 0x1F, 0xE2,
  0x3C, 0x0F, 0x3F, 0xDF, 0xFF, 0x3F, 0x8F, 0xF3, 0xFF, 0xF7, 0xDC, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x79, 0xFF, 0xBF, 0xF7, 0x8F, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0xFD, 0xFF, 0xBB, 0xE0, 0x3F, 0xBF, 0xDF, 0xDE,
  0x0E, 0x07, 0x03, 0x81, 0xE0, 0xFF, 0xBF, 0xCF, 0xC0, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x3D, 0xDF, 0xFF, 0xFF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0xC7,
  0xFF, 0xDF, 0xF3, 0xCC, 0x3F, 0x1F, 0xEF, 0x3F, 0xC7, 0xFF, 0xFF, 0xFE,
  0x03, 0xC0, 0xF8, 0xDF, 0xF3, 0xF8, 0x1F, 0x9F, 0x8F, 0x47, 0x07, 0xF7,
  0xFB, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x3D,
  0xDF, 0xFF, 0xBF, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0xC7, 0xFB, 0xDF, 0xF3,
  0xDC, 0x07, 0x83, 0xFF, 0xFF, 0xF8, 0xF8, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x79, 0xFF, 0xBF, 0xFF, 0x8F, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1F, 0xE3, 0xFC, 0x78, 0xFF, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3C, 0xF1, 0x80, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF,
  0x3F, 0xFF, 0xBC, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0xFF, 0x3C,
  0xF3, 0x8F, 0x70, 0xFF, 0x0F, 0xF0, 0xFF, 0x8F, 0x38, 0xF3, 0xCF, 0x1E,
  0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0x9F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x7F, 0x1E, 0x3F, 0x8F, 0x1F, 0xC7,
  0x8F, 0xE3, 0xC7, 0xF1, 0xE3, 0xF8, 0xF1, 0xFC, 0x78, 0xE0, 0xE7, 0x9F,
  0xFB, 0xFF, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0xC7, 0x80, 0x3F, 0x0F, 0xF1, 0xEF, 0x78, 0xEE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x8E, 0x7B, 0xCF, 0xF0, 0xFC, 0x00, 0xE7, 0x9F, 0xFB, 0xFF, 0x78, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xFF, 0xDF, 0xFB, 0xFE, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x3D, 0xDF, 0xFF, 0xBF, 0xC7, 0xE1, 0xF8, 0x7E,
  0x1F, 0xC7, 0xFB, 0xDF, 0xF3, 0xDC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0xE7, 0xEF, 0xFF, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x7F,
  0xFF, 0xE2, 0xF0, 0xFC, 0x7F, 0x1F, 0x07, 0xC7, 0xFF, 0xFE, 0x18, 0x38,
  0x7F, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3D, 0x3F, 0x1F, 0xF1,
  0xFE, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xFF, 0xEF,
  0xFC, 0xFB, 0x80, 0xF0, 0xF7, 0x0E, 0x71, 0xE7, 0x9C, 0x39, 0xC3, 0x9C,
  0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xF1, 0xE3, 0xB8, 0xF1,
  0xDC, 0xF8, 0xEE, 0x7C, 0xE7, 0xB7, 0x71, 0xDB, 0xB8, 0xFC, 0xDC, 0x7E,
  0x7C, 0x1E, 0x3E, 0x0F, 0x1F, 0x07, 0x87, 0x00, 0xF0, 0xF7, 0x9E, 0x3F,
  0xC1, 0xFC, 0x1F, 0x80, 0xF0, 0x1F, 0x83, 0xFC, 0x39, 0xC7, 0x9E, 0xF0,
  0xF0, 0xF0, 0xF7, 0x0E, 0x70, 0xE7, 0x9C, 0x39, 0xC3, 0x9C, 0x1F, 0x81,
  0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x07, 0xE0, 0x7C, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x3C, 0x78, 0x70, 0xFF, 0xFF, 0xFF,
  0x0F, 0x1F, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xF8, 0xE0, 0xF8, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF1, 0xE1, 0xC3, 0x87, 0x0E, 0x0E, 0x1F, 0x0E, 0x7C, 0xE3, 0x87,
  0x0E, 0x1C, 0x78, 0xE0, 0x70, 0x7F, 0xFF, 0xFE, 0x0C,
};

const GFXglyph NotoSans_ExtraBold20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 14, 6, 1, -14 },
  { 8, 8, 5, 10, 1, -14 },
  { 13, 13, 14, 13, 0, -14 },
  { 36, 10, 16, 11, 1, -15 },
  { 56, 18, 14, 18, 0, -14 },
  { 88, 15, 14, 15, 1, -14 },
  { 115, 3, 5, 6, 1, -14 },
  { 117, 5, 17, 7, 1, -14 },
  { 128, 5, 17, 7, 1, -14 },
  { 139, 9, 9, 11, 1, -15 },
  { 150, 10, 10, 12, 1, -12 },
  { 163, 4, 6, 6, 1, -3 },
  { 166, 6, 3, 6, 0, -7 },
  { 169, 4, 3, 6, 1, -3 },
  { 171, 8, 14, 9, 0, -14 },
  { 185, 10, 15, 12, 1, -15 },
  { 204, 8, 14, 12, 1, -14 },
  { 218, 10, 14, 12, 1, -14 },
  { 236, 10, 14, 12, 1, -14 },
  { 254, 11, 14, 12, 0, -14 },
  { 274, 10, 14, 12, 1, -14 },
  { 292, 10, 14, 12, 1, -14 },
  { 310, 10, 14, 12, 1, -14 },
  { 328, 10, 14, 12, 1, -14 },
  { 346, 10, 14, 12, 1, -14 },
  { 364, 4, 11, 6, 1, -11 },
  { 370, 4, 14, 6, 1, -11 },
  { 377, 10, 11, 12, 1, -13 },
  { 391, 10, 6, 12, 1, -10 },
  { 399, 10, 11, 12, 1, -13 },
  { 413, 9, 14, 10, 0, -14 },
  { 429, 16, 16, 18, 1, -14 },
  { 461, 14, 14, 14, 0, -14 },
  { 486, 10, 14, 13, 2, -14 },
  { 504, 11, 14, 13, 1, -14 },
  { 524, 12, 14, 15, 2, -14 },
  { 545, 8, 14, 11, 2, -14 },
  { 559, 8, 14, 11, 2, -14 },
  { 573, 12, 14, 15, 1, -14 },
  { 594, 12, 14, 15, 2, -14 },
  { 615, 7, 14, 8, 1, -14 },
  { 628, 7, 18, 7, -2, -14 },
  { 644, 12, 14, 14, 2, -14 },
  { 665, 9, 14, 11, 2, -14 },
  { 681, 15, 14, 19, 2, -14 },
  { 708, 13, 14, 16, 2, -14 },
  { 731, 14, 15, 16, 1, -15 },
  { 758, 10, 14, 13, 2, -14 },
  { 776, 14, 18, 16, 1, -15 },
  { 808, 11, 14, 13, 2, -14 },
  { 828, 10, 14, 11, 1, -14 },
  { 846, 11, 14, 12, 0, -14 },
  { 866, 12, 14, 15, 2, -14 },
  { 887, 13, 14, 13, 0, -14 },
  { 910, 20, 14, 20, 0, -14 },
  { 945, 14, 14, 14, 0, -14 },
  { 970, 13, 14, 13, 0, -14 },
  { 993, 10, 14, 12, 1, -14 },
  { 1011, 5, 17, 7, 1, -14 },
  { 1022, 8, 14, 9, 0, -14 },
  { 1036, 5, 17, 7, 0, -14 },
  { 1047, 11, 9, 11, 0, -14 },
  { 1060, 9, 1, 9, 0, 2 },
  { 1062, 6, 3, 8, 1, -15 },
  { 1065, 10, 11, 12, 1, -11 },
  { 1079, 11, 15, 13, 1, -15 },
  { 1100, 9, 11, 11, 1, -11 },
  { 1113, 10, 15, 13, 1, -15 },
  { 1132, 10, 11, 12, 1, -11 },
  { 1146, 9, 15, 8, 0, -15 },
  { 1163, 10, 16, 13, 1, -11 },
  { 1183, 11, 15, 13, 1, -15 },
  { 1204, 4, 15, 6, 1, -15 },
  { 1212, 6, 20, 6, -1, -15 },
  { 1227, 12, 15, 13, 1, -15 },
  { 1250, 4, 15, 6, 1, -15 },
  { 1258, 17, 11, 20, 1, -11 },
  { 1282, 11, 11, 13, 1, -11 },
  { 1298, 11, 11, 13, 1, -11 },
  { 1314, 11, 16, 13, 1, -11 },
  { 1336, 10, 16, 13, 1, -11 },
  { 1356, 8, 11, 9, 1, -11 },
  { 1367, 8, 11, 10, 1, -11 },
  { 1378, 8, 13, 9, 0, -13 },
  { 1391, 11, 11, 13, 1, -11 },
  { 1407, 12, 11, 12, 0, -11 },
  { 1424, 17, 11, 18, 0, -11 },
  { 1448, 12, 11, 12, 0, -11 },
  { 1465, 12, 16, 12, 0, -11 },
  { 1489, 8, 11, 10, 1, -11 },
  { 1500, 8, 17, 8, 0, -14 },
  { 1517, 3, 19, 11, 4, -15 },
  { 1525, 7, 17, 8, 1, -14 },
  { 1540, 10, 4, 12, 1, -9 },
};

const GFXfont NotoSans_ExtraBold20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold20pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_EXTRABOLD20PT7B_H_
