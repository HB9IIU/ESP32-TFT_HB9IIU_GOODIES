#ifndef _NOTOSANS_EXTRABOLD31PT7B_H_
#define _NOTOSANS_EXTRABOLD31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold31pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xC0, 0x01, 0xE7, 0xFF, 0x7D, 0xF0, 0xF9, 0xFF, 0x9E, 0xF9, 0xEF, 0x1E,
  0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0E,
  0x3C, 0x03, 0xC7, 0x80, 0x78, 0xE0, 0x0F, 0x1C, 0x1F, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE1, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x9E, 0x00, 0xE3,
  0xC1, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x1E, 0x78, 0x03, 0x8F,
  0x00, 0x71, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x79, 0xE0, 0x00, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFC, 0xF9, 0x84, 0xF9, 0x80, 0xFD, 0x80, 0xFF, 0x80, 0x7F, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0x9F, 0x81, 0x9F, 0xF1,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC, 0x1F, 0xE0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x3F, 0x00, 0x78, 0x0F, 0xF0, 0x1F, 0x03, 0xFF, 0x03,
  0xC0, 0x79, 0xE0, 0xF0, 0x0F, 0x3E, 0x1E, 0x01, 0xE3, 0xC7, 0x80, 0x3C,
  0x78, 0xF0, 0x07, 0x8F, 0x3C, 0x00, 0xF3, 0xE7, 0x84, 0x1E, 0x79, 0xE7,
  0xF1, 0xFF, 0x7D, 0xFF, 0x3F, 0xCF, 0x3F, 0xE3, 0xF3, 0xCF, 0x3C, 0x00,
  0x79, 0xE3, 0xC0, 0x1E, 0x3C, 0x78, 0x03, 0xC7, 0x8F, 0x00, 0xF0, 0xF1,
  0xE0, 0x1E, 0x1E, 0x3C, 0x07, 0x83, 0xEF, 0x01, 0xF0, 0x3F, 0xE0, 0x3C,
  0x07, 0xF8, 0x0F, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x83, 0xF1, 0xFF, 0x87, 0xE7, 0xFF, 0x8F, 0x8F, 0x9F, 0xBF, 0x3F, 0x1F,
  0xFC, 0x7E, 0x1F, 0xF8, 0xFC, 0x1F, 0xE1, 0xFC, 0x3F, 0x81, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0x1F, 0xC0, 0xFF, 0xFF,
  0xEF, 0x7B, 0xDE, 0x0F, 0x8F, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF0,
  0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x1E,
  0x0F, 0x87, 0xC3, 0xE0, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x07, 0xC3, 0xE0, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8,
  0x78, 0x7C, 0x3C, 0x3E, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x1C,
  0x08, 0x38, 0x3F, 0x77, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0,
  0x7F, 0x80, 0xF7, 0x83, 0xCF, 0x87, 0x8F, 0x03, 0x18, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x7D, 0xF7, 0xDE, 0x7B, 0xEF, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0x79, 0xFF, 0xDF, 0x7C, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03,
  0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC,
  0x7F, 0xFC, 0x7C, 0x7E, 0x7C, 0x3E, 0xFC, 0x3E, 0xFC, 0x3F, 0xF8, 0x3F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7E, 0x7E, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xF0, 0x03, 0xE0, 0xFC, 0x3F, 0x9F, 0xF7, 0xFF, 0xFF, 0xFE, 0xFB,
  0x9F, 0x23, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x1F, 0xF0, 0x3F,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFE, 0x7C, 0x7E, 0x30, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFE, 0x30, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x03, 0xFC, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x07,
  0xFC, 0x0F, 0xFC, 0x0F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x7C,
  0x7C, 0xF8, 0x7C, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x3F, 0xFC, 0x7F,
  0xF8, 0xFF, 0xF3, 0xFF, 0xE7, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7F, 0xF0, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0x8F, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x40, 0xFB, 0xF8, 0xFF, 0xFC, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x7C,
  0x1F, 0x7E, 0x3F, 0x7F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFC, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x7F,
  0xFE, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7E, 0x7E, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x7E, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFF, 0xFE, 0x7F, 0xFE, 0x3F,
  0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0xFC,
  0x7E, 0xF8, 0x3E, 0xF8, 0x3F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFF,
  0xFF, 0x7F, 0xFF, 0x3F, 0xDF, 0x1F, 0xDE, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7E, 0x00, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xE0, 0x3F, 0x80, 0x7D,
  0xFF, 0xDF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x79, 0xFF, 0xDF, 0x7C,
  0x7D, 0xF7, 0xDF, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xDF,
  0x79, 0xEF, 0xBC, 0xF0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7F,
  0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x0F,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0xFF, 0x80, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x3F, 0xF1, 0xFF, 0xF1,
  0xFF, 0xF3, 0xFF, 0xE3, 0x07, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xF8, 0x07, 0xC1, 0xF0, 0x01, 0xF1, 0xF0, 0x78, 0x78, 0xF1, 0xFF, 0x9E,
  0xF1, 0xFF, 0xCF, 0x79, 0xF9, 0xE3, 0xBC, 0xF0, 0xF1, 0xDC, 0x78, 0x78,
  0xFE, 0x78, 0x3C, 0x7F, 0x3C, 0x1E, 0x3F, 0x9E, 0x0F, 0x3F, 0xC7, 0x8F,
  0x9E, 0xE3, 0xFF, 0xFE, 0x78, 0xFF, 0xFF, 0x3C, 0x7F, 0x3F, 0x0F, 0x04,
  0x04, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03, 0x00, 0x7F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0x7C, 0x00, 0x7C, 0xF8,
  0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03,
  0xE1, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x9F, 0x80, 0x7E,
  0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xF0, 0xFF, 0xF0, 0xFF, 0xFC, 0xFF, 0xFE,
  0xFF, 0xFE, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0xFE,
  0xFF, 0xFC, 0xFF, 0xF0, 0xFF, 0xFE, 0xF9, 0xFE, 0xF8, 0x3F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xF0, 0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xE7, 0xF0,
  0x73, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x81, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF0, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF8, 0x7F,
  0xBE, 0x07, 0xEF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x7E, 0xF8, 0x3F, 0xBE, 0x7F, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8,
  0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x03, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFE, 0x7F, 0x81, 0x9F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x1F, 0xFF, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0x7E, 0x07, 0xDF, 0xC1, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1,
  0xFF, 0xE0, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xC1, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0xFF, 0xBF, 0xEF, 0xF3, 0xF8, 0xF0, 0x00,
  0xF8, 0x0F, 0xFE, 0x07, 0xEF, 0x83, 0xF3, 0xE1, 0xF8, 0xF8, 0x7C, 0x3E,
  0x3F, 0x0F, 0x9F, 0x83, 0xEF, 0xC0, 0xFB, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0x7E, 0x0F, 0x8F, 0x83, 0xE3, 0xF0,
  0xF8, 0x7E, 0x3E, 0x1F, 0x8F, 0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x1F, 0xBE,
  0x03, 0xF0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0xF7, 0x83, 0xFF, 0xF7, 0x83, 0xDF, 0xF7, 0xC3, 0xDF, 0xF3,
  0xC3, 0xDF, 0xF3, 0xC7, 0x9F, 0xF3, 0xE7, 0x9F, 0xF1, 0xE7, 0x9F, 0xF1,
  0xEF, 0x1F, 0xF1, 0xEF, 0x1F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFE, 0x1F, 0xF0,
  0xFE, 0x1F, 0xF0, 0xFE, 0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0x7C, 0x1F, 0xFE,
  0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF,
  0xFC, 0x1F, 0xF7, 0xC1, 0xFF, 0x7E, 0x1F, 0xF3, 0xE1, 0xFF, 0x3F, 0x1F,
  0xF1, 0xF1, 0xFF, 0x1F, 0x9F, 0xF0, 0xF9, 0xFF, 0x0F, 0xDF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0, 0x7F, 0x7F, 0x01, 0xFB, 0xF0, 0x07,
  0xDF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7E,
  0x7E, 0x03, 0xF3, 0xF8, 0x7F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0xFF,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0xFF, 0xEF,
  0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xFF,
  0xF7, 0xFF, 0xEF, 0xFF, 0x9F, 0xFC, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xF0, 0x7F, 0x7F,
  0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x7E, 0x7E, 0x03, 0xF3, 0xF8, 0x7F, 0x8F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0xFF, 0xE0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x7E, 0x3E, 0x0F, 0x8F, 0x83,
  0xE3, 0xE0, 0xF8, 0xF8, 0x7E, 0x3E, 0x3F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0x9F, 0x83, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x8F, 0x83, 0xF3, 0xE0, 0xFC, 0xF8, 0x1F, 0xBE, 0x07, 0xF0, 0x0F,
  0xFC, 0x7F, 0xFC, 0xFF, 0xFB, 0xFF, 0xE7, 0xC0, 0xCF, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00,
  0xFB, 0xE0, 0x3F, 0x7E, 0x07, 0xEF, 0xE3, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0x9F,
  0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xE0, 0x3E, 0x1F, 0x03, 0xF0, 0xFC, 0x1F,
  0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x7E, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF9, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0xF8, 0x0F, 0x80, 0xF9,
  0xF0, 0x3F, 0x81, 0xF3, 0xE0, 0x7F, 0x03, 0xE7, 0xC0, 0xFE, 0x07, 0xC7,
  0xC1, 0xFC, 0x1F, 0x0F, 0x87, 0xBC, 0x3E, 0x1F, 0x0F, 0x78, 0x7C, 0x3E,
  0x1E, 0xF0, 0xF8, 0x3E, 0x3D, 0xE3, 0xE0, 0x7C, 0xFB, 0xE7, 0xC0, 0xF9,
  0xE3, 0xCF, 0x81, 0xF3, 0xC7, 0x9F, 0x01, 0xE7, 0x8F, 0x3C, 0x03, 0xEF,
  0x1E, 0xF8, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF9, 0xF0, 0x1F, 0x8F,
  0xC1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0xFC, 0x07, 0xE7, 0xC0, 0x1F, 0x7E,
  0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFB, 0xF0,
  0x0F, 0x8F, 0xC0, 0xFC, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE7, 0xE0,
  0x3F, 0x7E, 0x00, 0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE3,
  0xF0, 0xFC, 0x3F, 0x0F, 0x81, 0xF1, 0xF8, 0x0F, 0x9F, 0x00, 0xF9, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xFF, 0xFF, 0xF8, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0xFF, 0xFF,
  0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0xFF, 0xFF, 0xF8, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3D,
  0xE0, 0x3C, 0xF0, 0x1E, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x87, 0x03, 0xC7,
  0x80, 0xF7, 0xC0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x1F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x0F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x1F,
  0x7E, 0x10, 0x3F, 0x00, 0x1F, 0x01, 0xFF, 0x1F, 0xFF, 0x7F, 0xFF, 0x7E,
  0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFE, 0xFF, 0x7F, 0xFF, 0x7F,
  0xCF, 0x3F, 0x8F, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFB,
  0xFC, 0xF1, 0xF8, 0x07, 0xFE, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC7, 0xE0,
  0x8F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0xCF, 0xFF, 0x8F, 0xFF, 0x0F, 0xFE, 0x07, 0xF8, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x1F, 0xBF, 0x3F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xEF, 0xC7,
  0xF7, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xDF, 0x07, 0xEF, 0xC3, 0xF7, 0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xBE,
  0x1F, 0x9F, 0x07, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x7F, 0x7F, 0x7C, 0x1F,
  0x7C, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x01, 0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC,
  0x03, 0xE0, 0xFF, 0x1F, 0xF3, 0xFF, 0x3F, 0x13, 0xE0, 0x3E, 0x07, 0xFE,
  0xFF, 0xEF, 0xFE, 0xFF, 0xE3, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x0F, 0xCF, 0x8F, 0xF7, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xE1, 0xFB, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xEF,
  0x83, 0xF7, 0xE1, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x0F, 0xDF,
  0x80, 0x0F, 0xC0, 0x07, 0xC8, 0x07, 0xE7, 0xFF, 0xF3, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFF, 0xF0, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF9, 0xFC, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0x73, 0xEF, 0xFF, 0x78, 0x00, 0x3E, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0x07, 0x03, 0xE0,
  0xFC, 0x3F, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFB, 0xFE, 0xFF, 0xBF, 0xCF, 0xE0,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x7E, 0xF8, 0x3F, 0x3E, 0x1F, 0x8F, 0x8F,
  0xC3, 0xE3, 0xE0, 0xF9, 0xF8, 0x3E, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0xCF, 0xC3, 0xE1, 0xF8, 0xF8, 0x7E, 0x3E,
  0x0F, 0xCF, 0x81, 0xFB, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xFC, 0x7F,
  0x3E, 0xFF, 0xBF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0x87, 0xFF, 0x0F, 0xC1, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0, 0x7C, 0x1F, 0xF8,
  0x1F, 0x07, 0xFE, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0x7C, 0x1F,
  0xF8, 0x1F, 0x07, 0xFE, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0x7C,
  0x1F, 0xF8, 0x1F, 0x07, 0xC0, 0xF1, 0xFC, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xFF, 0xE7,
  0xE1, 0xF3, 0xE0, 0xFD, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x07,
  0xDF, 0x03, 0xEF, 0x83, 0xF7, 0xE1, 0xF1, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F,
  0xF8, 0x07, 0xF8, 0x00, 0xF9, 0xF8, 0xFB, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0xFE, 0xFF, 0xFE, 0xFB, 0xFC,
  0xF9, 0xF8, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xCF, 0x9F, 0xF7, 0xCF, 0xFF, 0xEF, 0xFF,
  0xF7, 0xE1, 0xFB, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xEF, 0x83, 0xF7, 0xE1, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE,
  0x7F, 0xFF, 0x0F, 0xDF, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xF1, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xEF, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0xE7, 0xFF, 0xBF, 0x1C, 0xF8, 0x13, 0xF8, 0x07, 0xF8, 0x1F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFB, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFC, 0x7F, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xFF, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0x7F, 0xEF, 0x1F, 0xCF, 0xFC, 0x07, 0xDF,
  0x03, 0xF7, 0xC0, 0xF9, 0xF8, 0x3E, 0x3E, 0x1F, 0x8F, 0x87, 0xC3, 0xE1,
  0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x03, 0xCF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x1F, 0x83, 0xEF, 0x87, 0xF0, 0x7D, 0xF0, 0xFE, 0x1F, 0x3E, 0x1F,
  0xC3, 0xE3, 0xE3, 0xBC, 0x7C, 0x7C, 0xF7, 0x8F, 0x0F, 0x9E, 0xF3, 0xE1,
  0xF3, 0xDE, 0x7C, 0x1E, 0x79, 0xEF, 0x83, 0xEE, 0x3D, 0xE0, 0x7F, 0xC7,
  0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03,
  0xF8, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFE, 0x0F,
  0xCF, 0xC3, 0xF0, 0xFC, 0x7E, 0x0F, 0x9F, 0x81, 0xFB, 0xE0, 0x1F, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFF, 0x01, 0xFB, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xE3, 0xF0, 0x7E,
  0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xDF, 0x03, 0xF7, 0xC0, 0xF9, 0xF8, 0x3E,
  0x3E, 0x1F, 0x8F, 0x87, 0xC1, 0xF1, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x03,
  0xEF, 0x80, 0xFB, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xFB, 0xFF,
  0xEF, 0xFF, 0xBF, 0xFE, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xF1, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x7F, 0x8F, 0xE1, 0xF0, 0x3F, 0x87,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x7F,
  0x0F, 0xE1, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0xC3,
  0xF8, 0x7F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C,
  0x0F, 0xF0, 0xFE, 0x07, 0xC3, 0xF8, 0xFE, 0x1F, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x87, 0xF0, 0xFE, 0x1F, 0x83, 0xE0, 0x00, 0x1C,
  0x01, 0x7F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE, 0x80, 0x78,
};

const GFXglyph NotoSans_ExtraBold31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 6, 22, 9, 1, -22 },
  { 18, 12, 8, 16, 2, -22 },
  { 30, 19, 22, 20, 1, -22 },
  { 83, 16, 26, 18, 1, -24 },
  { 135, 27, 22, 29, 1, -22 },
  { 210, 23, 22, 24, 1, -22 },
  { 274, 5, 8, 9, 2, -22 },
  { 279, 9, 27, 11, 1, -22 },
  { 310, 9, 27, 11, 1, -22 },
  { 341, 15, 15, 17, 1, -24 },
  { 370, 16, 15, 18, 1, -18 },
  { 400, 6, 8, 9, 1, -4 },
  { 406, 8, 4, 10, 1, -10 },
  { 410, 6, 5, 9, 1, -5 },
  { 414, 13, 22, 13, 0, -22 },
  { 450, 16, 22, 18, 1, -22 },
  { 494, 11, 22, 18, 2, -22 },
  { 525, 16, 22, 18, 1, -22 },
  { 569, 16, 22, 18, 1, -22 },
  { 613, 16, 22, 18, 1, -22 },
  { 657, 15, 22, 18, 1, -22 },
  { 699, 16, 22, 18, 1, -22 },
  { 743, 16, 22, 18, 1, -22 },
  { 787, 16, 22, 18, 1, -22 },
  { 831, 16, 22, 18, 1, -22 },
  { 875, 6, 17, 9, 1, -17 },
  { 888, 6, 21, 9, 1, -17 },
  { 904, 16, 17, 18, 1, -20 },
  { 938, 16, 10, 18, 1, -16 },
  { 958, 16, 17, 18, 1, -20 },
  { 992, 15, 22, 15, 0, -22 },
  { 1034, 25, 24, 28, 1, -22 },
  { 1109, 22, 22, 22, 0, -22 },
  { 1170, 16, 22, 21, 3, -22 },
  { 1214, 17, 22, 20, 2, -22 },
  { 1261, 18, 22, 23, 3, -22 },
  { 1311, 13, 22, 17, 3, -22 },
  { 1347, 12, 22, 17, 3, -22 },
  { 1380, 18, 22, 23, 2, -22 },
  { 1430, 18, 22, 24, 3, -22 },
  { 1480, 11, 22, 13, 1, -22 },
  { 1511, 10, 29, 11, -2, -22 },
  { 1548, 18, 22, 21, 3, -22 },
  { 1598, 14, 22, 18, 3, -22 },
  { 1637, 24, 22, 30, 3, -22 },
  { 1703, 20, 22, 26, 3, -22 },
  { 1758, 21, 22, 25, 2, -22 },
  { 1816, 15, 22, 19, 3, -22 },
  { 1858, 21, 27, 25, 2, -22 },
  { 1929, 18, 22, 21, 3, -22 },
  { 1979, 15, 22, 17, 1, -22 },
  { 2021, 16, 22, 18, 1, -22 },
  { 2065, 19, 22, 23, 2, -22 },
  { 2118, 21, 22, 21, 0, -22 },
  { 2176, 31, 22, 31, 0, -22 },
  { 2262, 21, 22, 22, 0, -22 },
  { 2320, 20, 22, 20, 0, -22 },
  { 2375, 17, 22, 18, 1, -22 },
  { 2422, 7, 27, 10, 2, -22 },
  { 2446, 13, 22, 13, 0, -22 },
  { 2482, 7, 27, 10, 1, -22 },
  { 2506, 17, 14, 17, 0, -22 },
  { 2536, 14, 3, 14, 0, 2 },
  { 2542, 10, 5, 12, 1, -24 },
  { 2549, 16, 17, 19, 1, -17 },
  { 2583, 16, 24, 20, 2, -24 },
  { 2631, 15, 17, 16, 1, -17 },
  { 2663, 17, 24, 20, 1, -24 },
  { 2714, 16, 17, 19, 1, -17 },
  { 2748, 12, 24, 12, 1, -24 },
  { 2784, 17, 24, 20, 1, -17 },
  { 2835, 16, 24, 20, 2, -24 },
  { 2883, 6, 24, 10, 2, -24 },
  { 2901, 10, 31, 10, -2, -24 },
  { 2940, 18, 24, 20, 2, -24 },
  { 2994, 5, 24, 10, 2, -24 },
  { 3009, 26, 17, 31, 2, -17 },
  { 3065, 16, 17, 20, 2, -17 },
  { 3099, 17, 17, 20, 1, -17 },
  { 3136, 16, 24, 20, 2, -17 },
  { 3184, 17, 24, 20, 1, -17 },
  { 3235, 12, 17, 14, 2, -17 },
  { 3261, 14, 17, 16, 1, -17 },
  { 3291, 12, 21, 14, 1, -21 },
  { 3323, 16, 17, 20, 2, -17 },
  { 3357, 18, 17, 18, 0, -17 },
  { 3396, 27, 17, 27, 0, -17 },
  { 3454, 19, 17, 19, 0, -17 },
  { 3495, 18, 24, 18, 0, -17 },
  { 3549, 14, 17, 15, 1, -17 },
  { 3579, 11, 27, 13, 1, -22 },
  { 3617, 4, 31, 16, 6, -24 },
  { 3633, 11, 27, 13, 1, -22 },
  { 3671, 16, 6, 18, 1, -14 },
};

const GFXfont NotoSans_ExtraBold31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold31pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_EXTRABOLD31PT7B_H_
