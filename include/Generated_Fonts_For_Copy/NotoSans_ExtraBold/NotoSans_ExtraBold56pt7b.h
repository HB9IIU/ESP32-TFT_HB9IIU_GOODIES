#ifndef _NOTOSANS_EXTRABOLD56PT7B_H_
#define _NOTOSANS_EXTRABOLD56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFF, 0x7F, 0x9F, 0xE7,
  0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFE, 0x0C, 0x00, 0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0xE7, 0xF8,
  0x7F, 0x9F, 0xE1, 0xFE, 0x7F, 0x87, 0xF9, 0xFE, 0x1F, 0xE7, 0xF8, 0x7F,
  0x9F, 0xE1, 0xFE, 0x7F, 0x87, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0x9F,
  0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x83, 0xF8,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xCF, 0x07, 0xCF, 0xF8, 0xF0, 0x08, 0xFF,
  0x8F, 0x00, 0x0F, 0xF8, 0xF0, 0x00, 0xFF, 0xCF, 0x00, 0x0F, 0xFE, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0x3F, 0xF0, 0x00, 0xF1, 0xFF, 0x00, 0x0F, 0x0F, 0xF8, 0x00,
  0xF0, 0xFF, 0xF0, 0x0F, 0x1F, 0xFF, 0xF0, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0xFF, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x87,
  0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0xFE, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x3F, 0x83, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE,
  0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0xFE, 0x07, 0x80, 0x3F,
  0x87, 0xF8, 0xFE, 0x1F, 0xF8, 0x1F, 0xE3, 0xF8, 0xFF, 0x1F, 0xFE, 0x0F,
  0xFB, 0xFC, 0x7F, 0x1F, 0xFF, 0x83, 0xFF, 0xFE, 0x7F, 0x9F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x3F, 0x8F, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xCF, 0xFB, 0xFC,
  0x1F, 0xFE, 0x1F, 0xC7, 0xF8, 0xFF, 0x03, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F,
  0x80, 0x10, 0x0F, 0xE1, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x83,
  0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF1, 0xFF, 0xCF, 0xFC, 0x1F, 0xF8, 0x7F, 0xF7, 0xFE, 0x1F, 0xF8, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x7F, 0xF8, 0x07,
  0xFF, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x05, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xDF, 0xEF, 0xF7, 0xFB, 0xFD, 0xFE, 0xFF,
  0x7F, 0xBF, 0x9F, 0xCF, 0xE7, 0xF3, 0xF8, 0x01, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07,
  0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x04, 0x01, 0xF8, 0x02, 0x78, 0x1F, 0x81,
  0xE7, 0xF9, 0xF8, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x9F, 0xE0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0x20, 0x20, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0xFF, 0x9F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x83, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xF0, 0xFF, 0xC7,
  0xFE, 0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0,
  0x3F, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xF7, 0xFC, 0x03,
  0xFF, 0x7F, 0xC0, 0x3F, 0xE7, 0xFE, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xE3,
  0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xF7, 0xFC, 0xFF, 0x9F, 0x87, 0xFC, 0x78, 0x3F, 0xE1, 0x81,
  0xFF, 0x08, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFB, 0xFF, 0xE3,
  0xFC, 0x07, 0xFE, 0x1F, 0x00, 0x3F, 0xE0, 0xC0, 0x03, 0xFE, 0x08, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xC1, 0xFF, 0xE1,
  0xE0, 0x07, 0xFE, 0x08, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0x7F, 0xC0, 0x03, 0xFD, 0xFF, 0x00,
  0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0x1F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0, 0x1F,
  0xE1, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0xE0, 0x1F,
  0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x82, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0x00, 0x0F,
  0xFE, 0xFC, 0x07, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF3, 0xFF, 0xE0, 0xFF, 0xBF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFC, 0x3F, 0xFB, 0xFF, 0x80, 0xFF, 0xDF, 0xF8, 0x03, 0xFE, 0xFF,
  0xC0, 0x1F, 0xF7, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF9, 0xFF, 0x80, 0x7F,
  0xCF, 0xFC, 0x07, 0xFE, 0x3F, 0xF8, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x02, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFD, 0xFF, 0xE7, 0xFE, 0x07, 0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xE3,
  0xFF, 0x0F, 0xFC, 0x1F, 0xFD, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0x9F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE7, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xF7, 0xFF, 0x9F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFC, 0x03,
  0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xF1, 0xFF,
  0xFC, 0xFF, 0x0F, 0xFF, 0x9F, 0xF0, 0x3F, 0xF1, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0x83, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xF8, 0x30, 0x1F, 0x87, 0xF9, 0xFF, 0xBF, 0xF7,
  0xFE, 0xFF, 0xDF, 0xF9, 0xFF, 0x3F, 0xC0, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC, 0xFF, 0x9F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0x80, 0xFF, 0xC7, 0x00, 0x1F, 0xF1, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0x07, 0xF8, 0x0F, 0xFF, 0xF1, 0xFC, 0x1F,
  0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8,
  0x3F, 0xFF, 0xFC, 0x1F, 0x8F, 0xE1, 0xFF, 0x87, 0xF0, 0x7E, 0x7F, 0x07,
  0xF8, 0x1F, 0xC1, 0xFD, 0xFC, 0x3F, 0xC0, 0x7F, 0x07, 0xF7, 0xF0, 0xFE,
  0x01, 0xFC, 0x1F, 0xDF, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x7E, 0x0F, 0xE0,
  0x1F, 0xC1, 0xFD, 0xF8, 0x7F, 0x80, 0x7F, 0x07, 0xFF, 0xE1, 0xFC, 0x01,
  0xFC, 0x1F, 0xFF, 0x87, 0xF0, 0x07, 0xF0, 0x7E, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC1, 0xF9, 0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xE7, 0xE0, 0xFE, 0x03, 0xFC,
  0x3F, 0x9F, 0xC3, 0xFC, 0x1F, 0xF1, 0xFC, 0x7F, 0x07, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xF0, 0x3F, 0xFF, 0x7F, 0xFC,
  0x0F, 0xE0, 0x7F, 0xF8, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xC1, 0xFF, 0x00,
  0xFF, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xEF, 0xF8, 0x00,
  0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xE0, 0xFF, 0xFE, 0xFF, 0x80, 0x3F, 0xFB, 0xFE, 0x00, 0x7F,
  0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x07, 0xFE, 0xFF, 0x80, 0x1F, 0xFB,
  0xFE, 0x00, 0xFF, 0xCF, 0xF8, 0x03, 0xFF, 0x3F, 0xE0, 0x7F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xE0, 0x1F, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x7F,
  0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC7, 0xF8, 0x3F, 0xFC, 0x00, 0xF0, 0xFF, 0xF0, 0x00, 0x21,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x02, 0x3F, 0xFE, 0x00,
  0x3C, 0x3F, 0xFF, 0x87, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x7F,
  0xFE, 0x7F, 0xC0, 0x0F, 0xFF, 0x3F, 0xE0, 0x03, 0xFF, 0xDF, 0xF0, 0x00,
  0xFF, 0xEF, 0xF8, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x1F, 0xFB, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xBF,
  0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0xFF, 0xEF, 0xF8, 0x00, 0x7F, 0xF7,
  0xFC, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x7F, 0xF9, 0xFF, 0x00, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF1,
  0xFE, 0x07, 0xFF, 0xC0, 0x03, 0x83, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0xE0,
  0x00, 0x7F, 0xDF, 0xFC, 0x00, 0x1F, 0xF3, 0xFF, 0x80, 0x07, 0xFC, 0xFF,
  0xE0, 0x01, 0xFF, 0x3F, 0xFE, 0x00, 0x7F, 0xC7, 0xFF, 0xF8, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xE0,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x07, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xBF,
  0xE0, 0x03, 0xFF, 0x9F, 0xF0, 0x01, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x87,
  0xFC, 0x01, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0xE0,
  0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x7F, 0xF0,
  0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xBF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF7, 0xFE, 0x00, 0x7F, 0xE1,
  0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xFC, 0x3F,
  0xE0, 0x07, 0xFF, 0x1F, 0xF0, 0x03, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xE7,
  0xFC, 0x00, 0x7F, 0xF3, 0xFE, 0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x7F, 0x00, 0x1F, 0xDF, 0xFF, 0xF7, 0xF8, 0x01, 0xFD, 0xFF, 0xFF, 0x7F,
  0x80, 0x3F, 0xDF, 0xFF, 0xF3, 0xF8, 0x03, 0xF9, 0xFF, 0xFF, 0x3F, 0xC0,
  0x3F, 0x9F, 0xFF, 0xF3, 0xFC, 0x07, 0xF9, 0xFF, 0xFF, 0x3F, 0xC0, 0x7F,
  0x1F, 0xFF, 0xF1, 0xFC, 0x07, 0xF1, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F,
  0xFF, 0xF1, 0xFE, 0x0F, 0xE1, 0xFF, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xFF,
  0xF0, 0xFF, 0x0F, 0xE1, 0xFF, 0xFF, 0x0F, 0xF1, 0xFE, 0x1F, 0xFF, 0xF0,
  0x7F, 0x1F, 0xC1, 0xFF, 0xFF, 0x07, 0xF9, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xBF, 0xC1, 0xFF, 0xFF, 0x07, 0xFB, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xBF,
  0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xF7, 0xFE, 0x00, 0xFF,
  0xFF, 0x3F, 0xF0, 0x0F, 0xFF, 0xF1, 0xFF, 0x80, 0xFF, 0xFF, 0x1F, 0xF8,
  0x0F, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF, 0xF0,
  0x7F, 0xE0, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xF0, 0xFF,
  0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0xFF, 0x00, 0xFF,
  0xCF, 0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xFF, 0xF0,
  0x07, 0xFE, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0xFF, 0xC3, 0xFF, 0x80, 0x07,
  0xFF, 0x9F, 0xFC, 0x00, 0x0F, 0xFE, 0x7F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF,
  0x80, 0x00, 0x7F, 0xF7, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x07, 0xFF, 0x7F, 0xE0,
  0x00, 0x1F, 0xFD, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFF, 0x00, 0x03, 0xFF,
  0x8F, 0xFE, 0x00, 0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0xFF,
  0xEF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xF8, 0x0F, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0xFF, 0xE3, 0xFF, 0x80, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xFF, 0x9F, 0xF8, 0x00,
  0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x0F, 0xFD,
  0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xF7, 0xFE, 0x00,
  0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x01, 0xFF,
  0xBF, 0xF0, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xC0,
  0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x3F,
  0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x01, 0xFF, 0xCF, 0xFE,
  0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x00, 0x3F,
  0xFC, 0x3F, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x0F,
  0xF8, 0x03, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0xC1,
  0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xFC, 0x07,
  0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x7F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFE, 0x1F, 0xF0,
  0x03, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x7F, 0xF3, 0xFE,
  0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x7F,
  0x3F, 0xF0, 0x03, 0xCF, 0xFC, 0x00, 0x13, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFD, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0xFF, 0xDF, 0xF8, 0x00,
  0x7F, 0xE7, 0xFF, 0x00, 0x1F, 0xF9, 0xFF, 0xE0, 0x0F, 0xFE, 0x3F, 0xFF,
  0xBF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0x80,
  0x01, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x7F, 0xC0, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x1F, 0xF7,
  0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFC,
  0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFF, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xE7,
  0xF0, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE7, 0xF8, 0x1F, 0xE0, 0x07, 0xFC,
  0x1F, 0xE7, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F, 0xE0,
  0x07, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC0, 0x03, 0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F,
  0xC3, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0xC0, 0x01,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0x81, 0xFE, 0x7F,
  0x80, 0x01, 0xFF, 0x7F, 0x81, 0xFE, 0xFF, 0x80, 0x01, 0xFF, 0x7F, 0x81,
  0xFE, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F,
  0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF,
  0xC0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0x03,
  0xFF, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xC0, 0x01, 0xFF,
  0x81, 0xFF, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xFF, 0x83, 0xFF,
  0x80, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xF7, 0xFE,
  0x00, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0xFF, 0xE3, 0xFF, 0x00, 0x0F, 0xFC,
  0x3F, 0xF8, 0x01, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0x9F,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xE0, 0x1F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFD, 0xFF, 0xF0, 0x38, 0x03, 0xFF, 0x02, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0x81, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF1, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0x3F, 0xFF, 0xC7, 0xF1, 0xFF, 0xF8,
  0x7F, 0x07, 0xFE, 0x03, 0xF0, 0x05, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC7, 0xFF, 0x83, 0xFE,
  0x7F, 0xFE, 0x1F, 0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xF1, 0xFF, 0xEF, 0xFE, 0x03, 0xFF,
  0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFD, 0xFF, 0xF1, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0x3F, 0xFF,
  0x87, 0xF8, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0,
  0x7C, 0x7F, 0xF0, 0x04, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0B, 0xFF, 0x80, 0x0C,
  0xFF, 0xF0, 0x3E, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x1F, 0xE1, 0xFF, 0x83, 0xFF, 0xCF, 0xFC, 0x3F, 0xFF, 0x7F, 0xE3, 0xFF,
  0xFD, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0xFF,
  0xE0, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFD, 0xFF, 0x0F, 0xFF, 0xCF, 0xF8, 0x3F, 0xFC, 0x3F,
  0xC0, 0xFF, 0xC1, 0xFE, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xE3, 0xFF, 0x8F, 0xFC, 0x07,
  0xFE, 0x7F, 0xC0, 0x1F, 0xF7, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFD,
  0xFF, 0x00, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x8F, 0xFE, 0x00, 0x1C, 0x7F,
  0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x03, 0xFF, 0x8C, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF8,
  0x3F, 0xFC, 0x7F, 0xC3, 0xFF, 0xF3, 0xFE, 0x3F, 0xFF, 0xDF, 0xF3, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xFE, 0x0F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0x83, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0x7F,
  0xE0, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0xC0, 0x00, 0x7F, 0xE7, 0xE0, 0x0F, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC7, 0xFF, 0xC3, 0xFE, 0x7F, 0xFF, 0x1F, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFE,
  0x3F, 0x3F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB,
  0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF,
  0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xFB, 0xFE, 0xFF, 0xBF, 0xEF,
  0xFB, 0xFE, 0xFF, 0xBF, 0xEF, 0xF8, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x7F,
  0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFE,
  0x87, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xE3, 0xFF, 0xE1, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x1F,
  0xFC, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x7F,
  0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0x83, 0xFF,
  0x80, 0xFF, 0x87, 0xFF, 0x00, 0xFF, 0x8F, 0xFE, 0x00, 0xFF, 0x8F, 0xFC,
  0x00, 0xFF, 0x9F, 0xF8, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0xFF, 0xC1, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F,
  0xF0, 0xFF, 0xC0, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F,
  0xFC, 0xFF, 0xC0, 0x0F, 0xFE, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xC1, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0xE3, 0xFC, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE7, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x7F, 0xFC, 0x3F, 0xCF, 0xFF, 0xF1,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC, 0x1F, 0xFC,
  0x7F, 0xE0, 0x3F, 0xFB, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0xBF,
  0xF0, 0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0xFF, 0xC0, 0x0F,
  0xFB, 0xFF, 0x00, 0x7F, 0xE7, 0xFE, 0x01, 0xFF, 0x9F, 0xFC, 0x0F, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x7F,
  0xF8, 0x3F, 0xC7, 0xFF, 0xE1, 0xFF, 0x7F, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0x1F, 0xFE, 0xFF,
  0xE0, 0x3F, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xDF, 0xFE, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFB, 0xFF, 0xF8, 0x7F, 0xCF, 0xFF, 0x83, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0,
  0x08, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x3F, 0xFC, 0x7F, 0xC3, 0xFF, 0xF3, 0xFE, 0x3F, 0xFF, 0xDF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xEF, 0xFE, 0x0F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xDF, 0xF1, 0xFF, 0xFD, 0xFF, 0x83, 0xFF, 0xCF, 0xFC, 0x0F,
  0xFC, 0x7F, 0xE0, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF7, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xF1, 0xFC, 0x7F, 0xC0, 0x1C,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x70, 0x01, 0xFF,
  0x7F, 0xCF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0xB0, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x10, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x38, 0x00, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0xF3, 0xFF, 0xFE, 0x7F, 0x87, 0xFF, 0xE3, 0xFC, 0x1F, 0xFC,
  0x0F, 0xE0, 0x04, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xDF, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x03,
  0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x9F, 0xF0, 0x00,
  0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x03,
  0xFE, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x7F, 0xFC, 0x07, 0xFE, 0x7F, 0xC0, 0x7F, 0xFC, 0x07,
  0xFC, 0x7F, 0xC0, 0x7F, 0xFC, 0x07, 0xFC, 0x3F, 0xE0, 0x7E, 0xFE, 0x07,
  0xFC, 0x3F, 0xE0, 0x7E, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFE, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFE, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0xFE, 0x7F, 0x0F,
  0xF8, 0x1F, 0xF0, 0xFC, 0x7F, 0x1F, 0xF0, 0x1F, 0xF1, 0xFC, 0x7F, 0x1F,
  0xF0, 0x0F, 0xF1, 0xFC, 0x7F, 0x1F, 0xF0, 0x0F, 0xF1, 0xFC, 0x7F, 0x1F,
  0xE0, 0x0F, 0xF9, 0xFC, 0x3F, 0x9F, 0xE0, 0x0F, 0xFB, 0xF8, 0x3F, 0xBF,
  0xE0, 0x07, 0xFB, 0xF8, 0x3F, 0xBF, 0xE0, 0x07, 0xFB, 0xF8, 0x3F, 0xBF,
  0xC0, 0x07, 0xFB, 0xF8, 0x1F, 0xBF, 0xC0, 0x03, 0xFB, 0xF0, 0x1F, 0xBF,
  0xC0, 0x03, 0xFB, 0xF0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x9F,
  0xF8, 0x01, 0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC3, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0, 0xFF, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0,
  0x0F, 0xFE, 0x7F, 0xE0, 0x03, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE,
  0x1F, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x83, 0xFF,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1F, 0xFB, 0xFF,
  0x80, 0x0F, 0xFE, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xDF,
  0xF8, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x3F, 0xE1,
  0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8,
  0x1F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F,
  0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x11, 0xFF, 0xC0, 0x03, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xC8, 0x00, 0x0F, 0xF8,
};

const GFXglyph NotoSans_ExtraBold56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 10, 41, 16, 3, -40 },
  { 53, 22, 14, 28, 3, -40 },
  { 92, 34, 40, 37, 1, -40 },
  { 262, 28, 46, 32, 2, -43 },
  { 423, 49, 41, 52, 1, -41 },
  { 675, 41, 42, 43, 2, -41 },
  { 891, 9, 14, 16, 3, -40 },
  { 907, 16, 49, 19, 2, -40 },
  { 1005, 15, 49, 19, 2, -40 },
  { 1097, 28, 27, 30, 1, -43 },
  { 1192, 28, 27, 32, 2, -33 },
  { 1287, 11, 15, 17, 2, -7 },
  { 1308, 15, 8, 18, 1, -19 },
  { 1323, 10, 10, 16, 3, -9 },
  { 1336, 24, 40, 24, 0, -40 },
  { 1456, 28, 42, 32, 2, -41 },
  { 1603, 21, 40, 32, 3, -40 },
  { 1708, 28, 41, 32, 2, -41 },
  { 1852, 28, 42, 32, 2, -41 },
  { 1999, 30, 40, 32, 1, -40 },
  { 2149, 27, 41, 32, 3, -40 },
  { 2288, 29, 41, 32, 2, -40 },
  { 2437, 29, 40, 32, 2, -40 },
  { 2582, 28, 41, 32, 2, -40 },
  { 2726, 28, 41, 32, 2, -40 },
  { 2870, 10, 32, 16, 3, -31 },
  { 2910, 11, 39, 16, 2, -31 },
  { 2964, 28, 30, 32, 2, -35 },
  { 3069, 28, 18, 32, 2, -29 },
  { 3132, 28, 30, 32, 2, -35 },
  { 3237, 26, 42, 27, 0, -41 },
  { 3374, 46, 44, 50, 2, -40 },
  { 3627, 40, 40, 40, 0, -40 },
  { 3827, 30, 40, 37, 5, -40 },
  { 3977, 31, 42, 36, 3, -41 },
  { 4140, 33, 40, 41, 5, -40 },
  { 4305, 23, 40, 31, 5, -40 },
  { 4420, 23, 40, 30, 5, -40 },
  { 4535, 34, 42, 41, 3, -41 },
  { 4714, 33, 40, 43, 5, -40 },
  { 4879, 19, 40, 23, 2, -40 },
  { 4974, 18, 52, 19, -4, -40 },
  { 5091, 33, 40, 38, 5, -40 },
  { 5256, 25, 40, 32, 5, -40 },
  { 5381, 44, 40, 53, 5, -40 },
  { 5601, 36, 40, 46, 5, -40 },
  { 5781, 38, 42, 44, 3, -41 },
  { 5981, 28, 40, 35, 5, -40 },
  { 6121, 39, 51, 44, 3, -41 },
  { 6370, 33, 40, 37, 5, -40 },
  { 6535, 26, 42, 32, 3, -41 },
  { 6672, 30, 40, 33, 1, -40 },
  { 6822, 34, 41, 42, 4, -40 },
  { 6997, 38, 40, 38, 0, -40 },
  { 7187, 56, 40, 56, 0, -40 },
  { 7467, 39, 40, 39, 0, -40 },
  { 7662, 36, 40, 36, 0, -40 },
  { 7842, 30, 40, 33, 2, -40 },
  { 7992, 13, 49, 18, 4, -40 },
  { 8072, 24, 40, 24, 0, -40 },
  { 8192, 14, 49, 18, 1, -40 },
  { 8278, 30, 26, 31, 0, -40 },
  { 8376, 25, 6, 25, 0, 4 },
  { 8395, 18, 9, 22, 2, -43 },
  { 8416, 28, 32, 34, 2, -31 },
  { 8528, 29, 44, 36, 4, -43 },
  { 8688, 25, 32, 30, 3, -31 },
  { 8788, 29, 44, 36, 3, -43 },
  { 8948, 29, 32, 34, 3, -31 },
  { 9064, 23, 43, 22, 1, -43 },
  { 9188, 29, 44, 36, 3, -31 },
  { 9348, 29, 43, 37, 4, -43 },
  { 9504, 10, 43, 17, 4, -43 },
  { 9558, 17, 56, 17, -3, -43 },
  { 9677, 32, 43, 36, 4, -43 },
  { 9849, 9, 43, 17, 4, -43 },
  { 9898, 47, 31, 55, 4, -31 },
  { 10081, 29, 31, 37, 4, -31 },
  { 10194, 30, 32, 35, 3, -31 },
  { 10314, 29, 44, 36, 4, -31 },
  { 10474, 29, 44, 36, 3, -31 },
  { 10634, 21, 31, 26, 4, -31 },
  { 10716, 24, 32, 29, 2, -31 },
  { 10812, 22, 38, 25, 1, -37 },
  { 10917, 29, 32, 37, 4, -31 },
  { 11033, 33, 31, 33, 0, -31 },
  { 11161, 48, 31, 49, 1, -31 },
  { 11347, 33, 31, 34, 0, -31 },
  { 11475, 33, 44, 33, 0, -31 },
  { 11657, 24, 31, 28, 2, -31 },
  { 11750, 20, 49, 23, 1, -40 },
  { 11873, 6, 54, 30, 12, -42 },
  { 11914, 20, 49, 23, 2, -40 },
  { 12037, 28, 10, 32, 2, -25 },
};

const GFXfont NotoSans_ExtraBold56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold56pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_EXTRABOLD56PT7B_H_
