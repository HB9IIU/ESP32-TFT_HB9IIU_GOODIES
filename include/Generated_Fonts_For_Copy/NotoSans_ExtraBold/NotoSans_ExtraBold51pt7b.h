#ifndef _NOTOSANS_EXTRABOLD51PT7B_H_
#define _NOTOSANS_EXTRABOLD51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold51pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFD, 0xFF, 0x7F,
  0xDF, 0xF7, 0xFD, 0xFF, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xF7, 0xF8, 0xFE, 0x0C, 0x00,
  0xFF, 0x1F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFE,
  0xFE, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7F, 0x7E, 0x0F, 0xEF, 0xC1, 0xFD,
  0xF8, 0x3F, 0xBF, 0x07, 0xE7, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE3, 0xFC, 0x78, 0x38, 0xFF, 0x1E, 0x00, 0x3F, 0xC7, 0x80,
  0x0F, 0xF1, 0xE0, 0x03, 0xFF, 0x78, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xBF, 0xE0, 0x01, 0xE7, 0xFC, 0x00, 0x78, 0xFF, 0x80, 0x1E,
  0x3F, 0xFC, 0x07, 0x9F, 0xEF, 0xF1, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x10, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x00, 0x0F,
  0xC3, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0,
  0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x1F,
  0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xE1,
  0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x1F, 0xC0, 0x00, 0x0F, 0xC3, 0xF8, 0xFE,
  0x3F, 0xE0, 0x7F, 0x1F, 0xCF, 0xE3, 0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x3F,
  0xFE, 0x0F, 0xFF, 0xE7, 0xF3, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x1F, 0xFF,
  0xE1, 0xFF, 0xE3, 0xF8, 0xFE, 0x7F, 0x07, 0xFE, 0x1F, 0x8F, 0xE1, 0xF8,
  0x0F, 0xC1, 0xFC, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x7F, 0x00,
  0x00, 0xFE, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x1F, 0xC0, 0x00,
  0x7F, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x00, 0x3F,
  0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0x80,
  0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0xC0, 0xFF, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xF8,
  0x3F, 0xFF, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0xE1, 0xFF, 0x07, 0xFE, 0xFF,
  0xC7, 0xFC, 0x3F, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0x83, 0xFF, 0xFF, 0x83,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xE0, 0x1F,
  0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x10, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0,
  0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0,
  0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x81, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xE0, 0x7C, 0x0E,
  0x7F, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x01, 0xFE,
  0x7F, 0x00, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x0F, 0x07, 0xC0, 0x01,
  0x81, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xCF, 0xF3, 0xFC, 0xFE, 0x7F, 0x9F,
  0xE7, 0xF1, 0xFC, 0x7F, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xF7, 0xF8, 0xFE, 0x0E, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x8F, 0xFC, 0x7F, 0xC1, 0xFF, 0x1F,
  0xF0, 0x3F, 0xE7, 0xF8, 0x0F, 0xFB, 0xFE, 0x03, 0xFE, 0xFF, 0x80, 0x7F,
  0xBF, 0xE0, 0x1F, 0xEF, 0xF8, 0x07, 0xFB, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFE,
  0xFF, 0x80, 0x7F, 0xBF, 0xE0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF9, 0xFE, 0x03,
  0xFE, 0x7F, 0xC0, 0xFF, 0x9F, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFD, 0xFE, 0xFF,
  0xBF, 0x9F, 0xF3, 0xE3, 0xFE, 0x30, 0x7F, 0xC4, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF,
  0x9F, 0xFE, 0x3F, 0x01, 0xFF, 0x87, 0x80, 0x3F, 0xE0, 0x80, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7E,
  0x07, 0xFE, 0x1C, 0x01, 0xFF, 0x08, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x1F, 0xDF, 0xE0, 0x01, 0xFD, 0xFE, 0x00, 0x3F, 0x9F,
  0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x0F, 0xE1, 0xFE, 0x01,
  0xFE, 0x1F, 0xE0, 0x1F, 0xC1, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x40, 0x03, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC3, 0xE3, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xF7, 0xFC, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x0F,
  0xF3, 0xFF, 0x83, 0xFD, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xE0, 0xFF, 0xBF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x7F,
  0x9F, 0xF0, 0x3F, 0xE3, 0xFF, 0x7F, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF,
  0x7F, 0xF1, 0xFF, 0x03, 0xFE, 0x7F, 0x80, 0xFF, 0x9F, 0xE0, 0x1F, 0xE7,
  0xF8, 0x0F, 0xF9, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xFC, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x87, 0xFE, 0x3F, 0xF1, 0xFF, 0x07, 0xFE, 0xFF, 0x80, 0x7F,
  0xBF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF3, 0xFF, 0x0F, 0xFC, 0xFF, 0x80, 0xFF,
  0x3F, 0xE0, 0x3F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x01, 0xFE, 0xFF, 0x00,
  0x7F, 0xBF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xBF, 0x8F, 0xFF, 0xEF, 0xE1, 0xFF, 0xF3, 0xF8, 0x1F, 0xF9,
  0xFE, 0x00, 0x60, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x83, 0x03, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F,
  0x9F, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xF7, 0xF8, 0xFE, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xF7, 0xF8, 0xFE, 0x0E, 0x00,
  0x3F, 0x9F, 0xF7, 0xFD, 0xFF, 0x7F, 0xDF, 0xF7, 0xFC, 0xFE, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF3, 0xFC, 0xFF, 0x3F, 0x9F, 0xE7, 0xF9, 0xFC, 0x7F,
  0x1F, 0xCF, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x3F, 0x03, 0xFF,
  0x18, 0x01, 0xFF, 0x10, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x3F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC1, 0xFC,
  0x07, 0xFF, 0xC3, 0xF0, 0x7E, 0x07, 0xFF, 0xF8, 0xFC, 0x3F, 0x83, 0xFF,
  0xFE, 0x1F, 0x8F, 0xC1, 0xFF, 0xFF, 0x87, 0xE7, 0xF0, 0xFF, 0xFF, 0xE1,
  0xF9, 0xF8, 0x7F, 0x81, 0xF8, 0x7E, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0x9F,
  0x87, 0xE0, 0x1F, 0x83, 0xFF, 0xE3, 0xF8, 0x0F, 0xE0, 0xFF, 0xF8, 0xFE,
  0x03, 0xF8, 0x3F, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xBF, 0x0F, 0xE0, 0x3F,
  0x87, 0xEF, 0xC3, 0xF8, 0x0F, 0xE1, 0xFB, 0xF0, 0xFE, 0x03, 0xF8, 0x7E,
  0xFC, 0x1F, 0x81, 0xFE, 0x3F, 0x3F, 0x87, 0xF0, 0x7F, 0x8F, 0xC7, 0xE1,
  0xFF, 0xFF, 0xFF, 0xF1, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7E, 0x0F, 0xFF,
  0xDF, 0xFC, 0x1F, 0xC1, 0xFF, 0xC7, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x20, 0x00, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x1F, 0xFF,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x07,
  0xF9, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0,
  0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x7F, 0xE7, 0xFE,
  0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x00, 0x3F, 0xEF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0xFF, 0x83, 0xFF, 0xEF, 0xF8, 0x07, 0xFE, 0xFF, 0x80, 0x3F,
  0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x3F, 0xEF, 0xF8, 0x03, 0xFC, 0xFF,
  0x80, 0x7F, 0xCF, 0xF8, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFF, 0xCF, 0xF8, 0x07, 0xFE, 0xFF, 0x80,
  0x3F, 0xEF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xE0, 0xFC, 0x3F, 0xF8, 0x01, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x23, 0xFF, 0xC0, 0x1E, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xC0, 0x3F, 0xFC, 0xFF, 0x80, 0x3F, 0xF9, 0xFF,
  0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0xFF, 0xBF, 0xE0, 0x01, 0xFF, 0x7F, 0xC0, 0x03, 0xFE, 0xFF, 0x80, 0x0F,
  0xFD, 0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xE7, 0xFC, 0x03, 0xFF,
  0x8F, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC1, 0xF8, 0x3F, 0xFC, 0x00, 0x30, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0xFF,
  0x80, 0x07, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x1F, 0xF3, 0xFF,
  0x00, 0x3F, 0xE7, 0xFF, 0x80, 0x7F, 0xC7, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xF0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0xFF, 0xE1, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x07, 0xFE, 0x07, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF,
  0x8F, 0xFF, 0x87, 0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80,
  0x7F, 0xE3, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xE0, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xC0,
  0x3F, 0xE3, 0xFF, 0x00, 0xFF, 0x9F, 0xF8, 0x03, 0xFE, 0x7F, 0xC0, 0x0F,
  0xFB, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF,
  0x80, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x8F,
  0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x1F, 0xF3, 0xFE,
  0x00, 0x7F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0x7F, 0xFF, 0x7F, 0x00, 0x7F, 0x7F, 0xFF, 0x7F, 0x00, 0x7E, 0xFF, 0xFF,
  0x7F, 0x00, 0xFE, 0xFF, 0xFF, 0x3F, 0x80, 0xFE, 0xFF, 0xFF, 0x3F, 0x80,
  0xFC, 0xFF, 0xFF, 0x3F, 0x81, 0xFC, 0xFF, 0xFF, 0x3F, 0x81, 0xFC, 0xFF,
  0xFF, 0x1F, 0xC1, 0xF8, 0xFF, 0xFF, 0x1F, 0xC3, 0xF8, 0xFF, 0xFF, 0x1F,
  0xC3, 0xF8, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8, 0xFF, 0xFF, 0x0F, 0xE3, 0xF0,
  0xFF, 0xFF, 0x0F, 0xE7, 0xF0, 0xFF, 0xFF, 0x0F, 0xF7, 0xF0, 0xFF, 0xFF,
  0x07, 0xF7, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0x01,
  0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0x3F, 0xE0,
  0x3F, 0xFF, 0xCF, 0xF8, 0x0F, 0xFF, 0xF1, 0xFF, 0x03, 0xFF, 0xFC, 0x7F,
  0xC0, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xC3, 0xFF, 0xFC, 0x1F, 0xF8, 0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0xFF,
  0xC0, 0xFF, 0xCF, 0xFF, 0xF0, 0x1F, 0xF3, 0xFF, 0xFC, 0x03, 0xFE, 0xFF,
  0xFF, 0x00, 0xFF, 0xBF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0,
  0x7F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF,
  0x80, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFD,
  0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFE,
  0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x03,
  0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF8,
  0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFE, 0x07, 0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xF8,
  0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x03, 0xFF, 0x3F,
  0xE0, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF,
  0xBF, 0xE0, 0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F,
  0xDF, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0xFF, 0xC7, 0xFF, 0x00, 0x3F, 0xF8, 0x7F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xFC, 0x3F,
  0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8,
  0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01,
  0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F,
  0xE1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x01,
  0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x3F, 0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F,
  0xF3, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xC1,
  0xFC, 0x7F, 0xC0, 0x0C, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFB, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xFB, 0xFF, 0x00,
  0x1F, 0xF3, 0xFE, 0x00, 0x7F, 0xE7, 0xFF, 0x01, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xDF, 0xF0, 0x00,
  0x3F, 0xF7, 0xFC, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x03, 0xFE, 0x3F, 0xE0,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0xF0, 0x7F,
  0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x3F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F,
  0xCF, 0xF8, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0xFF, 0x3F, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x3F, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xE1, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0x03,
  0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7E, 0xFC, 0x03, 0xFC,
  0x0F, 0xF8, 0x1F, 0xDF, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFB, 0xF8, 0x1F,
  0xE0, 0x1F, 0xE0, 0x7F, 0x7F, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xEF, 0xE0,
  0x7F, 0x80, 0x7F, 0x83, 0xFC, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x1F,
  0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xE3, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFC,
  0x7F, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0x8F, 0xE1, 0xFE, 0x00, 0x3F, 0xCF,
  0xE0, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFC, 0x1F, 0xCF, 0xF0, 0x00, 0xFF,
  0x3F, 0x83, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF0, 0x7F, 0x3F, 0xC0, 0x01,
  0xFC, 0xFC, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x3F,
  0xF0, 0x7F, 0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x83, 0xFF, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00,
  0x03, 0xFE, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xFC,
  0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF8,
  0x3F, 0xF0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0xBF, 0xE0,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xC1, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x00,
  0xFF, 0x8F, 0xF8, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x0F, 0xFB, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0,
  0xFE, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF0,
  0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x1E, 0x03, 0xFE, 0x04, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xF8, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xF9, 0xFC, 0x7F, 0xFC, 0x7F, 0x0F,
  0xFC, 0x1F, 0xC0, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x18, 0x03, 0xFC, 0x7F, 0xC0, 0xFF, 0x3F, 0xFC,
  0x3F, 0xDF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xBF, 0xF8, 0xFF, 0xEF, 0xFC, 0x0F, 0xFB, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0xFE, 0x7F, 0xFE, 0x3F, 0x8F, 0xFF, 0x0F, 0xE1, 0xFF,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x3F, 0xF8, 0xFC, 0x7F, 0xE0, 0x08, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x02, 0x7F, 0xE0, 0x0E, 0x3F, 0xFC,
  0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0xC0, 0xFF, 0x81,
  0xFF, 0x1F, 0xF0, 0x7F, 0xFB, 0xFE, 0x1F, 0xFF, 0xBF, 0xC7, 0xFF, 0xF7,
  0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF,
  0x81, 0xFF, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFE,
  0xFF, 0x80, 0x7F, 0xDF, 0xF0, 0x0F, 0xFB, 0xFF, 0x03, 0xFF, 0x7F, 0xF9,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xEF, 0xF0,
  0xFF, 0xF9, 0xFE, 0x0F, 0xFE, 0x1F, 0xC0, 0xFF, 0x83, 0xF8, 0x01, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFF, 0x03, 0xFE, 0x7F, 0xC0, 0x3F, 0xCF, 0xF8, 0x07, 0xF9, 0xFE,
  0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x01, 0x0F, 0xFC, 0x01, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x3F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x1F, 0xFE, 0x7F,
  0x87, 0xFF, 0xEF, 0xF1, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFB, 0xFF, 0x87, 0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xF8, 0x07, 0xFD,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x03,
  0xFE, 0xFF, 0xC0, 0xFF, 0xDF, 0xFE, 0x7F, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFB, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0x9F,
  0xF0, 0x3F, 0xE3, 0xFE, 0x00, 0x40, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x40, 0x00, 0x7F, 0xE7, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x08, 0x03, 0xFC, 0x7F, 0xE0,
  0xFF, 0x3F, 0xFE, 0x3F, 0xDF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFC, 0x3F, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xDF, 0xE7,
  0xF8, 0x78, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE,
  0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F,
  0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9,
  0xFE, 0x7F, 0x9F, 0xE7, 0xF8, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xEF, 0xF0, 0x07, 0xFE, 0x7F, 0x80,
  0x7F, 0xE3, 0xFC, 0x07, 0xFE, 0x1F, 0xE0, 0x7F, 0xE0, 0xFF, 0x07, 0xFE,
  0x07, 0xF8, 0x3F, 0xE0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x3F, 0xF0, 0x0F,
  0xF3, 0xFF, 0x00, 0x7F, 0xBF, 0xF0, 0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE, 0xFF, 0x80, 0x7F, 0xE7, 0xFE, 0x03,
  0xFE, 0x1F, 0xF8, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x03, 0xFF, 0x07, 0xF8,
  0x0F, 0xFC, 0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x01, 0xFF, 0x8F, 0xF0, 0x07,
  0xFE, 0x7F, 0x80, 0x1F, 0xFB, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x80, 0x00, 0x40, 0x1F, 0x83, 0xFF, 0x01, 0xFF, 0x83, 0xF9,
  0xFF, 0xF8, 0x7F, 0xFC, 0x7F, 0x7F, 0xFF, 0x9F, 0xFF, 0xCF, 0xEF, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xF8, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x00, 0x80, 0x3F, 0x07, 0xFE, 0x0F, 0xE3, 0xFF, 0xE3, 0xF9, 0xFF,
  0xFC, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3,
  0xFF, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xE7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0,
  0x1F, 0xE7, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0x7F, 0x80, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0x7F, 0xC0, 0x3F,
  0xE7, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x80, 0x3F,
  0x87, 0xFC, 0x0F, 0xE3, 0xFF, 0xC3, 0xF9, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0x8F, 0xFE, 0xFF, 0xC0,
  0xFF, 0xBF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xF7, 0xFF, 0xE3,
  0xFC, 0xFF, 0xF0, 0xFF, 0x1F, 0xF0, 0x3F, 0xC0, 0x40, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x1F, 0xFE, 0x7F, 0x87, 0xFF, 0xEF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFB, 0xFF, 0x87,
  0xFF, 0x7F, 0xE0, 0x7F, 0xEF, 0xF8, 0x07, 0xFD, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xBF, 0xE0, 0x1F, 0xF7, 0xFC, 0x03, 0xFE, 0xFF, 0xC0, 0xFF,
  0xDF, 0xFE, 0x3F, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFB, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0x9F, 0xF0, 0x3F, 0xE3, 0xFE,
  0x00, 0x40, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0x1F, 0x81, 0xFF, 0xF0, 0xFF,
  0xFF, 0x3F, 0xEF, 0xEF, 0xFD, 0xFD, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x00, 0x00, 0x18, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFE, 0xFF, 0x3F, 0xE0, 0x1C,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x02, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC7, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x08, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xF7, 0xFC, 0x0F, 0xFE, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xF9, 0xFC, 0x3F, 0xFE, 0x3F,
  0x83, 0xFF, 0x07, 0xF0, 0x06, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFD, 0xFE,
  0x00, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x3F, 0xC0,
  0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC,
  0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0x3F, 0x8F, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xE7, 0xF8, 0x0F, 0xFE, 0x03, 0xFC, 0xFF, 0x03, 0xFF, 0xE0, 0x7F,
  0x9F, 0xF0, 0x7F, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xDF, 0x83, 0xFC, 0x3F,
  0xC1, 0xFB, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0x7E, 0x0F, 0xF0, 0xFF, 0x8F,
  0xCF, 0xE3, 0xFC, 0x0F, 0xF1, 0xF8, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0x1F,
  0x8F, 0xF0, 0x3F, 0xC7, 0xE3, 0xF1, 0xFE, 0x03, 0xF9, 0xFC, 0x7F, 0x7F,
  0x80, 0x7F, 0xBF, 0x0F, 0xEF, 0xF0, 0x0F, 0xF7, 0xE0, 0xFD, 0xFE, 0x01,
  0xFE, 0xFC, 0x1F, 0xBF, 0x80, 0x1F, 0xDF, 0x83, 0xF7, 0xF0, 0x03, 0xFB,
  0xF0, 0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xDF, 0xC0, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x07, 0xFC,
  0x0F, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF1, 0xFF, 0x00, 0x7F, 0xCF,
  0xFC, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xBF, 0xE0, 0x07, 0xFC, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0x00, 0xFF, 0x87,
  0xFE, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F,
  0xE7, 0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFD,
  0xFF, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0xFF, 0x9F, 0xF0, 0x03, 0xFE, 0x3F,
  0xC0, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xF8,
  0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03,
  0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFC, 0xFF, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xC0, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC,
  0x01, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x3F, 0xC0, 0x0F,
  0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFF,
  0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x8F, 0xF8, 0x00, 0x5F, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x07, 0xFE, 0x40, 0x00, 0x38, 0x00,
};

const GFXglyph NotoSans_ExtraBold51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 10, 37, 15, 2, -36 },
  { 48, 19, 13, 26, 3, -36 },
  { 79, 31, 36, 33, 1, -36 },
  { 219, 26, 42, 29, 2, -39 },
  { 356, 45, 37, 47, 1, -37 },
  { 565, 38, 38, 39, 2, -37 },
  { 746, 8, 13, 14, 3, -36 },
  { 759, 14, 45, 18, 2, -37 },
  { 838, 15, 45, 18, 1, -37 },
  { 923, 25, 24, 28, 1, -39 },
  { 998, 25, 24, 29, 2, -30 },
  { 1073, 10, 14, 15, 2, -7 },
  { 1091, 14, 7, 16, 1, -17 },
  { 1104, 10, 9, 15, 2, -8 },
  { 1116, 22, 37, 22, 0, -37 },
  { 1218, 26, 38, 29, 2, -37 },
  { 1342, 19, 36, 29, 3, -36 },
  { 1428, 26, 37, 29, 2, -37 },
  { 1549, 25, 38, 29, 2, -37 },
  { 1668, 28, 36, 29, 1, -36 },
  { 1794, 25, 37, 29, 2, -36 },
  { 1910, 26, 38, 29, 2, -37 },
  { 2034, 26, 36, 29, 2, -36 },
  { 2151, 26, 38, 29, 2, -37 },
  { 2275, 26, 38, 29, 2, -37 },
  { 2399, 10, 29, 15, 2, -28 },
  { 2436, 10, 35, 15, 2, -28 },
  { 2480, 25, 27, 29, 2, -32 },
  { 2565, 25, 16, 29, 2, -26 },
  { 2615, 25, 27, 29, 2, -32 },
  { 2700, 24, 38, 25, 0, -37 },
  { 2814, 42, 41, 46, 2, -37 },
  { 3030, 36, 37, 36, 0, -37 },
  { 3197, 28, 36, 34, 4, -36 },
  { 3323, 28, 38, 33, 3, -37 },
  { 3456, 31, 36, 37, 4, -36 },
  { 3596, 22, 36, 28, 4, -36 },
  { 3695, 21, 36, 28, 4, -36 },
  { 3790, 31, 38, 37, 3, -37 },
  { 3938, 31, 36, 39, 4, -36 },
  { 4078, 17, 36, 21, 2, -36 },
  { 4155, 17, 47, 17, -4, -36 },
  { 4255, 30, 36, 34, 4, -36 },
  { 4390, 23, 36, 29, 4, -36 },
  { 4494, 40, 36, 49, 4, -36 },
  { 4674, 34, 36, 42, 4, -36 },
  { 4827, 35, 38, 41, 3, -37 },
  { 4994, 26, 36, 32, 4, -36 },
  { 5111, 35, 46, 41, 3, -37 },
  { 5313, 30, 36, 34, 4, -36 },
  { 5448, 25, 38, 29, 2, -37 },
  { 5567, 28, 36, 30, 1, -36 },
  { 5693, 31, 37, 39, 4, -36 },
  { 5837, 34, 36, 34, 0, -36 },
  { 5990, 51, 36, 51, 0, -36 },
  { 6220, 35, 36, 35, 0, -36 },
  { 6378, 33, 36, 33, 0, -36 },
  { 6527, 28, 36, 30, 1, -36 },
  { 6653, 13, 45, 17, 3, -37 },
  { 6727, 22, 37, 22, 0, -37 },
  { 6829, 12, 45, 17, 1, -37 },
  { 6897, 28, 24, 28, 0, -37 },
  { 6981, 23, 5, 23, 0, 4 },
  { 6996, 16, 8, 20, 2, -39 },
  { 7012, 26, 30, 31, 2, -29 },
  { 7110, 26, 40, 32, 4, -39 },
  { 7240, 24, 30, 27, 2, -29 },
  { 7330, 27, 40, 32, 2, -39 },
  { 7465, 27, 30, 31, 2, -29 },
  { 7567, 21, 39, 20, 1, -39 },
  { 7670, 27, 41, 32, 2, -29 },
  { 7809, 26, 39, 34, 4, -39 },
  { 7936, 10, 39, 16, 3, -39 },
  { 7985, 16, 51, 16, -3, -39 },
  { 8087, 29, 39, 33, 4, -39 },
  { 8229, 8, 39, 16, 4, -39 },
  { 8268, 43, 29, 50, 4, -29 },
  { 8424, 26, 29, 34, 4, -29 },
  { 8519, 28, 30, 32, 2, -29 },
  { 8624, 26, 41, 32, 4, -29 },
  { 8758, 27, 41, 32, 2, -29 },
  { 8897, 19, 29, 23, 4, -29 },
  { 8966, 22, 30, 26, 2, -29 },
  { 9049, 20, 35, 23, 1, -34 },
  { 9137, 27, 29, 34, 3, -28 },
  { 9235, 30, 28, 30, 0, -28 },
  { 9340, 43, 28, 45, 1, -28 },
  { 9491, 30, 28, 31, 0, -28 },
  { 9596, 30, 40, 30, 0, -28 },
  { 9746, 23, 28, 25, 1, -28 },
  { 9827, 18, 45, 21, 1, -37 },
  { 9929, 6, 50, 27, 11, -39 },
  { 9967, 18, 45, 21, 2, -37 },
  { 10069, 25, 10, 29, 2, -23 },
};

const GFXfont NotoSans_ExtraBold51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold51pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_EXTRABOLD51PT7B_H_
