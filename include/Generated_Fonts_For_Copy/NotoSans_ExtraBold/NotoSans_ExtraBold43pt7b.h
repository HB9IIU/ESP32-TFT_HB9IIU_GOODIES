#ifndef _NOTOSANS_EXTRABOLD43PT7B_H_
#define _NOTOSANS_EXTRABOLD43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold43pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F,
  0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x00,
  0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0xFC, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC,
  0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0xFC, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC7, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF0, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x1F, 0x1F,
  0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x80, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF9, 0xFC, 0xE3, 0xC7, 0xE3, 0x81, 0x3F, 0x8E, 0x00, 0x7F, 0x38, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xEF,
  0xF0, 0x03, 0x9F, 0xC0, 0x0E, 0x3F, 0x40, 0x38, 0xFD, 0xF0, 0xE7, 0xF7,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x81, 0xFF,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xFF, 0x00, 0x7C, 0x00, 0x7F, 0xFC,
  0x03, 0xF0, 0x01, 0xF1, 0xF8, 0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x7E, 0x00,
  0x3F, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0xF8,
  0x7E, 0x00, 0x0F, 0xC3, 0xE1, 0xF0, 0x00, 0x3F, 0x1F, 0x8F, 0xC0, 0x00,
  0xFC, 0x7E, 0x3E, 0x1F, 0x81, 0xF1, 0xF9, 0xF9, 0xFF, 0x07, 0xEF, 0xC7,
  0xCF, 0xFE, 0x1F, 0xFF, 0x3F, 0x3F, 0xFC, 0x3F, 0xF9, 0xF9, 0xFF, 0xF8,
  0x7F, 0xC7, 0xE7, 0xE7, 0xE0, 0xFE, 0x3F, 0x1F, 0x0F, 0x80, 0x00, 0xF8,
  0x7C, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x3F, 0x00, 0x1F, 0x81,
  0xF0, 0xF8, 0x00, 0xFC, 0x07, 0xE3, 0xE0, 0x03, 0xF0, 0x1F, 0x9F, 0x80,
  0x1F, 0x80, 0x3F, 0xFC, 0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x03, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x3F,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0xFF, 0x0F, 0xFF, 0x01, 0xFE, 0x3F, 0xFF, 0x03,
  0xF8, 0xFF, 0xFF, 0x0F, 0xF1, 0xFE, 0xFF, 0x1F, 0xC7, 0xF8, 0xFF, 0x7F,
  0x8F, 0xE0, 0xFF, 0xFF, 0x1F, 0xC0, 0xFF, 0xFC, 0x3F, 0x80, 0xFF, 0xF0,
  0x7F, 0x00, 0xFF, 0xE0, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xDF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x1F,
  0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0x3F, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F,
  0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x01, 0xC3, 0xE0, 0xCF, 0xDF, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x1F, 0xFC, 0x01, 0xFB, 0xF0, 0x0F, 0xCF, 0xC0, 0xFC, 0x7F, 0x0F, 0xE1,
  0xF0, 0x0E, 0x0E, 0x00, 0x10, 0x40, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF9, 0xF8, 0xFC,
  0x7E, 0x3E, 0x1F, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFE,
  0x3F, 0xDF, 0xE0, 0xFE, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFE, 0x7F, 0x07,
  0xF3, 0xFE, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0,
  0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xBF, 0xCF, 0x9F, 0xE3, 0x8F, 0xF1, 0x87, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE3, 0xF8, 0x7F, 0x87, 0x80, 0xFF, 0x08, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xF0, 0x3F, 0xC4, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xF3, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xF0, 0x03, 0xEF, 0xE0, 0x0F, 0xDF, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0xFF,
  0x01, 0xF9, 0xFE, 0x07, 0xE3, 0xFC, 0x0F, 0xC7, 0xF8, 0x3F, 0x0F, 0xF0,
  0xFC, 0x1F, 0xE3, 0xF8, 0x3F, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF0, 0x80, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xF7, 0xF3,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xCF, 0xF0,
  0x7E, 0x7F, 0xE1, 0xFB, 0xFF, 0xC7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7F, 0x01,
  0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xE0, 0x7F, 0x3F, 0x83, 0xFC,
  0xFF, 0xBF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0x1F, 0xE7,
  0xF8, 0x3F, 0x9F, 0xC0, 0x7E, 0x7F, 0x01, 0xF8, 0xFE, 0x0F, 0xE3, 0xFC,
  0x7F, 0x87, 0xFB, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFC, 0xFF, 0x9F,
  0xE0, 0xFF, 0x7F, 0x01, 0xFD, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0x7F, 0x01, 0xFD, 0xFE, 0x0F, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE7, 0xF8, 0x7F, 0x9F, 0xC0, 0xFE, 0xFF, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFD, 0xFC, 0x0F, 0xF7,
  0xF8, 0x7F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFB, 0xF1, 0xFF,
  0xCF, 0xC1, 0xFE, 0x7F, 0x00, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0xC1, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x3C,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18,
  0x1E, 0x1F, 0xDF, 0xEF, 0xF7, 0xFB, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE7, 0xF3, 0xF9,
  0xF8, 0xFC, 0x7E, 0x7E, 0x3F, 0x1F, 0x8F, 0x87, 0xC7, 0xE0, 0x00, 0x00,
  0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x3C, 0x07, 0xF2, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xE0, 0x0F, 0xE0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x03, 0xFF, 0x0F,
  0x87, 0xC1, 0xFF, 0xF9, 0xF9, 0xF8, 0x7F, 0xFF, 0x1F, 0x3E, 0x1F, 0xFF,
  0xE3, 0xE7, 0xC3, 0xF0, 0x7C, 0x7F, 0xF8, 0xFC, 0x1F, 0x87, 0xFE, 0x1F,
  0x03, 0xF0, 0xFF, 0xC7, 0xE0, 0x7E, 0x1F, 0xF8, 0xFC, 0x0F, 0xC3, 0xFF,
  0x1F, 0x81, 0xF8, 0x7F, 0xE3, 0xF0, 0x3F, 0x1F, 0x7C, 0x7E, 0x07, 0xE3,
  0xEF, 0x87, 0xC1, 0xFC, 0x7D, 0xF0, 0xFC, 0x7F, 0x9F, 0x3F, 0x1F, 0xFF,
  0xFF, 0xE3, 0xE1, 0xFF, 0xFF, 0xF8, 0x7C, 0x1F, 0xF9, 0xFE, 0x0F, 0xC1,
  0xFC, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x02, 0x00, 0x1F, 0xF0, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFC, 0xFE, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x03,
  0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFE,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0,
  0xFF, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0xFF,
  0xFA, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0x03, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x03, 0xFE, 0xFF, 0x00, 0xFE, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x1F, 0xF0, 0x1E, 0x3F, 0xE0, 0x04, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x0E, 0x1F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xF0, 0x7F, 0xF3, 0xFC, 0x07, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0,
  0x1F, 0xEF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB, 0xFC, 0x07, 0xFC, 0xFF,
  0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0x80,
  0x70, 0xFF, 0x80, 0x04, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x1F, 0xDF, 0xE0,
  0x07, 0xF7, 0xFC, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0xF0, 0x1F, 0xC7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE3, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xEF, 0xFF, 0xBF, 0xFE, 0xFF, 0xF3,
  0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xBF,
  0x80, 0x7F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0, 0x3F, 0xC7, 0xF0, 0x3F, 0xC3,
  0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x1F, 0xE0, 0x7F, 0x1F, 0xE0,
  0x3F, 0x9F, 0xE0, 0x1F, 0xCF, 0xF0, 0x0F, 0xEF, 0xF0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xE1, 0xFE, 0x07, 0xF0,
  0xFF, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xF0, 0xFE, 0x07, 0xF8, 0x7F,
  0x01, 0xFE, 0x3F, 0x80, 0xFF, 0x1F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F, 0xF7,
  0xF0, 0x07, 0xFB, 0xF8, 0x03, 0xFE, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xEF, 0xFF, 0x7E, 0x03, 0xF7, 0xFF, 0xBF, 0x01,
  0xFB, 0xFF, 0xDF, 0x80, 0xF9, 0xFF, 0xE7, 0xC0, 0xFC, 0xFF, 0xF3, 0xF0,
  0x7E, 0x7F, 0xF9, 0xF8, 0x3E, 0x3F, 0xFC, 0xFC, 0x1F, 0x1F, 0xFE, 0x3F,
  0x1F, 0x8F, 0xFF, 0x1F, 0x8F, 0x87, 0xFF, 0x8F, 0xC7, 0xC3, 0xFF, 0xC3,
  0xF7, 0xE1, 0xFF, 0xE1, 0xFB, 0xF0, 0xFF, 0xF0, 0xFD, 0xF0, 0x7F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFC, 0x0F, 0xFF,
  0x07, 0xFE, 0x07, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0x01, 0xFF,
  0xE0, 0x7F, 0x80, 0xFF, 0xF0, 0x1F, 0xC0, 0x7E, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xFE, 0x07, 0xFF, 0xCF,
  0xE0, 0x7F, 0xFC, 0xFF, 0x07, 0xFF, 0xC7, 0xF0, 0x7F, 0xFC, 0x7F, 0x87,
  0xFF, 0xC3, 0xF8, 0x7F, 0xFC, 0x3F, 0xC7, 0xFF, 0xC1, 0xFE, 0x7F, 0xFC,
  0x1F, 0xE7, 0xFF, 0xC0, 0xFF, 0x7F, 0xFC, 0x07, 0xF7, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F,
  0xF8, 0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF,
  0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0x8F,
  0xF0, 0x03, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xF0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x03, 0xFF, 0x0F, 0xF8,
  0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x7F, 0x9F, 0xC0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0xFF, 0x7F,
  0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0x8F, 0xF0,
  0x03, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x01, 0xFC,
  0x3F, 0xC0, 0x7F, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0x03,
  0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xFC, 0x1F,
  0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC,
  0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xEF, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF3, 0xFC, 0x07, 0x9F, 0xE0, 0x04, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xF0, 0x07, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x0F, 0xF7, 0xF0, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F, 0xC0,
  0x7F, 0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87, 0xF8,
  0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0x80,
  0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x07, 0xF0, 0x03,
  0xF9, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xE0, 0x0F, 0xE7,
  0xF0, 0x07, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x80, 0x7F, 0x0F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xFF, 0x01, 0xFC, 0x3F, 0x80, 0xFF,
  0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0x7C, 0x0F, 0xE0, 0x7F, 0x03, 0xEF, 0x81,
  0xFC, 0x0F, 0xE0, 0xFD, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xBF, 0x07, 0xF0,
  0x1F, 0x83, 0xF7, 0xE0, 0xFC, 0x03, 0xF8, 0x7E, 0x7C, 0x3F, 0x80, 0x7F,
  0x1F, 0x8F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF1, 0xF8, 0xFE, 0x00, 0xFC, 0x7E,
  0x3F, 0x1F, 0x80, 0x1F, 0xCF, 0xC7, 0xE7, 0xF0, 0x03, 0xFB, 0xF0, 0x7E,
  0xFE, 0x00, 0x7F, 0x7E, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xC1, 0xFB, 0xF0,
  0x00, 0xFD, 0xF8, 0x3F, 0x7E, 0x00, 0x1F, 0xBE, 0x03, 0xEF, 0xC0, 0x03,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFF,
  0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00,
  0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xF7, 0xF8, 0x00,
  0x3F, 0xCF, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F,
  0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xC0,
  0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x0F, 0xF7, 0xF8, 0x01, 0xFE, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF9, 0xFC,
  0x00, 0x3F, 0xBF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0x9F, 0x80, 0x1F, 0x1F, 0x00, 0x7E,
  0x3F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x7C, 0x0F, 0x80,
  0xFC, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF9, 0xF8, 0x01, 0xF7, 0xE0, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x01,
  0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x87, 0x87, 0xFC, 0x20, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x0F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0xFC, 0xFF, 0xE3, 0xE3,
  0xFE, 0x1F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x7E, 0x0F, 0xE7, 0xFC, 0x3F, 0xBF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xE1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0x3F, 0x3F, 0xF8, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC,
  0x7F, 0x80, 0xC7, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x06, 0x7F, 0xE7, 0xE3, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xC7,
  0xF0, 0xFF, 0xDF, 0xC7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xDF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xF7, 0xF8, 0x3F, 0xDF,
  0xFB, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xEF, 0xC7, 0xFF,
  0x3F, 0x07, 0xF0, 0x7C, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0x1F, 0xE7, 0xF0, 0x1F, 0xDF,
  0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x27, 0xFC, 0x03, 0x8F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0xFE,
  0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xC1,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0xFC, 0x3F, 0xF3, 0xF1, 0xFF, 0xEF, 0xCF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFD,
  0xFE, 0x07, 0xF7, 0xFC, 0x7F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF1, 0xFF, 0xDF, 0xC1, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xD8, 0x00, 0xFF, 0x7F, 0x9F, 0xFD, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x7E, 0x0F, 0xE7, 0xFE, 0x3F, 0xBF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFC, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x38, 0x00, 0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0x03, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83,
  0xF8, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF, 0xE7, 0xFE, 0x3F,
  0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xFE, 0xFE, 0x03,
  0xFC, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xF0, 0xFE, 0x1F, 0xE0, 0xFE, 0x3F,
  0xE0, 0xFE, 0x3F, 0xC0, 0xFE, 0x7F, 0x80, 0xFE, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xFF, 0xBF, 0xE0, 0xFF, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F,
  0xF8, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xFE, 0xFE, 0x01,
  0xFE, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x3F, 0x80,
  0x7F, 0x07, 0xE3, 0xFF, 0x0F, 0xFE, 0x3F, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFE, 0x1F, 0xFC, 0x3F, 0xDF, 0xE0, 0x7F, 0xC0, 0xFE, 0xFF, 0x03,
  0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0x01, 0xFF,
  0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0x00, 0xFE,
  0x03, 0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0x80, 0xFF, 0xFE,
  0x01, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0x01,
  0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xFF, 0x00,
  0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0x80, 0xFF,
  0xFC, 0x1F, 0xC3, 0xF1, 0xFF, 0xCF, 0xCF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFD, 0xFF, 0x9F,
  0xE0, 0xFF, 0x3F, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xF9, 0xFF, 0x1F,
  0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xC0, 0xFC, 0x1F, 0x83, 0xF1, 0xFF, 0x8F, 0xEF, 0xFF, 0x3F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xF8, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xEF, 0xFE, 0x3F, 0x8F, 0xE0, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0xFC, 0x3F, 0xF3, 0xF1, 0xFF, 0xEF, 0xCF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFD,
  0xFE, 0x07, 0xF7, 0xFC, 0x7F, 0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF1, 0xFF, 0xDF, 0xC1, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x1F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x07,
  0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0x81,
  0xCF, 0xE0, 0x13, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xC0,
  0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xF1, 0xFF, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE7, 0x1F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0xFE, 0x01, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFB, 0xF3, 0xFF, 0xCF, 0xC3, 0xFE,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xF0,
  0x0F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x3F,
  0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x7E, 0x01,
  0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x9F, 0x80, 0x1F, 0xDF, 0xC0,
  0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xF0,
  0x1F, 0xDF, 0xC0, 0xFF, 0x80, 0xFE, 0xFE, 0x07, 0xFE, 0x07, 0xF3, 0xF8,
  0x3F, 0xF0, 0x7F, 0x1F, 0xC1, 0xFF, 0x83, 0xF8, 0xFE, 0x1F, 0xFC, 0x1F,
  0xC7, 0xF0, 0xFF, 0xF0, 0xFC, 0x1F, 0xC7, 0xDF, 0x8F, 0xE0, 0xFE, 0x3E,
  0x7C, 0x7F, 0x07, 0xF1, 0xF3, 0xE3, 0xF8, 0x1F, 0x9F, 0x9F, 0x9F, 0x80,
  0xFC, 0xF8, 0xFD, 0xFC, 0x07, 0xF7, 0xC3, 0xEF, 0xE0, 0x3F, 0xBE, 0x1F,
  0x7E, 0x00, 0xFD, 0xF0, 0xFB, 0xF0, 0x07, 0xFF, 0x87, 0xDF, 0x80, 0x3F,
  0xF8, 0x3E, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x9F, 0xE0,
  0x3F, 0xE3, 0xFC, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x03,
  0xFC, 0xFF, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0x87, 0xF8,
  0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x3F, 0xC7, 0xF8, 0x07, 0xFB, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xDF, 0xC0, 0x1F, 0xEF, 0xF0,
  0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x3F,
  0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x9F, 0x80, 0x0F, 0xDF, 0xC0,
  0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x03,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0xFF, 0xE1, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x0F, 0xFC,
  0x1F, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF8, 0x0F,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x0B, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0xFF, 0xD0, 0x00, 0x70,
};

const GFXglyph NotoSans_ExtraBold43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 8, 32, 12, 2, -31 },
  { 33, 16, 11, 22, 3, -31 },
  { 55, 26, 31, 28, 1, -31 },
  { 156, 22, 36, 25, 1, -33 },
  { 255, 38, 31, 40, 1, -31 },
  { 403, 31, 31, 33, 2, -31 },
  { 524, 6, 11, 12, 3, -31 },
  { 533, 12, 38, 15, 2, -31 },
  { 590, 12, 38, 15, 1, -31 },
  { 647, 21, 21, 23, 1, -33 },
  { 703, 21, 21, 25, 2, -26 },
  { 759, 9, 12, 13, 1, -6 },
  { 773, 12, 5, 14, 1, -14 },
  { 781, 8, 8, 12, 2, -7 },
  { 789, 18, 31, 18, 0, -31 },
  { 859, 21, 31, 25, 2, -31 },
  { 941, 17, 31, 25, 2, -31 },
  { 1007, 22, 31, 25, 1, -31 },
  { 1093, 21, 31, 25, 2, -31 },
  { 1175, 23, 31, 25, 1, -31 },
  { 1265, 21, 31, 25, 2, -31 },
  { 1347, 22, 31, 25, 1, -31 },
  { 1433, 22, 31, 25, 1, -31 },
  { 1519, 22, 31, 25, 1, -31 },
  { 1605, 22, 31, 25, 1, -31 },
  { 1691, 8, 25, 12, 2, -24 },
  { 1716, 9, 30, 13, 1, -24 },
  { 1750, 21, 23, 25, 2, -27 },
  { 1811, 21, 14, 25, 2, -22 },
  { 1848, 21, 23, 25, 2, -27 },
  { 1909, 20, 32, 21, 0, -31 },
  { 1989, 35, 34, 39, 2, -31 },
  { 2138, 30, 31, 30, 0, -31 },
  { 2255, 24, 31, 29, 3, -31 },
  { 2348, 24, 31, 28, 2, -31 },
  { 2441, 26, 31, 32, 3, -31 },
  { 2542, 18, 31, 24, 4, -31 },
  { 2612, 17, 31, 23, 4, -31 },
  { 2678, 26, 31, 31, 2, -31 },
  { 2779, 25, 31, 33, 4, -31 },
  { 2876, 15, 31, 18, 1, -31 },
  { 2935, 14, 40, 15, -3, -31 },
  { 3005, 25, 31, 29, 4, -31 },
  { 3102, 20, 31, 25, 3, -31 },
  { 3180, 33, 31, 41, 4, -31 },
  { 3308, 28, 31, 35, 4, -31 },
  { 3417, 30, 31, 34, 2, -31 },
  { 3534, 22, 31, 27, 3, -31 },
  { 3620, 30, 38, 34, 2, -31 },
  { 3763, 26, 31, 29, 3, -31 },
  { 3864, 21, 31, 24, 2, -31 },
  { 3946, 23, 31, 25, 1, -31 },
  { 4036, 26, 31, 33, 3, -31 },
  { 4137, 29, 31, 29, 0, -31 },
  { 4250, 43, 31, 43, 0, -31 },
  { 4417, 30, 31, 30, 0, -31 },
  { 4534, 28, 31, 28, 0, -31 },
  { 4643, 23, 31, 26, 1, -31 },
  { 4733, 10, 38, 14, 3, -31 },
  { 4781, 18, 31, 18, 0, -31 },
  { 4851, 10, 38, 14, 1, -31 },
  { 4899, 23, 20, 24, 0, -31 },
  { 4957, 20, 4, 19, 0, 3 },
  { 4967, 13, 7, 17, 2, -33 },
  { 4979, 21, 24, 26, 2, -24 },
  { 5042, 22, 33, 27, 3, -33 },
  { 5133, 20, 24, 23, 2, -24 },
  { 5193, 22, 33, 27, 2, -33 },
  { 5284, 22, 24, 26, 2, -24 },
  { 5350, 18, 33, 17, 1, -33 },
  { 5425, 22, 34, 27, 2, -24 },
  { 5519, 22, 33, 28, 3, -33 },
  { 5610, 8, 33, 13, 3, -33 },
  { 5643, 13, 43, 13, -2, -33 },
  { 5713, 24, 33, 27, 3, -33 },
  { 5812, 7, 33, 13, 3, -33 },
  { 5841, 37, 24, 42, 3, -24 },
  { 5952, 22, 24, 28, 3, -24 },
  { 6018, 23, 24, 27, 2, -24 },
  { 6087, 22, 34, 27, 3, -24 },
  { 6181, 22, 34, 27, 2, -24 },
  { 6275, 16, 24, 20, 3, -24 },
  { 6323, 18, 24, 22, 2, -24 },
  { 6377, 17, 29, 19, 1, -29 },
  { 6439, 22, 24, 28, 3, -24 },
  { 6505, 25, 24, 25, 0, -24 },
  { 6580, 37, 24, 38, 0, -24 },
  { 6691, 26, 24, 26, 0, -24 },
  { 6769, 25, 34, 25, 0, -24 },
  { 6876, 19, 24, 21, 1, -24 },
  { 6933, 15, 38, 18, 1, -31 },
  { 7005, 5, 43, 23, 9, -33 },
  { 7032, 15, 38, 18, 2, -31 },
  { 7104, 21, 8, 25, 2, -19 },
};

const GFXfont NotoSans_ExtraBold43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold43pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_EXTRABOLD43PT7B_H_
