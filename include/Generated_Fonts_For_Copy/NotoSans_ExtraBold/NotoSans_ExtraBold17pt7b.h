#ifndef _NOTOSANS_EXTRABOLD17PT7B_H_
#define _NOTOSANS_EXTRABOLD17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-ExtraBold.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_ExtraBold17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x1B, 0xF0, 0xEF, 0xBC, 0xF3, 0x0D, 0x81, 0xB0,
  0x66, 0x3F, 0xF7, 0xFE, 0x36, 0x06, 0xC7, 0xFE, 0xFF, 0xC6, 0x60, 0xD8,
  0x1B, 0x00, 0x18, 0x3C, 0xFF, 0xFE, 0xD8, 0xF8, 0xFC, 0x3F, 0x1F, 0x9B,
  0xFF, 0xFE, 0x18, 0x18, 0x78, 0x30, 0xF8, 0xC3, 0xB1, 0x87, 0x66, 0x0E,
  0xDC, 0x0F, 0xB7, 0x9E, 0xED, 0x81, 0xBB, 0x07, 0x76, 0x0C, 0xEC, 0x30,
  0xF8, 0xE1, 0xE0, 0x3E, 0x07, 0xF0, 0x67, 0x07, 0x70, 0x7E, 0x03, 0xC7,
  0xFC, 0xEE, 0xEE, 0xE7, 0xCE, 0x3C, 0xFF, 0xE7, 0xEF, 0xFF, 0x60, 0x76,
  0xEE, 0xCC, 0xCC, 0xCC, 0xEE, 0x67, 0x30, 0xE1, 0x8C, 0x71, 0x8C, 0x63,
  0x18, 0xCE, 0x73, 0x39, 0x80, 0x1C, 0x06, 0x12, 0x4F, 0xFF, 0xF8, 0xF0,
  0xDC, 0xEC, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0xFF, 0x60,
  0xFF, 0xFE, 0xDF, 0x80, 0x0E, 0x1C, 0x30, 0xE1, 0x83, 0x0E, 0x18, 0x70,
  0xE1, 0x87, 0x00, 0x7C, 0xFE, 0xE7, 0xE7, 0xE7, 0xC7, 0xC7, 0xE7, 0xE7,
  0xE7, 0x7E, 0x3C, 0x1C, 0xF7, 0xFF, 0x5C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x7E, 0xFF, 0xC7, 0x07, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xFF, 0xFF,
  0xFE, 0xFF, 0x47, 0x07, 0x0E, 0x7C, 0x7E, 0x07, 0x07, 0x87, 0xFF, 0xFC,
  0x07, 0x03, 0xC0, 0xF0, 0x7C, 0x3F, 0x0D, 0xC6, 0x73, 0xFF, 0xFF, 0xFF,
  0xF0, 0x70, 0x1C, 0xFE, 0xFE, 0xE0, 0xE0, 0xFC, 0xFE, 0x4F, 0x07, 0x07,
  0x8F, 0xFE, 0xFC, 0x3E, 0x7E, 0xF0, 0xE0, 0xDE, 0xFF, 0xE7, 0xC7, 0xE7,
  0xE7, 0x7F, 0x3E, 0xFF, 0xFF, 0x07, 0x06, 0x0E, 0x0E, 0x1C, 0x1C, 0x38,
  0x38, 0x70, 0x70, 0x7E, 0xFF, 0xE7, 0xE7, 0x7E, 0x3C, 0x7E, 0xE7, 0xC3,
  0xC7, 0xFF, 0x7E, 0x7C, 0xFE, 0xE7, 0xC7, 0xC7, 0xEF, 0xFB, 0x7F, 0x07,
  0x0E, 0xFE, 0xF8, 0xFD, 0x00, 0x37, 0xE0, 0xFD, 0x00, 0x07, 0xFB, 0x00,
  0x01, 0x03, 0x0F, 0x3C, 0xF0, 0xF0, 0x7C, 0x0F, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0xC0, 0xF0, 0x3C, 0x0F, 0x0F, 0x7C, 0xF0, 0xC0,
  0x7E, 0xFF, 0x47, 0x07, 0x0E, 0x1E, 0x18, 0x38, 0x00, 0x18, 0x38, 0x38,
  0x0F, 0xC0, 0xF3, 0xC7, 0x03, 0x99, 0xF6, 0xCF, 0xDB, 0x63, 0x3D, 0x8D,
  0xB6, 0x36, 0xDF, 0xFB, 0x3D, 0xC6, 0x00, 0x1E, 0x38, 0x1F, 0xE0, 0x0F,
  0x00, 0xF0, 0x1F, 0x81, 0xF8, 0x19, 0x83, 0x9C, 0x39, 0xC3, 0xFC, 0x7F,
  0xE7, 0x0E, 0x70, 0xFE, 0x07, 0xFF, 0x3F, 0xEE, 0x3B, 0x8E, 0xE7, 0xBF,
  0xCF, 0xFB, 0x8E, 0xE1, 0xF8, 0xEF, 0xFB, 0xFC, 0x1F, 0xBF, 0xDC, 0x3C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x3C, 0x5F, 0xE3, 0xF0, 0xFF, 0x1F,
  0xF3, 0x8F, 0x70, 0xEE, 0x1D, 0xC1, 0xF8, 0x3F, 0x0E, 0xE1, 0xDC, 0xFB,
  0xFE, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xFE, 0xFE, 0xE0, 0xE0,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1F, 0xFF, 0xF0, 0xE1, 0xC3,
  0x87, 0x00, 0x1F, 0xDF, 0xF7, 0x8B, 0xC0, 0xE0, 0x39, 0xFE, 0x7F, 0x87,
  0xE1, 0xDE, 0x77, 0xFC, 0x7F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x70, 0xFF, 0xDC,
  0xE7, 0x39, 0xCE, 0x73, 0xBF, 0xF0, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0xFF, 0xDC, 0xE1, 0xF8, 0xEE, 0x73, 0x9C, 0xEE, 0x3F, 0x8F,
  0xE3, 0xDC, 0xE7, 0x38, 0xEE, 0x3F, 0x87, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xFC, 0xFF, 0xB3, 0x7E, 0xCD, 0xFB, 0xB7, 0xE7, 0x9F, 0x9E,
  0x7E, 0x79, 0xF9, 0xC7, 0xF8, 0x7F, 0x87, 0xFC, 0x7F, 0xC7, 0xEE, 0x7E,
  0xE7, 0xE7, 0x7E, 0x77, 0xE3, 0xFE, 0x3F, 0xE1, 0xFE, 0x0F, 0x3F, 0x87,
  0xFC, 0x71, 0xEE, 0x0E, 0xE0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE0, 0xE7,
  0x9E, 0x7F, 0xC1, 0xF8, 0xFE, 0x7F, 0xB9, 0xFC, 0x7E, 0x3F, 0xFF, 0xFD,
  0xF8, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x3F, 0x87, 0xFC, 0x71, 0xEE, 0x0E,
  0xE0, 0xEE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE0, 0xE7, 0x9E, 0x7F, 0xC1, 0xF8,
  0x03, 0xC0, 0x1C, 0x00, 0xF0, 0xFE, 0x3F, 0xEE, 0x3B, 0x8E, 0xE3, 0xBF,
  0xCF, 0xE3, 0xB8, 0xE7, 0x38, 0xEE, 0x3B, 0x87, 0x7F, 0xFF, 0xE2, 0xE0,
  0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0xC7, 0xFE, 0xFC, 0xFF, 0xFF, 0xF1, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xCE,
  0x39, 0xFF, 0x1F, 0x80, 0xE0, 0xEE, 0x1D, 0xC3, 0xB8, 0xE3, 0x1C, 0x73,
  0x8E, 0xE0, 0xDC, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x00, 0xE1, 0xC3, 0xB0,
  0xE1, 0x9C, 0xF9, 0xCE, 0x6C, 0xE7, 0x36, 0x71, 0x9B, 0x30, 0xCD, 0x98,
  0x7E, 0xFC, 0x3E, 0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xF0,
  0xE7, 0x1C, 0x39, 0xC1, 0xF8, 0x1F, 0x80, 0xF0, 0x0F, 0x01, 0xF8, 0x3B,
  0x83, 0x9C, 0x71, 0xEF, 0x0F, 0xE1, 0xEE, 0x39, 0xC7, 0x1D, 0xC3, 0xB0,
  0x3E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x7F, 0xDF,
  0xF0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1C, 0x0F, 0xFF,
  0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xE0, 0xC1, 0xC3,
  0x83, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x70, 0xFF, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x3F, 0xF0, 0x18, 0x0E, 0x07, 0x06, 0xC3, 0x73, 0x19, 0x8F,
  0x83, 0xFF, 0xFF, 0xE3, 0x86, 0x08, 0x7E, 0x7F, 0x07, 0x3F, 0xFF, 0xE7,
  0xE7, 0xFF, 0x7B, 0xE0, 0x70, 0x38, 0x1C, 0x8F, 0xF7, 0xFF, 0x8F, 0xC7,
  0xE3, 0xF1, 0xFC, 0xFF, 0xEE, 0xF0, 0x08, 0x7F, 0xFE, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE2, 0x7E, 0x3E, 0x03, 0x81, 0xC0, 0xE2, 0x77, 0xFF, 0xFF, 0x8F,
  0xC7, 0xE3, 0xF1, 0xF9, 0xFF, 0xF7, 0xB8, 0x08, 0x3F, 0x3F, 0xDC, 0x6F,
  0xFF, 0xFF, 0x81, 0xC2, 0x7F, 0x1F, 0x80, 0x1E, 0x7C, 0xE1, 0xCF, 0xFF,
  0xCE, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x80, 0x10, 0x3F, 0xFF, 0xFC, 0x7E,
  0x3F, 0x1F, 0x8F, 0xCF, 0xFF, 0xBD, 0xC0, 0xF0, 0xEF, 0xF7, 0xF0, 0xE0,
  0x70, 0x38, 0x1C, 0x8F, 0xF7, 0xFF, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x38, 0xFD, 0x0F, 0xFF, 0xFF, 0xFE, 0x39, 0xC4, 0x03, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xFF, 0xF0, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xE3,
  0xB9, 0xCE, 0xE3, 0xF0, 0xFE, 0x3F, 0x8E, 0x73, 0x8E, 0xE3, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x04, 0x11, 0xFE, 0xFB, 0xFF, 0xF7, 0x1C, 0x7E,
  0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1C, 0x04,
  0x7F, 0xBF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xC0, 0x08,
  0x3F, 0x3F, 0xDC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x7F, 0x1F, 0x00, 0x04,
  0x7F, 0xBF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xE7, 0xFF, 0x77, 0xB8, 0x1C,
  0x0E, 0x07, 0x00, 0x10, 0x3F, 0xFF, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xCF,
  0xFF, 0xBD, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0xFB, 0xF7, 0x8E, 0x1C,
  0x38, 0x70, 0xE1, 0xC0, 0x11, 0xFF, 0xB7, 0x0F, 0x8F, 0x87, 0xC7, 0xFF,
  0xF8, 0x30, 0x61, 0xFF, 0xF3, 0x06, 0x0C, 0x18, 0x38, 0x7C, 0xF8, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0xFF, 0x7D, 0x80, 0xE1, 0xDC,
  0xE7, 0x39, 0xCE, 0x37, 0x0F, 0xC1, 0xE0, 0x78, 0x1E, 0x00, 0xE3, 0x8E,
  0xCF, 0x99, 0xDB, 0x73, 0xB6, 0xE3, 0x6D, 0x86, 0xDB, 0x0F, 0x16, 0x1E,
  0x3C, 0x1C, 0x70, 0xF3, 0xDE, 0xE3, 0xF0, 0x7C, 0x1E, 0x0F, 0xC3, 0xF9,
  0xCE, 0xF1, 0xC0, 0xE1, 0xDC, 0xE7, 0x38, 0xCE, 0x3B, 0x0F, 0xC1, 0xE0,
  0x78, 0x0E, 0x07, 0x01, 0xC1, 0xE0, 0x70, 0x00, 0x7F, 0x7F, 0x0E, 0x1C,
  0x1C, 0x38, 0x70, 0xFF, 0xFF, 0x1C, 0x73, 0x8E, 0x38, 0xEF, 0xBC, 0x78,
  0xE3, 0x8E, 0x38, 0x70, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE3, 0x87,
  0x1C, 0x71, 0xC3, 0xCF, 0x79, 0xC7, 0x1C, 0x73, 0x8C, 0x00, 0x41, 0xFF,
  0xFF, 0x84,
};

const GFXglyph NotoSans_ExtraBold17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 12, 5, 1, -12 },
  { 6, 6, 4, 9, 1, -12 },
  { 9, 11, 12, 11, 0, -12 },
  { 26, 8, 14, 10, 1, -13 },
  { 40, 15, 12, 16, 0, -12 },
  { 63, 12, 12, 13, 1, -12 },
  { 81, 3, 4, 5, 1, -12 },
  { 83, 4, 15, 6, 1, -12 },
  { 91, 5, 15, 6, 0, -12 },
  { 101, 9, 8, 9, 0, -13 },
  { 110, 8, 8, 10, 1, -10 },
  { 118, 3, 4, 5, 1, -2 },
  { 120, 5, 3, 5, 0, -6 },
  { 122, 3, 3, 5, 1, -3 },
  { 124, 7, 12, 7, 0, -12 },
  { 135, 8, 12, 10, 1, -12 },
  { 147, 6, 12, 10, 1, -12 },
  { 156, 8, 12, 10, 1, -12 },
  { 168, 8, 12, 10, 1, -12 },
  { 180, 10, 12, 10, 0, -12 },
  { 195, 8, 12, 10, 1, -12 },
  { 207, 8, 12, 10, 1, -12 },
  { 219, 8, 12, 10, 1, -12 },
  { 231, 8, 12, 10, 1, -12 },
  { 243, 8, 12, 10, 1, -12 },
  { 255, 3, 9, 5, 1, -9 },
  { 259, 3, 11, 5, 1, -9 },
  { 264, 8, 9, 10, 1, -11 },
  { 273, 8, 6, 10, 1, -9 },
  { 279, 8, 9, 10, 1, -11 },
  { 288, 8, 12, 8, 0, -12 },
  { 300, 14, 13, 15, 1, -12 },
  { 323, 12, 12, 12, 0, -12 },
  { 341, 10, 12, 11, 1, -12 },
  { 356, 9, 12, 11, 1, -12 },
  { 370, 11, 12, 12, 1, -12 },
  { 387, 8, 12, 9, 1, -12 },
  { 399, 7, 12, 9, 1, -12 },
  { 410, 10, 12, 12, 1, -12 },
  { 425, 11, 12, 13, 1, -12 },
  { 442, 5, 12, 7, 1, -12 },
  { 450, 5, 16, 6, -1, -12 },
  { 460, 10, 12, 11, 1, -12 },
  { 475, 8, 12, 10, 1, -12 },
  { 487, 14, 12, 16, 1, -12 },
  { 508, 12, 12, 14, 1, -12 },
  { 526, 12, 12, 14, 1, -12 },
  { 544, 9, 12, 11, 1, -12 },
  { 558, 12, 15, 14, 1, -12 },
  { 581, 10, 12, 11, 1, -12 },
  { 596, 8, 12, 10, 1, -12 },
  { 608, 10, 12, 10, 0, -12 },
  { 623, 11, 12, 13, 1, -12 },
  { 640, 11, 12, 11, 0, -12 },
  { 657, 17, 12, 17, 0, -12 },
  { 683, 12, 12, 12, 0, -12 },
  { 701, 11, 12, 11, 0, -12 },
  { 718, 10, 12, 10, 0, -12 },
  { 733, 4, 15, 6, 1, -12 },
  { 741, 7, 12, 7, 0, -12 },
  { 752, 4, 15, 6, 0, -12 },
  { 760, 9, 8, 9, 0, -12 },
  { 769, 8, 2, 8, 0, 1 },
  { 771, 5, 3, 7, 1, -13 },
  { 773, 8, 10, 10, 1, -10 },
  { 783, 9, 13, 11, 1, -13 },
  { 798, 8, 10, 9, 1, -10 },
  { 808, 9, 13, 11, 1, -13 },
  { 823, 9, 10, 10, 1, -10 },
  { 835, 7, 13, 7, 0, -13 },
  { 847, 9, 14, 11, 1, -10 },
  { 863, 9, 13, 11, 1, -13 },
  { 878, 3, 13, 5, 1, -13 },
  { 883, 5, 17, 5, -1, -13 },
  { 894, 10, 13, 11, 1, -13 },
  { 911, 3, 13, 5, 1, -13 },
  { 916, 15, 10, 17, 1, -10 },
  { 935, 9, 10, 11, 1, -10 },
  { 947, 9, 10, 11, 1, -10 },
  { 959, 9, 14, 11, 1, -10 },
  { 975, 9, 14, 11, 1, -10 },
  { 991, 7, 10, 8, 1, -10 },
  { 1000, 7, 10, 9, 1, -10 },
  { 1009, 7, 11, 8, 0, -11 },
  { 1019, 9, 9, 11, 1, -9 },
  { 1030, 10, 9, 10, 0, -9 },
  { 1042, 15, 9, 15, 0, -9 },
  { 1059, 10, 9, 10, 0, -9 },
  { 1071, 10, 13, 10, 0, -9 },
  { 1088, 8, 9, 8, 0, -9 },
  { 1097, 6, 15, 7, 0, -12 },
  { 1109, 2, 17, 9, 4, -13 },
  { 1114, 6, 15, 7, 1, -12 },
  { 1126, 8, 4, 10, 1, -8 },
};

const GFXfont NotoSans_ExtraBold17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_ExtraBold17pt7bBitmaps,
  (GFXglyph *)NotoSans_ExtraBold17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_EXTRABOLD17PT7B_H_
