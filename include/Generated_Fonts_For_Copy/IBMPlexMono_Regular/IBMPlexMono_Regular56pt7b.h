#ifndef _IBMPLEXMONO_REGULAR56PT7B_H_
#define _IBMPLEXMONO_REGULAR56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular56pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x18,
  0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x3F, 0xFC, 0x0F, 0xFF, 0x3F, 0xF8, 0x0F,
  0xFF, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xF0, 0x3F,
  0xFC, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xE0, 0x7C,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xC7, 0x3F, 0xC3,
  0xF0, 0x70, 0x7E, 0x3E, 0x07, 0x03, 0xF3, 0xC0, 0x70, 0x1C, 0x7C, 0x07,
  0x00, 0x87, 0xC0, 0x70, 0x00, 0x7C, 0x07, 0x00, 0x07, 0xC0, 0x70, 0x00,
  0x7C, 0x07, 0x00, 0x07, 0xC0, 0x70, 0x00, 0x3E, 0x07, 0x00, 0x03, 0xF0,
  0x70, 0x00, 0x1F, 0x87, 0x00, 0x01, 0xFF, 0x70, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x71, 0xFC, 0x00, 0x07, 0x07, 0xE0, 0x00, 0x70,
  0x3E, 0x00, 0x07, 0x01, 0xF0, 0x00, 0x70, 0x1F, 0x00, 0x07, 0x01, 0xF0,
  0x00, 0x70, 0x1F, 0x00, 0x07, 0x01, 0xF2, 0x00, 0x70, 0x1F, 0x30, 0x07,
  0x01, 0xF7, 0x80, 0x70, 0x3E, 0xFC, 0x07, 0x03, 0xE7, 0xF0, 0x70, 0xFC,
  0x3F, 0xC7, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x3F,
  0xFC, 0x00, 0x1E, 0x3F, 0xFE, 0x00, 0x3C, 0x7C, 0x1F, 0x00, 0x3C, 0x78,
  0x0F, 0x00, 0x78, 0xF0, 0x07, 0x00, 0x78, 0xF0, 0x07, 0x80, 0xF0, 0xF0,
  0x07, 0x80, 0xF0, 0xF0, 0x07, 0x81, 0xE0, 0xF0, 0x07, 0x83, 0xE0, 0xF0,
  0x07, 0x83, 0xC0, 0xF0, 0x07, 0x87, 0x80, 0xF0, 0x07, 0x07, 0x80, 0x78,
  0x0F, 0x0F, 0x00, 0x7C, 0x1F, 0x0F, 0x00, 0x3F, 0xFE, 0x1E, 0x00, 0x3F,
  0xFC, 0x1E, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x78, 0x7F, 0xF8, 0x00, 0xF0, 0xFF, 0xFC, 0x00, 0xF0, 0xF8, 0x7C, 0x01,
  0xE1, 0xF0, 0x1E, 0x01, 0xE1, 0xE0, 0x1E, 0x03, 0xC1, 0xE0, 0x0E, 0x03,
  0xC1, 0xE0, 0x0E, 0x07, 0x81, 0xE0, 0x0E, 0x07, 0x81, 0xE0, 0x0E, 0x0F,
  0x01, 0xE0, 0x0E, 0x1F, 0x01, 0xE0, 0x0E, 0x1E, 0x01, 0xE0, 0x1E, 0x3C,
  0x01, 0xF0, 0x1E, 0x3C, 0x00, 0xF8, 0x7C, 0x78, 0x00, 0xFF, 0xFC, 0x78,
  0x00, 0x7F, 0xF8, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0,
  0x07, 0x80, 0x07, 0xC0, 0x0C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC1, 0xF7, 0xC0, 0x7F,
  0x87, 0xC7, 0xC0, 0xF0, 0x1F, 0x07, 0xC1, 0xE0, 0x3C, 0x0F, 0xC3, 0xC0,
  0xF8, 0x0F, 0x87, 0x81, 0xE0, 0x0F, 0x8F, 0x03, 0xC0, 0x0F, 0x9C, 0x0F,
  0x80, 0x0F, 0xB8, 0x1F, 0x00, 0x0F, 0xF0, 0x3E, 0x00, 0x1F, 0xE0, 0x7C,
  0x00, 0x1F, 0x80, 0x78, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0xFF, 0x01, 0xF0, 0x03, 0x9F, 0x03, 0xF8, 0x1F, 0x1F, 0x03, 0xFF,
  0xFC, 0x3F, 0x03, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0x3F, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x3C, 0x03, 0x9F, 0xC1, 0xE0, 0xFE, 0xFF, 0xCF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0xE0, 0x01, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xE3,
  0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC1,
  0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFE,
  0x07, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x3E, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x03, 0xE0, 0x3F, 0xE0, 0x7E,
  0x07, 0xFC, 0x1F, 0xC0, 0xFF, 0x83, 0xF8, 0x1F, 0xF0, 0x7F, 0x03, 0xFE,
  0x07, 0xE0, 0x7F, 0xC0, 0xF8, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x80, 0xFE,
  0x07, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0x7C,
  0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x07,
  0xE0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0x80, 0x7C, 0x00, 0x30, 0x07,
  0xC0, 0x02, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0x81,
  0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0x1C, 0x00, 0x07, 0xC1, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F,
  0xC0, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0x70, 0x00, 0x3E, 0x08, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x30, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xFB, 0xF8, 0x00, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80,
  0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x1E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x01,
  0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x7F, 0x00, 0x3C,
  0x7F, 0xF0, 0x0F, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xFC,
  0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x40, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xC7, 0xE0, 0x03,
  0xF0, 0xFE, 0x03, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x7C, 0x7F, 0xF0,
  0x1E, 0x7F, 0xFF, 0x0F, 0xBF, 0xFF, 0xE3, 0xEE, 0x03, 0xFC, 0xFE, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7D, 0xE0, 0x00,
  0x1E, 0x78, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xE3, 0xE0, 0x03, 0xF0, 0x7E,
  0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xC0, 0x7F, 0x83, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x01,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x7C, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E,
  0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0xC0, 0x3F, 0x81, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F,
  0x80, 0xFE, 0x0F, 0x80, 0x0F, 0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xF7, 0xC0, 0x01, 0xFD,
  0xF8, 0x00, 0xFF, 0x3F, 0x80, 0xF7, 0x87, 0xFF, 0xF9, 0xE0, 0xFF, 0xFC,
  0xF8, 0x1F, 0xFE, 0x3E, 0x00, 0xFE, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7C, 0x1F, 0x07, 0xF0, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE0,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0xFE, 0x1F,
  0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F,
  0x81, 0xE0, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE1,
  0xF8, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0x1C, 0x00, 0x07, 0xC2, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xE0, 0x07,
  0xE1, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x3D, 0xE0, 0x0F, 0x8F, 0x78, 0x0F, 0xF3, 0xDE,
  0x07, 0xFE, 0xF7, 0x81, 0xFF, 0xFD, 0xE0, 0xFC, 0x3F, 0x78, 0x3C, 0x03,
  0xDE, 0x0F, 0x00, 0xF7, 0x87, 0xC0, 0x3D, 0xE1, 0xE0, 0x0F, 0xF8, 0x78,
  0x03, 0xFE, 0x1E, 0x00, 0xFF, 0x87, 0x80, 0x3F, 0xE1, 0xE0, 0x0F, 0xF8,
  0x78, 0x03, 0xDE, 0x1E, 0x00, 0xF7, 0x87, 0x80, 0x3D, 0xE1, 0xE0, 0x0F,
  0x78, 0x3C, 0x03, 0xDE, 0x0F, 0x00, 0xF7, 0x83, 0xE0, 0x7D, 0xE0, 0xFE,
  0x7F, 0x78, 0x1F, 0xFF, 0xDE, 0x03, 0xFE, 0xF7, 0x80, 0x7F, 0x3C, 0xF0,
  0x07, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0xF0, 0x7C, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x01,
  0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF0,
  0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3E,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x07, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xF3, 0xE0, 0x00,
  0xF9, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC7, 0xC0, 0x03, 0xF3, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xBE, 0x00, 0x1F, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x07, 0xE1,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0xC7, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x0C,
  0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0x7E, 0x00,
  0x7E, 0x0F, 0xE0, 0x7F, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0x80, 0x3F, 0xC7, 0xC0, 0x07,
  0xE3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x7E, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0x07,
  0xE0, 0x07, 0xE1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xC7, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3D, 0xE0,
  0x00, 0x0F, 0x78, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3D,
  0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF1, 0xF0, 0x00,
  0xFC, 0x7E, 0x00, 0x6F, 0x0F, 0xE0, 0x7B, 0xC3, 0xFF, 0xFC, 0xF0, 0x7F,
  0xFE, 0x3C, 0x07, 0xFF, 0x0F, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC2, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF8, 0x03,
  0xF1, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0x00, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFB, 0xC0, 0x00,
  0x7E, 0x78, 0x00, 0x1F, 0x8F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x3C,
  0x00, 0x3F, 0x07, 0x80, 0x0F, 0xC0, 0xF0, 0x03, 0xF0, 0x1E, 0x00, 0xFC,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x01, 0xF8, 0x01, 0xE0,
  0x7E, 0x00, 0x3C, 0x1F, 0x80, 0x07, 0x87, 0xE0, 0x00, 0xF0, 0xF8, 0x00,
  0x1E, 0x3F, 0x80, 0x03, 0xCF, 0xF8, 0x00, 0x7B, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0x3E, 0x00, 0x3F, 0xC3, 0xE0, 0x07, 0xF0, 0x7E, 0x00,
  0xFC, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0xC0, 0x78, 0x00,
  0xF8, 0x0F, 0x00, 0x1F, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x07,
  0x80, 0x03, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xE3, 0xC0, 0x00,
  0x7E, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xFD, 0xE0, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xDE, 0x01, 0xFF, 0xF7, 0x80,
  0x77, 0xFC, 0xF0, 0x3D, 0xFF, 0x3C, 0x0F, 0x7F, 0xCF, 0x87, 0x9F, 0xF1,
  0xE1, 0xE7, 0xFC, 0x78, 0xF1, 0xFF, 0x0F, 0x3C, 0x7F, 0xC3, 0xCF, 0x1F,
  0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xF0, 0x7F, 0xC0, 0xFC,
  0x1F, 0xF0, 0x3F, 0x07, 0xFC, 0x07, 0x81, 0xFF, 0x01, 0xE0, 0x7F, 0xC0,
  0x70, 0x1F, 0xF0, 0x0C, 0x07, 0xFC, 0x02, 0x01, 0xFF, 0x00, 0x80, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7C, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xF7, 0x80, 0x0F, 0xFB, 0xE0, 0x07, 0xFD, 0xF0, 0x03, 0xFE, 0x78,
  0x01, 0xFF, 0x3E, 0x00, 0xFF, 0x8F, 0x00, 0x7F, 0xC7, 0xC0, 0x3F, 0xE1,
  0xE0, 0x1F, 0xF0, 0xF0, 0x0F, 0xF8, 0x7C, 0x07, 0xFC, 0x1E, 0x03, 0xFE,
  0x0F, 0x81, 0xFF, 0x03, 0xC0, 0xFF, 0x81, 0xE0, 0x7F, 0xC0, 0xF8, 0x3F,
  0xE0, 0x3C, 0x1F, 0xF0, 0x1F, 0x0F, 0xF8, 0x07, 0x87, 0xFC, 0x03, 0xC3,
  0xFE, 0x01, 0xF1, 0xFF, 0x00, 0x78, 0xFF, 0x80, 0x3E, 0x7F, 0xC0, 0x0F,
  0x3F, 0xE0, 0x07, 0xDF, 0xF0, 0x03, 0xEF, 0xF8, 0x00, 0xF7, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x3E, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xBC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0xF3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xCF, 0x80, 0x07, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xBF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xF3, 0xE0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3E,
  0x0F, 0xC0, 0x0F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x7F, 0x3E, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC1,
  0xFC, 0x03, 0xFC, 0x7E, 0x00, 0x1F, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x0C, 0x7C, 0x00, 0x01, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x79, 0x00, 0x00, 0x1F, 0x30, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x3F, 0x80, 0x07, 0xE3,
  0xFC, 0x03, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00,
  0x03, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3C, 0x07,
  0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1E,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xF0, 0x3C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3E, 0x1E, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x01, 0xE7, 0x80,
  0xFC, 0x07, 0x9E, 0x03, 0xF0, 0x1E, 0x78, 0x0F, 0xC0, 0x79, 0xE0, 0x7F,
  0x01, 0xE7, 0x81, 0xFC, 0x0F, 0x9E, 0x07, 0xF8, 0x3C, 0x78, 0x1D, 0xE0,
  0xF1, 0xE0, 0x77, 0x83, 0xC7, 0x83, 0xCE, 0x0F, 0x1F, 0x0F, 0x3C, 0x3C,
  0x3C, 0x3C, 0xF0, 0xF0, 0xF0, 0xE3, 0xC3, 0xC3, 0xC3, 0x8F, 0x0F, 0x0F,
  0x1E, 0x1C, 0x3C, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7,
  0x07, 0x8F, 0x0F, 0x3C, 0x1E, 0x38, 0x3C, 0xF0, 0x39, 0xE0, 0xF3, 0xC0,
  0xF7, 0x83, 0xCF, 0x03, 0xDE, 0x0F, 0x38, 0x0F, 0x78, 0x1F, 0xE0, 0x3D,
  0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8,
  0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x03,
  0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0,
  0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x80,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x9E,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x1E, 0x00, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3E, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x20, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x08, 0x1C, 0x3F, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1E,
  0x07, 0x83, 0xC0, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x01, 0xF8,
  0x1E, 0x00, 0x1F, 0x00, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xE0, 0x07, 0xC3, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x1B, 0xC1, 0xF8, 0x0F, 0x7F, 0xBF,
  0xFF, 0xCF, 0xF3, 0xFF, 0xF0, 0xFE, 0x1F, 0xFC, 0x0F, 0xC0, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x03, 0xF0, 0x0F, 0x8F, 0xFF, 0x07, 0xCF, 0xFF, 0xC3, 0xEF, 0xFF, 0xF1,
  0xF7, 0x03, 0xFC, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xBE,
  0x00, 0x07, 0xDF, 0x80, 0x07, 0xEF, 0xE0, 0x07, 0xE7, 0xDC, 0x0F, 0xF3,
  0xEF, 0xFF, 0xF1, 0xF3, 0xFF, 0xF0, 0xF8, 0xFF, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xC0, 0xFC, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x7C, 0x00,
  0x1C, 0x78, 0x00, 0x10, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x0C, 0x7C, 0x00,
  0x0E, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x3E, 0x1F, 0xC0, 0xFE, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1F, 0xC0, 0xF0,
  0x3F, 0xF8, 0x78, 0x3F, 0xFE, 0x3C, 0x3F, 0xFF, 0x9E, 0x3F, 0x81, 0xEF,
  0x3F, 0x00, 0x3F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xEF, 0x80, 0x00,
  0xF7, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0,
  0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE7,
  0xC0, 0x01, 0xF3, 0xF0, 0x03, 0xF8, 0xFE, 0x03, 0xBC, 0x3F, 0xFF, 0x9E,
  0x0F, 0xFF, 0x8F, 0x03, 0xFF, 0x87, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xC0, 0xFE, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x3C,
  0x78, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x41, 0xF0, 0x00, 0x1C, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x07, 0xC1, 0xFC,
  0x07, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xDF, 0xF0, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF8, 0x3E,
  0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC7, 0x80, 0x00, 0xFD,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xCF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xFC, 0x0F,
  0x8F, 0xFE, 0x1F, 0x3F, 0xFE, 0x3E, 0xFF, 0xFE, 0x7D, 0xC0, 0xFE, 0xFE,
  0x00, 0x7D, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xBC, 0x00, 0x0F, 0x8F, 0x00, 0x07,
  0xC3, 0xC0, 0x07, 0xE0, 0xF0, 0x03, 0xF0, 0x3C, 0x01, 0xF8, 0x0F, 0x00,
  0xFC, 0x03, 0xC0, 0x7E, 0x00, 0xF0, 0x3F, 0x00, 0x3C, 0x1F, 0x80, 0x0F,
  0x0F, 0xC0, 0x03, 0xC7, 0xE0, 0x00, 0xF3, 0xFC, 0x00, 0x3D, 0xFF, 0x00,
  0x0F, 0xFB, 0xE0, 0x03, 0xFC, 0x7C, 0x00, 0xFE, 0x1F, 0x80, 0x3E, 0x03,
  0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x1F, 0x80, 0xF0, 0x03, 0xF0, 0x3C,
  0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xF0, 0xF0, 0x00, 0x7E,
  0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7E, 0xF0, 0x00,
  0x0F, 0xC0, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xF0, 0x1F, 0x0F, 0x3F, 0xC3, 0xFC, 0xF3, 0xFC, 0x7F, 0xCF, 0x7F, 0xEF,
  0xFE, 0xF4, 0x3E, 0xC3, 0xEF, 0x81, 0xF8, 0x1E, 0xF8, 0x1F, 0x01, 0xEF,
  0x00, 0xF0, 0x1F, 0xF0, 0x0F, 0x01, 0xFF, 0x00, 0xF0, 0x1F, 0xF0, 0x0F,
  0x01, 0xFF, 0x00, 0xF0, 0x1F, 0xF0, 0x0F, 0x01, 0xFF, 0x00, 0xF0, 0x1F,
  0xF0, 0x0F, 0x01, 0xFF, 0x00, 0xF0, 0x1F, 0xF0, 0x0F, 0x01, 0xFF, 0x00,
  0xF0, 0x1F, 0xF0, 0x0F, 0x01, 0xFF, 0x00, 0xF0, 0x1F, 0xF0, 0x0F, 0x01,
  0xFF, 0x00, 0xF0, 0x1F, 0xF0, 0x0F, 0x01, 0xFF, 0x00, 0xF0, 0x1F, 0xF0,
  0x0F, 0x01, 0xFF, 0x00, 0xF0, 0x1F, 0xF0, 0x0F, 0x01, 0xFF, 0x00, 0xF0,
  0x1F, 0xF0, 0x0F, 0x01, 0xFF, 0x00, 0xF0, 0x1F, 0x00, 0x3F, 0x81, 0xF1,
  0xFF, 0xC3, 0xE7, 0xFF, 0xC7, 0xDF, 0xFF, 0xCF, 0xB8, 0x1F, 0xDF, 0xC0,
  0x0F, 0xBF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xC0, 0xFE, 0x0F, 0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0xF9, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0x81,
  0xFC, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x7F, 0xF8, 0x3E, 0x7F,
  0xFE, 0x1F, 0x7F, 0xFF, 0x8F, 0xB8, 0x1F, 0xE7, 0xF0, 0x03, 0xF3, 0xF0,
  0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0x3E, 0xE0, 0x7F, 0x9F, 0x7F, 0xFF, 0x8F, 0x9F, 0xFF, 0x87, 0xC7,
  0xFF, 0x03, 0xE0, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xC3, 0xC1, 0xFF, 0xF1, 0xE1, 0xFF,
  0xFC, 0xF1, 0xFC, 0x0F, 0x79, 0xF8, 0x01, 0xFC, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xF0, 0x00,
  0x1E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x1F, 0xC7, 0xF0,
  0x1D, 0xE1, 0xFF, 0xFC, 0xF0, 0x7F, 0xFC, 0x78, 0x1F, 0xFC, 0x3C, 0x03,
  0xF8, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0,
  0x07, 0x9E, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC3, 0xF8, 0x07, 0xF9, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x18, 0xF8, 0x00,
  0x08, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x80, 0x00, 0x1E,
  0x60, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xDF, 0xE0, 0x1F,
  0xC7, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7E, 0x00,
  0x7E, 0x7F, 0x03, 0xBC, 0xFF, 0xFF, 0x78, 0xFF, 0xFC, 0xF0, 0x7F, 0xF1,
  0xE0, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F,
  0x81, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x3F, 0xC0, 0x3F, 0x00, 0xFF, 0x00,
  0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x0E, 0xF0, 0x1F, 0xC0, 0x79, 0xC0, 0x77,
  0x01, 0xE7, 0x81, 0xDE, 0x07, 0x9E, 0x07, 0x38, 0x1E, 0x78, 0x1C, 0xE0,
  0x79, 0xE0, 0x73, 0x81, 0xC7, 0x83, 0xCE, 0x07, 0x1E, 0x0E, 0x3C, 0x1C,
  0x38, 0x38, 0x70, 0xF0, 0xE0, 0xE1, 0xC3, 0xC3, 0xC3, 0x87, 0x0F, 0x0F,
  0x1E, 0x1C, 0x3C, 0x3C, 0x70, 0x78, 0xE0, 0xF1, 0xC1, 0xE3, 0x81, 0xC7,
  0x03, 0x8E, 0x07, 0x1C, 0x0E, 0x78, 0x1C, 0xF0, 0x39, 0xE0, 0x73, 0x80,
  0xF7, 0x81, 0xEE, 0x03, 0xDE, 0x07, 0xB8, 0x07, 0x70, 0x1E, 0xE0, 0x1D,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x1E, 0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x3F,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x1E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00,
  0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x3E,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xC0, 0xFF, 0x00, 0x0F, 0x1F, 0xF8, 0x00, 0xE3,
  0xFF, 0xC0, 0x1E, 0x3C, 0x7E, 0x01, 0xE7, 0xC1, 0xF0, 0x1C, 0x78, 0x0F,
  0x83, 0xC7, 0x80, 0xFC, 0x7C, 0xF0, 0x07, 0xFF, 0x8F, 0x00, 0x3F, 0xF0,
  0xF0, 0x01, 0xFE, 0x06, 0x00, 0x07, 0xC0,
};

const GFXglyph IBMPlexMono_Regular56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 8, 40, 34, 13, -39 },
  { 41, 14, 16, 34, 10, -41 },
  { 69, 32, 39, 34, 1, -39 },
  { 225, 28, 53, 34, 3, -46 },
  { 411, 32, 41, 34, 1, -40 },
  { 575, 31, 41, 34, 1, -40 },
  { 734, 4, 16, 34, 15, -41 },
  { 742, 17, 51, 34, 11, -43 },
  { 851, 16, 51, 34, 6, -43 },
  { 953, 29, 28, 34, 2, -32 },
  { 1055, 27, 28, 34, 3, -31 },
  { 1150, 11, 16, 34, 11, -8 },
  { 1172, 16, 4, 34, 9, -19 },
  { 1180, 8, 8, 34, 13, -7 },
  { 1188, 24, 51, 34, 5, -43 },
  { 1341, 27, 41, 34, 3, -40 },
  { 1480, 28, 39, 34, 3, -39 },
  { 1617, 26, 40, 34, 4, -40 },
  { 1747, 26, 41, 34, 3, -40 },
  { 1881, 29, 39, 34, 2, -39 },
  { 2023, 26, 40, 34, 4, -39 },
  { 2153, 26, 40, 34, 4, -39 },
  { 2283, 26, 39, 34, 4, -39 },
  { 2410, 28, 41, 34, 3, -40 },
  { 2554, 26, 40, 34, 4, -40 },
  { 2684, 8, 30, 34, 13, -29 },
  { 2714, 11, 37, 34, 11, -29 },
  { 2765, 24, 32, 34, 5, -33 },
  { 2861, 27, 15, 34, 3, -25 },
  { 2912, 24, 32, 34, 5, -33 },
  { 3008, 25, 41, 34, 4, -40 },
  { 3137, 26, 46, 34, 3, -40 },
  { 3287, 30, 39, 34, 2, -39 },
  { 3434, 25, 39, 34, 5, -39 },
  { 3556, 26, 41, 34, 4, -40 },
  { 3690, 25, 39, 34, 5, -39 },
  { 3812, 24, 39, 34, 5, -39 },
  { 3929, 25, 39, 34, 5, -39 },
  { 4051, 26, 41, 34, 3, -40 },
  { 4185, 25, 39, 34, 4, -39 },
  { 4307, 24, 39, 34, 5, -39 },
  { 4424, 23, 40, 34, 4, -39 },
  { 4539, 27, 39, 34, 5, -39 },
  { 4671, 23, 39, 34, 7, -39 },
  { 4784, 26, 39, 34, 4, -39 },
  { 4911, 25, 39, 34, 4, -39 },
  { 5033, 27, 41, 34, 3, -40 },
  { 5172, 25, 39, 34, 5, -39 },
  { 5294, 27, 50, 34, 3, -40 },
  { 5463, 26, 39, 34, 5, -39 },
  { 5590, 27, 41, 34, 3, -40 },
  { 5729, 31, 39, 34, 1, -39 },
  { 5881, 25, 40, 34, 4, -39 },
  { 6006, 30, 39, 34, 2, -39 },
  { 6153, 30, 39, 34, 2, -39 },
  { 6300, 31, 39, 34, 1, -39 },
  { 6452, 32, 39, 34, 1, -39 },
  { 6608, 28, 39, 34, 3, -39 },
  { 6745, 15, 51, 34, 13, -43 },
  { 6841, 24, 51, 34, 5, -43 },
  { 6994, 16, 51, 34, 5, -43 },
  { 7096, 28, 23, 34, 3, -39 },
  { 7177, 27, 4, 34, 3, 5 },
  { 7191, 9, 11, 34, 10, -44 },
  { 7204, 27, 31, 34, 4, -30 },
  { 7309, 25, 42, 34, 5, -41 },
  { 7441, 24, 31, 34, 5, -30 },
  { 7534, 25, 42, 34, 3, -41 },
  { 7666, 26, 31, 34, 4, -30 },
  { 7767, 26, 41, 34, 4, -41 },
  { 7901, 27, 45, 34, 4, -33 },
  { 8053, 23, 41, 34, 5, -41 },
  { 8171, 25, 42, 34, 6, -42 },
  { 8303, 20, 53, 34, 5, -42 },
  { 8436, 26, 41, 34, 6, -41 },
  { 8570, 25, 41, 34, 4, -41 },
  { 8699, 28, 30, 34, 3, -30 },
  { 8804, 23, 30, 34, 5, -30 },
  { 8891, 26, 31, 34, 4, -30 },
  { 8992, 25, 41, 34, 5, -30 },
  { 9121, 25, 41, 34, 3, -30 },
  { 9250, 27, 29, 34, 4, -29 },
  { 9348, 25, 31, 34, 4, -30 },
  { 9445, 27, 39, 34, 2, -39 },
  { 9577, 23, 30, 34, 5, -29 },
  { 9664, 26, 29, 34, 4, -29 },
  { 9759, 30, 29, 34, 2, -29 },
  { 9868, 27, 29, 34, 3, -29 },
  { 9966, 28, 40, 34, 3, -29 },
  { 10106, 24, 29, 34, 5, -29 },
  { 10193, 22, 51, 34, 6, -43 },
  { 10334, 4, 51, 34, 15, -43 },
  { 10360, 22, 51, 34, 6, -43 },
  { 10501, 28, 12, 34, 3, -23 },
};

const GFXfont IBMPlexMono_Regular56pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular56pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular56pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _IBMPLEXMONO_REGULAR56PT7B_H_
