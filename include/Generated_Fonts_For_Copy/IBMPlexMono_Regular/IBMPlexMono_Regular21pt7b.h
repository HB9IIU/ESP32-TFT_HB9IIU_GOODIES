#ifndef _IBMPLEXMONO_REGULAR21PT7B_H_
#define _IBMPLEXMONO_REGULAR21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular21pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6C, 0x92, 0x40, 0x0F, 0xF8, 0x9C, 0xE7, 0x39, 0xCC, 0x04,
  0x40, 0x4C, 0x0C, 0xC0, 0xCC, 0x0C, 0xC7, 0x8F, 0x08, 0x80, 0x98, 0x19,
  0x8F, 0x9F, 0x19, 0x01, 0x10, 0x11, 0x01, 0x30, 0x33, 0x00, 0x04, 0x00,
  0x80, 0x7E, 0x32, 0x66, 0x46, 0x88, 0x11, 0x03, 0x20, 0x34, 0x03, 0xF0,
  0x13, 0x02, 0x20, 0x46, 0x08, 0xD1, 0x17, 0x26, 0x3F, 0x00, 0x80, 0x10,
  0x00, 0x38, 0x34, 0x42, 0x46, 0x6C, 0x64, 0x46, 0xC4, 0x48, 0x39, 0x00,
  0x00, 0x01, 0xE1, 0xB3, 0x12, 0x13, 0x21, 0x22, 0x16, 0x33, 0xC1, 0xE0,
  0x1E, 0x04, 0x61, 0x88, 0x30, 0x06, 0x00, 0xC0, 0x0C, 0x03, 0xC7, 0xC8,
  0x90, 0x92, 0x1A, 0x41, 0xCC, 0x19, 0x85, 0x9F, 0x18, 0xFF, 0xF0, 0x0C,
  0x63, 0x08, 0x61, 0x04, 0x30, 0xC3, 0x0C, 0x30, 0x41, 0x06, 0x08, 0x30,
  0x60, 0xC0, 0xE0, 0x81, 0x06, 0x08, 0x30, 0xC1, 0x04, 0x10, 0x41, 0x0C,
  0x30, 0x86, 0x10, 0x8E, 0x00, 0x04, 0x00, 0x80, 0x10, 0x42, 0x2F, 0x7E,
  0x3E, 0x03, 0x80, 0xD8, 0x31, 0x0C, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x77, 0x66, 0x4C, 0xFC, 0xFF,
  0x80, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x10, 0x18, 0x08, 0x04,
  0x06, 0x02, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x00, 0x1F,
  0x0C, 0x66, 0x0D, 0x03, 0xC0, 0xF0, 0x1C, 0xE7, 0x39, 0xC0, 0x70, 0x1C,
  0x0D, 0x03, 0x60, 0xCC, 0x61, 0xF0, 0x1E, 0x06, 0xC1, 0x98, 0x63, 0x08,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x1F, 0xF8, 0x3F, 0x18, 0x64, 0x0B, 0x03, 0x00, 0xC0, 0x30, 0x18,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x0F, 0xFC, 0x3E, 0x18,
  0x64, 0x08, 0x03, 0x00, 0xC0, 0x60, 0x10, 0x78, 0x01, 0x80, 0x30, 0x0C,
  0x03, 0x40, 0xF8, 0x63, 0xE0, 0x03, 0x80, 0xF0, 0x16, 0x06, 0xC1, 0x98,
  0x23, 0x0C, 0x63, 0x0C, 0x61, 0x98, 0x33, 0x06, 0x7F, 0xF0, 0x18, 0x03,
  0x00, 0x60, 0x7F, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x79, 0xC6, 0x01,
  0x80, 0xC0, 0x60, 0x38, 0x1E, 0x19, 0xF8, 0x07, 0x03, 0x01, 0x80, 0xC0,
  0x30, 0x18, 0x06, 0xF1, 0xC6, 0xE0, 0xF0, 0x3C, 0x0D, 0x03, 0x60, 0xC8,
  0x61, 0xF0, 0xFF, 0xF0, 0x3C, 0x0F, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x1F, 0x18, 0x66,
  0x0D, 0x03, 0x40, 0xD8, 0x32, 0x18, 0x78, 0x61, 0xB0, 0x3C, 0x07, 0x01,
  0xC0, 0xD8, 0x71, 0xF0, 0x1F, 0x18, 0x66, 0x0F, 0x03, 0xC0, 0xF0, 0x36,
  0x0D, 0x87, 0x1E, 0xC0, 0x20, 0x18, 0x0C, 0x03, 0x01, 0x81, 0xC0, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x77, 0x70, 0x00, 0x00, 0x77, 0x66, 0x4C, 0x00,
  0x81, 0xC3, 0x83, 0x87, 0x06, 0x03, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xE0,
  0x10, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0x60, 0x1C, 0x03,
  0x80, 0x70, 0x1C, 0x06, 0x0E, 0x1C, 0x38, 0x30, 0x10, 0x00, 0x7E, 0x61,
  0xB0, 0x40, 0x30, 0x18, 0x18, 0x3C, 0x38, 0x18, 0x0C, 0x00, 0x00, 0x01,
  0x81, 0xC0, 0x60, 0x1F, 0x0C, 0x66, 0x0D, 0x03, 0x47, 0x73, 0x3C, 0x87,
  0x21, 0xC8, 0x72, 0x1C, 0x87, 0x23, 0x47, 0x50, 0x06, 0x00, 0xC0, 0x1F,
  0x80, 0x0E, 0x01, 0xC0, 0x68, 0x0D, 0x81, 0x30, 0x66, 0x0C, 0x41, 0x8C,
  0x21, 0x8F, 0xF1, 0x83, 0x20, 0x6C, 0x0D, 0x80, 0xF0, 0x18, 0xFE, 0x61,
  0xB0, 0x78, 0x3C, 0x1E, 0x0F, 0x0D, 0xFC, 0xC1, 0xE0, 0xF0, 0x38, 0x1C,
  0x1E, 0x0F, 0xF8, 0x1F, 0x0C, 0x36, 0x0D, 0x80, 0x40, 0x10, 0x0C, 0x03,
  0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0xCC, 0x31, 0xF0, 0xFC, 0x61,
  0xB0, 0x58, 0x3C, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x3C,
  0x16, 0x1B, 0xF0, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFE, 0xFF, 0xE0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0x1F, 0x0C, 0x66, 0x0D, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC7,
  0xF0, 0x3C, 0x0D, 0x03, 0x60, 0xCC, 0x71, 0xEC, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0xFF, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x06, 0xFF, 0x8C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC3, 0xFE, 0x7F, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x83, 0xC6, 0x7C, 0xC1, 0xF0, 0x6C,
  0x33, 0x18, 0xCC, 0x37, 0x0D, 0x83, 0xF0, 0xEC, 0x31, 0x8C, 0x63, 0x0C,
  0xC1, 0xB0, 0x6C, 0x0C, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xE0, 0xF8, 0x7F, 0x1F, 0x45,
  0xD3, 0x76, 0x9C, 0xA7, 0x39, 0xCC, 0x71, 0x1C, 0x87, 0x01, 0xC0, 0x70,
  0x1C, 0x04, 0xC1, 0xF0, 0xF8, 0x76, 0x3B, 0x1C, 0x8E, 0x67, 0x33, 0x8D,
  0xC6, 0xE1, 0x70, 0xF8, 0x7C, 0x1E, 0x0E, 0x1F, 0x0C, 0x66, 0x0D, 0x03,
  0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0D, 0x03, 0x60, 0xCC,
  0x61, 0xF0, 0xFF, 0x60, 0xF0, 0x78, 0x1C, 0x0E, 0x0F, 0x07, 0xFE, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x1F, 0x0C, 0x66, 0x0D, 0x03,
  0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0D, 0x03, 0x60, 0xCC,
  0x61, 0xF0, 0x30, 0x04, 0x01, 0xE0, 0xFF, 0x30, 0x6C, 0x1B, 0x02, 0xC0,
  0xB0, 0x6C, 0x1B, 0xF8, 0xCC, 0x31, 0x8C, 0x63, 0x0C, 0xC3, 0x30, 0x6C,
  0x1C, 0x1F, 0x98, 0x34, 0x0B, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x7C, 0x01,
  0xC0, 0x30, 0x04, 0x01, 0xC0, 0xF8, 0x63, 0xF0, 0xFF, 0xE1, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x3C, 0x1A, 0x18, 0xF8, 0xC0, 0x78,
  0x0B, 0x03, 0x30, 0x66, 0x0C, 0xC1, 0x08, 0x61, 0x8C, 0x31, 0x02, 0x60,
  0x6C, 0x0D, 0x81, 0xA0, 0x1C, 0x03, 0x80, 0x80, 0x70, 0x0E, 0x01, 0xE0,
  0x3C, 0xC7, 0x9C, 0xB3, 0x96, 0x52, 0xDA, 0x5B, 0x49, 0x4D, 0x29, 0xA5,
  0x1C, 0xE3, 0x9C, 0x70, 0xC0, 0x6C, 0x19, 0x86, 0x18, 0xC1, 0x30, 0x36,
  0x03, 0x80, 0x60, 0x0E, 0x03, 0x60, 0xCC, 0x18, 0xC6, 0x0D, 0x81, 0xB0,
  0x18, 0xE0, 0x36, 0x06, 0x30, 0x63, 0x0C, 0x18, 0xC0, 0x98, 0x0D, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xFF, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x08,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0x3F, 0xF8, 0xFE, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0,
  0xC0, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x04, 0x02,
  0x01, 0x80, 0x40, 0x30, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0xFC, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F,
  0xC0, 0x0E, 0x01, 0xC0, 0x6C, 0x19, 0x83, 0x18, 0xC1, 0x10, 0x36, 0x02,
  0x80, 0x60, 0xFF, 0xC0, 0xD9, 0x90, 0x3E, 0x0C, 0x61, 0x06, 0x00, 0xC0,
  0x18, 0x7F, 0x18, 0x66, 0x0C, 0xC1, 0x8C, 0x50, 0xF3, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0xF3, 0x8D, 0x83, 0xC1, 0xE0, 0x70, 0x38, 0x1C,
  0x1E, 0x0F, 0x8D, 0xBC, 0x3E, 0x31, 0xB0, 0x78, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC1, 0x30, 0xCF, 0x80, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCF,
  0xB6, 0x1D, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD8, 0x36, 0x1C,
  0xFB, 0x1F, 0x0C, 0x66, 0x0D, 0x03, 0xC0, 0xFF, 0xFC, 0x01, 0x00, 0x60,
  0x8C, 0x71, 0xF0, 0x0F, 0x84, 0x06, 0x03, 0x01, 0x87, 0xFC, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x61, 0xFF, 0x00, 0xE3, 0xE0,
  0x86, 0x30, 0x46, 0x08, 0xC1, 0x0C, 0x60, 0xF8, 0x20, 0x0C, 0x01, 0xFE,
  0x20, 0x24, 0x07, 0x80, 0xD8, 0x31, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0xF3, 0x8D, 0x82, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0x0C, 0x06, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x31, 0xFF, 0x06, 0x07, 0x00, 0x00, 0x00,
  0xFE, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0xFC, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x7C, 0x33,
  0x18, 0xCC, 0x36, 0x0F, 0xC3, 0x18, 0xC6, 0x30, 0xCC, 0x1B, 0x03, 0xF8,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x61, 0xFF, 0xD9, 0xFB, 0x9C, 0xC7, 0x11, 0xC4, 0x71,
  0x1C, 0x47, 0x11, 0xC4, 0x71, 0x1C, 0x44, 0xDE, 0x71, 0xB0, 0x58, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x60, 0x1F, 0x0C, 0x66, 0x0D,
  0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0x03, 0x60, 0xCC, 0x61, 0xF0, 0xDE, 0x71,
  0xB0, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xF1, 0xB7, 0x98, 0x0C,
  0x06, 0x03, 0x00, 0x3E, 0xD8, 0x76, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0x60, 0xD8, 0x73, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0xF3, 0xC5,
  0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x0F, 0xF8,
  0x1F, 0x18, 0x36, 0x09, 0x80, 0x70, 0x07, 0xC0, 0x0C, 0x03, 0x40, 0xF8,
  0x21, 0xF0, 0x18, 0x06, 0x01, 0x80, 0x60, 0xFF, 0xC6, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x02, 0x00, 0xFC, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xB1, 0xCF, 0x60, 0xC0, 0xD8,
  0x36, 0x08, 0x86, 0x31, 0x8C, 0x41, 0x30, 0x6C, 0x1A, 0x03, 0x80, 0xE0,
  0x8C, 0x71, 0xCE, 0x29, 0xE5, 0x2C, 0xA5, 0xB4, 0x94, 0x92, 0x9A, 0x51,
  0xCA, 0x39, 0xC6, 0x00, 0xE0, 0xD8, 0x63, 0x10, 0x6C, 0x0E, 0x03, 0x00,
  0xE0, 0x6C, 0x31, 0x98, 0x6E, 0x0C, 0xC0, 0x50, 0x36, 0x08, 0x86, 0x31,
  0x8C, 0x41, 0x30, 0x68, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x08, 0x06, 0x07,
  0x00, 0xFF, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60,
  0x3F, 0xE0, 0x1F, 0x10, 0x10, 0x10, 0x18, 0x0C, 0x0C, 0x04, 0x0C, 0xF0,
  0x0C, 0x04, 0x0C, 0x0C, 0x18, 0x10, 0x10, 0x10, 0x1F, 0xFF, 0xFF, 0xE0,
  0xF8, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x30, 0x30, 0x10, 0x0F, 0x18, 0x30,
  0x30, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0xF8, 0x38, 0x69, 0x8B, 0x1B, 0x41,
  0xC0,
};

const GFXglyph IBMPlexMono_Regular21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 5, 6, 13, 4, -16 },
  { 11, 12, 15, 13, 0, -15 },
  { 34, 11, 19, 13, 1, -17 },
  { 61, 12, 15, 13, 0, -15 },
  { 84, 11, 15, 13, 1, -15 },
  { 105, 2, 6, 13, 5, -16 },
  { 107, 6, 19, 13, 4, -16 },
  { 122, 6, 19, 13, 2, -16 },
  { 137, 11, 10, 13, 1, -12 },
  { 151, 10, 9, 13, 1, -11 },
  { 163, 4, 6, 13, 4, -3 },
  { 166, 6, 1, 13, 3, -7 },
  { 167, 3, 3, 13, 5, -3 },
  { 169, 9, 19, 13, 2, -16 },
  { 191, 10, 15, 13, 1, -15 },
  { 210, 11, 15, 13, 1, -15 },
  { 231, 10, 15, 13, 1, -15 },
  { 250, 10, 15, 13, 1, -15 },
  { 269, 11, 15, 13, 1, -15 },
  { 290, 9, 15, 13, 2, -15 },
  { 307, 10, 15, 13, 1, -15 },
  { 326, 10, 15, 13, 1, -15 },
  { 345, 10, 15, 13, 1, -15 },
  { 364, 10, 15, 13, 1, -15 },
  { 383, 3, 11, 13, 5, -11 },
  { 388, 4, 14, 13, 4, -11 },
  { 395, 9, 12, 13, 2, -12 },
  { 409, 10, 5, 13, 1, -9 },
  { 416, 9, 12, 13, 2, -12 },
  { 430, 9, 15, 13, 2, -15 },
  { 447, 10, 17, 13, 1, -15 },
  { 469, 11, 15, 13, 1, -15 },
  { 490, 9, 15, 13, 2, -15 },
  { 507, 10, 15, 13, 1, -15 },
  { 526, 9, 15, 13, 2, -15 },
  { 543, 9, 15, 13, 2, -15 },
  { 560, 9, 15, 13, 2, -15 },
  { 577, 10, 15, 13, 1, -15 },
  { 596, 9, 15, 13, 2, -15 },
  { 613, 9, 15, 13, 2, -15 },
  { 630, 8, 15, 13, 2, -15 },
  { 645, 10, 15, 13, 2, -15 },
  { 664, 8, 15, 13, 3, -15 },
  { 679, 10, 15, 13, 1, -15 },
  { 698, 9, 15, 13, 2, -15 },
  { 715, 10, 15, 13, 1, -15 },
  { 734, 9, 15, 13, 2, -15 },
  { 751, 10, 18, 13, 1, -15 },
  { 774, 10, 15, 13, 2, -15 },
  { 793, 10, 15, 13, 1, -15 },
  { 812, 11, 15, 13, 1, -15 },
  { 833, 9, 15, 13, 2, -15 },
  { 850, 11, 15, 13, 1, -15 },
  { 871, 11, 15, 13, 1, -15 },
  { 892, 11, 15, 13, 1, -15 },
  { 913, 12, 15, 13, 0, -15 },
  { 936, 11, 15, 13, 1, -15 },
  { 957, 6, 19, 13, 5, -16 },
  { 972, 9, 19, 13, 2, -16 },
  { 994, 6, 19, 13, 2, -16 },
  { 1009, 11, 9, 13, 1, -15 },
  { 1022, 10, 1, 13, 1, 2 },
  { 1024, 3, 4, 13, 4, -16 },
  { 1026, 11, 11, 13, 1, -11 },
  { 1042, 9, 16, 13, 2, -16 },
  { 1060, 9, 11, 13, 2, -11 },
  { 1073, 10, 16, 13, 1, -16 },
  { 1093, 10, 11, 13, 1, -11 },
  { 1107, 9, 16, 13, 2, -16 },
  { 1125, 11, 16, 13, 1, -12 },
  { 1147, 9, 16, 13, 2, -16 },
  { 1165, 9, 16, 13, 2, -16 },
  { 1183, 8, 20, 13, 2, -16 },
  { 1203, 10, 16, 13, 2, -16 },
  { 1223, 9, 16, 13, 2, -16 },
  { 1241, 10, 11, 13, 1, -11 },
  { 1255, 9, 11, 13, 2, -11 },
  { 1268, 10, 11, 13, 1, -11 },
  { 1282, 9, 15, 13, 2, -11 },
  { 1299, 10, 15, 13, 1, -11 },
  { 1318, 10, 11, 13, 2, -11 },
  { 1332, 10, 11, 13, 1, -11 },
  { 1346, 10, 15, 13, 1, -15 },
  { 1365, 9, 11, 13, 2, -11 },
  { 1378, 10, 11, 13, 1, -11 },
  { 1392, 11, 11, 13, 1, -11 },
  { 1408, 10, 11, 13, 1, -11 },
  { 1422, 10, 15, 13, 1, -11 },
  { 1441, 9, 11, 13, 2, -11 },
  { 1454, 8, 19, 13, 2, -16 },
  { 1473, 1, 19, 13, 6, -16 },
  { 1476, 8, 19, 13, 2, -16 },
  { 1495, 11, 4, 13, 1, -8 },
};

const GFXfont IBMPlexMono_Regular21pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular21pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular21pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _IBMPLEXMONO_REGULAR21PT7B_H_
