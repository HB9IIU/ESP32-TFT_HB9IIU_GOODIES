#ifndef _IBMPLEXMONO_REGULAR42PT7B_H_
#define _IBMPLEXMONO_REGULAR42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular42pt7bBitmaps[] PROGMEM = {
  0x00, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x06, 0x0C, 0x10, 0x20, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7D, 0xFF,
  0xFB, 0xF7, 0xC0, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x70, 0x00, 0x70, 0xF0, 0x00,
  0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xE1, 0xC0, 0x01, 0xC1, 0xC0, 0x7F,
  0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x7F, 0xC3, 0xFF, 0x01, 0xC3, 0x80, 0x03,
  0x83, 0x80, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80, 0xFF,
  0x87, 0xFC, 0xFF, 0x87, 0xFC, 0xFF, 0x07, 0xFC, 0x07, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xE0,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xC6, 0x7E, 0x3C, 0x30, 0xFB, 0xC1,
  0x83, 0x9E, 0x0C, 0x08, 0xF0, 0x60, 0x07, 0x83, 0x00, 0x3C, 0x18, 0x00,
  0xF0, 0xC0, 0x07, 0xC6, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0x3F, 0x00, 0x18, 0x7C, 0x00, 0xC1, 0xE0,
  0x06, 0x07, 0x00, 0x30, 0x38, 0x01, 0x81, 0xC8, 0x0C, 0x0E, 0xE0, 0x60,
  0xFF, 0x83, 0x0F, 0x3F, 0x19, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03,
  0xFE, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x1F, 0x80, 0x0E, 0x7F, 0x80, 0x1D, 0xFF, 0x80, 0x77, 0x87, 0x80,
  0xEE, 0x07, 0x03, 0x9C, 0x0E, 0x0F, 0x38, 0x1C, 0x1C, 0x70, 0x38, 0x70,
  0xE0, 0x70, 0xE1, 0xC0, 0xE3, 0x83, 0xC3, 0xC7, 0x03, 0xFF, 0x1C, 0x03,
  0xFC, 0x38, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x03,
  0xC7, 0xF8, 0x07, 0x1F, 0xF8, 0x1C, 0x78, 0x78, 0x38, 0xE0, 0x70, 0xE1,
  0xC0, 0xE1, 0xC3, 0x81, 0xC7, 0x07, 0x03, 0x8E, 0x0E, 0x07, 0x38, 0x1C,
  0x0E, 0x70, 0x3C, 0x3D, 0xC0, 0x3F, 0xF3, 0x80, 0x3F, 0xCE, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x78, 0x7C,
  0x01, 0xE0, 0x38, 0x03, 0x80, 0x60, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x0F, 0xC7, 0xF8, 0x1F, 0x9E, 0xF8, 0x7F, 0x78,
  0xF0, 0xE0, 0xE0, 0xF1, 0xC3, 0xC0, 0xF3, 0x87, 0x80, 0xF7, 0x0F, 0x00,
  0xFE, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x07,
  0xE0, 0xF8, 0x1D, 0xE0, 0xFF, 0xF1, 0xE0, 0xFF, 0xC1, 0xE0, 0x7E, 0x01,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x3C, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x02, 0x01, 0xC0, 0x3E,
  0x0E, 0x0F, 0xFE, 0x73, 0xFB, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x71, 0xE0, 0x07,
  0x87, 0x00, 0x78, 0x3C, 0x07, 0x80, 0xF0, 0x18, 0x03, 0x80, 0x40, 0x10,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x7D, 0xF3, 0xE7, 0x8F, 0x1E,
  0x78, 0xF1, 0xC3, 0x87, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0xFB,
  0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x83,
  0xC0, 0x1E, 0x1E, 0x00, 0x71, 0xE0, 0x03, 0xCF, 0x00, 0x0E, 0x70, 0x00,
  0x73, 0x80, 0x03, 0x9C, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0x87, 0xF8,
  0x7C, 0x3F, 0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0xF0, 0x78, 0x7F, 0x80, 0x03,
  0xDC, 0x00, 0x1E, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x3C, 0x00, 0x39, 0xE0,
  0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x01, 0xE0, 0xF8, 0x3E, 0x03, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0x78, 0x01, 0xF3, 0xC0, 0x1F, 0x1E, 0x01, 0xF0, 0xF0,
  0x1F, 0x07, 0x80, 0x70, 0x3C, 0x01, 0x01, 0xE0, 0x10, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xC0, 0xF8, 0x78, 0x07, 0xCF,
  0x00, 0x3C, 0xE0, 0x03, 0xC2, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0x7C, 0x7C, 0x03,
  0xE3, 0x80, 0x1E, 0x10, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x20, 0x00, 0xF7, 0x00, 0x1E,
  0xF8, 0x03, 0xE7, 0xE0, 0x7C, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xEE,
  0x00, 0x03, 0xDC, 0x00, 0x07, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x78, 0xE0,
  0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x70, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x70, 0x03, 0x81, 0xE0, 0x07, 0x03, 0x80, 0x0E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x7E, 0x07, 0x3F, 0xF0, 0xEF, 0xFF, 0x1F, 0x83,
  0xF3, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC8, 0x00, 0x7B, 0x80, 0x0F, 0xF8, 0x03,
  0xCF, 0xC1, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x0F, 0xC0, 0x73, 0xFF, 0x0F, 0x7F, 0xF8, 0xEE, 0x07, 0xCF,
  0x80, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0F,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xF0, 0x00, 0xE7, 0x00, 0x1E, 0x78, 0x03,
  0xC3, 0xE0, 0x7C, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xB8, 0x00, 0xF7, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xF0, 0x7C, 0x07, 0xC3, 0xC0, 0x1F, 0x3C, 0x00, 0x79,
  0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF1, 0xC0, 0x07, 0x8F, 0x00,
  0x78, 0x3C, 0x07, 0x80, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFE, 0x03,
  0xC0, 0x7C, 0x3C, 0x00, 0xF3, 0xC0, 0x03, 0x9C, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x0E, 0x7C,
  0x00, 0xF1, 0xF0, 0x1F, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xE0, 0x78, 0x78,
  0x03, 0xCF, 0x00, 0x1C, 0xF0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xE7, 0x80, 0x3E,
  0x7E, 0x06, 0xE3, 0xFF, 0xFE, 0x1F, 0xF9, 0xE0, 0x7F, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0xFB, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF9, 0xF7, 0xFF, 0xEF, 0xDF, 0x00, 0x7C,
  0xFB, 0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0xFB, 0xE7, 0xCF, 0x1E, 0x3C, 0xF1, 0xE3, 0x87, 0x0E,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0x80, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3C, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xF8, 0xF8, 0x3E, 0x78, 0x03, 0xDC, 0x00, 0xFF, 0x00, 0x1C, 0xC0,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x7F, 0x80, 0x1F, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0x03, 0xC3, 0x80,
  0x3C, 0xF0, 0x03, 0x9C, 0x00, 0x7B, 0x80, 0x07, 0xE0, 0x7C, 0xFC, 0x1F,
  0xDF, 0x87, 0xFF, 0xF0, 0xF0, 0xFE, 0x1C, 0x0F, 0xC7, 0x01, 0xF8, 0xE0,
  0x3F, 0x1C, 0x07, 0xE3, 0x80, 0xFC, 0x70, 0x1F, 0x8E, 0x03, 0xF1, 0xC0,
  0x7E, 0x3C, 0x0F, 0xC3, 0x83, 0xF8, 0x7F, 0xFF, 0x07, 0xF7, 0xE0, 0x7C,
  0xFC, 0x02, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0xE0,
  0x00, 0x1D, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x80,
  0x07, 0x8F, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0x38, 0x01, 0xC0, 0x70, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0x80,
  0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0xF0, 0x00,
  0x79, 0xE0, 0x00, 0xF3, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x70, 0x07, 0xCE, 0x00, 0x79, 0xC0, 0x07,
  0x38, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0x7B, 0x80, 0x0E,
  0x70, 0x03, 0xCE, 0x00, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xF8,
  0xE0, 0x07, 0x9C, 0x00, 0x7B, 0x80, 0x07, 0x70, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0E, 0xE0, 0x03, 0xDC, 0x00, 0xFB,
  0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF0,
  0x0F, 0xFF, 0x81, 0xF0, 0x7C, 0x3C, 0x01, 0xE3, 0x80, 0x1E, 0x78, 0x00,
  0xF7, 0x00, 0x08, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x08, 0x78, 0x00, 0xE3, 0x80, 0x1F, 0x3C, 0x01, 0xE1, 0xF0, 0x7C,
  0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xF8, 0x78, 0x0F, 0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0x3C, 0x00,
  0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x07,
  0xBC, 0x00, 0xF7, 0x80, 0x3C, 0xF0, 0x0F, 0x9E, 0x03, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFE, 0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0xC1, 0xF0, 0x7C, 0x3E, 0x01, 0xE3, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80,
  0x08, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x80, 0x0F,
  0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x01, 0xF1, 0xF0, 0x77, 0x0F, 0xFE,
  0x70, 0x7F, 0xC7, 0x01, 0xF8, 0x70, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F,
  0x78, 0x0F, 0x3E, 0x0F, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00, 0xE0,
  0x01, 0xFE, 0x00, 0x3E, 0xE0, 0x03, 0xCE, 0x00, 0x78, 0xE0, 0x0F, 0x0E,
  0x01, 0xE0, 0xE0, 0x3E, 0x0E, 0x07, 0xC0, 0xE0, 0x78, 0x0E, 0x0F, 0x00,
  0xE1, 0xE0, 0x0E, 0x3C, 0x00, 0xE7, 0xC0, 0x0E, 0x7E, 0x00, 0xEF, 0xE0,
  0x0F, 0xEF, 0x00, 0xFC, 0xF0, 0x0F, 0x87, 0x80, 0xF0, 0x3C, 0x0E, 0x03,
  0xC0, 0xE0, 0x1E, 0x0E, 0x01, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0x78, 0xE0,
  0x07, 0x8E, 0x00, 0x3C, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xDC, 0x0F, 0xFB, 0x83, 0xBF, 0x70, 0x77, 0xE7, 0x1C, 0xFC,
  0xE3, 0x9F, 0x8E, 0x73, 0xF1, 0xDC, 0x7E, 0x3F, 0x8F, 0xC3, 0xE1, 0xF8,
  0x7C, 0x3F, 0x07, 0x87, 0xE0, 0xE0, 0xFC, 0x0C, 0x1F, 0x81, 0x03, 0xF0,
  0x20, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0E, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x01, 0xFD, 0xC0, 0x3F, 0xB8, 0x07, 0xF7, 0x80, 0xFE, 0x70, 0x1F, 0xCF,
  0x03, 0xF8, 0xE0, 0x7F, 0x1C, 0x0F, 0xE3, 0xC1, 0xFC, 0x38, 0x3F, 0x87,
  0x87, 0xF0, 0x70, 0xFE, 0x0F, 0x1F, 0xC0, 0xE3, 0xF8, 0x1C, 0x7F, 0x03,
  0xCF, 0xE0, 0x39, 0xFC, 0x07, 0xBF, 0x80, 0x77, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3E, 0x01, 0xFC, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x83, 0xC0, 0x1E, 0x1E, 0x00, 0x71,
  0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0xE0, 0x00,
  0xE7, 0x00, 0x07, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xC7, 0x80, 0x1C, 0x3C,
  0x01, 0xE0, 0xF8, 0x3E, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x70, 0x03, 0xEE, 0x00,
  0x3D, 0xC0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xEE, 0x00, 0x3D, 0xC0, 0x0F, 0xBF, 0xFF,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x83, 0xC0, 0x1E, 0x1E,
  0x00, 0x71, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x70, 0x00, 0x73, 0x80, 0x03,
  0x9C, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDC, 0x00, 0x1E,
  0xE0, 0x00, 0xE7, 0x00, 0x07, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xC7, 0x80,
  0x1C, 0x3C, 0x01, 0xE0, 0xF8, 0x3E, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x70, 0x03, 0xEE, 0x00, 0x3D, 0xC0, 0x03, 0xB8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xEE, 0x00, 0x3D, 0xC0, 0x0F, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF,
  0xF8, 0x1C, 0x1E, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03, 0xC1, 0xC0,
  0x38, 0x38, 0x07, 0x87, 0x00, 0x78, 0xE0, 0x0F, 0x1C, 0x00, 0xF3, 0x80,
  0x0F, 0x70, 0x01, 0xEE, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF8, 0x7C, 0x07, 0xE3, 0xC0, 0x0F, 0xBC, 0x00, 0x31, 0xE0, 0x01,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x80, 0x01, 0xFE, 0x00, 0x1E, 0xF8, 0x00, 0xF3,
  0xF0, 0x1F, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xF7, 0x00,
  0x1E, 0xE0, 0x03, 0xDC, 0x00, 0x73, 0xC0, 0x0E, 0x78, 0x03, 0xC7, 0xC1,
  0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xEF, 0x00, 0x07, 0x9C, 0x00, 0x1E, 0x78, 0x00, 0x71, 0xE0, 0x03,
  0xC7, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xF0, 0x07, 0x81,
  0xC0, 0x1E, 0x07, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x38, 0x0F, 0x00, 0xE0,
  0x38, 0x03, 0xC0, 0xE0, 0x0F, 0x07, 0x80, 0x1C, 0x1C, 0x00, 0x78, 0x70,
  0x01, 0xE3, 0xC0, 0x03, 0x8F, 0x00, 0x0E, 0x38, 0x00, 0x3C, 0xE0, 0x00,
  0x77, 0x80, 0x01, 0xDC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x7B, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x70, 0x3C, 0x1C, 0xE0, 0xF8, 0x39, 0xC1, 0xF0, 0x73,
  0x83, 0xE0, 0xE7, 0x86, 0xE1, 0xC7, 0x1D, 0xC3, 0x8E, 0x3B, 0x87, 0x1C,
  0x77, 0x0E, 0x38, 0xE7, 0x38, 0x71, 0x8E, 0x70, 0xE7, 0x1C, 0xE1, 0xCE,
  0x39, 0xC3, 0x9C, 0x33, 0x87, 0x30, 0x77, 0x0E, 0xE0, 0xEE, 0x1D, 0xC1,
  0xDC, 0x3B, 0x83, 0xB8, 0x7F, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F,
  0xC1, 0xF0, 0x1F, 0x00, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x01,
  0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x78,
  0x03, 0xC1, 0xE0, 0x03, 0xC3, 0x80, 0x03, 0x8F, 0x00, 0x07, 0xBC, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xDE, 0x00, 0x07, 0x9E, 0x00, 0x1E,
  0x3C, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0x78, 0x07, 0x00,
  0x78, 0x1E, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF3, 0xC0, 0x01,
  0xEF, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0xF1, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x3C,
  0x07, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x0F, 0x0E, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00, 0x3D,
  0xE0, 0x01, 0xC7, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xF0, 0x0E, 0x03, 0x80,
  0xF0, 0x1E, 0x07, 0x00, 0x70, 0x78, 0x03, 0xC3, 0x80, 0x0E, 0x3C, 0x00,
  0x79, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0x60, 0x00, 0x30, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x23, 0xC7, 0x1E, 0x38, 0x71, 0xC2, 0x07,
  0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xC1, 0xF0, 0xF0, 0x07, 0x82,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x7F, 0xF8,
  0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xF8, 0x03, 0x8F, 0x00, 0x38, 0xE0, 0x03,
  0x8E, 0x00, 0x38, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0xF8, 0x1B, 0x87, 0xFF,
  0x3F, 0x3F, 0xF1, 0xF0, 0xFC, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x3F, 0x03, 0x9F, 0xF8, 0x77, 0xFF, 0x8E, 0xC0,
  0xF9, 0xF0, 0x0F, 0x3C, 0x00, 0xF7, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0E, 0xE0, 0x01, 0xDE, 0x00, 0x7B, 0xE0, 0x1E, 0x76, 0x07,
  0xCE, 0xFF, 0xF1, 0xC7, 0xFC, 0x38, 0x7E, 0x00, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xF8, 0x3C, 0x78, 0x07, 0x9C, 0x00, 0xEF, 0x00, 0x23,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x04, 0x70, 0x03, 0x9E, 0x00,
  0xF3, 0xE0, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC1, 0xF8, 0x71, 0xFF, 0x9C, 0xFF,
  0xF7, 0x7E, 0x0D, 0xDE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xF7, 0x80, 0x3D, 0xF8,
  0x37, 0x3F, 0xFD, 0xC7, 0xFE, 0x70, 0x7E, 0x1C, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0x80, 0x3C, 0xE0, 0x03, 0x9C, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x8F, 0x00, 0x3C, 0xF8, 0x1F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x07, 0xF4, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xF8,
  0x3E, 0x07, 0x00, 0x70, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0,
  0xF0, 0x07, 0x87, 0x80, 0x3C, 0x1C, 0x01, 0xC0, 0xF8, 0x3E, 0x03, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF7, 0x80, 0x07, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0x7C,
  0x00, 0xF9, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0xFC, 0x38, 0xFF, 0x9C, 0xFF, 0xEE,
  0xC1, 0xF7, 0x40, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0E, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF7, 0xFF, 0xEF, 0xFF, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF8, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3E,
  0xF0, 0x07, 0xCF, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x78,
  0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0xE0, 0x0F, 0xFE,
  0x00, 0xFE, 0xF0, 0x0F, 0x87, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x03, 0xCF,
  0x00, 0x1E, 0xF0, 0x00, 0xF0, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xE3, 0xC3, 0xE7, 0x3F, 0x3F,
  0xBB, 0xFB, 0xFD, 0xD1, 0xF0, 0xFF, 0x07, 0x87, 0xF0, 0x38, 0x1F, 0x81,
  0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0F,
  0xC0, 0xE0, 0x7E, 0x07, 0x03, 0xF0, 0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E,
  0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0F, 0xC0, 0xE0, 0x7E,
  0x07, 0x03, 0xF0, 0x38, 0x1C, 0xE1, 0xF8, 0x71, 0xFF, 0x39, 0xFF, 0xDD,
  0x83, 0xEE, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1C, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0x07, 0xC7, 0x80, 0x3C, 0xE0, 0x03, 0xBC, 0x00, 0x7F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0x70, 0x01, 0xCF, 0x00, 0x78, 0xF8,
  0x3E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xE1, 0xF8, 0x1C,
  0xFF, 0xC3, 0xBF, 0xFC, 0x76, 0x07, 0xCF, 0x80, 0x79, 0xE0, 0x07, 0xB8,
  0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x77, 0x00, 0x0E, 0xF0,
  0x03, 0xDF, 0x00, 0xF3, 0xB0, 0x3E, 0x77, 0xFF, 0x8E, 0x3F, 0xE1, 0xC3,
  0xF0, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xE1, 0xC7,
  0xFE, 0x73, 0xFF, 0xDD, 0xF8, 0x37, 0x78, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xDE,
  0x00, 0xF7, 0xE0, 0xDC, 0xFF, 0xF7, 0x1F, 0xF9, 0xC1, 0xF8, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0xF0, 0x1D, 0xC0, 0x01, 0xD0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0x03, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0x1E, 0x03, 0xF7, 0x80, 0x18,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x60, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0x1F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xDF, 0x06, 0xE7, 0xFF,
  0x71, 0xFF, 0x38, 0x7E, 0x1C, 0xE0, 0x00, 0xFF, 0x00, 0x0E, 0x70, 0x01,
  0xE7, 0x00, 0x1C, 0x78, 0x01, 0xC3, 0x80, 0x3C, 0x38, 0x03, 0x83, 0xC0,
  0x38, 0x1C, 0x07, 0x81, 0xC0, 0x70, 0x1E, 0x07, 0x00, 0xE0, 0xE0, 0x0E,
  0x0E, 0x00, 0xF0, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x9C, 0x00,
  0x3B, 0x80, 0x03, 0xB8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0xE0, 0x3C, 0x0F, 0xC0, 0xF8, 0x1D, 0xC1, 0xF0, 0x3B, 0x83, 0xE0, 0x67,
  0x06, 0xC1, 0xCE, 0x0D, 0xC3, 0x9C, 0x1B, 0x87, 0x38, 0x73, 0x0E, 0x30,
  0xE6, 0x1C, 0x61, 0x8C, 0x38, 0xE3, 0x1C, 0x61, 0xC6, 0x38, 0xC3, 0x9C,
  0x73, 0x87, 0x38, 0x67, 0x0E, 0x60, 0xCE, 0x0C, 0xC1, 0xDC, 0x19, 0x83,
  0xB0, 0x3F, 0x07, 0x60, 0x7E, 0x06, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x01, 0xE7, 0x80, 0x1C, 0x3C, 0x03, 0xC3,
  0xC0, 0x78, 0x1E, 0x0F, 0x00, 0xF0, 0xE0, 0x0F, 0x1E, 0x00, 0x7B, 0xC0,
  0x03, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF8,
  0x00, 0x3B, 0xC0, 0x07, 0xBC, 0x00, 0xF1, 0xE0, 0x0E, 0x0F, 0x01, 0xE0,
  0xF0, 0x3C, 0x07, 0x87, 0x80, 0x3C, 0x70, 0x01, 0xEF, 0x00, 0x1F, 0xF0,
  0x00, 0x7B, 0x80, 0x03, 0x9E, 0x00, 0x1C, 0x70, 0x01, 0xE3, 0x80, 0x0E,
  0x1E, 0x00, 0xF0, 0x70, 0x07, 0x03, 0xC0, 0x38, 0x0E, 0x03, 0xC0, 0x78,
  0x1C, 0x01, 0xC1, 0xE0, 0x0E, 0x0E, 0x00, 0x78, 0x70, 0x01, 0xC7, 0x00,
  0x0E, 0x38, 0x00, 0x3B, 0xC0, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0xFF, 0xE0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x01, 0xF0, 0x7F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x7F,
  0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xF0,
  0x3F, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x1F,
  0xE0, 0x3F, 0xF0, 0x3C, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x1F, 0xFC,
  0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0x00, 0x38, 0xFE, 0x01, 0xCF, 0xF8,
  0x0E, 0x71, 0xE0, 0xE7, 0x07, 0x87, 0x38, 0x3E, 0x79, 0x80, 0xFF, 0x9C,
  0x03, 0xF8, 0x60, 0x07, 0x80,
};

const GFXglyph IBMPlexMono_Regular42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 29, 25, 9, -29 },
  { 27, 11, 12, 25, 7, -31 },
  { 44, 24, 29, 25, 1, -29 },
  { 131, 21, 37, 25, 2, -33 },
  { 229, 23, 29, 25, 1, -29 },
  { 313, 23, 29, 25, 1, -29 },
  { 397, 3, 12, 25, 11, -31 },
  { 402, 12, 38, 25, 9, -32 },
  { 459, 13, 38, 25, 4, -32 },
  { 521, 21, 21, 25, 2, -24 },
  { 577, 20, 21, 25, 3, -23 },
  { 630, 7, 12, 25, 9, -6 },
  { 641, 12, 3, 25, 7, -14 },
  { 646, 7, 6, 25, 9, -6 },
  { 652, 17, 38, 25, 4, -32 },
  { 733, 21, 29, 25, 2, -29 },
  { 810, 21, 29, 25, 2, -29 },
  { 887, 20, 29, 25, 3, -29 },
  { 960, 20, 29, 25, 2, -29 },
  { 1033, 23, 29, 25, 1, -29 },
  { 1117, 19, 29, 25, 3, -29 },
  { 1186, 20, 29, 25, 3, -29 },
  { 1259, 19, 29, 25, 3, -29 },
  { 1328, 21, 29, 25, 2, -29 },
  { 1405, 20, 29, 25, 3, -29 },
  { 1478, 7, 23, 25, 9, -23 },
  { 1499, 7, 29, 25, 9, -23 },
  { 1525, 18, 24, 25, 4, -25 },
  { 1579, 20, 12, 25, 3, -19 },
  { 1609, 18, 24, 25, 4, -25 },
  { 1663, 18, 29, 25, 3, -29 },
  { 1729, 19, 34, 25, 3, -29 },
  { 1810, 23, 29, 25, 1, -29 },
  { 1894, 19, 29, 25, 4, -29 },
  { 1963, 20, 29, 25, 3, -29 },
  { 2036, 19, 29, 25, 4, -29 },
  { 2105, 18, 29, 25, 4, -29 },
  { 2171, 18, 29, 25, 4, -29 },
  { 2237, 20, 29, 25, 2, -29 },
  { 2310, 19, 29, 25, 3, -29 },
  { 2379, 18, 29, 25, 4, -29 },
  { 2445, 17, 29, 25, 3, -29 },
  { 2507, 20, 29, 25, 4, -29 },
  { 2580, 17, 29, 25, 5, -29 },
  { 2642, 19, 29, 25, 3, -29 },
  { 2711, 19, 29, 25, 3, -29 },
  { 2780, 21, 29, 25, 2, -29 },
  { 2857, 19, 29, 25, 4, -29 },
  { 2926, 21, 36, 25, 2, -29 },
  { 3021, 19, 29, 25, 4, -29 },
  { 3090, 21, 29, 25, 2, -29 },
  { 3167, 23, 29, 25, 1, -29 },
  { 3251, 19, 29, 25, 3, -29 },
  { 3320, 22, 29, 25, 2, -29 },
  { 3400, 23, 29, 25, 1, -29 },
  { 3484, 23, 29, 25, 1, -29 },
  { 3568, 23, 29, 25, 1, -29 },
  { 3652, 21, 29, 25, 2, -29 },
  { 3729, 12, 38, 25, 9, -32 },
  { 3786, 17, 38, 25, 4, -32 },
  { 3867, 12, 38, 25, 4, -32 },
  { 3924, 21, 17, 25, 2, -29 },
  { 3969, 20, 3, 25, 3, 4 },
  { 3977, 6, 8, 25, 8, -33 },
  { 3983, 20, 22, 25, 3, -22 },
  { 4038, 19, 31, 25, 4, -31 },
  { 4112, 18, 22, 25, 4, -22 },
  { 4162, 18, 31, 25, 3, -31 },
  { 4232, 19, 22, 25, 3, -22 },
  { 4285, 20, 31, 25, 3, -31 },
  { 4363, 21, 33, 25, 3, -25 },
  { 4450, 17, 31, 25, 4, -31 },
  { 4516, 19, 32, 25, 4, -32 },
  { 4592, 15, 40, 25, 4, -32 },
  { 4667, 20, 31, 25, 4, -31 },
  { 4745, 19, 31, 25, 3, -31 },
  { 4819, 21, 22, 25, 2, -22 },
  { 4877, 17, 22, 25, 4, -22 },
  { 4924, 19, 22, 25, 3, -22 },
  { 4977, 19, 30, 25, 4, -22 },
  { 5049, 18, 30, 25, 3, -22 },
  { 5117, 20, 22, 25, 3, -22 },
  { 5172, 19, 22, 25, 3, -22 },
  { 5225, 20, 29, 25, 2, -29 },
  { 5298, 17, 22, 25, 4, -22 },
  { 5345, 20, 22, 25, 3, -22 },
  { 5400, 23, 22, 25, 1, -22 },
  { 5464, 20, 22, 25, 3, -22 },
  { 5519, 21, 30, 25, 2, -22 },
  { 5598, 18, 22, 25, 4, -22 },
  { 5648, 17, 38, 25, 4, -32 },
  { 5729, 3, 38, 25, 11, -32 },
  { 5744, 17, 38, 25, 4, -32 },
  { 5825, 21, 9, 25, 2, -17 },
};

const GFXfont IBMPlexMono_Regular42pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular42pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _IBMPLEXMONO_REGULAR42PT7B_H_
