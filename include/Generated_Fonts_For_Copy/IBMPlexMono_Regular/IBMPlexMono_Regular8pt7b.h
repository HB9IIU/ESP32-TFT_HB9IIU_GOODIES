#ifndef _IBMPLEXMONO_REGULAR8PT7B_H_
#define _IBMPLEXMONO_REGULAR8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x52, 0xB6, 0xCF, 0x30, 0x6B, 0x63, 0x3F, 0x20, 0x4D,
  0xB4, 0x26, 0xD8, 0x64, 0x11, 0xAB, 0x7C, 0xC0, 0xEA, 0xAC, 0x95, 0x58,
  0x22, 0xF7, 0x2F, 0x22, 0xC0, 0xE0, 0x80, 0x29, 0x29, 0x20, 0x2D, 0x9B,
  0x97, 0x26, 0xA2, 0x27, 0xD4, 0xA9, 0xC0, 0x69, 0x13, 0x1F, 0x11, 0x95,
  0x2F, 0x88, 0xF2, 0x73, 0xC0, 0x52, 0x7B, 0xC0, 0xF4, 0xA5, 0x00, 0x69,
  0x57, 0x97, 0x56, 0xF3, 0x80, 0x90, 0x98, 0x2A, 0x22, 0xF0, 0xF0, 0x88,
  0xA8, 0x54, 0xA0, 0x80, 0x2D, 0xBD, 0xDA, 0x70, 0x23, 0x18, 0xAB, 0x4C,
  0xD6, 0xFB, 0xC0, 0x56, 0x49, 0xC0, 0xD6, 0xDB, 0xC0, 0xF2, 0x79, 0xC0,
  0xF2, 0x79, 0x00, 0x2D, 0x8B, 0x97, 0xB6, 0xFB, 0x40, 0xE9, 0x25, 0xC0,
  0xE4, 0x93, 0xC0, 0xBA, 0xCC, 0xAB, 0x92, 0x49, 0xC0, 0xB7, 0xFB, 0x40,
  0xB6, 0xFF, 0x40, 0x2D, 0x99, 0x97, 0xD6, 0xE9, 0x00, 0x2D, 0x99, 0x95,
  0x30, 0xD6, 0xEB, 0x40, 0x69, 0x87, 0x1F, 0xF9, 0x08, 0x42, 0x10, 0xB6,
  0xDB, 0xC0, 0x9C, 0x94, 0xA6, 0x10, 0x8C, 0xAD, 0xE7, 0x28, 0x9A, 0x98,
  0x45, 0x4C, 0x8C, 0x98, 0x42, 0x10, 0x71, 0x24, 0x4F, 0xEA, 0xAC, 0x92,
  0x24, 0x88, 0xD5, 0x5C, 0x26, 0x59, 0xF0, 0xC0, 0xE7, 0xF0, 0x93, 0xDB,
  0xC0, 0xF2, 0x70, 0x11, 0x79, 0x97, 0xF7, 0x70, 0x6B, 0xA5, 0xC0, 0x3E,
  0xAF, 0x78, 0x93, 0xDB, 0x40, 0x43, 0x25, 0xC0, 0x23, 0x24, 0x96, 0x88,
  0xAC, 0xCB, 0xC9, 0x25, 0xC0, 0xFB, 0xBB, 0xF6, 0xD0, 0xF6, 0xF0, 0xF6,
  0xDD, 0x00, 0x79, 0x95, 0x31, 0xBA, 0x70, 0xF1, 0xF0, 0x44, 0xF4, 0x43,
  0xB6, 0xF0, 0xB7, 0x20, 0xBF, 0xBC, 0xA0, 0x52, 0x2D, 0x95, 0x62, 0x44,
  0xEA, 0x70, 0xE9, 0x44, 0xB8, 0xFE, 0xCA, 0x3C, 0xB0, 0xF0,
};

const GFXglyph IBMPlexMono_Regular8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 7, 5, 0, -6 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 2, 5, 2, -6 },
  { 20, 2, 7, 5, 2, -6 },
  { 22, 2, 7, 5, 1, -6 },
  { 24, 4, 4, 5, 0, -5 },
  { 26, 4, 4, 5, 0, -4 },
  { 28, 1, 2, 5, 2, -1 },
  { 29, 3, 1, 5, 1, -3 },
  { 30, 1, 1, 5, 2, -1 },
  { 31, 3, 7, 5, 1, -6 },
  { 34, 4, 6, 5, 0, -6 },
  { 37, 4, 6, 5, 0, -6 },
  { 40, 3, 6, 5, 1, -6 },
  { 43, 4, 6, 5, 0, -6 },
  { 46, 5, 6, 5, 0, -6 },
  { 50, 3, 6, 5, 1, -6 },
  { 53, 3, 6, 5, 1, -6 },
  { 56, 3, 6, 5, 1, -6 },
  { 59, 4, 6, 5, 0, -6 },
  { 62, 3, 6, 5, 1, -6 },
  { 65, 1, 4, 5, 2, -4 },
  { 66, 1, 5, 5, 2, -4 },
  { 67, 3, 5, 5, 1, -5 },
  { 69, 4, 3, 5, 0, -4 },
  { 71, 3, 5, 5, 1, -5 },
  { 73, 3, 6, 5, 1, -6 },
  { 76, 4, 7, 5, 0, -6 },
  { 80, 5, 6, 5, 0, -6 },
  { 84, 3, 6, 5, 1, -6 },
  { 87, 3, 6, 5, 1, -6 },
  { 90, 3, 6, 5, 1, -6 },
  { 93, 3, 6, 5, 1, -6 },
  { 96, 3, 6, 5, 1, -6 },
  { 99, 4, 6, 5, 0, -6 },
  { 102, 3, 6, 5, 1, -6 },
  { 105, 3, 6, 5, 1, -6 },
  { 108, 3, 6, 5, 1, -6 },
  { 111, 4, 6, 5, 1, -6 },
  { 114, 3, 6, 5, 1, -6 },
  { 117, 3, 6, 5, 1, -6 },
  { 120, 3, 6, 5, 1, -6 },
  { 123, 4, 6, 5, 0, -6 },
  { 126, 3, 6, 5, 1, -6 },
  { 129, 4, 7, 5, 0, -6 },
  { 133, 3, 6, 5, 1, -6 },
  { 136, 4, 6, 5, 0, -6 },
  { 139, 5, 6, 5, 0, -6 },
  { 143, 3, 6, 5, 1, -6 },
  { 146, 5, 6, 5, 0, -6 },
  { 150, 5, 6, 5, 0, -6 },
  { 154, 5, 6, 5, 0, -6 },
  { 158, 5, 6, 5, 0, -6 },
  { 162, 4, 6, 5, 0, -6 },
  { 165, 2, 7, 5, 2, -6 },
  { 167, 3, 7, 5, 1, -6 },
  { 170, 2, 7, 5, 1, -6 },
  { 172, 4, 4, 5, 0, -6 },
  { 174, 4, 1, 5, 0, 1 },
  { 175, 2, 1, 5, 1, -6 },
  { 176, 3, 4, 5, 1, -4 },
  { 178, 3, 6, 5, 1, -6 },
  { 181, 3, 4, 5, 1, -4 },
  { 183, 4, 6, 5, 0, -6 },
  { 186, 3, 4, 5, 1, -4 },
  { 188, 3, 6, 5, 1, -6 },
  { 191, 3, 7, 5, 1, -5 },
  { 194, 3, 6, 5, 1, -6 },
  { 197, 3, 6, 5, 1, -6 },
  { 200, 3, 8, 5, 1, -6 },
  { 203, 4, 6, 5, 1, -6 },
  { 206, 3, 6, 5, 1, -6 },
  { 209, 4, 4, 5, 0, -4 },
  { 211, 3, 4, 5, 1, -4 },
  { 213, 3, 4, 5, 1, -4 },
  { 215, 3, 6, 5, 1, -4 },
  { 218, 4, 6, 5, 0, -4 },
  { 221, 3, 4, 5, 1, -4 },
  { 223, 3, 4, 5, 1, -4 },
  { 225, 4, 6, 5, 0, -6 },
  { 228, 3, 4, 5, 1, -4 },
  { 230, 3, 4, 5, 1, -4 },
  { 232, 5, 4, 5, 0, -4 },
  { 235, 4, 4, 5, 0, -4 },
  { 237, 4, 6, 5, 0, -4 },
  { 240, 3, 4, 5, 1, -4 },
  { 242, 3, 7, 5, 1, -6 },
  { 245, 1, 7, 5, 2, -6 },
  { 246, 3, 7, 5, 1, -6 },
  { 249, 4, 1, 5, 0, -3 },
};

const GFXfont IBMPlexMono_Regular8pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular8pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular8pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _IBMPLEXMONO_REGULAR8PT7B_H_
