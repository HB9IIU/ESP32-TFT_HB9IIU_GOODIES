#ifndef _IBMPLEXMONO_REGULAR71PT7B_H_
#define _IBMPLEXMONO_REGULAR71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular71pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE1, 0xFF,
  0x7F, 0xEF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFC, 0x00,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0x00, 0x01, 0xF8,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0x8F, 0x3F, 0xF8, 0x3F, 0xC1, 0xE0, 0xFF, 0x8F, 0xE0, 0x3C, 0x07,
  0xF9, 0xF8, 0x07, 0x80, 0x7E, 0x3F, 0x00, 0xF0, 0x07, 0x87, 0xC0, 0x1E,
  0x00, 0x41, 0xF8, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x07, 0xE0,
  0x0F, 0x00, 0x00, 0xFC, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x3C, 0x00, 0x01,
  0xF8, 0x07, 0x80, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x1E, 0x00,
  0x00, 0xFF, 0x03, 0xC0, 0x00, 0x0F, 0xF8, 0x78, 0x00, 0x00, 0xFF, 0xCF,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x79, 0xFF, 0xC0, 0x00, 0x0F, 0x07,
  0xF8, 0x00, 0x01, 0xE0, 0x3F, 0x80, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x07,
  0x80, 0x7F, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0xFC, 0x00,
  0x03, 0xC0, 0x1F, 0x80, 0x00, 0x78, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x7E,
  0x00, 0x01, 0xE0, 0x0F, 0xC4, 0x00, 0x3C, 0x01, 0xF9, 0xC0, 0x07, 0x80,
  0x3F, 0x7C, 0x00, 0xF0, 0x0F, 0xFF, 0xC0, 0x1E, 0x01, 0xFB, 0xFE, 0x03,
  0xC0, 0x7F, 0x3F, 0xE0, 0x78, 0x3F, 0xC3, 0xFF, 0x8F, 0x3F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0x0F, 0xFF, 0xC0, 0x00, 0x3E, 0x1F, 0xFF, 0xE0, 0x00, 0x7C,
  0x3F, 0x87, 0xF0, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x01,
  0xF0, 0x78, 0x00, 0x78, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0x7C,
  0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x78, 0x00, 0x78, 0x1F, 0x00,
  0x78, 0x00, 0x78, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x87, 0xF0, 0xF8,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x83, 0xFF, 0xFC, 0x00, 0x1F,
  0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x7E, 0x00, 0x3E, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0x1F, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x1F,
  0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x3E,
  0x00, 0x03, 0xFF, 0xFC, 0x7C, 0x00, 0x01, 0xFF, 0xF8, 0x7C, 0x00, 0x00,
  0xFF, 0xE0, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFF, 0x80,
  0x1F, 0xF8, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0xFE, 0x7F, 0x00, 0x7F, 0xE3,
  0xF8, 0x7F, 0x00, 0xF0, 0x07, 0xE0, 0x7F, 0x01, 0xE0, 0x1F, 0x80, 0x7F,
  0x07, 0xC0, 0x3F, 0x00, 0x7F, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x1F, 0x01,
  0xF8, 0x00, 0x7E, 0x3E, 0x03, 0xF0, 0x00, 0xFE, 0x78, 0x07, 0xE0, 0x00,
  0xFE, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0xFF, 0xC0,
  0x3F, 0x00, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xFC,
  0x03, 0xF8, 0x00, 0x1D, 0xFC, 0x03, 0xF8, 0x00, 0x79, 0xFC, 0x07, 0xFC,
  0x07, 0xE1, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFC, 0x07, 0xFF, 0xFF, 0x01,
  0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0xC7, 0xE0, 0x0F, 0x80,
  0x3F, 0x3F, 0xE0, 0x7C, 0x0F, 0xFB, 0xFF, 0xE3, 0xE3, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x30, 0x00, 0x04, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xF8, 0x7F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0xF0, 0x7F, 0x83,
  0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0x0F, 0xFB, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xC7,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x7C, 0x03, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xFC, 0x07,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xF0, 0x3F, 0xFE,
  0x03, 0xFE, 0x07, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xF8, 0x07, 0xE0, 0x1F,
  0xFF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x00,
  0xFF, 0x3F, 0x00, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x0F, 0xF0, 0xFC, 0x00,
  0x03, 0xFC, 0x1F, 0x80, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x7E,
  0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x01, 0xC0, 0x07, 0xE0, 0x00, 0x10, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x0F, 0xC3, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x30, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x20, 0x00, 0x00, 0x7F, 0x1C, 0x00, 0x00, 0x1F, 0x8F, 0x00, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0xC0,
  0x01, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0x80,
  0x03, 0xE0, 0xFF, 0xF8, 0x01, 0xF1, 0xFF, 0xFF, 0x00, 0xF9, 0xFF, 0xFF,
  0xC0, 0x7D, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xE0, 0x01,
  0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x87, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x10, 0x00, 0x00, 0x7E, 0x18,
  0x00, 0x00, 0x3F, 0x1E, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0xC1, 0xFF, 0x80, 0x7F, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x07, 0xE1, 0xFF, 0xF8, 0x03,
  0xF1, 0xFF, 0xFF, 0x01, 0xF9, 0xFF, 0xFF, 0xC0, 0xF9, 0xFF, 0xFF, 0xF0,
  0xFD, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x1F, 0xC7, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xF8, 0x00,
  0x3F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xF8,
  0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xF8,
  0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x3F, 0x80, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0x9F, 0xE0,
  0x00, 0xEF, 0x87, 0xFC, 0x03, 0xF7, 0xC3, 0xFF, 0xFF, 0xF7, 0xE0, 0xFF,
  0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xF1, 0xF0, 0x07, 0xFF, 0xE1, 0xF8, 0x00,
  0x7F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x0F, 0xFB, 0xFF, 0x7F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x7F, 0xC7, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xBF,
  0xF7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xFC, 0x7E, 0x00, 0x0F,
  0xC0, 0xFF, 0x8F, 0xFC, 0x7F, 0xE3, 0xFF, 0x9F, 0xFC, 0xFF, 0xC7, 0xFE,
  0x1F, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x87, 0xF8,
  0x3F, 0xC3, 0xFE, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0x80,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0xFC, 0x3E, 0xF8, 0x01, 0xFF, 0x1F, 0x7C, 0x01, 0xFF, 0xCF, 0xBE,
  0x01, 0xFF, 0xF7, 0xDF, 0x01, 0xFF, 0xFB, 0xEF, 0x80, 0xFE, 0x0F, 0xF7,
  0xC0, 0x7C, 0x01, 0xFB, 0xE0, 0x7E, 0x00, 0x7D, 0xF0, 0x3E, 0x00, 0x3E,
  0xF8, 0x1F, 0x00, 0x1F, 0xFC, 0x0F, 0x80, 0x0F, 0xFE, 0x07, 0xC0, 0x07,
  0xFF, 0x07, 0xE0, 0x03, 0xFF, 0x83, 0xF0, 0x01, 0xFF, 0xC1, 0xF8, 0x00,
  0xFF, 0xE0, 0xFC, 0x00, 0x7F, 0xF0, 0x7E, 0x00, 0x3F, 0xF8, 0x3F, 0x00,
  0x1F, 0xFC, 0x1F, 0x80, 0x0F, 0xFE, 0x07, 0xC0, 0x07, 0xDF, 0x03, 0xE0,
  0x03, 0xEF, 0x81, 0xF0, 0x01, 0xF7, 0xC0, 0xF8, 0x00, 0xFB, 0xE0, 0x7E,
  0x00, 0x7D, 0xF0, 0x1F, 0x80, 0x7E, 0xF8, 0x0F, 0xF0, 0xFF, 0x7C, 0x07,
  0xFF, 0xEF, 0xBE, 0x01, 0xFF, 0xF7, 0xDF, 0x80, 0x7F, 0xF3, 0xE7, 0xC0,
  0x1F, 0xF1, 0xF3, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x00, 0x7F, 0xC3,
  0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x1F, 0x80, 0x00, 0xFF, 0x0F, 0xC0, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F,
  0xCF, 0xC0, 0x00, 0x7F, 0xC7, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x00, 0x83, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x20, 0x7E, 0x00, 0x00, 0x3C, 0x3F,
  0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0x1F,
  0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03,
  0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x03, 0xC3, 0xF0, 0x00, 0x00, 0x83, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1E, 0xF8, 0x3F, 0xE0, 0x3E,
  0x7C, 0x1F, 0xFF, 0xFF, 0x3E, 0x07, 0xFF, 0xFF, 0x1F, 0x01, 0xFF, 0xFF,
  0x0F, 0x80, 0x3F, 0xFE, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE3,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xF0, 0x1F,
  0xF0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x00, 0x7F,
  0x8F, 0xC0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0x80,
  0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7F, 0x80,
  0x07, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0xFE,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x1F, 0xF0, 0x00, 0x07,
  0xE7, 0xFF, 0x00, 0x00, 0xFD, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0xFE, 0x00,
  0x03, 0xFF, 0xCF, 0xC0, 0x00, 0x7F, 0xF1, 0xFC, 0x00, 0x0F, 0xFE, 0x1F,
  0xC0, 0x01, 0xFF, 0x81, 0xF8, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x07, 0xF8,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFE,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x01, 0xFC, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFD, 0xF0, 0x01, 0xFF, 0xFE, 0xFC, 0x01, 0xF7, 0xFF, 0x3E, 0x00,
  0xFB, 0xFF, 0x9F, 0x00, 0xF9, 0xFF, 0xC7, 0xC0, 0x7C, 0xFF, 0xE3, 0xE0,
  0x3E, 0x7F, 0xF1, 0xF8, 0x3E, 0x3F, 0xF8, 0x7C, 0x1F, 0x1F, 0xFC, 0x3E,
  0x0F, 0x0F, 0xFE, 0x0F, 0x8F, 0x87, 0xFF, 0x07, 0xC7, 0xC3, 0xFF, 0x83,
  0xF7, 0xC1, 0xFF, 0xC0, 0xFB, 0xE0, 0xFF, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFC, 0x07, 0xF8, 0x0F, 0xFE,
  0x01, 0xFC, 0x07, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0x3E, 0x01, 0xFF,
  0xC0, 0x1F, 0x00, 0xFF, 0xE0, 0x0F, 0x00, 0x7F, 0xF0, 0x03, 0x80, 0x3F,
  0xF8, 0x01, 0x80, 0x1F, 0xFC, 0x00, 0x40, 0x0F, 0xFE, 0x00, 0x20, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFB, 0xF0,
  0x00, 0x3F, 0xF7, 0xE0, 0x00, 0x7F, 0xE7, 0xC0, 0x00, 0xFF, 0xCF, 0xC0,
  0x01, 0xFF, 0x9F, 0x80, 0x03, 0xFF, 0x1F, 0x80, 0x07, 0xFE, 0x3F, 0x00,
  0x0F, 0xFC, 0x3E, 0x00, 0x1F, 0xF8, 0x7E, 0x00, 0x3F, 0xF0, 0xFC, 0x00,
  0x7F, 0xE0, 0xFC, 0x00, 0xFF, 0xC1, 0xF8, 0x01, 0xFF, 0x81, 0xF0, 0x03,
  0xFF, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xE0, 0x0F, 0xFC, 0x07, 0xE0, 0x1F,
  0xF8, 0x0F, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x80, 0xFF,
  0xC0, 0x3F, 0x01, 0xFF, 0x80, 0x3F, 0x03, 0xFF, 0x00, 0x7E, 0x07, 0xFE,
  0x00, 0x7C, 0x0F, 0xFC, 0x00, 0xFC, 0x1F, 0xF8, 0x01, 0xF8, 0x3F, 0xF0,
  0x01, 0xF8, 0x7F, 0xE0, 0x03, 0xF0, 0xFF, 0xC0, 0x03, 0xE1, 0xFF, 0x80,
  0x07, 0xE3, 0xFF, 0x00, 0x0F, 0xC7, 0xFE, 0x00, 0x0F, 0xCF, 0xFC, 0x00,
  0x1F, 0x9F, 0xF8, 0x00, 0x1F, 0x3F, 0xF0, 0x00, 0x3F, 0x7F, 0xE0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC7, 0xE0, 0x00,
  0x1F, 0xE3, 0xF0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xE0, 0x00, 0x1F,
  0xE3, 0xF0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0xFE, 0x00,
  0x00, 0xFF, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0xF0, 0xFC,
  0x00, 0x00, 0x0C, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x40, 0x00, 0x00, 0x3F, 0x3C, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x3F,
  0xC0, 0x00, 0x0F, 0xE3, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x87, 0xFC, 0x03,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x03,
  0xF1, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x00, 0x0F, 0x87, 0xE0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0xF8, 0x03, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0xE0, 0x0F,
  0x8F, 0x80, 0x7F, 0x80, 0x3E, 0x3E, 0x01, 0xFE, 0x00, 0xF8, 0xF8, 0x07,
  0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0xF0, 0x0F, 0x8F, 0x80, 0x7F, 0xC0, 0x3E,
  0x3E, 0x03, 0xEF, 0x01, 0xF8, 0xF8, 0x0F, 0xBE, 0x07, 0xC3, 0xE0, 0x3E,
  0xF8, 0x1F, 0x0F, 0x80, 0xF3, 0xE0, 0x7C, 0x3F, 0x03, 0xCF, 0x81, 0xF0,
  0xFC, 0x1F, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x7C, 0x1F, 0x07, 0xC1, 0xF1,
  0xF0, 0x7C, 0x1F, 0x07, 0x87, 0xC1, 0xF0, 0x7C, 0x1E, 0x1F, 0x07, 0xC1,
  0xF0, 0xF8, 0x3C, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x1E, 0x3E, 0x07,
  0xC7, 0xC0, 0x78, 0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x7C, 0x7C, 0x07,
  0xCF, 0x81, 0xF9, 0xE0, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x3C, 0xF8, 0x0F,
  0xBE, 0x00, 0xFB, 0xE0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x0F,
  0xBE, 0x03, 0xEF, 0x00, 0x3E, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x1F,
  0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0x1E,
  0x18, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x04, 0x01, 0xC0, 0x7E, 0x0F, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x18,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F,
  0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3C, 0x00,
  0x03, 0xF0, 0x02, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x00, 0x7E, 0x0F, 0xF0, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x3B, 0xE0, 0x7F, 0xC0, 0x7E, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xF1, 0xFF, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0x07, 0xFF, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x01,
  0xF0, 0x3F, 0xFC, 0x03, 0xE1, 0xFF, 0xFE, 0x07, 0xC7, 0xFF, 0xFE, 0x0F,
  0x9F, 0xFF, 0xFE, 0x1F, 0x7C, 0x07, 0xFE, 0x3E, 0xE0, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFE, 0x7D, 0xC0, 0x03, 0xFC,
  0xFB, 0xE0, 0x3F, 0xF1, 0xF3, 0xFF, 0xFF, 0xC3, 0xE3, 0xFF, 0xFF, 0x07,
  0xC3, 0xFF, 0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xE1, 0xF8, 0x00, 0x01, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0x83, 0xF0, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F,
  0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0xFF, 0xF8, 0x3F, 0x01, 0xFF, 0xFC, 0x3F, 0x07, 0xFF, 0xFF, 0x3F,
  0x0F, 0xFF, 0xFF, 0x3F, 0x0F, 0xF8, 0x0F, 0xBF, 0x1F, 0xE0, 0x01, 0xFF,
  0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFF,
  0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x0F, 0xBF, 0x0F, 0xFF, 0xFF, 0x3F,
  0x07, 0xFF, 0xFF, 0x3F, 0x01, 0xFF, 0xFE, 0x3F, 0x00, 0xFF, 0xF8, 0x3F,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x04, 0x0F, 0xC0, 0x00, 0x03, 0x83,
  0xF0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF3, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7F,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0xFF, 0x3E,
  0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x7F, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x07, 0xF0, 0x07, 0xE1, 0xFF, 0xF0, 0x3F, 0x1F, 0xFF, 0xC1, 0xF9, 0xFF,
  0xFF, 0x0F, 0xDF, 0xFF, 0xFC, 0x7E, 0xF0, 0x1F, 0xF3, 0xFE, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0x00,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x03, 0xF3, 0xFF,
  0x00, 0x00, 0xFD, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x7F, 0x00, 0x03, 0xFF, 0x8F, 0xE0, 0x00, 0xFF, 0x83, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x3E,
  0x00, 0xFC, 0x1F, 0x1F, 0xF0, 0x3F, 0xE3, 0xE7, 0xFF, 0x0F, 0xFE, 0x7D,
  0xFF, 0xE3, 0xFF, 0xCF, 0xBF, 0xFE, 0xFF, 0xFD, 0xF6, 0x1F, 0xDC, 0x3F,
  0xBF, 0x00, 0xFE, 0x03, 0xF7, 0xE0, 0x1F, 0xC0, 0x3E, 0xF8, 0x03, 0xF0,
  0x07, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x07, 0xC0, 0x1F, 0xFC, 0x00,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x7F, 0xF0, 0x03, 0xE0, 0x07, 0xFE,
  0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x03,
  0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x00,
  0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xFF,
  0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0x7C,
  0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x00,
  0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0x00, 0x3E, 0xFC, 0x07, 0xF0, 0x07, 0xE1, 0xFF, 0xF0, 0x3F,
  0x1F, 0xFF, 0xC1, 0xF9, 0xFF, 0xFF, 0x0F, 0xDF, 0xFF, 0xFC, 0x7E, 0xF0,
  0x1F, 0xF3, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x07, 0xF8, 0x01,
  0xF0, 0x3F, 0xFC, 0x03, 0xE1, 0xFF, 0xFE, 0x07, 0xC7, 0xFF, 0xFE, 0x0F,
  0x9F, 0xFF, 0xFE, 0x1F, 0x7C, 0x07, 0xFE, 0x3E, 0xE0, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFE, 0x7D, 0xC0, 0x03, 0xFC,
  0xFB, 0xE0, 0x3F, 0xF1, 0xF3, 0xFF, 0xFF, 0xC3, 0xE3, 0xFF, 0xFF, 0x07,
  0xC3, 0xFF, 0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0x1F, 0x00, 0xFF, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0xFF, 0xF8, 0x3F, 0x01, 0xFF,
  0xFC, 0x3F, 0x07, 0xFF, 0xFF, 0x3F, 0x0F, 0xFF, 0xFF, 0x3F, 0x0F, 0xF8,
  0x0F, 0xBF, 0x1F, 0xE0, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0x7F, 0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8,
  0x0F, 0xBF, 0x0F, 0xFF, 0xFF, 0x3F, 0x07, 0xFF, 0xFF, 0x3F, 0x01, 0xFF,
  0xFE, 0x3F, 0x00, 0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFE,
  0x00, 0x3F, 0x3E, 0x00, 0x00, 0x07, 0xEF, 0x00, 0x00, 0x00, 0xFD, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x07, 0xFE, 0x1F, 0xC0, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0x18, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x10, 0x00, 0x00, 0x1F,
  0x38, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFE, 0x7F, 0xF0, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF0, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xBF, 0x3F, 0xE0, 0x7D,
  0xF9, 0xFF, 0xFF, 0xCF, 0xC7, 0xFF, 0xFE, 0x7E, 0x1F, 0xFF, 0xE3, 0xF0,
  0x3F, 0xFC, 0x1F, 0x80, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xF8,
  0x01, 0xF7, 0xC0, 0x0F, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0x80, 0x1F, 0x7C,
  0x01, 0xFE, 0x00, 0x7D, 0xF0, 0x07, 0xFC, 0x01, 0xF7, 0xC0, 0x1E, 0xF0,
  0x07, 0x9F, 0x00, 0x7B, 0xC0, 0x1E, 0x7C, 0x01, 0xEF, 0x00, 0xF8, 0xF0,
  0x0F, 0x3C, 0x03, 0xE3, 0xE0, 0x3C, 0x78, 0x0F, 0x8F, 0x80, 0xF1, 0xE0,
  0x3E, 0x3E, 0x03, 0xC7, 0x80, 0xF8, 0xF8, 0x0F, 0x1E, 0x03, 0xC3, 0xE0,
  0x78, 0x78, 0x0F, 0x0F, 0x81, 0xE1, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC1,
  0xF0, 0x78, 0x1E, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0xC3,
  0xC0, 0xF0, 0x7C, 0x1F, 0x0F, 0x03, 0xE1, 0xE0, 0x7C, 0x3C, 0x07, 0x87,
  0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0xF8, 0x0F, 0x1F,
  0x01, 0xE3, 0xE0, 0x3E, 0x78, 0x07, 0x8F, 0x80, 0xF9, 0xE0, 0x0F, 0x3C,
  0x03, 0xE7, 0x80, 0x3C, 0xF0, 0x0F, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0xF8,
  0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x3F, 0xF0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xF9, 0xF8,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x80, 0x7F,
  0xC0, 0x00, 0x7C, 0x3F, 0xFC, 0x00, 0x0F, 0x87, 0xFF, 0xC0, 0x01, 0xE1,
  0xFF, 0xFC, 0x00, 0x3C, 0x7E, 0x1F, 0x80, 0x0F, 0x8F, 0x81, 0xF8, 0x01,
  0xF1, 0xF0, 0x1F, 0x80, 0x7C, 0x7C, 0x01, 0xF8, 0x0F, 0x8F, 0x80, 0x3F,
  0x83, 0xF1, 0xE0, 0x03, 0xF8, 0xFC, 0x7C, 0x00, 0x3F, 0xFF, 0x8F, 0x80,
  0x03, 0xFF, 0xE1, 0xF0, 0x00, 0x3F, 0xF8, 0x3C, 0x00, 0x03, 0xFE, 0x01,
  0x80, 0x00, 0x1F, 0x00,
};

const GFXglyph IBMPlexMono_Regular71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 43, 0, -1 },
  { 1, 11, 51, 43, 16, -50 },
  { 72, 18, 20, 43, 12, -53 },
  { 117, 40, 50, 43, 1, -50 },
  { 367, 35, 65, 43, 4, -57 },
  { 652, 40, 51, 43, 1, -50 },
  { 907, 39, 51, 43, 2, -50 },
  { 1156, 5, 20, 43, 19, -53 },
  { 1169, 20, 64, 43, 15, -54 },
  { 1329, 20, 64, 43, 8, -54 },
  { 1489, 37, 35, 43, 3, -40 },
  { 1651, 34, 35, 43, 4, -39 },
  { 1800, 13, 20, 43, 14, -10 },
  { 1833, 21, 5, 43, 11, -24 },
  { 1847, 11, 10, 43, 16, -9 },
  { 1861, 30, 64, 43, 6, -54 },
  { 2101, 35, 51, 43, 4, -50 },
  { 2325, 35, 50, 43, 4, -50 },
  { 2544, 33, 50, 43, 5, -50 },
  { 2751, 34, 51, 43, 3, -50 },
  { 2968, 38, 50, 43, 2, -50 },
  { 3206, 33, 51, 43, 5, -50 },
  { 3417, 33, 51, 43, 5, -50 },
  { 3628, 33, 50, 43, 5, -50 },
  { 3835, 35, 51, 43, 4, -50 },
  { 4059, 33, 50, 43, 5, -50 },
  { 4266, 11, 38, 43, 16, -37 },
  { 4319, 13, 47, 43, 14, -37 },
  { 4396, 31, 41, 43, 6, -42 },
  { 4555, 34, 19, 43, 4, -31 },
  { 4636, 31, 41, 43, 6, -42 },
  { 4795, 31, 51, 43, 5, -50 },
  { 4993, 33, 58, 43, 4, -50 },
  { 5233, 38, 50, 43, 2, -50 },
  { 5471, 33, 50, 43, 6, -50 },
  { 5678, 33, 51, 43, 5, -50 },
  { 5889, 32, 50, 43, 7, -50 },
  { 6089, 31, 50, 43, 6, -50 },
  { 6283, 32, 50, 43, 6, -50 },
  { 6483, 33, 51, 43, 4, -50 },
  { 6694, 31, 50, 43, 6, -50 },
  { 6888, 31, 50, 43, 6, -50 },
  { 7082, 29, 51, 43, 5, -50 },
  { 7267, 35, 50, 43, 6, -50 },
  { 7486, 29, 50, 43, 9, -50 },
  { 7668, 33, 50, 43, 5, -50 },
  { 7875, 31, 50, 43, 6, -50 },
  { 8069, 35, 51, 43, 4, -50 },
  { 8293, 33, 50, 43, 6, -50 },
  { 8500, 35, 62, 43, 4, -50 },
  { 8772, 33, 50, 43, 6, -50 },
  { 8979, 35, 51, 43, 3, -50 },
  { 9203, 39, 50, 43, 2, -50 },
  { 9447, 31, 51, 43, 6, -50 },
  { 9645, 37, 50, 43, 3, -50 },
  { 9877, 38, 50, 43, 2, -50 },
  { 10115, 39, 50, 43, 2, -50 },
  { 10359, 40, 50, 43, 1, -50 },
  { 10609, 36, 50, 43, 3, -50 },
  { 10834, 20, 64, 43, 16, -54 },
  { 10994, 30, 64, 43, 6, -54 },
  { 11234, 20, 64, 43, 7, -54 },
  { 11394, 36, 29, 43, 3, -50 },
  { 11525, 34, 5, 43, 4, 7 },
  { 11547, 12, 14, 43, 13, -56 },
  { 11568, 34, 38, 43, 5, -37 },
  { 11730, 31, 54, 43, 7, -53 },
  { 11940, 31, 38, 43, 6, -37 },
  { 12088, 32, 54, 43, 4, -53 },
  { 12304, 33, 38, 43, 5, -37 },
  { 12461, 34, 53, 43, 5, -53 },
  { 12687, 35, 57, 43, 5, -42 },
  { 12937, 29, 53, 43, 7, -53 },
  { 13130, 31, 53, 43, 8, -53 },
  { 13336, 25, 67, 43, 7, -53 },
  { 13546, 34, 53, 43, 7, -53 },
  { 13772, 31, 53, 43, 6, -53 },
  { 13978, 35, 37, 43, 4, -37 },
  { 14140, 29, 37, 43, 7, -37 },
  { 14275, 33, 38, 43, 5, -37 },
  { 14432, 31, 51, 43, 7, -37 },
  { 14630, 32, 51, 43, 4, -37 },
  { 14834, 35, 37, 43, 5, -37 },
  { 14996, 32, 38, 43, 5, -37 },
  { 15148, 34, 50, 43, 3, -50 },
  { 15361, 29, 38, 43, 7, -37 },
  { 15499, 33, 37, 43, 5, -37 },
  { 15652, 38, 37, 43, 2, -37 },
  { 15828, 34, 37, 43, 4, -37 },
  { 15986, 35, 51, 43, 4, -37 },
  { 16210, 31, 37, 43, 6, -37 },
  { 16354, 28, 64, 43, 7, -54 },
  { 16578, 5, 64, 43, 19, -54 },
  { 16618, 28, 64, 43, 7, -54 },
  { 16842, 35, 16, 43, 4, -29 },
};

const GFXfont IBMPlexMono_Regular71pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular71pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular71pt7bGlyphs,
  0x20, 0x7E, 92
};

#endif // _IBMPLEXMONO_REGULAR71PT7B_H_
