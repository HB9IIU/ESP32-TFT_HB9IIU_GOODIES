#ifndef _IBMPLEXMONO_REGULAR48PT7B_H_
#define _IBMPLEXMONO_REGULAR48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular48pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xE3, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x83, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0,
  0x70, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0F,
  0x00, 0x03, 0xC1, 0xE0, 0x3F, 0xF8, 0x3F, 0xF7, 0xFF, 0x07, 0xFE, 0xFF,
  0xC0, 0xFF, 0xC0, 0x38, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x0F, 0xFC,
  0x1F, 0xF9, 0xFF, 0x83, 0xFF, 0x3F, 0xF0, 0x7F, 0xE0, 0x1E, 0x0E, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x38, 0x1C, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xCE, 0x7F, 0x0F, 0x87, 0x07, 0xC7, 0x83, 0x81, 0xE3,
  0xC1, 0xC0, 0x41, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x38, 0x00,
  0x3C, 0x1C, 0x00, 0x1F, 0x0E, 0x00, 0x0F, 0xC7, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0E, 0x1F, 0x80, 0x07, 0x07, 0xC0, 0x03,
  0x81, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x1E, 0x20,
  0x38, 0x1E, 0x30, 0x1C, 0x0F, 0x3E, 0x0E, 0x07, 0xBF, 0x87, 0x07, 0xC7,
  0xF3, 0x9F, 0xC1, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xC0, 0x01, 0xE3, 0xFE,
  0x00, 0x38, 0xFF, 0xE0, 0x0F, 0x3C, 0x3C, 0x01, 0xC7, 0x03, 0xC0, 0x79,
  0xE0, 0x38, 0x0E, 0x38, 0x07, 0x03, 0x87, 0x00, 0xE0, 0xF0, 0xE0, 0x1C,
  0x1C, 0x1C, 0x03, 0x87, 0x83, 0x80, 0x70, 0xE0, 0x70, 0x0E, 0x3C, 0x07,
  0x03, 0xC7, 0x00, 0xF0, 0xF1, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x1E, 0x3F, 0xF8, 0x03, 0x87, 0x87, 0x80, 0xE1, 0xE0,
  0x70, 0x3C, 0x38, 0x0F, 0x07, 0x07, 0x00, 0xE1, 0xE0, 0xE0, 0x1C, 0x38,
  0x1C, 0x03, 0x8F, 0x03, 0x80, 0x71, 0xC0, 0x70, 0x1E, 0x78, 0x0E, 0x03,
  0xCE, 0x01, 0xE0, 0x73, 0xC0, 0x1E, 0x1E, 0x70, 0x03, 0xFF, 0x9E, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x03, 0xC0,
  0x38, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0,
  0x1F, 0xC3, 0xFC, 0x07, 0xF1, 0xE7, 0x81, 0xFC, 0xF1, 0xF0, 0x70, 0x7C,
  0x3C, 0x1C, 0x1E, 0x07, 0x87, 0x07, 0x80, 0xF1, 0xC3, 0xC0, 0x1E, 0x70,
  0xF0, 0x07, 0xD8, 0x3C, 0x00, 0xFE, 0x0F, 0x00, 0x1F, 0x83, 0xC0, 0x03,
  0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x2F, 0x07, 0xC0, 0x19, 0xE0, 0xFC,
  0x1E, 0x3C, 0x1F, 0xFF, 0x07, 0x83, 0xFF, 0x81, 0xF0, 0x3F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x80,
  0x38, 0x02, 0x78, 0x1C, 0x0F, 0x7F, 0x8E, 0x3F, 0xBF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0xF8, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x18, 0x01,
  0xC0, 0x04, 0x00, 0x40, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3F,
  0x9F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1E,
  0x0F, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8, 0x3F, 0x07, 0xC0, 0x1F, 0x1F, 0x00,
  0x1E, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0x77, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x3C, 0x0F, 0xF0, 0x7C, 0x1F, 0xE1, 0xF8, 0x3F, 0xC3, 0xF0, 0x7F,
  0x83, 0xE0, 0xFF, 0x07, 0x81, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0,
  0x03, 0xE7, 0xC0, 0x07, 0x87, 0xC0, 0x1F, 0x07, 0xE0, 0xFC, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xDE,
  0x00, 0x1F, 0x9E, 0x00, 0x3F, 0x1E, 0x00, 0x7E, 0x1E, 0x00, 0xFC, 0x1E,
  0x00, 0xF8, 0x1E, 0x00, 0x70, 0x1E, 0x00, 0x60, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x0F, 0x80, 0x1F, 0x1E, 0x00, 0x3E,
  0x7C, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0x20, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x1F, 0x87, 0xC0, 0x0F, 0x8F,
  0x00, 0x1F, 0x04, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x80, 0x00, 0xF9,
  0x80, 0x01, 0xF7, 0x80, 0x03, 0xDF, 0x80, 0x0F, 0x8F, 0xC0, 0x7E, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0E, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x00, 0x3C, 0x07, 0x00,
  0x1E, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x0F, 0xE0, 0x0E, 0x3F, 0xF0, 0x1D, 0xFF, 0xF0, 0x3B, 0xFF, 0xF0, 0x7E,
  0x07, 0xF0, 0xF8, 0x03, 0xF0, 0xC0, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x40, 0x00, 0xF1, 0x80, 0x01, 0xE7, 0x80, 0x07, 0xDF, 0x80, 0x1F,
  0x0F, 0xC0, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC3, 0xF0, 0x07, 0x9F, 0xF8, 0x1E, 0x7F, 0xF8, 0x3D, 0xFF,
  0xF8, 0x7F, 0x03, 0xF9, 0xE8, 0x01, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x01,
  0xEF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7D, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7,
  0xC0, 0x07, 0xC7, 0x80, 0x1F, 0x0F, 0xC0, 0x7E, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xF0, 0x1F, 0x8F, 0x80, 0x0F, 0x9E,
  0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xF3, 0xC0, 0x01, 0xC3, 0xC0, 0x07, 0x83, 0xE0, 0x3E, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xFC, 0x07,
  0xE3, 0xE0, 0x03, 0xE7, 0x80, 0x03, 0xDE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0x80, 0x0F, 0x9F, 0xC0, 0x7F, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0,
  0x1F, 0x8F, 0x80, 0x1F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xBC, 0x00, 0x3F, 0x7C, 0x00, 0xFC,
  0x7E, 0x03, 0xF8, 0xFF, 0xFE, 0xF0, 0xFF, 0xF9, 0xE0, 0x7F, 0xE7, 0x80,
  0x3F, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8,
  0x3E, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF3, 0xF1,
  0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0,
  0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0x07, 0xF7, 0xC0, 0x1F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF2, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x1F, 0xF8,
  0x01, 0xFE, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x1E, 0x00, 0xF0, 0xF0,
  0x01, 0xE3, 0x80, 0x03, 0x9E, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x00,
  0x77, 0x01, 0xF1, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F, 0xDF, 0xC3, 0xE1, 0xFF,
  0x0F, 0x03, 0xFC, 0x38, 0x07, 0xF0, 0xE0, 0x1F, 0xC7, 0x80, 0x7F, 0x1E,
  0x01, 0xFC, 0x78, 0x07, 0xF1, 0xE0, 0x1F, 0xC7, 0x80, 0x7F, 0x1E, 0x01,
  0xFC, 0x38, 0x07, 0xF0, 0xE0, 0x1F, 0xC3, 0xC0, 0x7F, 0x0F, 0x03, 0xFC,
  0x1F, 0xB7, 0x70, 0x7F, 0xDD, 0xC0, 0xFE, 0x77, 0x80, 0x40, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x01,
  0xE0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x00,
  0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x79, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF0,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF0,
  0x03, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0xF0, 0x00,
  0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x3C, 0xF0, 0x00, 0xF3,
  0xC0, 0x03, 0x8F, 0x00, 0x3E, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0xEF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFC, 0x1F,
  0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x18,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x61, 0xE0, 0x01, 0xF3, 0xE0, 0x03, 0xC3, 0xE0, 0x0F,
  0x87, 0xF0, 0x7E, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0x00, 0xFC, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3E,
  0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC,
  0x00, 0x7D, 0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x78, 0x07, 0xE3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x83, 0xF0, 0xF8,
  0x03, 0xE3, 0xC0, 0x07, 0x9F, 0x00, 0x0F, 0x78, 0x00, 0x39, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE,
  0x00, 0x0F, 0x7C, 0x00, 0x7C, 0xF8, 0x03, 0xF3, 0xF8, 0x3F, 0xC7, 0xFF,
  0xEF, 0x0F, 0xFF, 0x3C, 0x1F, 0xF8, 0xF0, 0x1F, 0xC0, 0x00, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0x9F, 0x83, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x01,
  0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0xF8,
  0x00, 0xF0, 0xF0, 0x00, 0xF1, 0xF0, 0x00, 0xF3, 0xF0, 0x00, 0xF7, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x3C, 0x00, 0xFE, 0x3E, 0x00, 0xFC, 0x1E,
  0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07,
  0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x77, 0xFB, 0x80, 0xEF, 0xF7, 0x83, 0xDF, 0xE7, 0x07, 0x3F, 0xCE, 0x0E,
  0x7F, 0x9E, 0x38, 0xFF, 0x1C, 0x71, 0xFE, 0x3D, 0xE3, 0xFC, 0x3B, 0x87,
  0xF8, 0x7F, 0x0F, 0xF0, 0xFC, 0x1F, 0xE0, 0xF8, 0x3F, 0xC1, 0xF0, 0x7F,
  0x81, 0xC0, 0xFF, 0x03, 0x81, 0xFE, 0x06, 0x03, 0xFC, 0x04, 0x07, 0xF8,
  0x08, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xF7, 0x80, 0x3F, 0xBC,
  0x01, 0xFC, 0xF0, 0x0F, 0xE7, 0x80, 0x7F, 0x1C, 0x03, 0xF8, 0xF0, 0x1F,
  0xC7, 0x80, 0xFE, 0x1E, 0x07, 0xF0, 0xF0, 0x3F, 0x87, 0x81, 0xFC, 0x1E,
  0x0F, 0xE0, 0xF0, 0x7F, 0x03, 0xC3, 0xF8, 0x1E, 0x1F, 0xC0, 0xF0, 0xFE,
  0x03, 0xC7, 0xF0, 0x1E, 0x3F, 0x80, 0x79, 0xFC, 0x03, 0xCF, 0xE0, 0x1E,
  0x7F, 0x00, 0x7B, 0xF8, 0x03, 0xDF, 0xC0, 0x0E, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x81, 0xF8, 0x3F, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3E,
  0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xE7, 0xC0, 0x07,
  0x87, 0xC0, 0x1F, 0x07, 0xE0, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xF0, 0x01, 0xFB, 0xC0, 0x01, 0xEF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xBC,
  0x00, 0x7E, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x1E,
  0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xE0, 0x03,
  0xC3, 0xE0, 0x0F, 0x87, 0xF0, 0x7E, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFC, 0xF0, 0x01, 0xFB, 0xC0, 0x01, 0xEF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00,
  0x7C, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3C, 0x0F, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0,
  0x07, 0x83, 0xC0, 0x1F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x3F, 0x80, 0xFE, 0x3E, 0x00, 0x3F, 0x3C, 0x00, 0x1E,
  0x7C, 0x00, 0x0C, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x20, 0x00, 0x0F,
  0x70, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x7E, 0x00, 0x3E, 0x3F, 0x80, 0xFE,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3E,
  0x00, 0xF9, 0xF8, 0x0F, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC,
  0x00, 0xFF, 0x80, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01,
  0xE0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0x78, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xB8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x78, 0x1F, 0x03, 0x9C, 0x0F, 0x81,
  0xCE, 0x07, 0xC0, 0xE7, 0x07, 0xE0, 0x73, 0x83, 0xF8, 0x39, 0xC1, 0xDC,
  0x1C, 0xE0, 0xEE, 0x1E, 0x70, 0x77, 0x0F, 0x3C, 0x73, 0xC7, 0x9E, 0x38,
  0xE3, 0xCF, 0x1C, 0x71, 0xE7, 0x8E, 0x38, 0xF3, 0xC7, 0x1C, 0x71, 0xE7,
  0x0F, 0x38, 0x73, 0x83, 0x9C, 0x39, 0xC1, 0xCE, 0x1C, 0xE0, 0xE7, 0x0E,
  0xF0, 0x73, 0x87, 0x70, 0x3D, 0xC3, 0xB8, 0x0E, 0xE1, 0xDC, 0x07, 0x70,
  0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x00, 0x1E, 0x03, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xBC, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0xF8, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0x80, 0x78, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x7C,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03,
  0x81, 0xE0, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x01,
  0xE0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x3C,
  0x78, 0x00, 0x0F, 0x38, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xE4, 0x00, 0x00,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x30, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x05, 0x01, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xF0, 0x3F, 0x07, 0x80, 0x1E,
  0x06, 0x00, 0x3E, 0x04, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x1F, 0x80, 0x3C, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0,
  0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1F, 0x0F, 0x00,
  0x7E, 0x1F, 0x83, 0x9F, 0x9F, 0xFF, 0x3F, 0x1F, 0xFC, 0x3E, 0x0F, 0xE0,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC1, 0xF8, 0x0E, 0x3F, 0xF0, 0x73,
  0xFF, 0xE3, 0xB8, 0x1F, 0x1F, 0x00, 0x7C, 0xF0, 0x01, 0xF7, 0x80, 0x07,
  0xB8, 0x00, 0x3D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0x70, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00,
  0x3E, 0xF8, 0x03, 0xE7, 0x70, 0x3E, 0x39, 0xFF, 0xF1, 0xC7, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3E,
  0x07, 0xC3, 0xE0, 0x0F, 0x1E, 0x00, 0x39, 0xE0, 0x01, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x43, 0xC0, 0x07, 0x9F, 0x00,
  0x78, 0x7C, 0x0F, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0xF0, 0xF0, 0xFF, 0xE7, 0x8F, 0xFF,
  0xBC, 0xFC, 0x0F, 0xE7, 0x80, 0x1F, 0x7C, 0x00, 0x7B, 0xC0, 0x03, 0xDE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x80, 0x0F,
  0x3E, 0x00, 0xF9, 0xF8, 0x1F, 0xC7, 0xFF, 0xDE, 0x1F, 0xFC, 0xF0, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFC,
  0x1F, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x0F, 0x1E, 0x00, 0x0E, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x3C, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x43, 0xC0, 0x01, 0xC3,
  0xC0, 0x07, 0xC3, 0xC0, 0x1F, 0x07, 0xE0, 0x7C, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFE,
  0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0x03, 0xF0, 0x1E, 0x00,
  0xF0, 0x3C, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x1E, 0x00,
  0xF0, 0x1F, 0x03, 0xE0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x38, 0x00, 0x3F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x7E, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x7E, 0x0F,
  0x3F, 0xF1, 0xEF, 0xFF, 0x3F, 0x83, 0xF7, 0xC0, 0x1E, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x71, 0xFF, 0xFC, 0x7F,
  0xFE, 0x1F, 0xFF, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x07, 0xCF, 0x00, 0x1F, 0x1E, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0x78,
  0x07, 0xC0, 0xF0, 0x1F, 0x01, 0xE0, 0x7C, 0x03, 0xC1, 0xE0, 0x07, 0x8F,
  0x80, 0x0F, 0x3E, 0x00, 0x1E, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xBC,
  0x00, 0xFE, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF8,
  0x0F, 0x00, 0xF8, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xF0,
  0xF0, 0x01, 0xF1, 0xE0, 0x01, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xF0,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3,
  0xC0, 0xF9, 0xCF, 0xE7, 0xFB, 0xBF, 0xDF, 0xF7, 0x47, 0xF1, 0xFF, 0x07,
  0xC1, 0xFC, 0x0F, 0x03, 0xF8, 0x0E, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38,
  0x0F, 0xC0, 0x70, 0x1F, 0x80, 0xE0, 0x3F, 0x01, 0xC0, 0x7E, 0x03, 0x80,
  0xFC, 0x07, 0x01, 0xF8, 0x0E, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F,
  0xC0, 0x70, 0x1F, 0x80, 0xE0, 0x3F, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0xFC,
  0x07, 0x01, 0xF8, 0x0E, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0E, 0xF0,
  0xFC, 0x1E, 0x7F, 0xE3, 0xDF, 0xFE, 0x7F, 0x07, 0xEF, 0x80, 0x3D, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xE0,
  0x0F, 0x07, 0x80, 0x0F, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x70, 0x00,
  0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x3C,
  0xE0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xC3, 0xC0, 0x07, 0x87,
  0xC0, 0x1E, 0x07, 0xE0, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0xE0, 0xFC, 0x07, 0x1F, 0xF8, 0x39, 0xFF, 0xF1, 0xDC, 0x0F,
  0x8F, 0x80, 0x3E, 0x78, 0x00, 0xFB, 0xC0, 0x03, 0xDC, 0x00, 0x1E, 0xE0,
  0x00, 0x77, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xB8, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1F, 0x7C, 0x01, 0xF3,
  0xB8, 0x1F, 0x1C, 0xFF, 0xF8, 0xE3, 0xFF, 0x07, 0x07, 0xE0, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF8,
  0x78, 0x7F, 0xF3, 0xC7, 0xFF, 0xDE, 0x7E, 0x07, 0xF3, 0xC0, 0x0F, 0xBE,
  0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDE, 0x00, 0x1E,
  0xF0, 0x00, 0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x7C, 0xFC, 0x0F, 0xE3, 0xFF,
  0xEF, 0x0F, 0xFE, 0x78, 0x1F, 0xC3, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x9F, 0xF8, 0x0F, 0x7F, 0xF0, 0x1E, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xFF, 0x07, 0xC0, 0x7E, 0x3C, 0x00, 0x7C, 0xF0, 0x00, 0xC3, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC8, 0x00,
  0x0F, 0x70, 0x00, 0x3F, 0xF0, 0x01, 0xE3, 0xF0, 0x1F, 0x87, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00,
  0xF7, 0xC0, 0x1F, 0x3E, 0x07, 0xF1, 0xFF, 0xEF, 0x0F, 0xFC, 0xF0, 0x3F,
  0x00, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01,
  0xE3, 0x80, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x78,
  0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0x70, 0x1C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x03,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x07, 0x1C, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0xF0, 0x1F, 0x01, 0xDC, 0x07, 0xC0, 0x77, 0x01, 0xF0, 0x1D, 0xC0,
  0x7C, 0x07, 0x70, 0x3B, 0x03, 0xDE, 0x0E, 0xE0, 0xF7, 0x83, 0xB8, 0x38,
  0xE0, 0xEE, 0x0E, 0x38, 0x33, 0x83, 0x8E, 0x1C, 0x60, 0xE3, 0x87, 0x1C,
  0x38, 0xE1, 0xC7, 0x0E, 0x38, 0x71, 0xC7, 0x0F, 0x18, 0x71, 0xC1, 0xC6,
  0x0C, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1,
  0xCC, 0x0E, 0x70, 0x73, 0x01, 0x98, 0x0D, 0xC0, 0x6E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7E, 0x00, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0xF0, 0x07, 0x81, 0xF0,
  0x1E, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xEF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xF7, 0x80, 0x03, 0xCF, 0x80,
  0x0F, 0x8F, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x1F, 0x01, 0xE0, 0x1F, 0x07,
  0xC0, 0x1E, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80,
  0x03, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x78, 0x1E, 0x00,
  0xF0, 0x3C, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x70, 0x3C,
  0x00, 0xF0, 0x78, 0x01, 0xE0, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x03, 0x8E, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x81, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x7C, 0x0F, 0xFE, 0x01,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xE0,
  0x3F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x07, 0x0F, 0xE0, 0x07, 0x1F,
  0xF0, 0x07, 0x3C, 0x78, 0x0F, 0x38, 0x3C, 0x0E, 0x78, 0x1E, 0x0E, 0x70,
  0x0F, 0x1C, 0x70, 0x07, 0xFC, 0x70, 0x03, 0xF8, 0xF0, 0x01, 0xF0,
};

const GFXglyph IBMPlexMono_Regular48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 7, 34, 29, 11, -34 },
  { 31, 12, 13, 29, 8, -36 },
  { 51, 27, 34, 29, 1, -34 },
  { 166, 25, 45, 29, 2, -39 },
  { 307, 27, 35, 29, 1, -34 },
  { 426, 26, 35, 29, 1, -34 },
  { 540, 3, 13, 29, 13, -36 },
  { 545, 14, 43, 29, 10, -36 },
  { 621, 14, 43, 29, 5, -36 },
  { 697, 25, 24, 29, 2, -27 },
  { 772, 23, 23, 29, 3, -26 },
  { 839, 9, 14, 29, 10, -7 },
  { 855, 14, 4, 29, 7, -17 },
  { 862, 7, 7, 29, 11, -7 },
  { 869, 20, 43, 29, 4, -36 },
  { 977, 23, 35, 29, 3, -34 },
  { 1078, 24, 34, 29, 3, -34 },
  { 1180, 23, 34, 29, 3, -34 },
  { 1278, 23, 35, 29, 2, -34 },
  { 1379, 25, 34, 29, 2, -34 },
  { 1486, 23, 35, 29, 3, -34 },
  { 1587, 23, 35, 29, 3, -34 },
  { 1688, 22, 34, 29, 3, -34 },
  { 1782, 23, 35, 29, 3, -34 },
  { 1883, 23, 34, 29, 3, -34 },
  { 1981, 7, 26, 29, 11, -26 },
  { 2004, 9, 33, 29, 10, -26 },
  { 2042, 21, 28, 29, 4, -29 },
  { 2116, 23, 13, 29, 3, -21 },
  { 2154, 21, 28, 29, 4, -29 },
  { 2228, 20, 34, 29, 4, -34 },
  { 2313, 22, 39, 29, 3, -34 },
  { 2421, 26, 34, 29, 1, -34 },
  { 2532, 22, 34, 29, 4, -34 },
  { 2626, 23, 35, 29, 3, -34 },
  { 2727, 21, 34, 29, 5, -34 },
  { 2817, 21, 34, 29, 4, -34 },
  { 2907, 21, 34, 29, 4, -34 },
  { 2997, 22, 35, 29, 3, -34 },
  { 3094, 21, 34, 29, 4, -34 },
  { 3184, 21, 34, 29, 4, -34 },
  { 3274, 19, 35, 29, 4, -34 },
  { 3358, 24, 34, 29, 4, -34 },
  { 3460, 20, 34, 29, 6, -34 },
  { 3545, 23, 34, 29, 3, -34 },
  { 3643, 21, 34, 29, 4, -34 },
  { 3733, 23, 35, 29, 3, -34 },
  { 3834, 22, 34, 29, 4, -34 },
  { 3928, 23, 42, 29, 3, -34 },
  { 4049, 22, 34, 29, 4, -34 },
  { 4143, 24, 35, 29, 2, -34 },
  { 4248, 27, 34, 29, 1, -34 },
  { 4363, 21, 35, 29, 4, -34 },
  { 4455, 25, 34, 29, 2, -34 },
  { 4562, 25, 34, 29, 2, -34 },
  { 4669, 27, 34, 29, 1, -34 },
  { 4784, 27, 34, 29, 1, -34 },
  { 4899, 25, 34, 29, 2, -34 },
  { 5006, 13, 43, 29, 11, -36 },
  { 5076, 20, 43, 29, 4, -36 },
  { 5184, 13, 43, 29, 5, -36 },
  { 5254, 25, 20, 29, 2, -34 },
  { 5317, 23, 4, 29, 3, 4 },
  { 5329, 8, 9, 29, 9, -37 },
  { 5338, 23, 26, 29, 3, -25 },
  { 5413, 21, 37, 29, 5, -36 },
  { 5511, 21, 26, 29, 4, -25 },
  { 5580, 21, 37, 29, 3, -36 },
  { 5678, 23, 26, 29, 3, -25 },
  { 5753, 23, 36, 29, 3, -36 },
  { 5857, 24, 38, 29, 3, -28 },
  { 5971, 19, 36, 29, 5, -36 },
  { 6057, 21, 36, 29, 5, -36 },
  { 6152, 18, 46, 29, 4, -36 },
  { 6256, 23, 36, 29, 5, -36 },
  { 6360, 21, 36, 29, 4, -36 },
  { 6455, 23, 25, 29, 3, -25 },
  { 6527, 19, 25, 29, 5, -25 },
  { 6587, 23, 26, 29, 3, -25 },
  { 6662, 21, 35, 29, 5, -25 },
  { 6754, 21, 35, 29, 3, -25 },
  { 6846, 23, 25, 29, 4, -25 },
  { 6918, 22, 26, 29, 3, -25 },
  { 6990, 23, 34, 29, 2, -34 },
  { 7088, 20, 26, 29, 4, -25 },
  { 7153, 23, 25, 29, 3, -25 },
  { 7225, 26, 25, 29, 1, -25 },
  { 7307, 23, 25, 29, 3, -25 },
  { 7379, 23, 35, 29, 3, -25 },
  { 7480, 21, 25, 29, 4, -25 },
  { 7546, 19, 43, 29, 5, -36 },
  { 7649, 3, 43, 29, 13, -36 },
  { 7666, 19, 43, 29, 5, -36 },
  { 7769, 24, 10, 29, 2, -20 },
};

const GFXfont IBMPlexMono_Regular48pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular48pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular48pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _IBMPLEXMONO_REGULAR48PT7B_H_
