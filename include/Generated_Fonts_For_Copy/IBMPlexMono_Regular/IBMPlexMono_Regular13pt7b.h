#ifndef _IBMPLEXMONO_REGULAR13PT7B_H_
#define _IBMPLEXMONO_REGULAR13PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular13pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA3, 0xC0, 0x99, 0x99, 0x14, 0x14, 0x14, 0x67, 0x24, 0xEE,
  0x28, 0x28, 0x48, 0x21, 0xEA, 0x68, 0xE1, 0xE2, 0x49, 0xA5, 0xE2, 0x00,
  0x73, 0x92, 0x94, 0x74, 0x00, 0x2E, 0x29, 0x49, 0x8E, 0x38, 0x89, 0x01,
  0x07, 0x6B, 0xA3, 0x62, 0x7A, 0xF0, 0x2A, 0x49, 0x24, 0x91, 0x10, 0xC2,
  0x21, 0x11, 0x11, 0x12, 0x2C, 0x20, 0x8A, 0xDC, 0x31, 0x20, 0x20, 0x82,
  0x3F, 0x20, 0x82, 0x00, 0xEA, 0xF0, 0xF0, 0x0C, 0x20, 0x84, 0x10, 0x42,
  0x08, 0x41, 0x04, 0x20, 0x7B, 0x38, 0x6D, 0xB6, 0x18, 0x73, 0x78, 0x31,
  0x49, 0x04, 0x10, 0x41, 0x04, 0xFC, 0x7A, 0x28, 0xC2, 0x08, 0x46, 0x30,
  0xFC, 0x7A, 0x20, 0xC2, 0x30, 0x20, 0x63, 0x78, 0x0C, 0x28, 0x51, 0x24,
  0x48, 0xBF, 0x82, 0x04, 0x7E, 0x08, 0x2E, 0xCC, 0x10, 0x63, 0x78, 0x39,
  0x04, 0x2E, 0xCE, 0x18, 0x63, 0x78, 0xFE, 0x18, 0x82, 0x10, 0x43, 0x08,
  0x60, 0x7A, 0x38, 0x62, 0x73, 0x38, 0x61, 0x78, 0x7A, 0x38, 0x61, 0x8D,
  0xD0, 0x84, 0x60, 0xF0, 0x3C, 0xF0, 0x3A, 0x80, 0x04, 0x62, 0x30, 0xC0,
  0x81, 0x81, 0xFC, 0x00, 0x3F, 0x81, 0x83, 0x03, 0x0C, 0xC6, 0x20, 0x7B,
  0x28, 0xC2, 0x30, 0x80, 0x0C, 0x30, 0x7B, 0x38, 0x6F, 0xA6, 0x9A, 0x6F,
  0xC1, 0xE0, 0x18, 0x30, 0xA1, 0x22, 0x4F, 0x90, 0xA1, 0xC2, 0xFA, 0x38,
  0x62, 0xFA, 0x18, 0x61, 0xF8, 0x79, 0x38, 0x20, 0x82, 0x08, 0x13, 0x78,
  0xFA, 0x28, 0x61, 0x86, 0x18, 0x62, 0xF8, 0xFE, 0x08, 0x20, 0xFE, 0x08,
  0x20, 0xFC, 0xFE, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x80, 0x7B, 0x38, 0x20,
  0x9E, 0x18, 0x73, 0x74, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x84, 0xFC,
  0x82, 0x08, 0x20, 0x82, 0x08, 0xFC, 0x78, 0x42, 0x10, 0x84, 0x31, 0x70,
  0x85, 0x12, 0x45, 0x0F, 0x1A, 0x22, 0x46, 0x86, 0x84, 0x21, 0x08, 0x42,
  0x10, 0xF8, 0x8F, 0x3D, 0x6D, 0xB6, 0x98, 0x61, 0x84, 0xC7, 0x1A, 0x69,
  0xA6, 0x59, 0x63, 0x8C, 0x7B, 0x38, 0x61, 0x86, 0x18, 0x73, 0x78, 0xFA,
  0x18, 0x61, 0xFA, 0x08, 0x20, 0x80, 0x7B, 0x28, 0x61, 0x86, 0x18, 0x73,
  0x78, 0x81, 0x80, 0xFA, 0x18, 0x61, 0xFA, 0x48, 0xA2, 0x84, 0x7A, 0x18,
  0x30, 0x78, 0x10, 0x61, 0x78, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x86, 0x18, 0x61, 0x86, 0x18, 0x72, 0x78, 0xC2, 0x85, 0x19, 0x22,
  0x44, 0x8A, 0x0C, 0x18, 0x82, 0x85, 0x6A, 0xD5, 0xAD, 0x5A, 0xB3, 0x66,
  0xC2, 0xC8, 0x90, 0xC1, 0x83, 0x09, 0x23, 0xC2, 0xC3, 0x46, 0x24, 0x38,
  0x18, 0x10, 0x10, 0x10, 0x10, 0xFC, 0x30, 0x84, 0x21, 0x84, 0x20, 0xFC,
  0xF8, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04,
  0x10, 0x20, 0x83, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x31, 0xC4, 0xA2,
  0x84, 0xFC, 0x94, 0x72, 0x20, 0x9E, 0x8A, 0x27, 0x40, 0x82, 0x08, 0x2E,
  0xCE, 0x18, 0x61, 0xCE, 0xE0, 0x79, 0x38, 0x20, 0x81, 0x37, 0x80, 0x04,
  0x10, 0x5D, 0x8E, 0x18, 0x61, 0x8D, 0xD0, 0x7B, 0x28, 0x7F, 0x82, 0x17,
  0x80, 0x1C, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x23, 0xF0, 0x0D, 0xEC, 0xA2,
  0xC9, 0xE8, 0x1F, 0x86, 0x1F, 0x80, 0x82, 0x08, 0x2E, 0xCA, 0x18, 0x61,
  0x86, 0x10, 0x10, 0xC0, 0x3C, 0x10, 0x41, 0x04, 0x13, 0xF0, 0x18, 0xC1,
  0xF0, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x00, 0x82, 0x08, 0x23, 0x9A, 0xCD,
  0x26, 0x8A, 0x10, 0xE0, 0x82, 0x08, 0x20, 0x82, 0x08, 0x23, 0xF0, 0xEE,
  0xDA, 0x69, 0xA6, 0x9A, 0x40, 0xBB, 0x28, 0x61, 0x86, 0x18, 0x40, 0x7B,
  0x38, 0x61, 0x87, 0x37, 0x80, 0xBB, 0x38, 0x61, 0x87, 0x3B, 0xA0, 0x82,
  0x00, 0x76, 0x38, 0x61, 0x86, 0x37, 0x41, 0x04, 0x10, 0xEC, 0xC2, 0x08,
  0x20, 0x8F, 0xC0, 0x7A, 0x38, 0x1E, 0x06, 0x17, 0x80, 0x10, 0x23, 0xF8,
  0x81, 0x02, 0x04, 0x08, 0x1E, 0x8E, 0x38, 0xE3, 0x8F, 0x37, 0xC0, 0x86,
  0x24, 0x92, 0x50, 0xC3, 0x00, 0x9A, 0xB5, 0x6B, 0x56, 0xAC, 0xD9, 0x00,
  0x8D, 0x23, 0x0C, 0x31, 0x28, 0xC0, 0x86, 0x14, 0x92, 0x50, 0xC3, 0x08,
  0x23, 0x00, 0xFC, 0x21, 0x08, 0x63, 0x0F, 0xC0, 0x39, 0x08, 0x21, 0x70,
  0x42, 0x21, 0x08, 0x70, 0xFF, 0xF0, 0xF0, 0x84, 0x42, 0x0C, 0x84, 0x20,
  0x85, 0xE0, 0x66, 0xD9, 0x80,
};

const GFXglyph IBMPlexMono_Regular13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 4, 8, 2, -10 },
  { 6, 8, 9, 8, 0, -9 },
  { 15, 6, 11, 8, 1, -10 },
  { 24, 8, 9, 8, 0, -9 },
  { 33, 7, 9, 8, 0, -9 },
  { 41, 1, 4, 8, 3, -10 },
  { 42, 3, 12, 8, 3, -10 },
  { 47, 4, 12, 8, 1, -10 },
  { 53, 6, 6, 8, 1, -7 },
  { 58, 6, 7, 8, 1, -7 },
  { 64, 2, 4, 8, 3, -2 },
  { 65, 4, 1, 8, 2, -4 },
  { 66, 2, 2, 8, 3, -2 },
  { 67, 6, 12, 8, 1, -10 },
  { 76, 6, 9, 8, 1, -9 },
  { 83, 6, 9, 8, 1, -9 },
  { 90, 6, 9, 8, 1, -9 },
  { 97, 6, 9, 8, 1, -9 },
  { 104, 7, 9, 8, 0, -9 },
  { 112, 6, 9, 8, 1, -9 },
  { 119, 6, 9, 8, 1, -9 },
  { 126, 6, 9, 8, 1, -9 },
  { 133, 6, 9, 8, 1, -9 },
  { 140, 6, 9, 8, 1, -9 },
  { 147, 2, 7, 8, 3, -7 },
  { 149, 2, 9, 8, 3, -7 },
  { 152, 6, 8, 8, 1, -8 },
  { 158, 6, 4, 8, 1, -6 },
  { 161, 6, 8, 8, 1, -8 },
  { 167, 6, 9, 8, 1, -9 },
  { 174, 6, 10, 8, 1, -9 },
  { 182, 7, 9, 8, 0, -9 },
  { 190, 6, 9, 8, 1, -9 },
  { 197, 6, 9, 8, 1, -9 },
  { 204, 6, 9, 8, 1, -9 },
  { 211, 6, 9, 8, 1, -9 },
  { 218, 6, 9, 8, 1, -9 },
  { 225, 6, 9, 8, 1, -9 },
  { 232, 6, 9, 8, 1, -9 },
  { 239, 6, 9, 8, 1, -9 },
  { 246, 5, 9, 8, 1, -9 },
  { 252, 7, 9, 8, 1, -9 },
  { 260, 5, 9, 8, 2, -9 },
  { 266, 6, 9, 8, 1, -9 },
  { 273, 6, 9, 8, 1, -9 },
  { 280, 6, 9, 8, 1, -9 },
  { 287, 6, 9, 8, 1, -9 },
  { 294, 6, 11, 8, 1, -9 },
  { 303, 6, 9, 8, 1, -9 },
  { 310, 6, 9, 8, 1, -9 },
  { 317, 7, 9, 8, 0, -9 },
  { 325, 6, 9, 8, 1, -9 },
  { 332, 7, 9, 8, 0, -9 },
  { 340, 7, 9, 8, 0, -9 },
  { 348, 7, 9, 8, 0, -9 },
  { 356, 8, 9, 8, 0, -9 },
  { 365, 6, 9, 8, 1, -9 },
  { 372, 4, 12, 8, 3, -10 },
  { 378, 6, 12, 8, 1, -10 },
  { 387, 4, 12, 8, 1, -10 },
  { 393, 6, 5, 8, 1, -9 },
  { 397, 6, 1, 8, 1, 1 },
  { 398, 2, 3, 8, 2, -11 },
  { 399, 6, 7, 8, 1, -7 },
  { 405, 6, 10, 8, 1, -10 },
  { 413, 6, 7, 8, 1, -7 },
  { 419, 6, 10, 8, 1, -10 },
  { 427, 6, 7, 8, 1, -7 },
  { 433, 6, 10, 8, 1, -10 },
  { 441, 6, 11, 8, 1, -8 },
  { 450, 6, 10, 8, 1, -10 },
  { 458, 6, 10, 8, 1, -10 },
  { 466, 5, 13, 8, 1, -10 },
  { 475, 6, 10, 8, 1, -10 },
  { 483, 6, 10, 8, 1, -10 },
  { 491, 6, 7, 8, 1, -7 },
  { 497, 6, 7, 8, 1, -7 },
  { 503, 6, 7, 8, 1, -7 },
  { 509, 6, 10, 8, 1, -7 },
  { 517, 6, 10, 8, 1, -7 },
  { 525, 6, 7, 8, 1, -7 },
  { 531, 6, 7, 8, 1, -7 },
  { 537, 7, 9, 8, 0, -9 },
  { 545, 6, 7, 8, 1, -7 },
  { 551, 6, 7, 8, 1, -7 },
  { 557, 7, 7, 8, 0, -7 },
  { 564, 6, 7, 8, 1, -7 },
  { 570, 6, 10, 8, 1, -7 },
  { 578, 6, 7, 8, 1, -7 },
  { 584, 5, 12, 8, 1, -10 },
  { 592, 1, 12, 8, 3, -10 },
  { 594, 5, 12, 8, 1, -10 },
  { 602, 6, 3, 8, 1, -5 },
};

const GFXfont IBMPlexMono_Regular13pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular13pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _IBMPLEXMONO_REGULAR13PT7B_H_
