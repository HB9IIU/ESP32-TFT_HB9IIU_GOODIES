#ifndef _IBMPLEXMONO_REGULAR23PT7B_H_
#define _IBMPLEXMONO_REGULAR23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular23pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x44, 0x00, 0x0E, 0xFE, 0xCF, 0x3C, 0xF3,
  0xCF, 0x30, 0x06, 0x20, 0x33, 0x01, 0x98, 0x08, 0xC7, 0xC7, 0xBE, 0x3C,
  0x33, 0x01, 0x98, 0x0C, 0xC0, 0x46, 0x3E, 0x3F, 0xF1, 0xF1, 0x98, 0x0C,
  0xC0, 0x46, 0x02, 0x30, 0x06, 0x00, 0x60, 0x1F, 0x83, 0xFC, 0x76, 0x66,
  0x63, 0x66, 0x06, 0x60, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x66, 0x06, 0x30,
  0x63, 0x46, 0x3F, 0x66, 0x3F, 0xE1, 0xF8, 0x06, 0x00, 0x60, 0x3C, 0x1B,
  0xF0, 0xD1, 0x8D, 0x84, 0x6C, 0x26, 0x23, 0x21, 0xFB, 0x07, 0x80, 0x00,
  0xF0, 0x6F, 0xC6, 0x46, 0x22, 0x13, 0x30, 0x90, 0x8D, 0x87, 0xF8, 0x1E,
  0x1E, 0x03, 0xF0, 0x71, 0x86, 0x10, 0x60, 0x06, 0x00, 0x30, 0x03, 0x87,
  0x7C, 0x7C, 0xE4, 0xC7, 0xC8, 0x3C, 0xC1, 0x8E, 0x1C, 0x7E, 0x63, 0xC3,
  0xFF, 0xF0, 0x0C, 0x63, 0x18, 0x61, 0x0C, 0x30, 0x82, 0x08, 0x20, 0xC3,
  0x04, 0x18, 0x60, 0xC1, 0x83, 0xE0, 0x60, 0x60, 0x40, 0xC0, 0x81, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x08, 0x30, 0xC7, 0x00, 0x06,
  0x00, 0x60, 0x06, 0x08, 0x62, 0xF6, 0xF7, 0xFC, 0x0E, 0x00, 0xF0, 0x19,
  0x83, 0x18, 0x30, 0xC0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x61, 0xFF,
  0xFF, 0xF8, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x76, 0xEC, 0xC8,
  0xFF, 0xF0, 0xEF, 0xE0, 0x00, 0xC0, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x04, 0x03, 0x00, 0x1F, 0x03, 0xFC, 0x70, 0xC6, 0x06, 0x60,
  0x6C, 0x06, 0xC6, 0x2C, 0xE3, 0xC6, 0x3C, 0x02, 0xC0, 0x66, 0x06, 0x60,
  0x67, 0x0C, 0x3F, 0xC1, 0xF0, 0x0E, 0x01, 0xE0, 0x3A, 0x07, 0x20, 0xE2,
  0x04, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02, 0x00, 0x20, 0x02,
  0x00, 0x20, 0x7F, 0xF7, 0xFF, 0x1F, 0x07, 0xF9, 0xC3, 0x30, 0x7C, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0,
  0x1F, 0xFB, 0xFF, 0x1F, 0x07, 0xF9, 0xC3, 0x10, 0x30, 0x0C, 0x01, 0x87,
  0xE0, 0xFC, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x34, 0x07, 0xC1, 0x9F, 0xF0,
  0xF8, 0x03, 0xC0, 0x3C, 0x06, 0xC0, 0x4C, 0x0C, 0xC1, 0x8C, 0x10, 0xC3,
  0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0xCF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0xC0,
  0x0C, 0x7F, 0xDF, 0xF4, 0x01, 0x00, 0xC0, 0x30, 0x0D, 0xF3, 0xFE, 0xE1,
  0xC0, 0x30, 0x0C, 0x03, 0xC0, 0xF8, 0x77, 0xF8, 0xF8, 0x03, 0x81, 0xC0,
  0x70, 0x0C, 0x03, 0x00, 0xCF, 0x1F, 0xF3, 0x87, 0x60, 0x7C, 0x0F, 0x01,
  0xB0, 0x36, 0x06, 0xE1, 0xCF, 0xF0, 0xF8, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x2C, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0xC0, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x06, 0x60,
  0x66, 0x06, 0x70, 0xC1, 0xF8, 0x3F, 0x86, 0x0E, 0xC0, 0x6C, 0x03, 0xC0,
  0x66, 0x0E, 0x7F, 0xC1, 0xF8, 0x1F, 0x07, 0xF9, 0xC3, 0x30, 0x34, 0x07,
  0x80, 0xD8, 0x1B, 0x87, 0x3F, 0x63, 0xCC, 0x03, 0x00, 0x60, 0x18, 0x06,
  0x01, 0x80, 0xE0, 0xEF, 0xE0, 0x00, 0x00, 0x0E, 0xFE, 0xEF, 0xE0, 0x00,
  0x00, 0x07, 0x6E, 0xCC, 0x80, 0x00, 0x40, 0x70, 0x78, 0x38, 0x38, 0x38,
  0x0C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x40, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0C, 0x07, 0x07, 0x07, 0x07, 0x03, 0x80, 0x80, 0x00,
  0x1F, 0x1F, 0xEE, 0x1F, 0x03, 0x40, 0xC0, 0x60, 0x38, 0x78, 0x18, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0x07, 0xF8, 0xC3,
  0x30, 0x36, 0x06, 0x8E, 0xD1, 0xFE, 0x63, 0xCC, 0x79, 0x8F, 0x31, 0xE6,
  0x34, 0xFE, 0x8F, 0xD8, 0x03, 0x00, 0x30, 0x07, 0xF0, 0x3E, 0x00, 0x0E,
  0x00, 0xF0, 0x0F, 0x00, 0xB0, 0x19, 0x81, 0x98, 0x19, 0x83, 0x08, 0x30,
  0xC3, 0x0C, 0x7F, 0xC7, 0xFE, 0x60, 0x6E, 0x06, 0xC0, 0x3C, 0x03, 0xFF,
  0x3F, 0xEC, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x1B, 0xFC, 0xFF, 0xB0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFB, 0xFC, 0x1F, 0x0F, 0xE6, 0x1F, 0x03,
  0xC0, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x02, 0xC0, 0xD8,
  0x73, 0xF8, 0x7C, 0xFE, 0x1F, 0xF3, 0x06, 0x60, 0x6C, 0x0D, 0x81, 0xB0,
  0x36, 0x07, 0xC0, 0xF8, 0x1B, 0x03, 0x60, 0x6C, 0x0D, 0x83, 0x3F, 0xE7,
  0xF0, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF,
  0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x0F, 0x07, 0xF9, 0xC3, 0x30, 0x36, 0x05,
  0x80, 0x30, 0x06, 0x00, 0xC3, 0xF8, 0x7F, 0x01, 0xB0, 0x36, 0x06, 0xE1,
  0xCF, 0xF8, 0xF3, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF,
  0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x7F, 0xBF, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3C, 0x1F, 0x1D, 0xFC,
  0x7C, 0xC0, 0xF8, 0x1B, 0x06, 0x61, 0x8C, 0x61, 0x9C, 0x37, 0x06, 0xE0,
  0xFE, 0x1C, 0xC3, 0x0C, 0x61, 0x8C, 0x19, 0x83, 0xB0, 0x36, 0x03, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xC0, 0xF8, 0x7E, 0x1E, 0x8F, 0xB3, 0xE4,
  0xB9, 0xEE, 0x73, 0x8C, 0xE3, 0x38, 0x8E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xD0, 0xF6, 0x3D, 0x8F, 0x33, 0xCC,
  0xF1, 0x3C, 0x6F, 0x1B, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0x1F, 0x03, 0xFC,
  0x70, 0xC6, 0x06, 0x60, 0x6C, 0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x7C, 0x06,
  0xC0, 0x66, 0x06, 0x60, 0x67, 0x0C, 0x3F, 0xC1, 0xF0, 0xFF, 0x3F, 0xEC,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xBF, 0xCC, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0x1F, 0x03, 0xFC, 0x70, 0xC6, 0x06, 0x60,
  0x6C, 0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x7C, 0x06, 0xC0, 0x66, 0x06, 0x60,
  0x67, 0x0C, 0x3F, 0xC1, 0xF0, 0x06, 0x00, 0x60, 0x07, 0xC0, 0x3C, 0xFF,
  0x1F, 0xF3, 0x03, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xFF, 0x9F,
  0xE3, 0x18, 0x61, 0x8C, 0x31, 0x83, 0x30, 0x76, 0x07, 0x1F, 0x87, 0xF9,
  0xC3, 0xB0, 0x16, 0x00, 0xC0, 0x1E, 0x01, 0xFC, 0x0F, 0xC0, 0x1C, 0x01,
  0x80, 0x1C, 0x06, 0xE1, 0xCF, 0xF0, 0xFC, 0xFF, 0xFF, 0xFF, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8,
  0x67, 0xF8, 0xFC, 0xC0, 0x3C, 0x03, 0x60, 0x66, 0x06, 0x60, 0x66, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0x81, 0x98, 0x19, 0x81, 0x98, 0x0B, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC6, 0x3C, 0x63,
  0xCF, 0x2C, 0xF2, 0xCB, 0x24, 0x92, 0x59, 0x25, 0x9E, 0x59, 0xE7, 0x1E,
  0x70, 0xE7, 0x0E, 0xC0, 0x36, 0x06, 0x70, 0xC3, 0x0C, 0x19, 0x81, 0x98,
  0x0F, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x19, 0x83, 0x98, 0x30, 0xC6, 0x06,
  0x60, 0x6C, 0x03, 0xE0, 0x1B, 0x01, 0xCC, 0x0C, 0x60, 0xC1, 0x86, 0x0E,
  0x60, 0x33, 0x00, 0xF0, 0x07, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0xFF, 0xEF, 0xFE, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xC0,
  0x10, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03, 0x00,
  0xC0, 0x10, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03,
  0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xF0, 0x06, 0x00, 0xF0, 0x1B, 0x01, 0x98,
  0x30, 0x83, 0x0C, 0x60, 0x66, 0x06, 0xC0, 0x30, 0xFF, 0xFF, 0xFC, 0xC6,
  0x23, 0x3E, 0x0F, 0xE3, 0x0E, 0x40, 0xC0, 0x18, 0xFF, 0x3F, 0xE6, 0x0C,
  0x81, 0x98, 0x73, 0xF3, 0xBE, 0x70, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x33, 0xCD, 0xFB, 0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E,
  0x1F, 0x7E, 0xCF, 0x00, 0x1E, 0x1F, 0xE6, 0x1B, 0x03, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x98, 0x77, 0xF8, 0x7C, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x3C, 0xCF, 0xDB, 0x87, 0x60, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x06, 0xC0, 0xDC, 0x39, 0xFB, 0x1E, 0x60, 0x1E, 0x1F, 0xEE, 0x1F, 0x03,
  0xFF, 0xFF, 0xF8, 0x03, 0x00, 0xC0, 0xB8, 0x77, 0xF8, 0x7C, 0x07, 0xE1,
  0xFC, 0x30, 0x06, 0x00, 0xC1, 0xFF, 0xFF, 0xF8, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0xE0,
  0x3C, 0xFC, 0x3F, 0xC6, 0x19, 0x83, 0x30, 0x67, 0x0C, 0x7F, 0x87, 0xC1,
  0x00, 0x60, 0x07, 0xF8, 0xFF, 0xB0, 0x1C, 0x03, 0xC0, 0xFF, 0xF9, 0xFE,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x33, 0xCD, 0xFB, 0x86, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x0E,
  0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xFF, 0xFF, 0xFC,
  0x03, 0x03, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFE, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x81, 0xF0, 0x66, 0x18, 0xC6, 0x19,
  0x83, 0x70, 0x7B, 0x0C, 0x31, 0x87, 0x30, 0x66, 0x06, 0xC0, 0x60, 0xFC,
  0x3F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xC0, 0xDC, 0xED, 0xDE,
  0xE6, 0x2C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63,
  0xC6, 0x3C, 0x63, 0xCF, 0x37, 0xEE, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x3E, 0x1F, 0xEE, 0x1B, 0x03, 0xC0,
  0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF8, 0x67, 0xF8, 0xF8, 0xCF, 0x37, 0xEE,
  0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x7D, 0xFB, 0x3C,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x1E, 0x67, 0xED, 0xC3, 0xB0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x60, 0x6E, 0x1C, 0xFD, 0x8F, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0xF9, 0xFF, 0x7C, 0x68, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x03, 0xFF, 0x7F, 0xE0,
  0x3F, 0x1F, 0xEE, 0x0F, 0x00, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0x00, 0xF0,
  0x3F, 0xF8, 0xFC, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x0F, 0xFF, 0xFF, 0xC3,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xF8,
  0x3F, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF8, 0xF7, 0xEC, 0xF3, 0xC0, 0x6C, 0x0D, 0x81, 0x18, 0x63, 0x0C, 0x61,
  0x06, 0x60, 0xCC, 0x19, 0x01, 0xE0, 0x3C, 0x03, 0x00, 0x86, 0x3C, 0x63,
  0xCE, 0x3C, 0xF3, 0xCB, 0x24, 0x92, 0x49, 0x25, 0x92, 0x59, 0xE7, 0x1E,
  0x70, 0xE7, 0x0C, 0x60, 0x66, 0x18, 0xC6, 0x0C, 0xC0, 0xF0, 0x0C, 0x03,
  0x80, 0x78, 0x19, 0x86, 0x39, 0xC3, 0x70, 0x30, 0xC0, 0x36, 0x06, 0x60,
  0x62, 0x0C, 0x30, 0xC3, 0x08, 0x19, 0x81, 0x98, 0x0B, 0x00, 0xF0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x07, 0x80, 0x78, 0x00, 0xFF, 0xFF,
  0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0F, 0xFF,
  0xFF, 0x0F, 0x8F, 0xC6, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x06, 0x7E,
  0x3F, 0x00, 0xC0, 0x60, 0x20, 0x30, 0x10, 0x18, 0x0C, 0x07, 0xE1, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7E, 0x01, 0x00, 0x80, 0x40, 0x60,
  0x60, 0x20, 0x18, 0x07, 0xC3, 0xE3, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x04,
  0x02, 0x3F, 0x1F, 0x80, 0x38, 0x37, 0xC2, 0x66, 0x6C, 0x3E, 0xC1, 0xC0,
};

const GFXglyph IBMPlexMono_Regular23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 16, 14, 5, -16 },
  { 9, 6, 6, 14, 4, -17 },
  { 14, 13, 16, 14, 0, -16 },
  { 40, 12, 20, 14, 1, -18 },
  { 70, 13, 16, 14, 0, -16 },
  { 96, 12, 16, 14, 1, -16 },
  { 120, 2, 6, 14, 6, -17 },
  { 122, 6, 20, 14, 5, -17 },
  { 137, 7, 20, 14, 2, -17 },
  { 155, 12, 11, 14, 1, -13 },
  { 172, 11, 12, 14, 1, -13 },
  { 189, 4, 6, 14, 5, -3 },
  { 192, 6, 2, 14, 4, -8 },
  { 194, 4, 3, 14, 5, -3 },
  { 196, 10, 20, 14, 2, -17 },
  { 221, 12, 16, 14, 1, -16 },
  { 245, 12, 16, 14, 1, -16 },
  { 269, 11, 16, 14, 1, -16 },
  { 291, 11, 16, 14, 1, -16 },
  { 313, 12, 16, 14, 1, -16 },
  { 337, 10, 16, 14, 2, -16 },
  { 357, 11, 16, 14, 1, -16 },
  { 379, 11, 16, 14, 1, -16 },
  { 401, 12, 16, 14, 1, -16 },
  { 425, 11, 16, 14, 1, -16 },
  { 447, 4, 12, 14, 5, -12 },
  { 453, 4, 15, 14, 5, -12 },
  { 461, 10, 13, 14, 2, -14 },
  { 478, 11, 6, 14, 1, -10 },
  { 487, 10, 13, 14, 2, -14 },
  { 504, 10, 16, 14, 2, -16 },
  { 524, 11, 19, 14, 1, -16 },
  { 551, 12, 16, 14, 1, -16 },
  { 575, 10, 16, 14, 2, -16 },
  { 595, 10, 16, 14, 2, -16 },
  { 615, 11, 16, 14, 2, -16 },
  { 637, 10, 16, 14, 2, -16 },
  { 657, 10, 16, 14, 2, -16 },
  { 677, 11, 16, 14, 1, -16 },
  { 699, 10, 16, 14, 2, -16 },
  { 719, 10, 16, 14, 2, -16 },
  { 739, 9, 16, 14, 2, -16 },
  { 757, 11, 16, 14, 2, -16 },
  { 779, 9, 16, 14, 3, -16 },
  { 797, 10, 16, 14, 2, -16 },
  { 817, 10, 16, 14, 2, -16 },
  { 837, 12, 16, 14, 1, -16 },
  { 861, 10, 16, 14, 2, -16 },
  { 881, 12, 20, 14, 1, -16 },
  { 911, 11, 16, 14, 2, -16 },
  { 933, 11, 16, 14, 1, -16 },
  { 955, 12, 16, 14, 1, -16 },
  { 979, 10, 16, 14, 2, -16 },
  { 999, 12, 16, 14, 1, -16 },
  { 1023, 12, 16, 14, 1, -16 },
  { 1047, 12, 16, 14, 1, -16 },
  { 1071, 13, 16, 14, 0, -16 },
  { 1097, 12, 16, 14, 1, -16 },
  { 1121, 7, 20, 14, 5, -17 },
  { 1139, 10, 20, 14, 2, -17 },
  { 1164, 7, 20, 14, 2, -17 },
  { 1182, 12, 9, 14, 1, -16 },
  { 1196, 11, 2, 14, 1, 2 },
  { 1199, 4, 4, 14, 4, -17 },
  { 1201, 11, 12, 14, 2, -12 },
  { 1218, 10, 17, 14, 2, -17 },
  { 1240, 10, 12, 14, 2, -12 },
  { 1255, 11, 17, 14, 1, -17 },
  { 1279, 10, 12, 14, 2, -12 },
  { 1294, 11, 17, 14, 2, -17 },
  { 1318, 11, 19, 14, 2, -14 },
  { 1345, 10, 17, 14, 2, -17 },
  { 1367, 11, 18, 14, 2, -18 },
  { 1392, 8, 23, 14, 2, -18 },
  { 1415, 11, 17, 14, 2, -17 },
  { 1439, 10, 17, 14, 2, -17 },
  { 1461, 12, 12, 14, 1, -12 },
  { 1479, 10, 12, 14, 2, -12 },
  { 1494, 10, 12, 14, 2, -12 },
  { 1509, 10, 17, 14, 2, -12 },
  { 1531, 11, 17, 14, 1, -12 },
  { 1555, 11, 12, 14, 2, -12 },
  { 1572, 10, 12, 14, 2, -12 },
  { 1587, 11, 16, 14, 1, -16 },
  { 1609, 10, 12, 14, 2, -12 },
  { 1624, 11, 12, 14, 1, -12 },
  { 1641, 12, 12, 14, 1, -12 },
  { 1659, 11, 12, 14, 1, -12 },
  { 1676, 12, 17, 14, 1, -12 },
  { 1702, 10, 12, 14, 2, -12 },
  { 1717, 9, 20, 14, 2, -17 },
  { 1740, 2, 20, 14, 6, -17 },
  { 1745, 9, 20, 14, 2, -17 },
  { 1768, 12, 5, 14, 1, -10 },
};

const GFXfont IBMPlexMono_Regular23pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular23pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _IBMPLEXMONO_REGULAR23PT7B_H_
