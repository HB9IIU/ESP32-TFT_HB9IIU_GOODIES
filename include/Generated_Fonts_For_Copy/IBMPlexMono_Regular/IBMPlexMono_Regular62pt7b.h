#ifndef _IBMPLEXMONO_REGULAR62PT7B_H_
#define _IBMPLEXMONO_REGULAR62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular62pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xC1,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xC7, 0xC0, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1E, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xCF, 0xFF, 0x80, 0xFF, 0xF9, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x0F, 0x01, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x7F, 0xFC, 0x07,
  0xFF, 0xCF, 0xFF, 0x80, 0xFF, 0xF9, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x0F,
  0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0x9E, 0x7F, 0xC1, 0xFC, 0x3C, 0x1F, 0xC7, 0xE0,
  0x78, 0x1F, 0xCF, 0xC0, 0xF0, 0x1F, 0x1F, 0x01, 0xE0, 0x18, 0x3E, 0x03,
  0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x0F, 0x00, 0x01, 0xF0, 0x1E,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x0F, 0xC0, 0xF0,
  0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x1F, 0xF3, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xE7, 0xFE,
  0x00, 0x03, 0xC1, 0xFC, 0x00, 0x07, 0x81, 0xF8, 0x00, 0x0F, 0x01, 0xF8,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x78, 0x07, 0xC0,
  0x00, 0xF0, 0x0F, 0x80, 0x01, 0xE0, 0x1F, 0x10, 0x03, 0xC0, 0x3E, 0x70,
  0x07, 0x80, 0x7D, 0xF0, 0x0F, 0x01, 0xFF, 0xF8, 0x1E, 0x07, 0xE7, 0xF8,
  0x3C, 0x1F, 0xC7, 0xFE, 0x79, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x7F, 0xFC,
  0x00, 0x0F, 0x1F, 0xFF, 0xC0, 0x03, 0xE3, 0xE0, 0xF8, 0x00, 0x78, 0xF8,
  0x0F, 0x80, 0x1F, 0x1E, 0x00, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x00, 0xF8,
  0xF8, 0x03, 0xE0, 0x1E, 0x1E, 0x00, 0x7C, 0x07, 0xC3, 0xC0, 0x0F, 0x80,
  0xF0, 0x78, 0x01, 0xF0, 0x3C, 0x0F, 0x00, 0x3E, 0x0F, 0x81, 0xF0, 0x07,
  0xC1, 0xE0, 0x1E, 0x00, 0xF0, 0x7C, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x7C,
  0x07, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x78, 0x00, 0xFF, 0xFE, 0x1F, 0x00,
  0x0F, 0xFF, 0x83, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xC3, 0xFF, 0xE0, 0x01, 0xF0, 0xFF, 0xFE, 0x00,
  0x3C, 0x1F, 0x07, 0xE0, 0x0F, 0x87, 0xC0, 0x7C, 0x01, 0xE0, 0xF0, 0x07,
  0x80, 0x7C, 0x1E, 0x00, 0xF8, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0xE0, 0x78,
  0x01, 0xE0, 0x78, 0x1F, 0x00, 0x3C, 0x1F, 0x03, 0xE0, 0x07, 0x83, 0xC0,
  0x3C, 0x00, 0xF0, 0xF8, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0xF0, 0x07, 0xC7,
  0xC0, 0x1E, 0x00, 0xF1, 0xF0, 0x03, 0xE0, 0x3E, 0x3C, 0x00, 0x3E, 0x0F,
  0xCF, 0x80, 0x07, 0xFF, 0xF1, 0xE0, 0x00, 0x7F, 0xFC, 0x7C, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x3F, 0xF8, 0x03, 0xFE, 0x3F, 0x7E, 0x01, 0xFF, 0x3F, 0x1F, 0x80,
  0xFF, 0x9F, 0x07, 0xC0, 0x78, 0x1F, 0x01, 0xF0, 0x3C, 0x0F, 0x80, 0xFC,
  0x1E, 0x0F, 0x80, 0x3F, 0x0F, 0x07, 0xC0, 0x0F, 0xC7, 0x03, 0xE0, 0x03,
  0xE3, 0x81, 0xF0, 0x00, 0xFB, 0xC0, 0xF8, 0x00, 0x3F, 0xE0, 0x7C, 0x00,
  0x1F, 0xF0, 0x3E, 0x00, 0x07, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x81, 0xF0, 0x00, 0x77, 0xE0, 0xFE,
  0x00, 0x71, 0xF8, 0x3F, 0xC0, 0xF8, 0x7C, 0x0F, 0xFF, 0xF8, 0x3F, 0x03,
  0xFF, 0xF8, 0x0F, 0xC0, 0xFF, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x80, 0x07, 0xC0, 0x04, 0x70, 0x07, 0xC0, 0x1E,
  0xFE, 0x07, 0xC0, 0xFE, 0xFF, 0xE7, 0xC7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0,
  0x03, 0x80, 0x03, 0x80, 0x01, 0x00, 0x01, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE3, 0xF8,
  0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8,
  0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x3F, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x01,
  0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xFB,
  0xE0, 0x3E, 0x03, 0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xFF,
  0x03, 0xF8, 0x1F, 0xFE, 0x07, 0xF0, 0x3F, 0xFC, 0x0F, 0xE0, 0x7E, 0xF8,
  0x0F, 0x80, 0xFD, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xDF, 0x00,
  0x00, 0x7F, 0x3E, 0x00, 0x01, 0xFC, 0x7C, 0x00, 0x07, 0xF0, 0xF8, 0x00,
  0x1F, 0xC1, 0xF0, 0x00, 0x7F, 0x03, 0xE0, 0x03, 0xFC, 0x07, 0xC0, 0x03,
  0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x1F, 0x00, 0x07, 0x00, 0x3E, 0x00, 0x04,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF8, 0x70, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x7E, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0xFE, 0x1E, 0x00, 0x03, 0xF0, 0x60, 0x00, 0x1F, 0x81, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC4,
  0x00, 0x00, 0x7E, 0x70, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7F, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x07, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x78,
  0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC3, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x1F,
  0xE0, 0x07, 0xC7, 0xFF, 0x80, 0x7C, 0xFF, 0xFE, 0x07, 0xDF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x87, 0xFC, 0x07, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0xFE, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF1, 0x00, 0x00,
  0x3F, 0x30, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xE7,
  0xF0, 0x01, 0xFC, 0x7F, 0xC0, 0x7F, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x07,
  0xF0, 0x01, 0xF1, 0xFF, 0xF0, 0x1F, 0x9F, 0xFF, 0xC0, 0xF9, 0xFF, 0xFF,
  0x07, 0xDF, 0xFF, 0xFC, 0x3F, 0xF0, 0x1F, 0xF3, 0xEE, 0x00, 0x3F, 0xDF,
  0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x3F, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03,
  0xFE, 0x03, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0xE0,
  0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x07,
  0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x0F,
  0xF8, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0x7C, 0xFF, 0x80, 0xFB, 0xE3, 0xFF,
  0xFF, 0xBE, 0x0F, 0xFF, 0xF9, 0xF0, 0x3F, 0xFF, 0x8F, 0x80, 0xFF, 0xF8,
  0xF8, 0x00, 0xFF, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0x1F, 0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x3F, 0xE7,
  0xFC, 0xFF, 0x9F, 0xF1, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC1, 0xF8, 0x3E, 0x07,
  0xC0, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F,
  0x80, 0xFF, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x9C, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x07, 0xE0,
  0x7C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x01, 0xE7, 0x80, 0x1F,
  0x0F, 0x3C, 0x03, 0xFE, 0x79, 0xE0, 0x3F, 0xFB, 0xFF, 0x03, 0xFF, 0xDF,
  0xF8, 0x1F, 0x83, 0xFF, 0xC1, 0xF8, 0x0F, 0xFE, 0x0F, 0x80, 0x3F, 0xF0,
  0x78, 0x01, 0xFF, 0x83, 0xC0, 0x0F, 0xFC, 0x1E, 0x00, 0x7F, 0xE1, 0xF0,
  0x03, 0xFF, 0x0F, 0x80, 0x1F, 0xF8, 0x7C, 0x00, 0xFF, 0xC3, 0xE0, 0x07,
  0xFE, 0x1F, 0x00, 0x3F, 0xF0, 0xF8, 0x01, 0xFF, 0x83, 0xC0, 0x0F, 0xFC,
  0x1E, 0x00, 0x7F, 0xE0, 0xF0, 0x03, 0xFF, 0x07, 0xC0, 0x1F, 0xF8, 0x3E,
  0x00, 0xFF, 0xC0, 0xF8, 0x0F, 0xFE, 0x07, 0xF1, 0xFF, 0xF0, 0x1F, 0xFD,
  0xF7, 0x80, 0xFF, 0xEF, 0xBC, 0x03, 0xFE, 0x7D, 0xE0, 0x03, 0x80, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x03, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7E,
  0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF8, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x83, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xF3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x07,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x01, 0xF9, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3C, 0x7C, 0x00, 0x00,
  0x87, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x02, 0x0F, 0x80, 0x00, 0x3C,
  0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x3F,
  0x80, 0x1F, 0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x1F, 0xF0, 0xF8, 0x00,
  0x7F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC,
  0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFC,
  0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x7F, 0x8F, 0x80,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFC, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3C, 0x7C, 0x00,
  0x00, 0x87, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFB, 0xE0, 0x0F, 0xFF, 0xDF, 0x00, 0x7F, 0xFE, 0xF8, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x01, 0xEF, 0xC0,
  0x00, 0x0F, 0x7E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x3E, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC,
  0x7F, 0x00, 0x1D, 0xE1, 0xFE, 0x03, 0xEF, 0x07, 0xFF, 0xFE, 0x78, 0x1F,
  0xFF, 0xE3, 0xC0, 0x7F, 0xFE, 0x1E, 0x01, 0xFF, 0xE0, 0xF0, 0x01, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xBC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xEF, 0xC0,
  0x03, 0xF3, 0xF0, 0x03, 0xF9, 0xFE, 0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFE, 0x1F, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x01, 0xF0,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0xF8, 0x3F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x07, 0xC7, 0xF8, 0x00, 0x0F, 0x9F, 0xF8, 0x00, 0x1F, 0x7F, 0xF0,
  0x00, 0x3F, 0xFB, 0xF0, 0x00, 0x7F, 0xE3, 0xF0, 0x00, 0xFF, 0xC7, 0xE0,
  0x01, 0xFF, 0x07, 0xE0, 0x03, 0xFC, 0x07, 0xC0, 0x07, 0xF0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFB, 0xC0, 0x1E, 0xFF, 0xDF, 0x00, 0xF7, 0xFE, 0x78, 0x0F, 0xBF, 0xF3,
  0xE0, 0x79, 0xFF, 0x9F, 0x07, 0xCF, 0xFC, 0x78, 0x3C, 0x7F, 0xE3, 0xE1,
  0xE3, 0xFF, 0x0F, 0x1F, 0x1F, 0xF8, 0x7C, 0xF0, 0xFF, 0xC3, 0xEF, 0x87,
  0xFE, 0x0F, 0x78, 0x3F, 0xF0, 0x7F, 0xC1, 0xFF, 0x81, 0xFE, 0x0F, 0xFC,
  0x0F, 0xE0, 0x7F, 0xE0, 0x3F, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F,
  0x80, 0xFF, 0xC0, 0x38, 0x07, 0xFE, 0x01, 0xC0, 0x3F, 0xF0, 0x06, 0x01,
  0xFF, 0x80, 0x20, 0x0F, 0xFC, 0x01, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFB, 0xE0,
  0x01, 0xFF, 0x7C, 0x00, 0x3F, 0xE7, 0xC0, 0x07, 0xFC, 0xF8, 0x00, 0xFF,
  0x9F, 0x00, 0x1F, 0xF1, 0xF0, 0x03, 0xFE, 0x3E, 0x00, 0x7F, 0xC3, 0xE0,
  0x0F, 0xF8, 0x7C, 0x01, 0xFF, 0x0F, 0x80, 0x3F, 0xE0, 0xF8, 0x07, 0xFC,
  0x1F, 0x00, 0xFF, 0x81, 0xF0, 0x1F, 0xF0, 0x3E, 0x03, 0xFE, 0x07, 0xE0,
  0x7F, 0xC0, 0x7C, 0x0F, 0xF8, 0x0F, 0x81, 0xFF, 0x00, 0xF8, 0x3F, 0xE0,
  0x1F, 0x07, 0xFC, 0x01, 0xF0, 0xFF, 0x80, 0x3E, 0x1F, 0xF0, 0x07, 0xC3,
  0xFE, 0x00, 0x7C, 0x7F, 0xC0, 0x0F, 0x8F, 0xF8, 0x00, 0xF9, 0xFF, 0x00,
  0x1F, 0x3F, 0xE0, 0x03, 0xE7, 0xFC, 0x00, 0x3E, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF0, 0x01, 0xF8,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x3E, 0x7E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E,
  0x03, 0xF0, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0x80, 0x03,
  0xFC, 0xF8, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xEF, 0x80,
  0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF0,
  0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xCF, 0x80, 0x03, 0xFC, 0xF8, 0x00, 0x0F, 0xEF, 0x80, 0x00,
  0x7E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E,
  0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F,
  0x80, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F,
  0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03,
  0xFE, 0x01, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0x1F, 0x80, 0x00, 0x7E, 0x3E,
  0x00, 0x00, 0x78, 0xFC, 0x00, 0x00, 0x61, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x40, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x1F,
  0xF8, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F,
  0xBE, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xF0,
  0x1F, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xF8,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x03,
  0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00, 0x3E, 0xF0, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0x03, 0xCF, 0x80, 0x7E, 0x01, 0xE7, 0xC0, 0x7F, 0x00, 0xF3, 0xE0,
  0x3F, 0x80, 0x79, 0xF0, 0x1F, 0xC0, 0x7C, 0xF8, 0x0F, 0xF0, 0x3E, 0x7C,
  0x07, 0xF8, 0x1F, 0x1E, 0x07, 0xBC, 0x0F, 0x8F, 0x03, 0xDE, 0x07, 0xC7,
  0x81, 0xEF, 0x03, 0xC3, 0xC0, 0xF3, 0xC1, 0xE1, 0xE0, 0xF1, 0xE0, 0xF0,
  0xF0, 0x78, 0xF0, 0x78, 0x7C, 0x3C, 0x78, 0x3C, 0x3E, 0x1E, 0x3C, 0x1E,
  0x1F, 0x0F, 0x0F, 0x0F, 0x0F, 0x8F, 0x07, 0x87, 0x87, 0xC7, 0x83, 0xC7,
  0xC3, 0xE3, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0, 0xF9, 0xF0, 0x78, 0xF0, 0x3C,
  0xF8, 0x3C, 0xF0, 0x1E, 0x7C, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x3C, 0x07,
  0x9E, 0x07, 0x9E, 0x03, 0xEF, 0x03, 0xDF, 0x00, 0xF7, 0x81, 0xEF, 0x00,
  0x7B, 0xC0, 0xFF, 0x80, 0x3D, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x01, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x30,
  0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x10, 0x3C,
  0x3E, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x40,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xF8, 0x00, 0xFC, 0x07, 0xC0,
  0x01, 0xF8, 0x06, 0x00, 0x03, 0xE0, 0x08, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F,
  0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x37,
  0xC1, 0xFE, 0x03, 0xDF, 0xF3, 0xFF, 0xFE, 0x3F, 0xC7, 0xFF, 0xF0, 0xFF,
  0x07, 0xFF, 0x80, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x3F, 0xC0, 0x3E, 0x1F, 0xFE, 0x07, 0xC7,
  0xFF, 0xE0, 0xF9, 0xFF, 0xFE, 0x1F, 0x78, 0x1F, 0xE3, 0xFC, 0x00, 0xFE,
  0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7E, 0xFE,
  0x00, 0x1F, 0x9F, 0xE0, 0x07, 0xF3, 0xEF, 0x03, 0xFC, 0x7C, 0xFF, 0xFF,
  0x0F, 0x8F, 0xFF, 0xC1, 0xF0, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x80, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x03, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0x07,
  0xC0, 0x00, 0x30, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x1F, 0xC0, 0x7F, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0xFE, 0x07, 0xC0, 0xFF, 0xF0, 0xF8, 0x3F, 0xFF, 0x9F,
  0x0F, 0xFF, 0xFB, 0xE3, 0xFC, 0x0F, 0x7C, 0xFE, 0x00, 0x7F, 0x9F, 0x80,
  0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xE7, 0xF0, 0x03, 0xFC, 0x7F, 0x81, 0xEF, 0x87, 0xFF, 0xFD, 0xF0, 0x7F,
  0xFF, 0x3E, 0x07, 0xFF, 0x87, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x81, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x7C, 0x3E,
  0x00, 0x07, 0xC1, 0xFC, 0x00, 0x7E, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x3E,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x70, 0x00, 0x0F, 0xE3, 0xC0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7F, 0x87, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x0F, 0x87, 0xFF, 0x03, 0xE3,
  0xFF, 0xF0, 0xF9, 0xFF, 0xFE, 0x3E, 0xF0, 0x3F, 0x8F, 0xF0, 0x03, 0xF3,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0x9E, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x3F, 0x07, 0x80, 0x03,
  0xF0, 0x3C, 0x00, 0x3F, 0x01, 0xE0, 0x03, 0xF0, 0x0F, 0x00, 0x3F, 0x00,
  0x78, 0x03, 0xF0, 0x03, 0xC0, 0x3F, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0xF0,
  0x3F, 0x00, 0x07, 0x87, 0xF0, 0x00, 0x3C, 0x7F, 0x00, 0x01, 0xE7, 0xFC,
  0x00, 0x0F, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFE, 0x7E, 0x00,
  0x1F, 0xE1, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x3C,
  0x00, 0xFC, 0x01, 0xE0, 0x03, 0xF0, 0x0F, 0x00, 0x1F, 0x80, 0x78, 0x00,
  0x7E, 0x03, 0xC0, 0x01, 0xF8, 0x1E, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x3F,
  0x07, 0x80, 0x00, 0xFC, 0x3C, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x0F, 0xCF,
  0x00, 0x00, 0x7E, 0x78, 0x00, 0x01, 0xFC, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x07, 0xE1, 0xF3,
  0xFE, 0x1F, 0xF3, 0xEF, 0xFC, 0x7F, 0xE7, 0xDF, 0xFD, 0xFF, 0xEF, 0xE1,
  0xFB, 0x0F, 0xDF, 0x81, 0xFC, 0x0F, 0xBE, 0x01, 0xF0, 0x0F, 0xFC, 0x03,
  0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F,
  0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF8,
  0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0,
  0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x3E, 0x01,
  0xFF, 0x80, 0x7C, 0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x0F,
  0xFC, 0x03, 0xE0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F,
  0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xFF,
  0x00, 0xF8, 0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0x1F, 0xC0, 0x3E, 0x1F, 0xFC, 0x0F, 0x8F, 0xFF,
  0xC3, 0xE7, 0xFF, 0xF8, 0xFB, 0xC0, 0xFE, 0x3F, 0xC0, 0x0F, 0xCF, 0xC0,
  0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0x0F,
  0xFF, 0x03, 0xE3, 0xFF, 0xF0, 0x7C, 0xFF, 0xFF, 0x0F, 0xBC, 0x0F, 0xF1,
  0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xF8, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xCF, 0xF0, 0x03, 0xF9, 0xF7, 0x81, 0xFE,
  0x3E, 0x7F, 0xFF, 0x87, 0xC7, 0xFF, 0xE0, 0xF8, 0x7F, 0xF8, 0x1F, 0x03,
  0xFC, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x7C, 0x1F, 0xFF,
  0xCF, 0x87, 0xFF, 0xFD, 0xF1, 0xFE, 0x07, 0xBE, 0x7F, 0x00, 0x3F, 0xCF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xF3, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0xF7, 0xC3, 0xFF, 0xFE, 0xF8,
  0x3F, 0xFF, 0x9F, 0x03, 0xFF, 0xC3, 0xE0, 0x1F, 0xE0, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0x00, 0x7C, 0xFF, 0xFC, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xDC,
  0x00, 0x00, 0x1F, 0x60, 0x00, 0x00, 0x7D, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x1F, 0xE0, 0x1F, 0xE1, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xC3,
  0xE0, 0x00, 0x08, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF1, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0x7F, 0x00, 0x07, 0xE3, 0xFE, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x07,
  0xF3, 0xF8, 0x1E, 0xF9, 0xFF, 0xFF, 0x7C, 0x7F, 0xFF, 0x3E, 0x0F, 0xFE,
  0x1F, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0x78, 0x03, 0xE0, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x78,
  0x0F, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x78, 0x3E,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xF8, 0x01, 0xF8, 0x03, 0xFE, 0x01, 0xFC,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0xF7, 0x80, 0x7F, 0x00, 0xFB, 0xC0, 0x3B,
  0x80, 0x7D, 0xE0, 0x1D, 0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0x78, 0x0F,
  0x38, 0x0F, 0x3E, 0x07, 0x9C, 0x07, 0x9F, 0x03, 0x8E, 0x03, 0xC7, 0x81,
  0xC7, 0x81, 0xE3, 0xC1, 0xE3, 0xC1, 0xE1, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0,
  0x78, 0x70, 0x78, 0x78, 0x38, 0x38, 0x3C, 0x3C, 0x1C, 0x1E, 0x1E, 0x0F,
  0x0E, 0x0F, 0x0F, 0x07, 0x8F, 0x07, 0x87, 0x83, 0xC7, 0x81, 0xC7, 0x81,
  0xE3, 0x80, 0xE3, 0xC0, 0xF1, 0xC0, 0x79, 0xE0, 0x78, 0xE0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x1E, 0x78, 0x0E, 0x78, 0x07, 0x3C, 0x07, 0xB8, 0x03, 0x9C,
  0x03, 0xDC, 0x01, 0xEE, 0x01, 0xEE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x07,
  0xF0, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF8,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x7C, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x00, 0xFC, 0x03,
  0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01,
  0xF0, 0x1F, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x0F,
  0x1F, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x18, 0x0F, 0xF8, 0x00, 0x3C, 0x3F, 0xF8, 0x00, 0x78, 0xFF,
  0xF8, 0x01, 0xE1, 0xF1, 0xF8, 0x03, 0xC7, 0xC1, 0xF0, 0x07, 0x8F, 0x01,
  0xF0, 0x1E, 0x3C, 0x01, 0xF0, 0x3C, 0x78, 0x01, 0xF0, 0xF8, 0xF0, 0x01,
  0xFF, 0xE1, 0xE0, 0x01, 0xFF, 0x87, 0x80, 0x01, 0xFE, 0x03, 0x00, 0x01,
  0xF0, 0x00,
};

const GFXglyph IBMPlexMono_Regular62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 9, 44, 37, 14, -43 },
  { 51, 15, 17, 37, 11, -46 },
  { 83, 35, 43, 37, 1, -43 },
  { 272, 31, 57, 37, 3, -50 },
  { 493, 35, 45, 37, 1, -44 },
  { 690, 33, 45, 37, 2, -44 },
  { 876, 5, 17, 37, 16, -46 },
  { 887, 18, 56, 37, 13, -47 },
  { 1013, 17, 56, 37, 7, -47 },
  { 1132, 32, 31, 37, 3, -35 },
  { 1256, 29, 30, 37, 4, -34 },
  { 1365, 11, 17, 37, 13, -8 },
  { 1389, 18, 5, 37, 10, -21 },
  { 1401, 9, 9, 37, 14, -8 },
  { 1412, 26, 56, 37, 6, -47 },
  { 1594, 31, 45, 37, 3, -44 },
  { 1769, 31, 43, 37, 3, -43 },
  { 1936, 29, 44, 37, 4, -44 },
  { 2096, 29, 45, 37, 3, -44 },
  { 2260, 33, 43, 37, 2, -43 },
  { 2438, 28, 44, 37, 5, -43 },
  { 2592, 29, 44, 37, 4, -43 },
  { 2752, 29, 43, 37, 4, -43 },
  { 2908, 31, 45, 37, 3, -44 },
  { 3083, 29, 44, 37, 4, -44 },
  { 3243, 9, 34, 37, 14, -33 },
  { 3282, 11, 42, 37, 13, -33 },
  { 3340, 27, 36, 37, 5, -37 },
  { 3462, 29, 16, 37, 4, -27 },
  { 3520, 27, 36, 37, 5, -37 },
  { 3642, 27, 45, 37, 5, -44 },
  { 3794, 29, 51, 37, 4, -44 },
  { 3979, 33, 43, 37, 2, -43 },
  { 4157, 29, 43, 37, 5, -43 },
  { 4313, 29, 45, 37, 4, -44 },
  { 4477, 28, 43, 37, 6, -43 },
  { 4628, 26, 43, 37, 6, -43 },
  { 4768, 27, 43, 37, 6, -43 },
  { 4914, 29, 45, 37, 3, -44 },
  { 5078, 27, 43, 37, 5, -43 },
  { 5224, 27, 43, 37, 5, -43 },
  { 5370, 25, 44, 37, 5, -43 },
  { 5508, 31, 43, 37, 5, -43 },
  { 5675, 26, 43, 37, 7, -43 },
  { 5815, 29, 43, 37, 4, -43 },
  { 5971, 27, 43, 37, 5, -43 },
  { 6117, 31, 45, 37, 3, -44 },
  { 6292, 28, 43, 37, 6, -43 },
  { 6443, 31, 55, 37, 3, -44 },
  { 6657, 28, 43, 37, 6, -43 },
  { 6808, 31, 45, 37, 3, -44 },
  { 6983, 34, 43, 37, 2, -43 },
  { 7166, 27, 44, 37, 5, -43 },
  { 7315, 33, 43, 37, 2, -43 },
  { 7493, 33, 43, 37, 2, -43 },
  { 7671, 34, 43, 37, 2, -43 },
  { 7854, 35, 43, 37, 1, -43 },
  { 8043, 31, 43, 37, 3, -43 },
  { 8210, 17, 56, 37, 14, -47 },
  { 8329, 26, 56, 37, 6, -47 },
  { 8511, 17, 56, 37, 6, -47 },
  { 8630, 31, 25, 37, 3, -43 },
  { 8727, 29, 5, 37, 4, 6 },
  { 8746, 9, 12, 37, 12, -48 },
  { 8760, 30, 34, 37, 4, -33 },
  { 8888, 27, 47, 37, 6, -46 },
  { 9047, 27, 34, 37, 5, -33 },
  { 9162, 27, 47, 37, 4, -46 },
  { 9321, 29, 34, 37, 4, -33 },
  { 9445, 29, 46, 37, 5, -46 },
  { 9612, 31, 49, 37, 4, -36 },
  { 9802, 26, 46, 37, 6, -46 },
  { 9952, 27, 46, 37, 7, -46 },
  { 10108, 22, 58, 37, 6, -46 },
  { 10268, 29, 46, 37, 7, -46 },
  { 10435, 27, 46, 37, 5, -46 },
  { 10591, 31, 33, 37, 3, -33 },
  { 10719, 26, 33, 37, 6, -33 },
  { 10827, 29, 34, 37, 4, -33 },
  { 10951, 27, 45, 37, 6, -33 },
  { 11103, 27, 45, 37, 4, -33 },
  { 11255, 30, 32, 37, 5, -32 },
  { 11375, 28, 34, 37, 4, -33 },
  { 11494, 31, 43, 37, 2, -43 },
  { 11661, 25, 33, 37, 6, -32 },
  { 11765, 29, 32, 37, 4, -32 },
  { 11881, 33, 32, 37, 2, -32 },
  { 12013, 29, 32, 37, 4, -32 },
  { 12129, 31, 44, 37, 3, -32 },
  { 12300, 27, 32, 37, 5, -32 },
  { 12408, 24, 56, 37, 7, -47 },
  { 12576, 5, 56, 37, 16, -47 },
  { 12611, 24, 56, 37, 7, -47 },
  { 12779, 31, 13, 37, 3, -26 },
};

const GFXfont IBMPlexMono_Regular62pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular62pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular62pt7bGlyphs,
  0x20, 0x7E, 81
};

#endif // _IBMPLEXMONO_REGULAR62PT7B_H_
