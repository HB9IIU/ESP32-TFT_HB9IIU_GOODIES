#ifndef _IBMPLEXMONO_REGULAR17PT7B_H_
#define _IBMPLEXMONO_REGULAR17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xD6, 0x0F, 0x99, 0x99, 0x90, 0x09, 0x02, 0x40, 0x90, 0x6C,
  0x73, 0xC4, 0x81, 0x23, 0xCE, 0x32, 0x0D, 0x82, 0x40, 0x90, 0x08, 0x08,
  0x3E, 0x4B, 0xC8, 0xC8, 0x48, 0x78, 0x0F, 0x09, 0x09, 0x89, 0xCB, 0x7E,
  0x08, 0x08, 0x70, 0xD2, 0x2C, 0x9B, 0x24, 0x4A, 0x1C, 0x00, 0x38, 0x53,
  0x24, 0x49, 0x14, 0x4F, 0x0E, 0x1C, 0x08, 0x82, 0x00, 0x80, 0x20, 0x04,
  0x06, 0x9D, 0x34, 0xC7, 0x30, 0xC6, 0x58, 0xF3, 0xFF, 0xC0, 0x18, 0x88,
  0xC4, 0x21, 0x18, 0x42, 0x10, 0xC2, 0x08, 0x60, 0xC3, 0x08, 0x21, 0x0C,
  0x63, 0x18, 0xC4, 0x22, 0x33, 0x00, 0x18, 0x18, 0x18, 0xFF, 0x3C, 0x1C,
  0x24, 0x62, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x76,
  0x4C, 0xF8, 0xF0, 0x06, 0x08, 0x30, 0x40, 0x83, 0x04, 0x18, 0x20, 0x41,
  0x82, 0x04, 0x10, 0x20, 0x00, 0x3C, 0x62, 0xC3, 0xC1, 0x81, 0x99, 0x99,
  0x81, 0xC1, 0xC3, 0x62, 0x3C, 0x18, 0x68, 0xC8, 0x88, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0xFF, 0x3C, 0x46, 0xC3, 0x03, 0x03, 0x02, 0x04,
  0x08, 0x10, 0x60, 0xC0, 0xFF, 0x3C, 0xC6, 0x83, 0x02, 0x06, 0x38, 0x06,
  0x03, 0x03, 0x83, 0xC6, 0x7C, 0x0E, 0x07, 0x07, 0x82, 0xC2, 0x63, 0x31,
  0x19, 0x8C, 0x86, 0x7F, 0xC1, 0x80, 0xC0, 0x7F, 0x40, 0x40, 0x40, 0x40,
  0x5E, 0x63, 0x03, 0x01, 0x83, 0xC2, 0x3C, 0x0C, 0x10, 0x20, 0x60, 0x40,
  0xFE, 0xC3, 0xC1, 0xC1, 0xC1, 0x42, 0x3C, 0xFF, 0x83, 0x83, 0x02, 0x06,
  0x04, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x30, 0x3E, 0x43, 0xC3, 0xC3, 0x42,
  0x3C, 0x43, 0xC1, 0x81, 0xC1, 0x43, 0x3C, 0x3C, 0x42, 0xC1, 0xC1, 0xC1,
  0x47, 0x3B, 0x03, 0x06, 0x04, 0x0C, 0x38, 0xF0, 0x03, 0xC0, 0x66, 0x00,
  0x00, 0x07, 0x64, 0xC0, 0x01, 0x07, 0x0C, 0x30, 0xC0, 0xE0, 0x30, 0x0C,
  0x07, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x03,
  0x0C, 0x38, 0x60, 0x80, 0x3C, 0x62, 0xC3, 0x03, 0x02, 0x1C, 0x10, 0x10,
  0x00, 0x00, 0x18, 0x18, 0x3C, 0x62, 0x41, 0xCD, 0x93, 0x91, 0x91, 0x91,
  0x91, 0x9F, 0xC0, 0x40, 0x60, 0x3E, 0x18, 0x0E, 0x0F, 0x04, 0x82, 0x41,
  0x31, 0x08, 0xFC, 0x43, 0x60, 0xA0, 0x50, 0x30, 0xFE, 0xC2, 0xC3, 0xC3,
  0xC2, 0xFC, 0xC3, 0xC1, 0xC1, 0xC1, 0xC3, 0xFE, 0x3E, 0x63, 0x41, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x41, 0x63, 0x3E, 0xF9, 0x0A, 0x1C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x0E, 0x17, 0xC0, 0xFF, 0x02, 0x04, 0x08, 0x1F,
  0xE0, 0x40, 0x81, 0x02, 0x07, 0xF0, 0xFF, 0x02, 0x04, 0x08, 0x1F, 0xE0,
  0x40, 0x81, 0x02, 0x04, 0x00, 0x3C, 0x62, 0x43, 0xC0, 0x80, 0x80, 0x8F,
  0x81, 0xC1, 0xC3, 0x65, 0x3D, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0x7E, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x87, 0x19, 0xE0, 0xC1, 0xE1, 0x31, 0x99, 0x8D, 0x86, 0xC3, 0xA1,
  0x98, 0xC6, 0x61, 0x30, 0xD8, 0x30, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x07, 0xF0, 0xC3, 0xE3, 0xA5, 0xA5, 0x9D, 0x99, 0x99,
  0x91, 0x81, 0x81, 0x81, 0x81, 0xE1, 0xE1, 0xE1, 0xF1, 0xD1, 0xD9, 0xC9,
  0xC9, 0xCD, 0xC5, 0xC7, 0xC3, 0x3C, 0x62, 0xC3, 0xC1, 0x81, 0x81, 0x81,
  0x81, 0xC1, 0xC3, 0x62, 0x3C, 0xFD, 0x0E, 0x0C, 0x18, 0x30, 0xFF, 0x40,
  0x81, 0x02, 0x04, 0x00, 0x3C, 0x62, 0xC3, 0xC1, 0x81, 0x81, 0x81, 0x81,
  0xC1, 0xC3, 0x62, 0x3C, 0x18, 0x0E, 0xFD, 0x0E, 0x0C, 0x18, 0x30, 0xFF,
  0x4C, 0x89, 0x1A, 0x14, 0x30, 0x3E, 0x43, 0xC0, 0xC0, 0xC0, 0x78, 0x06,
  0x03, 0x01, 0x81, 0xC3, 0x7E, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x43, 0x42, 0x3C, 0x81, 0xE0, 0xB0, 0xC8,
  0x64, 0x23, 0x10, 0x98, 0x48, 0x34, 0x1E, 0x07, 0x03, 0x00, 0x81, 0xC0,
  0xA0, 0x53, 0x29, 0x94, 0xCA, 0x55, 0x4A, 0xA5, 0x72, 0xB9, 0x5C, 0x60,
  0x60, 0xC8, 0x63, 0x10, 0x48, 0x1E, 0x03, 0x00, 0xC0, 0x78, 0x13, 0x0C,
  0x46, 0x1B, 0x03, 0xC0, 0xD8, 0x22, 0x18, 0xCC, 0x12, 0x07, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0x03, 0x02, 0x04, 0x0C, 0x18,
  0x10, 0x30, 0x60, 0x40, 0xC0, 0xFF, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x43, 0xE0, 0x81, 0x01, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10,
  0x30, 0x20, 0x40, 0xC0, 0x81, 0x80, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0xF0, 0x18, 0x3C, 0x24, 0x66, 0x42, 0xC3, 0x81, 0xFF, 0xC8, 0x80,
  0x3C, 0xC6, 0x02, 0x02, 0x7E, 0xC2, 0xC2, 0xC6, 0x7B, 0x81, 0x02, 0x04,
  0x0B, 0xD8, 0xA0, 0xC1, 0x83, 0x06, 0x0E, 0x2B, 0xC0, 0x3C, 0x62, 0x41,
  0xC0, 0xC0, 0xC0, 0x42, 0x63, 0x3E, 0x03, 0x03, 0x03, 0x03, 0x3B, 0x47,
  0xC3, 0x83, 0x83, 0x83, 0xC3, 0x43, 0x3F, 0x3C, 0x62, 0xC3, 0xC1, 0xFF,
  0xC0, 0xC0, 0x63, 0x3E, 0x0F, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0x03, 0x1E, 0x18, 0x88, 0x44, 0x23, 0x10,
  0xF0, 0x80, 0x40, 0x3F, 0xB0, 0x58, 0x37, 0xE0, 0x81, 0x02, 0x04, 0x0B,
  0x98, 0xA1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0x18, 0x30, 0x00, 0x0F,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0, 0x0C, 0x30, 0x00, 0xF8,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xBE, 0x80, 0x80, 0x80, 0x80,
  0x86, 0x8C, 0x98, 0xB0, 0xD0, 0x88, 0x8C, 0x86, 0x83, 0xF8, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xB7, 0xD9,
  0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0x99, 0xB9, 0x8A, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x86, 0x3C, 0x42, 0xC3, 0xC1, 0xC1, 0xC1, 0xC3, 0x42, 0x3C,
  0xBD, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xE2, 0xBD, 0x02, 0x04, 0x00, 0x3B,
  0x47, 0xC3, 0x83, 0x83, 0x83, 0xC3, 0x43, 0x3F, 0x03, 0x03, 0x03, 0xF7,
  0x8C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0xFF, 0x00, 0x3E, 0x43,
  0x40, 0x60, 0x3E, 0x03, 0x01, 0xC3, 0x3E, 0x10, 0x10, 0x10, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xE3, 0x7E, 0xC1, 0x43, 0x42, 0x62, 0x26, 0x24, 0x34, 0x18, 0x18,
  0x99, 0xCC, 0xA6, 0x52, 0xAA, 0x55, 0x2B, 0x94, 0xCA, 0x66, 0x00, 0xC3,
  0x66, 0x24, 0x1C, 0x18, 0x1C, 0x24, 0x66, 0xC3, 0xC1, 0x43, 0x42, 0x62,
  0x24, 0x34, 0x1C, 0x18, 0x18, 0x10, 0x10, 0xE0, 0x7F, 0x02, 0x04, 0x0C,
  0x18, 0x30, 0x20, 0x40, 0xFF, 0x3C, 0x82, 0x08, 0x10, 0x61, 0x38, 0x10,
  0x61, 0x08, 0x20, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x41, 0x04,
  0x20, 0x82, 0x07, 0x20, 0x82, 0x04, 0x10, 0x4F, 0x00, 0x71, 0xD1, 0x89,
  0x86,
};

const GFXglyph IBMPlexMono_Regular17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 4, 5, 10, 3, -13 },
  { 7, 10, 12, 10, 0, -12 },
  { 22, 8, 16, 10, 1, -14 },
  { 38, 10, 12, 10, 0, -12 },
  { 53, 10, 12, 10, 0, -12 },
  { 68, 2, 5, 10, 4, -13 },
  { 70, 5, 15, 10, 3, -13 },
  { 80, 5, 15, 10, 2, -13 },
  { 90, 8, 8, 10, 1, -10 },
  { 98, 8, 9, 10, 1, -10 },
  { 107, 4, 4, 10, 3, -2 },
  { 109, 5, 1, 10, 3, -6 },
  { 110, 2, 2, 10, 4, -2 },
  { 111, 7, 15, 10, 2, -13 },
  { 125, 8, 12, 10, 1, -12 },
  { 137, 8, 12, 10, 1, -12 },
  { 149, 8, 12, 10, 1, -12 },
  { 161, 8, 12, 10, 1, -12 },
  { 173, 9, 12, 10, 1, -12 },
  { 187, 8, 12, 10, 1, -12 },
  { 199, 8, 12, 10, 1, -12 },
  { 211, 8, 12, 10, 1, -12 },
  { 223, 8, 12, 10, 1, -12 },
  { 235, 8, 12, 10, 1, -12 },
  { 247, 2, 9, 10, 4, -9 },
  { 250, 4, 11, 10, 3, -9 },
  { 256, 8, 10, 10, 1, -10 },
  { 266, 8, 4, 10, 1, -7 },
  { 270, 8, 10, 10, 1, -10 },
  { 280, 8, 12, 10, 1, -12 },
  { 292, 8, 14, 10, 1, -12 },
  { 306, 9, 12, 10, 1, -12 },
  { 320, 8, 12, 10, 1, -12 },
  { 332, 8, 12, 10, 1, -12 },
  { 344, 7, 12, 10, 2, -12 },
  { 355, 7, 12, 10, 2, -12 },
  { 366, 7, 12, 10, 2, -12 },
  { 377, 8, 12, 10, 1, -12 },
  { 389, 8, 12, 10, 1, -12 },
  { 401, 8, 12, 10, 1, -12 },
  { 413, 7, 12, 10, 1, -12 },
  { 424, 9, 12, 10, 1, -12 },
  { 438, 7, 12, 10, 2, -12 },
  { 449, 8, 12, 10, 1, -12 },
  { 461, 8, 12, 10, 1, -12 },
  { 473, 8, 12, 10, 1, -12 },
  { 485, 7, 12, 10, 2, -12 },
  { 496, 8, 14, 10, 1, -12 },
  { 510, 7, 12, 10, 2, -12 },
  { 521, 8, 12, 10, 1, -12 },
  { 533, 10, 12, 10, 0, -12 },
  { 548, 8, 12, 10, 1, -12 },
  { 560, 9, 12, 10, 1, -12 },
  { 574, 9, 12, 10, 1, -12 },
  { 588, 10, 12, 10, 0, -12 },
  { 603, 10, 12, 10, 0, -12 },
  { 618, 8, 12, 10, 1, -12 },
  { 630, 5, 15, 10, 4, -13 },
  { 640, 7, 15, 10, 2, -13 },
  { 654, 4, 15, 10, 2, -13 },
  { 662, 8, 7, 10, 1, -12 },
  { 669, 8, 1, 10, 1, 2 },
  { 670, 3, 3, 10, 3, -13 },
  { 672, 8, 9, 10, 1, -9 },
  { 681, 7, 13, 10, 2, -13 },
  { 693, 8, 9, 10, 1, -9 },
  { 702, 8, 13, 10, 1, -13 },
  { 715, 8, 9, 10, 1, -9 },
  { 724, 8, 13, 10, 1, -13 },
  { 737, 9, 13, 10, 1, -10 },
  { 752, 7, 13, 10, 2, -13 },
  { 764, 7, 13, 10, 2, -13 },
  { 776, 6, 16, 10, 2, -13 },
  { 788, 8, 13, 10, 2, -13 },
  { 801, 8, 13, 10, 1, -13 },
  { 814, 8, 9, 10, 1, -9 },
  { 823, 7, 9, 10, 2, -9 },
  { 831, 8, 9, 10, 1, -9 },
  { 840, 7, 12, 10, 2, -9 },
  { 851, 8, 12, 10, 1, -9 },
  { 863, 9, 9, 10, 1, -9 },
  { 874, 8, 9, 10, 1, -9 },
  { 883, 8, 12, 10, 1, -12 },
  { 895, 7, 9, 10, 2, -9 },
  { 903, 8, 9, 10, 1, -9 },
  { 912, 9, 9, 10, 1, -9 },
  { 923, 8, 9, 10, 1, -9 },
  { 932, 8, 12, 10, 1, -9 },
  { 944, 8, 9, 10, 1, -9 },
  { 953, 6, 15, 10, 2, -13 },
  { 965, 2, 15, 10, 4, -13 },
  { 969, 6, 15, 10, 2, -13 },
  { 981, 8, 4, 10, 1, -7 },
};

const GFXfont IBMPlexMono_Regular17pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular17pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _IBMPLEXMONO_REGULAR17PT7B_H_
