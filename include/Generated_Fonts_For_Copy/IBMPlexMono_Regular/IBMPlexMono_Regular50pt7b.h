#ifndef _IBMPLEXMONO_REGULAR50PT7B_H_
#define _IBMPLEXMONO_REGULAR50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular50pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0x00, 0x1C, 0x0F,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x3F, 0xF0, 0x3F, 0xF3,
  0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x3F, 0xF3, 0xFF, 0x07, 0xFF, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFC, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0xFF,
  0xC0, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x03,
  0x81, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF3, 0x9F, 0xC3, 0xF0, 0xE1, 0xF8,
  0xF8, 0x38, 0x1E, 0x3C, 0x0E, 0x02, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0xE0,
  0x00, 0xF0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x83, 0x80, 0x03, 0xF0,
  0xE0, 0x00, 0x7F, 0x38, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0x9F,
  0xC0, 0x00, 0xE1, 0xF8, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x03,
  0x81, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x0F, 0x10, 0x0E, 0x07, 0x8E,
  0x03, 0x81, 0xEF, 0xC0, 0xE0, 0xF9, 0xF8, 0x38, 0x7E, 0x3F, 0xCE, 0x7F,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0x3F, 0xF8, 0x00, 0xE7, 0x87, 0xC0, 0x1E, 0x70, 0x1C, 0x01, 0xCF,
  0x01, 0xC0, 0x3C, 0xF0, 0x1E, 0x03, 0x8E, 0x01, 0xE0, 0x78, 0xE0, 0x1E,
  0x0F, 0x0E, 0x01, 0xE0, 0xF0, 0xE0, 0x1E, 0x1E, 0x0E, 0x01, 0xE1, 0xE0,
  0xF0, 0x1C, 0x3C, 0x07, 0x01, 0xC3, 0x80, 0x78, 0x7C, 0x78, 0x03, 0xFF,
  0x87, 0x00, 0x1F, 0xF0, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0x1F, 0xFC, 0x01,
  0xE3, 0xE1, 0xE0, 0x1C, 0x38, 0x0E, 0x03, 0xC7, 0x80, 0xF0, 0x78, 0x78,
  0x0F, 0x07, 0x87, 0x80, 0x70, 0xF0, 0x78, 0x07, 0x0F, 0x07, 0x80, 0x71,
  0xE0, 0x78, 0x07, 0x1C, 0x07, 0x80, 0xF3, 0xC0, 0x78, 0x0F, 0x38, 0x03,
  0x80, 0xE7, 0x80, 0x3E, 0x1E, 0x70, 0x01, 0xFF, 0xCF, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xF8, 0x0F,
  0x80, 0x0F, 0x00, 0x70, 0x01, 0xF0, 0x04, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xF8, 0x0F, 0xE1, 0xF7,
  0xC0, 0xFE, 0x3E, 0x7E, 0x0E, 0x03, 0xC3, 0xE0, 0xE0, 0x78, 0x1F, 0x0E,
  0x07, 0x80, 0xF8, 0xE0, 0xF8, 0x07, 0xDE, 0x0F, 0x00, 0x3F, 0xC0, 0xF0,
  0x03, 0xFC, 0x0F, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07,
  0xC0, 0x78, 0x00, 0x7E, 0x07, 0xC0, 0x0D, 0xF0, 0x3F, 0x03, 0xCF, 0x83,
  0xFF, 0xF8, 0x78, 0x1F, 0xFF, 0x07, 0xC0, 0xFF, 0xE0, 0x3E, 0x03, 0xF8,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x70, 0x1E, 0x03, 0x9F, 0x87, 0x87, 0xEF, 0xFD, 0xEF, 0xFC, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x02, 0x00, 0x10, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0x8F, 0xCF,
  0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3E, 0x00,
  0x7C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x7E,
  0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00,
  0x3E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0x81, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFD,
  0xE0, 0x00, 0xFC, 0xF0, 0x00, 0xFC, 0x78, 0x00, 0xFC, 0x3C, 0x00, 0xFC,
  0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x0C, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x3F, 0x03, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x3C,
  0xF8, 0x00, 0x3C, 0x10, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x1F, 0x81, 0xFC, 0x3E, 0x00, 0x7E, 0x3C, 0x00, 0x3E, 0x0C, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x10, 0x00, 0x1F, 0x30, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0xFC, 0x00, 0x7E,
  0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x1E,
  0x00, 0x3C, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x1E, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x0F,
  0xE0, 0x1E, 0x7F, 0xF0, 0x3D, 0xFF, 0xF0, 0x77, 0xFF, 0xF0, 0xFE, 0x07,
  0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF1, 0x00, 0x01, 0xE7, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBF,
  0x00, 0x3E, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x3F, 0x80, 0x3C,
  0xFF, 0xE0, 0x79, 0xFF, 0xF0, 0x7B, 0xFF, 0xF8, 0x7B, 0x81, 0xFC, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78,
  0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x1F, 0x81, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0x81, 0xF8, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F,
  0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0x3F, 0x00, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xF8, 0x3E, 0x00, 0x7C, 0x7C,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x3F,
  0x81, 0xDE, 0x1F, 0xFF, 0xDE, 0x0F, 0xFF, 0xBE, 0x07, 0xFF, 0x3C, 0x01,
  0xFC, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x1E, 0x1F, 0x9F, 0xEF,
  0xF7, 0xF9, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0xFC, 0x7E, 0x3E,
  0x1F, 0x0F, 0x8F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x03, 0xF1, 0xF0,
  0x03, 0xE7, 0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF0, 0x00, 0x78, 0x40, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1,
  0xF8, 0x1F, 0x83, 0xC0, 0x0F, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x78,
  0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x3E, 0x7B, 0x80, 0xFE, 0x77, 0x03,
  0xFE, 0xFE, 0x0F, 0xFD, 0xFC, 0x1F, 0x0F, 0xF8, 0x78, 0x0F, 0xF0, 0xF0,
  0x0F, 0xE1, 0xE0, 0x1F, 0xC3, 0xC0, 0x3F, 0x87, 0x80, 0x7F, 0x0F, 0x00,
  0xFE, 0x1E, 0x01, 0xFC, 0x3C, 0x03, 0xF8, 0x78, 0x07, 0xF0, 0xF0, 0x0F,
  0xE1, 0xE0, 0x3F, 0xC3, 0xE0, 0x7F, 0x83, 0xF7, 0x7F, 0x07, 0xFE, 0xEE,
  0x07, 0xF9, 0xDC, 0x07, 0xF3, 0xBC, 0x01, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0x78, 0x00, 0xF0,
  0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x07, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x3C, 0xF8, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x80,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0x80, 0x1F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80,
  0x07, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xC0, 0x07, 0xCF, 0x80, 0x07,
  0xDF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xBE, 0x00, 0x3F, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0x3E, 0x1E,
  0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x08, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x08, 0x3C, 0x00, 0x0E, 0x3E, 0x00, 0x1F, 0x1E,
  0x00, 0x1E, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0xFC, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF0, 0x0F, 0xE3, 0xC0, 0x0F,
  0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00,
  0x3E, 0xF0, 0x01, 0xF3, 0xC0, 0x0F, 0xCF, 0x00, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x3E,
  0x00, 0x1F, 0x7C, 0x00, 0x1C, 0xF0, 0x00, 0x21, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7,
  0x80, 0x01, 0xEF, 0x80, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x80, 0x3F, 0x1F,
  0x81, 0xDE, 0x3F, 0xFF, 0xBC, 0x3F, 0xFE, 0x78, 0x3F, 0xF8, 0xF0, 0x0F,
  0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF7,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x03, 0xE7, 0xE0, 0x7E,
  0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x8F, 0x00,
  0x0F, 0x87, 0x80, 0x0F, 0x83, 0xC0, 0x0F, 0x81, 0xE0, 0x0F, 0x80, 0xF0,
  0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x0F,
  0x07, 0xC0, 0x07, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE3, 0xF0, 0x00,
  0xF3, 0xF8, 0x00, 0x7B, 0xFE, 0x00, 0x3F, 0xEF, 0x80, 0x1F, 0xE7, 0xC0,
  0x0F, 0xE1, 0xF0, 0x07, 0xE0, 0x78, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x1E, 0x00,
  0x3E, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xF1, 0xE0,
  0x00, 0x7C, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xF7, 0x00, 0xEF, 0xF7, 0x81, 0xEF, 0xF3, 0x81, 0xCF, 0xF3,
  0xC1, 0xCF, 0xF3, 0xC3, 0xCF, 0xF1, 0xC3, 0x8F, 0xF1, 0xE7, 0x8F, 0xF0,
  0xE7, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0,
  0x7E, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x18, 0x0F, 0xF0,
  0x18, 0x0F, 0xF0, 0x18, 0x0F, 0xF0, 0x10, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x78, 0x03,
  0xFD, 0xE0, 0x0F, 0xF7, 0x80, 0x3F, 0xCF, 0x00, 0xFF, 0x3C, 0x03, 0xFC,
  0x78, 0x0F, 0xF1, 0xE0, 0x3F, 0xC7, 0x80, 0xFF, 0x0F, 0x03, 0xFC, 0x3C,
  0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x0F, 0x0F,
  0xF0, 0x3C, 0x3F, 0xC0, 0x78, 0xFF, 0x01, 0xE3, 0xFC, 0x07, 0x8F, 0xF0,
  0x0F, 0x3F, 0xC0, 0x3C, 0xFF, 0x00, 0x7B, 0xFC, 0x01, 0xEF, 0xF0, 0x07,
  0xBF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3E, 0x00, 0xFC,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0x80, 0x0F, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x7C,
  0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F,
  0x81, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFC, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xCF, 0x80, 0x0F, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x7E,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x0F,
  0x81, 0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xF8,
  0x07, 0x81, 0xF0, 0x0F, 0x83, 0xE0, 0x0F, 0x07, 0xC0, 0x0F, 0x0F, 0x80,
  0x1F, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFC, 0x07, 0xF1, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF1, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3C, 0xFC, 0x00, 0x3E, 0x3F,
  0x80, 0x7E, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0x78,
  0x00, 0x79, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x8F, 0xC0, 0xFC, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x7C, 0x00,
  0x07, 0x9F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3E,
  0x00, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x78,
  0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x0F, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x3C,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x07, 0xC0, 0xF7,
  0x03, 0xF0, 0x39, 0xC0, 0xFC, 0x0E, 0x70, 0x3F, 0x03, 0x9C, 0x0F, 0xC0,
  0xE7, 0x83, 0xF8, 0x39, 0xE1, 0xEE, 0x1E, 0x78, 0x73, 0x87, 0x9E, 0x1C,
  0xE1, 0xE7, 0x87, 0x38, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0xE1, 0xC7, 0x9E,
  0x38, 0x71, 0xE3, 0x8E, 0x1C, 0x70, 0xE3, 0x87, 0x1C, 0x39, 0xE1, 0xE7,
  0x0E, 0x70, 0x39, 0xC3, 0x9C, 0x0E, 0x70, 0xE7, 0x03, 0x9C, 0x3D, 0xC0,
  0xF7, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0x7C, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x03,
  0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0x78,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x7C, 0x3C, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1E, 0x7C, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x03, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x3E, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x07,
  0x81, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x20, 0x00, 0x02, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x10, 0x78, 0xF8, 0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x06, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xF0,
  0x3F, 0x03, 0xE0, 0x0F, 0x80, 0xE0, 0x03, 0xE0, 0x20, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7E, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x0F,
  0x0F, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC1, 0xF8, 0x1D, 0xFE, 0xFF, 0xFE,
  0x7F, 0x3F, 0xFE, 0x3F, 0x8F, 0xFE, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x1F, 0x80, 0xF1, 0xFF, 0x83, 0xCF,
  0xFF, 0x0F, 0x7F, 0xFE, 0x3F, 0x81, 0xFC, 0xF8, 0x01, 0xF3, 0xE0, 0x03,
  0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x00, 0x07,
  0xBE, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xF8, 0x1F, 0xCF, 0x7F, 0xFE, 0x3C,
  0xFF, 0xF0, 0xF1, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x81, 0xF0, 0xF8, 0x03,
  0xE3, 0xC0, 0x07, 0x9E, 0x00, 0x0C, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x02,
  0x1E, 0x00, 0x0C, 0x7C, 0x00, 0x3C, 0xF8, 0x01, 0xE1, 0xF8, 0x1F, 0x87,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0x07, 0xFE, 0x3C, 0x3F,
  0xFC, 0xF1, 0xFF, 0xFB, 0xCF, 0xE0, 0x7F, 0x7E, 0x00, 0x7D, 0xF0, 0x01,
  0xF7, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0x80, 0x03,
  0xDF, 0x00, 0x1F, 0x7E, 0x00, 0x7C, 0xFE, 0x07, 0xF1, 0xFF, 0xFB, 0xC3,
  0xFF, 0xCF, 0x07, 0xFE, 0x3C, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3E,
  0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x18, 0x3E,
  0x00, 0x3C, 0x1F, 0x80, 0xFE, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x0F, 0xE6, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0x00, 0x3C, 0x0F,
  0x00, 0x1F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x0F, 0xC0, 0xFC,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF8, 0x70, 0x00, 0x7E, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF7, 0xE0, 0x03, 0xF3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x07, 0xE0, 0xF1, 0xFF, 0x8F, 0x3F, 0xFC,
  0xF7, 0xFF, 0xEF, 0x60, 0x7E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x01,
  0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x0F, 0x80, 0xF0, 0x1F,
  0x00, 0xF0, 0x7E, 0x00, 0xF0, 0xFC, 0x00, 0xF1, 0xF0, 0x00, 0xF3, 0xF0,
  0x00, 0xF7, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0x7C, 0x00, 0xFE, 0x3E,
  0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x07,
  0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE3, 0xE0, 0x7C, 0xE7, 0xF1, 0xFE, 0xE7, 0xF9,
  0xFE, 0xEF, 0xFB, 0xFF, 0xE8, 0x7A, 0x1F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C,
  0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C,
  0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C,
  0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C,
  0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xF0, 0x7E,
  0x0F, 0x1F, 0xF8, 0xF3, 0xFF, 0xCF, 0x7F, 0xFE, 0xF6, 0x07, 0xEF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0x81, 0xF8,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0xF0, 0x7E, 0x03, 0xC7, 0xFE, 0x0F, 0x3F, 0xFC, 0x3D, 0xFF, 0xF8, 0xFE,
  0x07, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0xBC, 0x00, 0x1E, 0xF0, 0x00,
  0x7B, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF8, 0x00, 0xFB, 0xE0, 0x07,
  0xCF, 0xE0, 0x7F, 0x3D, 0xFF, 0xF8, 0xF3, 0xFF, 0xC3, 0xC7, 0xFE, 0x0F,
  0x07, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF8, 0x3C, 0x1F, 0xF8, 0xF0, 0xFF, 0xF3, 0xC7,
  0xFF, 0xEF, 0x3F, 0x81, 0xFD, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xDE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x7C, 0x00,
  0x7D, 0xF8, 0x01, 0xF3, 0xF8, 0x1F, 0xC7, 0xFF, 0xEF, 0x0F, 0xFF, 0x3C,
  0x1F, 0xF8, 0xF0, 0x1F, 0x83, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xE7, 0xFF, 0x01, 0xE7, 0x00, 0x01, 0xEC, 0x00,
  0x01, 0xE8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1,
  0xF0, 0x0F, 0xE7, 0xC0, 0x07, 0x8F, 0x00, 0x04, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x79, 0x00, 0x00, 0xF3, 0x00, 0x01,
  0xEF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0x7E, 0x07,
  0xF7, 0xFF, 0xEF, 0x3F, 0xFC, 0xF1, 0xFF, 0x8F, 0x07, 0xF0, 0x00, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0x78, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x00, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xC0, 0x03,
  0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0x80, 0x01, 0xE7, 0x80, 0x00,
  0xE7, 0x80, 0x00, 0xF7, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x0F, 0x00, 0xF7, 0x00, 0xF8, 0x0E,
  0x70, 0x1F, 0x80, 0xE7, 0x81, 0xF8, 0x0E, 0x78, 0x1F, 0x81, 0xE7, 0x81,
  0xF8, 0x1E, 0x78, 0x19, 0xC1, 0xE3, 0x83, 0x9C, 0x1C, 0x38, 0x39, 0xC1,
  0xC3, 0x83, 0x9C, 0x1C, 0x38, 0x39, 0xC1, 0xC3, 0xC3, 0x0E, 0x3C, 0x3C,
  0x70, 0xE3, 0xC1, 0xC7, 0x0E, 0x38, 0x1C, 0x70, 0xE3, 0x81, 0xC7, 0x0E,
  0x38, 0x1C, 0x60, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1E, 0xE0, 0x73, 0x81,
  0xEE, 0x07, 0x78, 0x0E, 0xE0, 0x77, 0x00, 0xEE, 0x07, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x78,
  0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xE0, 0x03, 0xC3, 0xC0,
  0x01, 0xE7, 0x80, 0x01, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0x81, 0xE0,
  0x0F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x78,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0,
  0x03, 0xC1, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE7, 0x80,
  0x01, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0x80, 0x06, 0x1F, 0xE0, 0x07, 0x3F, 0xF0, 0x07,
  0x3F, 0xF8, 0x0F, 0x78, 0xFC, 0x0F, 0x70, 0x7E, 0x1E, 0xF0, 0x3F, 0x1E,
  0xF0, 0x1F, 0xFC, 0xE0, 0x0F, 0xFC, 0xE0, 0x07, 0xF8, 0x60, 0x01, 0xE0,
};

const GFXglyph IBMPlexMono_Regular50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 8, 35, 30, 11, -35 },
  { 36, 12, 14, 30, 9, -37 },
  { 57, 28, 35, 30, 1, -35 },
  { 180, 26, 46, 30, 2, -40 },
  { 330, 28, 37, 30, 1, -36 },
  { 460, 28, 37, 30, 1, -36 },
  { 590, 4, 14, 30, 13, -37 },
  { 597, 15, 45, 30, 10, -38 },
  { 682, 15, 45, 30, 5, -38 },
  { 767, 26, 25, 30, 2, -28 },
  { 849, 24, 24, 30, 3, -27 },
  { 921, 9, 14, 30, 10, -7 },
  { 937, 14, 4, 30, 8, -17 },
  { 944, 8, 7, 30, 11, -7 },
  { 951, 22, 45, 30, 4, -38 },
  { 1075, 24, 37, 30, 3, -36 },
  { 1186, 25, 35, 30, 3, -35 },
  { 1296, 24, 36, 30, 3, -36 },
  { 1404, 24, 37, 30, 2, -36 },
  { 1515, 26, 35, 30, 2, -35 },
  { 1629, 23, 36, 30, 4, -35 },
  { 1733, 24, 36, 30, 3, -35 },
  { 1841, 24, 35, 30, 3, -35 },
  { 1946, 24, 37, 30, 3, -36 },
  { 2057, 24, 36, 30, 3, -36 },
  { 2165, 8, 27, 30, 11, -27 },
  { 2192, 9, 34, 30, 10, -27 },
  { 2231, 22, 29, 30, 4, -30 },
  { 2311, 24, 14, 30, 3, -22 },
  { 2353, 22, 29, 30, 4, -30 },
  { 2433, 22, 36, 30, 4, -36 },
  { 2532, 23, 42, 30, 3, -36 },
  { 2653, 27, 35, 30, 2, -35 },
  { 2772, 23, 35, 30, 4, -35 },
  { 2873, 24, 37, 30, 3, -36 },
  { 2984, 22, 35, 30, 5, -35 },
  { 3081, 22, 35, 30, 4, -35 },
  { 3178, 23, 35, 30, 4, -35 },
  { 3279, 23, 37, 30, 3, -36 },
  { 3386, 22, 35, 30, 4, -35 },
  { 3483, 22, 35, 30, 4, -35 },
  { 3580, 20, 36, 30, 4, -35 },
  { 3670, 25, 35, 30, 4, -35 },
  { 3780, 21, 35, 30, 6, -35 },
  { 3872, 24, 35, 30, 3, -35 },
  { 3977, 22, 35, 30, 4, -35 },
  { 4074, 24, 37, 30, 3, -36 },
  { 4185, 23, 35, 30, 4, -35 },
  { 4286, 24, 44, 30, 3, -36 },
  { 4418, 23, 35, 30, 4, -35 },
  { 4519, 25, 37, 30, 2, -36 },
  { 4635, 28, 35, 30, 1, -35 },
  { 4758, 22, 36, 30, 4, -35 },
  { 4857, 26, 35, 30, 2, -35 },
  { 4971, 26, 35, 30, 2, -35 },
  { 5085, 28, 35, 30, 1, -35 },
  { 5208, 28, 35, 30, 1, -35 },
  { 5331, 26, 35, 30, 2, -35 },
  { 5445, 14, 45, 30, 11, -38 },
  { 5524, 22, 45, 30, 4, -38 },
  { 5648, 14, 45, 30, 5, -38 },
  { 5727, 26, 21, 30, 2, -35 },
  { 5796, 24, 4, 30, 3, 5 },
  { 5808, 8, 10, 30, 9, -39 },
  { 5818, 25, 27, 30, 3, -26 },
  { 5903, 22, 38, 30, 5, -37 },
  { 6008, 22, 27, 30, 4, -26 },
  { 6083, 22, 38, 30, 3, -37 },
  { 6188, 24, 27, 30, 3, -26 },
  { 6269, 23, 37, 30, 4, -37 },
  { 6376, 25, 41, 30, 3, -30 },
  { 6505, 20, 37, 30, 5, -37 },
  { 6598, 22, 38, 30, 5, -38 },
  { 6703, 18, 48, 30, 5, -38 },
  { 6811, 24, 37, 30, 5, -37 },
  { 6922, 22, 37, 30, 4, -37 },
  { 7024, 24, 26, 30, 3, -26 },
  { 7102, 20, 26, 30, 5, -26 },
  { 7167, 24, 27, 30, 3, -26 },
  { 7248, 22, 36, 30, 5, -26 },
  { 7347, 22, 36, 30, 3, -26 },
  { 7446, 24, 26, 30, 4, -26 },
  { 7524, 23, 27, 30, 3, -26 },
  { 7602, 24, 35, 30, 2, -35 },
  { 7707, 20, 27, 30, 5, -26 },
  { 7775, 24, 26, 30, 3, -26 },
  { 7853, 28, 26, 30, 1, -26 },
  { 7944, 24, 26, 30, 3, -26 },
  { 8022, 24, 36, 30, 3, -26 },
  { 8130, 22, 26, 30, 4, -26 },
  { 8202, 20, 45, 30, 5, -38 },
  { 8315, 4, 45, 30, 13, -38 },
  { 8338, 20, 45, 30, 5, -38 },
  { 8451, 24, 11, 30, 3, -21 },
};

const GFXfont IBMPlexMono_Regular50pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular50pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular50pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _IBMPLEXMONO_REGULAR50PT7B_H_
