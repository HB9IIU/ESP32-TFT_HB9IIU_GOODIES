#ifndef _IBMPLEXMONO_REGULAR34PT7B_H_
#define _IBMPLEXMONO_REGULAR34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular34pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x18, 0xC6, 0x30, 0x84, 0x00,
  0x01, 0xEF, 0xFF, 0xFE, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0x80, 0x01, 0x87, 0x00, 0x30, 0xC0, 0x0E, 0x18, 0x01, 0xC3,
  0x00, 0x38, 0xE0, 0x06, 0x1C, 0x00, 0xC3, 0x80, 0x18, 0x60, 0x7F, 0x0F,
  0xEF, 0xE1, 0xFC, 0x1C, 0x70, 0x03, 0x0E, 0x00, 0x61, 0x80, 0x0C, 0x30,
  0x3F, 0x87, 0xF7, 0xF1, 0xFE, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x30, 0xC0,
  0x0E, 0x18, 0x01, 0xC3, 0x00, 0x38, 0xE0, 0x06, 0x1C, 0x00, 0xC3, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xFF, 0x01, 0xFF, 0xE1, 0xE6,
  0xF9, 0xC3, 0x1E, 0xE1, 0x84, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0E,
  0x18, 0x07, 0x8C, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0xDF,
  0x00, 0x63, 0x80, 0x30, 0xE0, 0x18, 0x70, 0x0C, 0x38, 0x06, 0x1D, 0x83,
  0x0D, 0xE1, 0x8E, 0x78, 0xDE, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0xEF, 0xE0, 0x1B, 0x8E, 0x06, 0x60,
  0xC1, 0xCC, 0x1C, 0x31, 0x83, 0x8E, 0x30, 0x71, 0x86, 0x0E, 0x70, 0xC1,
  0x8C, 0x1C, 0x73, 0x81, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0x01, 0xDC, 0x70, 0x73, 0x06, 0x0C, 0x60, 0xE3, 0x8C, 0x1C, 0x61,
  0x83, 0x98, 0x30, 0x77, 0x06, 0x0C, 0xC0, 0xE3, 0xB8, 0x0F, 0xE6, 0x00,
  0xF8, 0x03, 0xE0, 0x03, 0xFE, 0x01, 0xC3, 0x80, 0xE0, 0x70, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x7C, 0x1F, 0x3B, 0x87, 0xDC, 0x61, 0x86, 0x1C, 0x63, 0x83,
  0x98, 0xE0, 0x76, 0x38, 0x0F, 0x8E, 0x01, 0xC3, 0x80, 0x78, 0xF0, 0x17,
  0x1E, 0x19, 0xC3, 0xFE, 0x38, 0x3E, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xC1,
  0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x3C, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01,
  0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x38, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x83, 0x83, 0x83, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x10,
  0x30, 0x27, 0x8C, 0x7F, 0xFF, 0xFF, 0x0F, 0xFE, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0E, 0xE0, 0x07, 0x38, 0x03, 0x87, 0x00, 0xE0, 0xE0, 0x70, 0x38,
  0x08, 0x04, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3D,
  0xF7, 0x9E, 0x71, 0xC7, 0x38, 0xE3, 0x00, 0xFF, 0xFF, 0xF0, 0xF7, 0xFF,
  0xFF, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x0F,
  0xFC, 0x0F, 0x0F, 0x07, 0x01, 0xC7, 0x00, 0xE3, 0x00, 0x3B, 0x80, 0x1D,
  0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x01, 0xB8, 0x70, 0xDC, 0x78, 0x6E, 0x3C,
  0x3F, 0x0E, 0x1B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0x9C,
  0x01, 0xCE, 0x01, 0xC3, 0x80, 0xE1, 0xE1, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x07, 0xB8, 0x07, 0x9C, 0x07, 0x8E, 0x07, 0x87,
  0x03, 0x83, 0x80, 0x81, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF,
  0xFE, 0xFF, 0xFF, 0x07, 0xE0, 0x1F, 0xF8, 0x78, 0x3C, 0x70, 0x1E, 0xE0,
  0x0E, 0x60, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0xF8, 0x78, 0x3C, 0x70, 0x1E, 0x20,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x40, 0x0E, 0xE0, 0x0E, 0xF8, 0x3C, 0x3F,
  0xF8, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xB8,
  0x00, 0xCE, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x03,
  0x83, 0x80, 0xE0, 0xE0, 0x70, 0x38, 0x18, 0x0E, 0x0E, 0x03, 0x87, 0x00,
  0xE1, 0xC0, 0x38, 0xE0, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x3F, 0xFE, 0x3F,
  0xFE, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x73, 0xF0, 0x77, 0xFC, 0x7C, 0x3E, 0x70, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x20,
  0x07, 0xF0, 0x0E, 0x78, 0x1C, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0xF0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x73, 0xF0, 0x77, 0xFC, 0x6C, 0x1E, 0xF0, 0x0E, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x70,
  0x07, 0x30, 0x0E, 0x3C, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0x07, 0x8E, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x39, 0x80, 0x1C,
  0xE0, 0x0E, 0x70, 0x06, 0x18, 0x07, 0x0F, 0x07, 0x01, 0xFF, 0x00, 0xFF,
  0x81, 0xC0, 0xF1, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x03, 0x70, 0x01, 0xF8,
  0x00, 0xDC, 0x00, 0xE7, 0x00, 0x73, 0xC0, 0xF0, 0xFF, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x1F, 0xF8, 0x3C, 0x1C, 0x70, 0x0E, 0x70, 0x06, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x0F,
  0x3C, 0x1F, 0x1F, 0xF7, 0x0F, 0xC6, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0x80,
  0x79, 0xF7, 0xDF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF7, 0xDE,
  0x79, 0xC7, 0x1C, 0xE3, 0x8C, 0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8,
  0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x03,
  0x00, 0x04, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0x83, 0xBC, 0x07, 0xE0,
  0x1D, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x1F, 0x81,
  0xF8, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xC0, 0x07, 0xE0,
  0x1F, 0xF8, 0x1C, 0x1C, 0x38, 0x0E, 0x70, 0x06, 0x60, 0x07, 0x60, 0x07,
  0x60, 0xF7, 0xE1, 0xFF, 0xE3, 0x8F, 0xE3, 0x07, 0xE3, 0x07, 0xE7, 0x07,
  0xE7, 0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE3, 0x07, 0xE3, 0x87,
  0xE3, 0xFF, 0x61, 0xF7, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xB0, 0x00, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0x60,
  0x07, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x38, 0x0C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0x70, 0x7F, 0xFC, 0x3F, 0xFF, 0x0E, 0x01, 0xC3, 0x80,
  0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xFF, 0xE1, 0xFF, 0xF3, 0x80, 0xE7, 0x00, 0xEE, 0x01, 0xDC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xE7, 0xFF, 0x8F, 0xFF,
  0x9C, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xBF, 0xFE, 0x7F, 0xF8, 0x03, 0xF0, 0x0F,
  0xFC, 0x1E, 0x1E, 0x38, 0x0F, 0x38, 0x07, 0x70, 0x02, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x02, 0x38,
  0x07, 0x38, 0x0F, 0x1E, 0x1E, 0x0F, 0xFC, 0x03, 0xF0, 0xFF, 0xC0, 0xFF,
  0xF0, 0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x78, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xEF, 0xFF, 0xDC, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0xFF, 0xEF, 0xFF, 0xDC, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3C, 0x1E, 0x38, 0x0E, 0x70,
  0x07, 0x70, 0x04, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x38, 0x0F, 0x3C, 0x3F, 0x1F,
  0xF7, 0x07, 0xC7, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xF9, 0xFF,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x39, 0xFF, 0x83, 0xF0,
  0xE0, 0x07, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x07, 0x8E, 0x07, 0x87, 0x07,
  0x83, 0x83, 0x81, 0xC3, 0x80, 0xE3, 0x80, 0x73, 0xC0, 0x3B, 0xC0, 0x1D,
  0xF0, 0x0F, 0xFC, 0x07, 0xCE, 0x03, 0xC3, 0x81, 0xC1, 0xC0, 0xE0, 0x70,
  0x70, 0x3C, 0x38, 0x0E, 0x1C, 0x03, 0x8E, 0x01, 0xE7, 0x00, 0x73, 0x80,
  0x3D, 0xC0, 0x0F, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0xEC, 0x3F, 0xEC, 0x37, 0xEE,
  0x37, 0xE6, 0x77, 0xE7, 0x67, 0xE3, 0x67, 0xE3, 0xC7, 0xE3, 0xC7, 0xE1,
  0xC7, 0xE1, 0x87, 0xE0, 0x87, 0xE1, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7D, 0xC0, 0xFB, 0x81, 0xF3, 0x03, 0xE7, 0x07,
  0xCE, 0x0F, 0x8E, 0x1F, 0x1C, 0x3E, 0x18, 0x7C, 0x38, 0xF8, 0x71, 0xF0,
  0x73, 0xE0, 0xE7, 0xC0, 0xCF, 0x81, 0xDF, 0x03, 0xBE, 0x03, 0xFC, 0x07,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0x0F,
  0x07, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0,
  0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x7F, 0x00, 0x3B,
  0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0x9C, 0x01, 0xCE, 0x01,
  0xC3, 0x80, 0xE1, 0xE1, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0xFF, 0xF1, 0xFF,
  0xF3, 0x80, 0x77, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x77, 0xFF, 0xEF, 0xFF, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0x0F,
  0x07, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0,
  0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x7F, 0x00, 0x3B,
  0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0x9C, 0x01, 0xCE, 0x01,
  0xC3, 0x80, 0xE1, 0xE1, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8,
  0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xFF, 0xF8, 0xFF, 0xE0, 0xE1, 0xC0,
  0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x38,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0F, 0x07, 0xF0, 0x1F, 0xFC,
  0x3C, 0x1F, 0x70, 0x07, 0x70, 0x02, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x07, 0xC0, 0x07,
  0xF0, 0x0F, 0x78, 0x1E, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1B, 0x80, 0x37, 0x00, 0xE7, 0x01, 0xCF, 0x07, 0x0F, 0xFC,
  0x07, 0xF0, 0xE0, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x19, 0xC0, 0x0E, 0x38,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x1C, 0x07, 0x07, 0x01,
  0x81, 0xC0, 0xE0, 0x30, 0x38, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0xE1, 0xC0,
  0x1C, 0x70, 0x07, 0x18, 0x01, 0xCE, 0x00, 0x33, 0x80, 0x0E, 0xC0, 0x03,
  0xB0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x76, 0x0E, 0x1D,
  0x87, 0x87, 0x61, 0xE1, 0xD8, 0x7C, 0x66, 0x1B, 0x19, 0xCE, 0xC6, 0x73,
  0x31, 0x9C, 0xCC, 0x67, 0x33, 0x99, 0xCC, 0x66, 0x77, 0x19, 0x8D, 0x86,
  0xE3, 0x61, 0xB8, 0xD8, 0x7E, 0x36, 0x0F, 0x8F, 0x83, 0xE3, 0xC0, 0xF0,
  0xF0, 0x3C, 0xF0, 0x01, 0xCE, 0x00, 0x70, 0xE0, 0x0E, 0x1E, 0x03, 0x81,
  0xC0, 0xF0, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0x38, 0xE0, 0x03, 0xB8, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0xEE, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x01, 0xC3, 0xC0, 0x70, 0x38, 0x0E,
  0x03, 0x83, 0x80, 0x70, 0xF0, 0x07, 0x1C, 0x00, 0xF7, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x39, 0xC0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x70, 0x38,
  0x0E, 0x07, 0x03, 0x80, 0x70, 0x70, 0x0E, 0x1C, 0x00, 0xE3, 0x80, 0x1C,
  0xE0, 0x01, 0xD8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0x7F, 0xFF,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xE0, 0x01,
  0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xCE, 0x00, 0xE7, 0x00, 0x61, 0xC0, 0x70, 0xE0, 0x30,
  0x38, 0x38, 0x0C, 0x38, 0x07, 0x1C, 0x01, 0xDC, 0x00, 0xEC, 0x00, 0x3A,
  0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0x21, 0x8F, 0x0C, 0x38, 0x60, 0xC0,
  0x0F, 0xE0, 0x1F, 0xF8, 0x1E, 0x0E, 0x0C, 0x03, 0x82, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x18, 0x0F, 0xFC, 0x1F, 0xFE, 0x1E, 0x03, 0x1C,
  0x01, 0x8E, 0x00, 0xC7, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0xD8, 0x3F, 0xEF,
  0x8F, 0xC3, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x71, 0xF0, 0xEF, 0xF9, 0xF0, 0x7B, 0xC0, 0x77,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xBE, 0x0F, 0x77, 0xFC,
  0xE3, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0xE0, 0xF3, 0x80, 0xE6, 0x00, 0x9C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x0C, 0x01, 0x1C, 0x03, 0x9C, 0x1E, 0x1F, 0xF8, 0x0F, 0xC0,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x87, 0xE7, 0x1F, 0xEE, 0x78, 0x7D, 0xC0, 0x3B, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x77, 0x00, 0xEE, 0x01, 0xCF, 0x0F, 0x8F, 0xF7, 0x0F, 0xCE, 0x03,
  0xE0, 0x0F, 0xF8, 0x3C, 0x3C, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0x60,
  0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x04, 0x38, 0x0F, 0x3C, 0x1E, 0x0F, 0xFC, 0x03, 0xF0, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC1, 0xFA, 0x03,
  0xFF, 0x03, 0xC3, 0xC1, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E,
  0x38, 0x07, 0x0E, 0x03, 0x07, 0x87, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0xC2, 0x00, 0xF6,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0x70, 0x07, 0x1F, 0xFF,
  0x03, 0xFE, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0xF8, 0xEF, 0xF3, 0xE0, 0xEF, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0C, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0xFF, 0xEF, 0xFC, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x1E, 0xC0, 0x38, 0xC0, 0x70, 0xC0, 0xE0, 0xC1, 0xC0, 0xC7, 0x80,
  0xCF, 0x00, 0xDF, 0x00, 0xFF, 0x00, 0xF3, 0x80, 0xE1, 0xC0, 0xC1, 0xE0,
  0xC0, 0xE0, 0xC0, 0x70, 0xC0, 0x38, 0xC0, 0x3C, 0xC0, 0x1C, 0xC0, 0x0F,
  0xFF, 0x81, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0xCF,
  0x1E, 0x6F, 0xDF, 0xB8, 0xF1, 0xDC, 0x38, 0x6C, 0x18, 0x3E, 0x0C, 0x1F,
  0x06, 0x0F, 0x83, 0x07, 0xC1, 0x83, 0xE0, 0xC1, 0xF0, 0x60, 0xF8, 0x30,
  0x7C, 0x18, 0x3E, 0x0C, 0x1F, 0x06, 0x0F, 0x83, 0x07, 0xC1, 0x83, 0xE0,
  0xC1, 0xC0, 0xE3, 0xE3, 0xBF, 0xCF, 0x83, 0xBC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x30, 0x07, 0xE0,
  0x1F, 0xF8, 0x3C, 0x1C, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07,
  0x70, 0x06, 0x30, 0x0E, 0x3C, 0x1C, 0x1F, 0xF8, 0x07, 0xE0, 0xE3, 0xE1,
  0xDF, 0xF3, 0xE0, 0xF7, 0x80, 0xEE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xFC, 0x07, 0x7C, 0x1E, 0xEF, 0xF9, 0xC7, 0xC3, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x0F, 0xCE, 0x3F,
  0xDC, 0xF0, 0xFB, 0x80, 0x77, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xEE, 0x01, 0xDC,
  0x03, 0x9E, 0x1F, 0x1F, 0xEE, 0x1F, 0x9C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0xFE, 0x1F, 0xFE, 0x7F,
  0x06, 0xC0, 0x06, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xFC,
  0x3C, 0x1E, 0x70, 0x06, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x07, 0x40, 0x07,
  0xF0, 0x06, 0x78, 0x1E, 0x1F, 0xFC, 0x07, 0xF0, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77,
  0x01, 0xDE, 0x1F, 0x3F, 0xDC, 0x3E, 0x70, 0xE0, 0x07, 0x60, 0x07, 0x70,
  0x06, 0x70, 0x0E, 0x30, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x18, 0x1C, 0x1C,
  0x18, 0x1C, 0x38, 0x0C, 0x38, 0x0E, 0x30, 0x06, 0x70, 0x06, 0x70, 0x07,
  0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0xE0, 0xF8, 0x78, 0x3E,
  0x1E, 0x0D, 0x87, 0x83, 0x61, 0xB1, 0xD8, 0x6C, 0x76, 0x13, 0x19, 0x8C,
  0xC6, 0x73, 0x31, 0x9C, 0xC6, 0x63, 0x31, 0x98, 0xC8, 0x66, 0x36, 0x1B,
  0x8D, 0x86, 0xC3, 0x60, 0xB0, 0xD8, 0x3C, 0x3E, 0x0F, 0x07, 0x03, 0xC0,
  0xF0, 0x07, 0x78, 0x0E, 0x38, 0x1C, 0x1C, 0x1C, 0x1E, 0x38, 0x0E, 0x70,
  0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0x70,
  0x0E, 0x70, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x1E, 0x70, 0x0E, 0xF0, 0x07,
  0xE0, 0x03, 0xF0, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC3, 0x00, 0xE1, 0xC0,
  0x60, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x18, 0x06, 0x1C, 0x03, 0x8C, 0x01,
  0xCE, 0x00, 0x67, 0x00, 0x3B, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0xC3, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x03, 0xC3, 0xF8, 0x1F, 0xC0, 0x07, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0xFC, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFE, 0x07, 0xF8, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x1F, 0xE0, 0xFF, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x7F, 0x83, 0xF8, 0x00, 0x1E, 0x03, 0x9F, 0x81, 0x9C, 0xE0,
  0xCC, 0x38, 0x6C, 0x0E, 0x66, 0x03, 0xF3, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_Regular34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 5, 24, 20, 8, -24 },
  { 16, 9, 9, 20, 6, -25 },
  { 27, 19, 24, 20, 1, -24 },
  { 84, 17, 30, 20, 2, -27 },
  { 148, 19, 24, 20, 1, -24 },
  { 205, 18, 24, 20, 1, -24 },
  { 259, 2, 9, 20, 9, -25 },
  { 262, 10, 31, 20, 7, -26 },
  { 301, 9, 31, 20, 4, -26 },
  { 336, 18, 17, 20, 1, -19 },
  { 375, 16, 16, 20, 2, -18 },
  { 407, 6, 10, 20, 7, -5 },
  { 415, 10, 2, 20, 5, -11 },
  { 418, 5, 5, 20, 8, -5 },
  { 422, 14, 31, 20, 3, -26 },
  { 477, 17, 24, 20, 2, -24 },
  { 528, 17, 24, 20, 2, -24 },
  { 579, 16, 24, 20, 2, -24 },
  { 627, 16, 24, 20, 2, -24 },
  { 675, 18, 24, 20, 1, -24 },
  { 729, 16, 24, 20, 2, -24 },
  { 777, 16, 24, 20, 2, -24 },
  { 825, 16, 24, 20, 2, -24 },
  { 873, 17, 24, 20, 2, -24 },
  { 924, 16, 24, 20, 2, -24 },
  { 972, 5, 18, 20, 8, -18 },
  { 984, 6, 23, 20, 7, -18 },
  { 1002, 15, 20, 20, 3, -20 },
  { 1040, 16, 9, 20, 2, -15 },
  { 1058, 15, 20, 20, 3, -20 },
  { 1096, 14, 24, 20, 3, -24 },
  { 1138, 16, 28, 20, 2, -24 },
  { 1194, 18, 24, 20, 1, -24 },
  { 1248, 15, 24, 20, 3, -24 },
  { 1293, 16, 24, 20, 2, -24 },
  { 1341, 16, 24, 20, 3, -24 },
  { 1389, 15, 24, 20, 3, -24 },
  { 1434, 15, 24, 20, 3, -24 },
  { 1479, 16, 24, 20, 2, -24 },
  { 1527, 15, 24, 20, 3, -24 },
  { 1572, 15, 24, 20, 3, -24 },
  { 1617, 13, 24, 20, 3, -24 },
  { 1656, 17, 24, 20, 3, -24 },
  { 1707, 14, 24, 20, 4, -24 },
  { 1749, 16, 24, 20, 2, -24 },
  { 1797, 15, 24, 20, 3, -24 },
  { 1842, 17, 24, 20, 2, -24 },
  { 1893, 15, 24, 20, 3, -24 },
  { 1938, 17, 29, 20, 2, -24 },
  { 2000, 16, 24, 20, 3, -24 },
  { 2048, 16, 24, 20, 2, -24 },
  { 2096, 19, 24, 20, 1, -24 },
  { 2153, 15, 24, 20, 3, -24 },
  { 2198, 18, 24, 20, 1, -24 },
  { 2252, 18, 24, 20, 1, -24 },
  { 2306, 19, 24, 20, 1, -24 },
  { 2363, 19, 24, 20, 1, -24 },
  { 2420, 17, 24, 20, 2, -24 },
  { 2471, 9, 31, 20, 8, -26 },
  { 2506, 14, 31, 20, 3, -26 },
  { 2561, 10, 31, 20, 3, -26 },
  { 2600, 17, 14, 20, 2, -24 },
  { 2630, 16, 2, 20, 2, 3 },
  { 2634, 6, 7, 20, 6, -27 },
  { 2640, 17, 18, 20, 2, -18 },
  { 2679, 15, 25, 20, 3, -25 },
  { 2726, 15, 18, 20, 3, -18 },
  { 2760, 15, 25, 20, 2, -25 },
  { 2807, 16, 18, 20, 2, -18 },
  { 2843, 17, 25, 20, 2, -25 },
  { 2897, 17, 27, 20, 2, -20 },
  { 2955, 14, 25, 20, 3, -25 },
  { 2999, 15, 25, 20, 4, -25 },
  { 3046, 12, 32, 20, 3, -25 },
  { 3094, 16, 25, 20, 4, -25 },
  { 3144, 15, 25, 20, 3, -25 },
  { 3191, 17, 18, 20, 2, -18 },
  { 3230, 14, 18, 20, 3, -18 },
  { 3262, 16, 18, 20, 2, -18 },
  { 3298, 15, 25, 20, 3, -18 },
  { 3345, 15, 25, 20, 2, -18 },
  { 3392, 16, 18, 20, 3, -18 },
  { 3428, 16, 18, 20, 2, -18 },
  { 3464, 17, 24, 20, 1, -24 },
  { 3515, 14, 18, 20, 3, -18 },
  { 3547, 16, 18, 20, 2, -18 },
  { 3583, 18, 18, 20, 1, -18 },
  { 3624, 16, 18, 20, 2, -18 },
  { 3660, 17, 25, 20, 2, -18 },
  { 3714, 15, 18, 20, 3, -18 },
  { 3748, 13, 31, 20, 4, -26 },
  { 3799, 2, 31, 20, 9, -26 },
  { 3807, 13, 31, 20, 4, -26 },
  { 3858, 17, 7, 20, 2, -14 },
};

const GFXfont IBMPlexMono_Regular34pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular34pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular34pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _IBMPLEXMONO_REGULAR34PT7B_H_
