#ifndef _IBMPLEXMONO_REGULAR65PT7B_H_
#define _IBMPLEXMONO_REGULAR65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular65pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF9, 0xF0, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0,
  0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFC, 0xFF, 0xFC, 0x03, 0xFF, 0xE7, 0xFF, 0xE0, 0x3F, 0xFF, 0x3F, 0xFF,
  0x01, 0xFF, 0xF9, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xC0, 0x7C, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1F, 0x01, 0xF0,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xCF, 0xFF, 0xC0, 0x7F, 0xFE, 0x7F, 0xFE,
  0x03, 0xFF, 0xF3, 0xFF, 0xE0, 0x1F, 0xFF, 0x9F, 0xFF, 0x01, 0xFF, 0xFC,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0x9E, 0x7F, 0xE0, 0xFE, 0x0F, 0x07, 0xF8, 0x7E,
  0x07, 0x80, 0xFE, 0x7E, 0x03, 0xC0, 0x3E, 0x3F, 0x01, 0xE0, 0x0C, 0x1F,
  0x00, 0xF0, 0x04, 0x0F, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00,
  0x7E, 0x03, 0xC0, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x0F, 0xF0, 0xF0, 0x00,
  0x03, 0xFE, 0x78, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xF3, 0xFF, 0x00, 0x00, 0x78,
  0x3F, 0xC0, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x1E, 0x03, 0xF0, 0x00, 0x0F,
  0x00, 0xFC, 0x00, 0x07, 0x80, 0x7E, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x01,
  0xE0, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xC4, 0x00, 0x78, 0x07, 0xE3, 0x00,
  0x3C, 0x03, 0xF3, 0xC0, 0x1E, 0x01, 0xF3, 0xF0, 0x0F, 0x01, 0xFB, 0xFC,
  0x07, 0x81, 0xFC, 0x7F, 0x83, 0xC1, 0xFC, 0x1F, 0xF9, 0xE7, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xC7, 0xFF,
  0xE0, 0x00, 0x7C, 0x7F, 0xFF, 0x00, 0x03, 0xE3, 0xF0, 0xFC, 0x00, 0x3E,
  0x3E, 0x01, 0xF0, 0x01, 0xE1, 0xE0, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0xF8, 0x01, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x80, 0x78, 0x3E,
  0x00, 0x7C, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x0F, 0x00,
  0x3C, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x1F, 0x0F, 0x80,
  0x0F, 0xC3, 0xF0, 0x7C, 0x00, 0x7F, 0xFF, 0x87, 0xC0, 0x01, 0xFF, 0xF8,
  0x3C, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0x83, 0xFF, 0xF0, 0x00, 0x7C, 0x3F, 0xFF, 0xC0, 0x07,
  0xC1, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xC0, 0x1F, 0x07, 0x80, 0x1E, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0x0F, 0x83,
  0xE0, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0xF8, 0x01, 0xF0,
  0x7C, 0x07, 0xC0, 0x0F, 0x83, 0xC0, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF0,
  0x03, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0xF0,
  0x01, 0xF0, 0x0F, 0x8F, 0x80, 0x07, 0xE1, 0xF8, 0xF8, 0x00, 0x3F, 0xFF,
  0xC7, 0xC0, 0x00, 0xFF, 0xFC, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xF8, 0x03, 0xFE,
  0x1F, 0xFF, 0x80, 0x7F, 0xC3, 0xF3, 0xF8, 0x0F, 0xF8, 0xFC, 0x3F, 0x81,
  0xF0, 0x3F, 0x03, 0xF0, 0x3C, 0x07, 0xC0, 0x3F, 0x07, 0x81, 0xF8, 0x03,
  0xF0, 0xF0, 0x3E, 0x00, 0x7F, 0x1E, 0x07, 0xC0, 0x07, 0xF3, 0xC0, 0xF8,
  0x00, 0x7E, 0x78, 0x1F, 0x00, 0x07, 0xFE, 0x03, 0xE0, 0x00, 0x7F, 0xC0,
  0x7C, 0x00, 0x07, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x01, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0x00,
  0x1E, 0xFC, 0x07, 0xF8, 0x0F, 0x8F, 0xC0, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F,
  0xFF, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x0F,
  0xC0, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x18, 0x00,
  0xF8, 0x00, 0xCF, 0x80, 0x7C, 0x03, 0xEF, 0xF8, 0x3E, 0x0F, 0xFF, 0xFF,
  0x9F, 0x3F, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x00, 0x01, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x3E, 0x01,
  0xFF, 0x80, 0xFE, 0x03, 0xFF, 0x01, 0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x0F,
  0xFC, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x3F, 0xF0, 0x1F, 0xC0, 0x7F,
  0xE0, 0x1F, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0x0F,
  0xE3, 0xE0, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x0F,
  0xE0, 0x7C, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x0F,
  0xC0, 0x0F, 0x80, 0x01, 0xC0, 0x07, 0xC0, 0x00, 0x40, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFC, 0x07, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x7E,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE1, 0xE0,
  0x00, 0x0F, 0xC0, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x00,
  0x01, 0xF8, 0x1C, 0x00, 0x01, 0xF8, 0x10, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF1, 0x80,
  0x00, 0x07, 0xC7, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3F, 0x7F, 0x00,
  0x00, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x3F, 0xC0, 0x03, 0xC3, 0xFF, 0xE0, 0x0F, 0x1F,
  0xFF, 0xC0, 0x3C, 0xFF, 0xFF, 0xC1, 0xF7, 0xFF, 0xFF, 0x07, 0xFC, 0x03,
  0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x7E, 0x00, 0x07, 0xF0, 0x70, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x84, 0x00,
  0x00, 0x7E, 0x38, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x3F, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x0F,
  0xF0, 0x00, 0xF8, 0x7F, 0xFC, 0x01, 0xF1, 0xFF, 0xFE, 0x07, 0xE7, 0xFF,
  0xFE, 0x0F, 0x9F, 0xFF, 0xFE, 0x1F, 0x7C, 0x07, 0xFC, 0x3F, 0xC0, 0x01,
  0xFC, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7E, 0x7F, 0x80, 0x03,
  0xFC, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xBE, 0x1F, 0xFF,
  0xFE, 0x7C, 0x1F, 0xFF, 0xF9, 0xF8, 0x1F, 0xFF, 0xE3, 0xE0, 0x0F, 0xFF,
  0x87, 0xC0, 0x03, 0xFC, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0x80, 0x0F, 0x83, 0xFE, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3,
  0xFE, 0x3F, 0xE3, 0xFE, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1,
  0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFE, 0x03, 0xFC, 0x3F, 0x80,
  0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x3F, 0x08, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFC, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0,
  0x03, 0xE1, 0xF7, 0xC0, 0x3F, 0xE7, 0xDE, 0x01, 0xFF, 0xDF, 0x78, 0x0F,
  0xFF, 0xBF, 0xE0, 0x3F, 0x06, 0xFF, 0x81, 0xF8, 0x0F, 0xFE, 0x07, 0xC0,
  0x1F, 0xF8, 0x1E, 0x00, 0x7F, 0xE0, 0xF8, 0x01, 0xFF, 0x83, 0xE0, 0x03,
  0xFE, 0x0F, 0x80, 0x0F, 0xF8, 0x3E, 0x00, 0x3F, 0xE0, 0xF8, 0x00, 0xFF,
  0x83, 0xE0, 0x03, 0xFE, 0x0F, 0x80, 0x0F, 0xF8, 0x3E, 0x00, 0x3F, 0xE0,
  0xF8, 0x00, 0xFF, 0x83, 0xE0, 0x03, 0xFE, 0x0F, 0x80, 0x0F, 0xF8, 0x3E,
  0x00, 0x7F, 0xE0, 0x78, 0x01, 0xFF, 0x81, 0xF0, 0x07, 0xDE, 0x07, 0xE0,
  0x3F, 0x78, 0x0F, 0xE3, 0xBD, 0xE0, 0x3F, 0xFE, 0xF7, 0xC0, 0x7F, 0xF3,
  0xDF, 0x00, 0xFF, 0x8F, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0x7C,
  0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFC, 0x7C, 0x00, 0x1F, 0xE3, 0xE0, 0x00, 0x3F, 0x9F,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF8, 0xF8, 0x00, 0x1F, 0xE7, 0xC0, 0x00, 0x3F, 0xBE, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0xDF, 0x00, 0x03, 0xFC, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xE0, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFE,
  0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0x18, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x18, 0x7E, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFE,
  0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x7F,
  0xC3, 0xF0, 0x00, 0xFF, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFF,
  0x1F, 0x80, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0,
  0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x18,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0x1F, 0xC0, 0x07,
  0x7C, 0x3F, 0xC0, 0x7D, 0xF0, 0xFF, 0xFF, 0xE7, 0xC1, 0xFF, 0xFF, 0x1F,
  0x03, 0xFF, 0xFC, 0x7C, 0x03, 0xFF, 0xC1, 0xF0, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x01, 0xF9, 0xFC,
  0x00, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00,
  0x00, 0xFE, 0xF8, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x03, 0xF8, 0xF8, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xE0, 0xF8, 0x00,
  0x1F, 0xC0, 0xF8, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x7F, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x03,
  0xF8, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0xF8, 0x0F, 0xE0, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x7F,
  0x00, 0x00, 0xF8, 0xFF, 0x00, 0x00, 0xF8, 0xFF, 0x00, 0x00, 0xF9, 0xFF,
  0x80, 0x00, 0xFB, 0xFF, 0x80, 0x00, 0xFF, 0xEF, 0xC0, 0x00, 0xFF, 0xCF,
  0xE0, 0x00, 0xFF, 0x87, 0xE0, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0xC0, 0xF8, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFB, 0xE0, 0x0F, 0xBF, 0xF7, 0xC0, 0x1F, 0x7F, 0xE7, 0xC0, 0x7C,
  0xFF, 0xCF, 0x80, 0xF9, 0xFF, 0x8F, 0x81, 0xE3, 0xFF, 0x1F, 0x07, 0xC7,
  0xFE, 0x1E, 0x0F, 0x0F, 0xFC, 0x3E, 0x3E, 0x1F, 0xF8, 0x7C, 0x7C, 0x3F,
  0xF0, 0x7C, 0xF0, 0x7F, 0xE0, 0xFB, 0xE0, 0xFF, 0xC0, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0x07, 0xFE, 0x03, 0xF8, 0x0F, 0xFC,
  0x07, 0xF0, 0x1F, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7F, 0xE0,
  0x0E, 0x00, 0xFF, 0xC0, 0x1C, 0x01, 0xFF, 0x80, 0x38, 0x03, 0xFF, 0x00,
  0x20, 0x07, 0xFE, 0x00, 0x40, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xE0, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0x7C, 0x00, 0x1F, 0xFB, 0xE0, 0x00, 0xFF, 0xCF, 0x80,
  0x07, 0xFE, 0x7C, 0x00, 0x3F, 0xF3, 0xF0, 0x01, 0xFF, 0x8F, 0x80, 0x0F,
  0xFC, 0x7C, 0x00, 0x7F, 0xE1, 0xF0, 0x03, 0xFF, 0x0F, 0x80, 0x1F, 0xF8,
  0x7E, 0x00, 0xFF, 0xC1, 0xF0, 0x07, 0xFE, 0x0F, 0xC0, 0x3F, 0xF0, 0x3E,
  0x01, 0xFF, 0x81, 0xF0, 0x0F, 0xFC, 0x0F, 0xC0, 0x7F, 0xE0, 0x3E, 0x03,
  0xFF, 0x01, 0xF8, 0x1F, 0xF8, 0x07, 0xC0, 0xFF, 0xC0, 0x3E, 0x07, 0xFE,
  0x01, 0xF8, 0x3F, 0xF0, 0x07, 0xC1, 0xFF, 0x80, 0x3F, 0x0F, 0xFC, 0x00,
  0xF8, 0x7F, 0xE0, 0x07, 0xC3, 0xFF, 0x00, 0x1F, 0x1F, 0xF8, 0x00, 0xF8,
  0xFF, 0xC0, 0x07, 0xE7, 0xFE, 0x00, 0x1F, 0x3F, 0xF0, 0x00, 0xF9, 0xFF,
  0x80, 0x03, 0xEF, 0xFC, 0x00, 0x1F, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x0F, 0xFB, 0xE0, 0x00,
  0x1F, 0xDF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x0F,
  0xEF, 0x80, 0x00, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3,
  0xE0, 0x00, 0x7F, 0xCF, 0x80, 0x00, 0x7F, 0x3E, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x0F, 0xE3,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8,
  0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80,
  0x00, 0x7F, 0x3F, 0x00, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0x18, 0x3E, 0x00,
  0x00, 0x10, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x10, 0x00, 0x00, 0x1F, 0x18, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0xC0,
  0x01, 0xFC, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0xE0, 0x3F, 0xE0,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xBC, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0x07, 0x9F, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0x3E,
  0x00, 0x00, 0x03, 0xE7, 0xC0, 0x3F, 0x80, 0x7C, 0xF8, 0x07, 0xF0, 0x0F,
  0x9F, 0x00, 0xFE, 0x01, 0xF1, 0xE0, 0x1F, 0xC0, 0x3C, 0x3C, 0x03, 0xFC,
  0x07, 0x87, 0x80, 0xFF, 0x80, 0xF0, 0xF0, 0x1E, 0xF0, 0x1E, 0x1F, 0x03,
  0xDE, 0x03, 0xC3, 0xE0, 0x7B, 0xC0, 0xF8, 0x7C, 0x1F, 0x7C, 0x1F, 0x0F,
  0x83, 0xC7, 0x83, 0xE1, 0xF0, 0x78, 0xF0, 0x7C, 0x3E, 0x0F, 0x1E, 0x0F,
  0x87, 0xC1, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x0F, 0x07,
  0x87, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1E, 0x1E, 0x07, 0x8F,
  0x83, 0xE3, 0xC0, 0xF1, 0xF0, 0x7C, 0x78, 0x1F, 0x3C, 0x07, 0x8F, 0x03,
  0xE7, 0x80, 0xF1, 0xE0, 0x7C, 0xF0, 0x1F, 0x7C, 0x0F, 0xBE, 0x03, 0xEF,
  0x81, 0xF7, 0x80, 0x3D, 0xF0, 0x3E, 0xF0, 0x07, 0xBE, 0x07, 0xDE, 0x00,
  0xF7, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0x80,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x0F, 0x9C, 0x00, 0x00, 0x07, 0x04, 0x00, 0x00,
  0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x08, 0x06,
  0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C,
  0x0F, 0x01, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F,
  0xC0, 0x7F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x1C,
  0x00, 0x07, 0xE0, 0x08, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x03, 0xE0, 0x7E,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x7B, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0x0F,
  0xFF, 0xE0, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x3F, 0xC0, 0x1F, 0x07, 0xFF, 0x80, 0xF8, 0x7F, 0xFF,
  0x07, 0xC7, 0xFF, 0xFC, 0x3E, 0x7F, 0xFF, 0xF1, 0xF7, 0x80, 0xFF, 0x8F,
  0xB0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x3E, 0xC0, 0x03, 0xF9, 0xF7,
  0x80, 0xFF, 0x8F, 0x9F, 0xFF, 0xFC, 0x7C, 0x7F, 0xFF, 0xC3, 0xE1, 0xFF,
  0xFC, 0x1F, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0E, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x81, 0xF0, 0x00, 0x07, 0x0F, 0xC0, 0x00, 0x7C, 0x3F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x01, 0xFE, 0x03, 0xE0, 0x3F,
  0xFC, 0x1F, 0x07, 0xFF, 0xF0, 0xF8, 0x7F, 0xFF, 0xC7, 0xC7, 0xFF, 0xFF,
  0x3E, 0x3F, 0xC0, 0x3D, 0xF3, 0xF8, 0x00, 0x6F, 0x9F, 0x80, 0x01, 0xFD,
  0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F,
  0xCF, 0xE0, 0x01, 0xBE, 0x3F, 0xE0, 0x3D, 0xF1, 0xFF, 0xFF, 0xCF, 0x87,
  0xFF, 0xFC, 0x7C, 0x1F, 0xFF, 0xC3, 0xE0, 0x3F, 0xFC, 0x1F, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0x03,
  0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x80, 0xFC, 0x00, 0x01, 0xC0, 0xFC,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x81, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x1F, 0xF3, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x1F, 0x00, 0x00, 0x7F, 0x3C, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x7F, 0x7F, 0x80, 0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x03, 0xF8, 0x07, 0xE1, 0xFF, 0xE0, 0xFC, 0x7F, 0xFE, 0x1F,
  0x9F, 0xFF, 0xE3, 0xF7, 0xFF, 0xFE, 0x7F, 0xF0, 0x3F, 0xCF, 0xF0, 0x01,
  0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0xBE, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x7E, 0x0F, 0x80, 0x07, 0xF0, 0x3E, 0x00, 0x3F, 0x80, 0xF8, 0x01, 0xFC,
  0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0x80, 0x7F, 0x00, 0x3E, 0x03, 0xF8, 0x00,
  0xF8, 0x1F, 0xC0, 0x03, 0xE0, 0xFE, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0x3E,
  0x3F, 0x80, 0x00, 0xF9, 0xFF, 0x00, 0x03, 0xEF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xF3, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xFC,
  0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x3F, 0x83, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x3E,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x03, 0xF1, 0xE3, 0xFC, 0x1F, 0xF3, 0xCF, 0xFC, 0x7F, 0xF7,
  0x9F, 0xF9, 0xFF, 0xEF, 0x7F, 0xFB, 0xFF, 0xFE, 0xC3, 0xFE, 0x0F, 0xFE,
  0x03, 0xF8, 0x0F, 0xFC, 0x03, 0xE0, 0x1F, 0xF0, 0x07, 0xC0, 0x3F, 0xE0,
  0x0F, 0x80, 0x3F, 0xC0, 0x1F, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0xFF, 0x00,
  0x7C, 0x01, 0xFE, 0x00, 0xF8, 0x03, 0xFC, 0x01, 0xF0, 0x07, 0xF8, 0x03,
  0xE0, 0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0x1F,
  0x00, 0x7F, 0x80, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0xF8,
  0x03, 0xFC, 0x01, 0xF0, 0x07, 0xF8, 0x03, 0xE0, 0x0F, 0xF0, 0x07, 0xC0,
  0x1F, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0x1F, 0x00, 0x7F, 0x80, 0x3E, 0x00,
  0xFF, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0xF8, 0x03, 0xFC, 0x01, 0xF0, 0x07,
  0xF8, 0x03, 0xE0, 0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x3C,
  0xFC, 0x0F, 0xE0, 0x1F, 0x87, 0xFF, 0x83, 0xF1, 0xFF, 0xF8, 0x7E, 0x7F,
  0xFF, 0x8F, 0xDF, 0xFF, 0xF9, 0xFF, 0xC0, 0xFF, 0x3F, 0xC0, 0x07, 0xF7,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80,
  0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x81, 0xFC, 0x00, 0x7F, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xF8,
  0x0F, 0xF0, 0x07, 0xC1, 0xFF, 0xE0, 0x3E, 0x1F, 0xFF, 0xC1, 0xF1, 0xFF,
  0xFF, 0x0F, 0x9F, 0xFF, 0xFC, 0x7D, 0xE0, 0x3F, 0xE3, 0xEC, 0x00, 0x3F,
  0x9F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x0F, 0xCF, 0xB0, 0x00, 0xFE, 0x7D, 0xE0, 0x3F, 0xE3,
  0xE7, 0xFF, 0xFF, 0x1F, 0x1F, 0xFF, 0xF0, 0xF8, 0x7F, 0xFF, 0x07, 0xC1,
  0xFF, 0xE0, 0x3E, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0xF8, 0x0F, 0xFF, 0x07, 0xC1, 0xFF, 0xFC,
  0x3E, 0x1F, 0xFF, 0xF1, 0xF1, 0xFF, 0xFF, 0xCF, 0x8F, 0xF0, 0x0F, 0x7C,
  0xFE, 0x00, 0x1B, 0xE7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x6F, 0x8F,
  0xF8, 0x0F, 0x7C, 0x7F, 0xFF, 0xF3, 0xE1, 0xFF, 0xFF, 0x1F, 0x07, 0xFF,
  0xF0, 0xF8, 0x0F, 0xFF, 0x07, 0xC0, 0x1F, 0xE0, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xE0, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0xB8, 0x00, 0x00, 0x1F, 0x60, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7F, 0x80, 0x3F, 0xE1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x18, 0x3F,
  0x00, 0x00, 0x40, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x40, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xF9, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF7, 0xF0,
  0x01, 0xFE, 0x7F, 0x81, 0xFF, 0xCF, 0xFF, 0xFD, 0xF8, 0xFF, 0xFF, 0x3F,
  0x0F, 0xFF, 0xC7, 0xE0, 0xFF, 0xF0, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xF8,
  0x01, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFC, 0x01, 0xF7, 0x80, 0x3F, 0x80, 0x3C, 0xF0, 0x07, 0x78,
  0x07, 0x9E, 0x01, 0xEF, 0x00, 0xF3, 0xE0, 0x3D, 0xE0, 0x1E, 0x7C, 0x07,
  0xBC, 0x07, 0xCF, 0x80, 0xF3, 0x80, 0xF8, 0xF0, 0x1C, 0x70, 0x1E, 0x1E,
  0x07, 0x8F, 0x03, 0xC3, 0xC0, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x3C, 0x0F,
  0x0F, 0x03, 0xC3, 0x81, 0xE1, 0xF0, 0x70, 0x70, 0x7C, 0x3E, 0x1E, 0x0F,
  0x0F, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x3C, 0x3C, 0x0F, 0x0F,
  0x07, 0x87, 0x81, 0xE1, 0xC0, 0x70, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x07,
  0xCF, 0x01, 0xE3, 0xC0, 0xF9, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x07, 0x9E,
  0x01, 0xE7, 0x00, 0x73, 0xC0, 0x3D, 0xE0, 0x0F, 0x78, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x03,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7C, 0x3F,
  0x00, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x06, 0x01, 0xFE,
  0x00, 0x07, 0xC1, 0xFF, 0x80, 0x03, 0xC1, 0xFF, 0xE0, 0x01, 0xE1, 0xFF,
  0xF8, 0x00, 0xF0, 0xF8, 0xFE, 0x00, 0xF8, 0xF8, 0x1F, 0x80, 0x78, 0x7C,
  0x0F, 0xE0, 0x7C, 0x3C, 0x03, 0xF0, 0x3E, 0x3E, 0x00, 0xFE, 0x3E, 0x1E,
  0x00, 0x3F, 0xFF, 0x0F, 0x00, 0x0F, 0xFF, 0x07, 0x80, 0x03, 0xFF, 0x07,
  0xC0, 0x00, 0xFF, 0x00, 0xC0, 0x00, 0x1F, 0x00,
};

const GFXglyph IBMPlexMono_Regular65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 9, 46, 39, 15, -45 },
  { 53, 17, 18, 39, 11, -48 },
  { 92, 37, 45, 39, 1, -45 },
  { 301, 33, 61, 39, 3, -53 },
  { 553, 37, 47, 39, 1, -46 },
  { 771, 35, 47, 39, 2, -46 },
  { 977, 5, 18, 39, 17, -48 },
  { 989, 19, 58, 39, 13, -49 },
  { 1127, 19, 58, 39, 7, -49 },
  { 1265, 33, 32, 39, 3, -37 },
  { 1397, 31, 33, 39, 4, -36 },
  { 1525, 12, 18, 39, 13, -9 },
  { 1552, 19, 5, 39, 10, -22 },
  { 1564, 9, 9, 39, 15, -8 },
  { 1575, 27, 58, 39, 6, -49 },
  { 1771, 31, 47, 39, 4, -46 },
  { 1954, 33, 45, 39, 3, -45 },
  { 2140, 31, 46, 39, 4, -46 },
  { 2319, 31, 47, 39, 3, -46 },
  { 2502, 35, 45, 39, 2, -45 },
  { 2699, 30, 46, 39, 5, -45 },
  { 2872, 31, 46, 39, 4, -45 },
  { 3051, 31, 45, 39, 4, -45 },
  { 3226, 31, 47, 39, 4, -46 },
  { 3409, 31, 46, 39, 4, -46 },
  { 3588, 9, 35, 39, 15, -34 },
  { 3628, 12, 43, 39, 13, -34 },
  { 3693, 27, 38, 39, 6, -39 },
  { 3822, 31, 18, 39, 4, -29 },
  { 3892, 27, 38, 39, 6, -39 },
  { 4021, 28, 47, 39, 5, -46 },
  { 4186, 30, 53, 39, 4, -46 },
  { 4385, 35, 45, 39, 2, -45 },
  { 4582, 29, 45, 39, 6, -45 },
  { 4746, 30, 47, 39, 5, -46 },
  { 4923, 29, 45, 39, 6, -45 },
  { 5087, 28, 45, 39, 6, -45 },
  { 5245, 28, 45, 39, 6, -45 },
  { 5403, 30, 47, 39, 4, -46 },
  { 5580, 29, 45, 39, 5, -45 },
  { 5744, 29, 45, 39, 5, -45 },
  { 5908, 26, 46, 39, 5, -45 },
  { 6058, 32, 45, 39, 6, -45 },
  { 6238, 27, 45, 39, 8, -45 },
  { 6390, 31, 45, 39, 4, -45 },
  { 6565, 29, 45, 39, 5, -45 },
  { 6729, 31, 47, 39, 4, -46 },
  { 6912, 29, 45, 39, 6, -45 },
  { 7076, 31, 58, 39, 4, -46 },
  { 7301, 30, 45, 39, 6, -45 },
  { 7470, 32, 47, 39, 3, -46 },
  { 7658, 35, 45, 39, 2, -45 },
  { 7855, 29, 46, 39, 5, -45 },
  { 8022, 35, 45, 39, 2, -45 },
  { 8219, 35, 45, 39, 2, -45 },
  { 8416, 35, 45, 39, 2, -45 },
  { 8613, 37, 45, 39, 1, -45 },
  { 8822, 33, 45, 39, 3, -45 },
  { 9008, 18, 58, 39, 15, -49 },
  { 9139, 27, 58, 39, 6, -49 },
  { 9335, 18, 58, 39, 6, -49 },
  { 9466, 33, 27, 39, 3, -45 },
  { 9578, 31, 5, 39, 4, 6 },
  { 9598, 10, 13, 39, 12, -51 },
  { 9615, 32, 35, 39, 4, -34 },
  { 9755, 29, 49, 39, 6, -48 },
  { 9933, 29, 35, 39, 5, -34 },
  { 10060, 29, 49, 39, 4, -48 },
  { 10238, 31, 35, 39, 4, -34 },
  { 10374, 30, 48, 39, 5, -48 },
  { 10554, 32, 53, 39, 4, -39 },
  { 10766, 27, 48, 39, 6, -48 },
  { 10928, 28, 49, 39, 7, -49 },
  { 11100, 24, 62, 39, 6, -49 },
  { 11286, 30, 48, 39, 7, -48 },
  { 11466, 29, 48, 39, 5, -48 },
  { 11640, 31, 34, 39, 4, -34 },
  { 11772, 27, 34, 39, 6, -34 },
  { 11887, 31, 35, 39, 4, -34 },
  { 12023, 29, 47, 39, 6, -34 },
  { 12194, 29, 47, 39, 4, -34 },
  { 12365, 31, 34, 39, 5, -34 },
  { 12497, 30, 35, 39, 4, -34 },
  { 12629, 31, 45, 39, 3, -45 },
  { 12804, 27, 35, 39, 6, -34 },
  { 12923, 31, 34, 39, 4, -34 },
  { 13055, 35, 34, 39, 2, -34 },
  { 13204, 31, 34, 39, 4, -34 },
  { 13336, 33, 47, 39, 3, -34 },
  { 13530, 27, 34, 39, 6, -34 },
  { 13645, 25, 58, 39, 7, -49 },
  { 13827, 5, 58, 39, 17, -49 },
  { 13864, 25, 58, 39, 7, -49 },
  { 14046, 33, 15, 39, 3, -27 },
};

const GFXfont IBMPlexMono_Regular65pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular65pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular65pt7bGlyphs,
  0x20, 0x7E, 85
};

#endif // _IBMPLEXMONO_REGULAR65PT7B_H_
