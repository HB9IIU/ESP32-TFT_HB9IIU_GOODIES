#ifndef _IBMPLEXMONO_REGULAR10PT7B_H_
#define _IBMPLEXMONO_REGULAR10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular10pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0x8C, 0xFC, 0x28, 0xA6, 0xD4, 0xD9, 0x45, 0x00, 0x21, 0xE6,
  0x98, 0x38, 0xAE, 0xDE, 0x20, 0xE6, 0xAF, 0x00, 0x7D, 0x59, 0xC0, 0x71,
  0x44, 0x1B, 0x9A, 0x27, 0xC0, 0xE0, 0x6A, 0x49, 0x22, 0x60, 0x88, 0x92,
  0x4A, 0x80, 0x20, 0x8F, 0xCC, 0x48, 0x44, 0xF4, 0x40, 0xE0, 0xC0, 0xC0,
  0x11, 0x22, 0x44, 0x48, 0x80, 0x69, 0x9F, 0x99, 0x60, 0x65, 0x28, 0x42,
  0x13, 0xE0, 0x69, 0x11, 0x68, 0xF0, 0x32, 0x42, 0x60, 0xC5, 0xC0, 0x18,
  0xA2, 0x92, 0x8B, 0xF0, 0x80, 0xF8, 0xF9, 0x19, 0x60, 0x68, 0xF9, 0x99,
  0xE0, 0xF9, 0x12, 0x24, 0x40, 0xF9, 0x96, 0x99, 0xF0, 0x79, 0x99, 0xF2,
  0x40, 0xC0, 0xC0, 0xC0, 0xE0, 0x12, 0xC8, 0x61, 0xF0, 0xF0, 0x84, 0x31,
  0x68, 0x79, 0x12, 0x40, 0x60, 0x79, 0xBD, 0xDF, 0x87, 0x30, 0xC5, 0x12,
  0x79, 0x28, 0x40, 0xF9, 0x9E, 0x99, 0xF0, 0x79, 0x88, 0x89, 0x70, 0xE9,
  0x99, 0x99, 0xE0, 0xF8, 0x8F, 0x88, 0xF0, 0xF8, 0x8F, 0x88, 0x80, 0x69,
  0x8B, 0x99, 0xF0, 0x99, 0x9F, 0x99, 0x90, 0xF4, 0x44, 0x44, 0xF0, 0xF1,
  0x11, 0x19, 0xE0, 0x9D, 0x29, 0xCA, 0x4A, 0x60, 0x88, 0x88, 0x88, 0xF0,
  0x9B, 0xFF, 0xD9, 0x90, 0x9D, 0xDD, 0xBB, 0x90, 0x69, 0x99, 0x99, 0x60,
  0xF9, 0x9F, 0x88, 0x80, 0x69, 0x99, 0x99, 0xF4, 0x30, 0xF9, 0x9F, 0xA9,
  0x90, 0x7A, 0x50, 0xF0, 0xE5, 0xE0, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x00,
  0x99, 0x99, 0x99, 0xF0, 0x8D, 0x24, 0x92, 0x30, 0xC3, 0x00, 0x86, 0x1B,
  0xAE, 0xB9, 0x64, 0x80, 0xCD, 0x23, 0x0C, 0x31, 0x2C, 0xC0, 0x85, 0x23,
  0x0C, 0x20, 0x82, 0x00, 0x78, 0x21, 0x08, 0x21, 0x0F, 0xC0, 0xF2, 0x49,
  0x24, 0xE0, 0x88, 0x44, 0x42, 0x21, 0x10, 0xE4, 0x92, 0x49, 0xE0, 0x30,
  0xC4, 0xA3, 0xF0, 0xC0, 0xE4, 0xBD, 0x2F, 0x80, 0x88, 0xF9, 0x99, 0xF0,
  0x69, 0x89, 0x60, 0x11, 0xF9, 0x99, 0xF0, 0x69, 0xF8, 0x70, 0x34, 0xF4,
  0x44, 0xF0, 0x1F, 0xA5, 0xE8, 0x7A, 0x3E, 0x88, 0xF9, 0x99, 0x90, 0x20,
  0xE2, 0x22, 0xF0, 0x30, 0xE2, 0x22, 0x22, 0xE0, 0x84, 0x25, 0x4E, 0x4A,
  0x60, 0xC4, 0x44, 0x44, 0xF0, 0xDF, 0xDD, 0xD0, 0xF9, 0x99, 0x90, 0xF9,
  0x99, 0xF0, 0xF9, 0x99, 0xF8, 0x80, 0xF9, 0x99, 0xF1, 0x10, 0xDB, 0x10,
  0x8F, 0x00, 0xF8, 0xF1, 0xF0, 0x21, 0x3E, 0x42, 0x10, 0xE0, 0x99, 0x99,
  0xF0, 0x99, 0xA6, 0x60, 0xB6, 0xEB, 0x92, 0x48, 0x96, 0x46, 0x90, 0x99,
  0xA6, 0x64, 0xC0, 0xF1, 0x68, 0xF0, 0x74, 0x42, 0xC2, 0x44, 0x70, 0xFF,
  0x80, 0xE2, 0x44, 0x34, 0x42, 0xE0, 0xDB,
};

const GFXglyph IBMPlexMono_Regular10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 2, 3, 6, 2, -7 },
  { 4, 6, 7, 6, 0, -7 },
  { 10, 6, 9, 6, 0, -8 },
  { 17, 6, 7, 6, 0, -7 },
  { 23, 6, 7, 6, 0, -7 },
  { 29, 1, 3, 6, 3, -7 },
  { 30, 3, 9, 6, 2, -8 },
  { 34, 3, 9, 6, 1, -8 },
  { 38, 6, 5, 6, 0, -6 },
  { 42, 4, 5, 6, 1, -6 },
  { 45, 2, 2, 6, 2, -1 },
  { 46, 2, 1, 6, 2, -4 },
  { 47, 2, 1, 6, 2, -1 },
  { 48, 4, 9, 6, 1, -8 },
  { 53, 4, 7, 6, 1, -7 },
  { 57, 5, 7, 6, 1, -7 },
  { 62, 4, 7, 6, 1, -7 },
  { 66, 5, 7, 6, 0, -7 },
  { 71, 6, 7, 6, 0, -7 },
  { 77, 4, 7, 6, 1, -7 },
  { 81, 4, 7, 6, 1, -7 },
  { 85, 4, 7, 6, 1, -7 },
  { 89, 4, 7, 6, 1, -7 },
  { 93, 4, 7, 6, 1, -7 },
  { 97, 2, 5, 6, 2, -5 },
  { 99, 2, 6, 6, 2, -5 },
  { 101, 4, 6, 6, 1, -6 },
  { 104, 4, 3, 6, 1, -5 },
  { 106, 4, 6, 6, 1, -6 },
  { 109, 4, 7, 6, 1, -7 },
  { 113, 4, 8, 6, 1, -7 },
  { 117, 6, 7, 6, 0, -7 },
  { 123, 4, 7, 6, 1, -7 },
  { 127, 4, 7, 6, 1, -7 },
  { 131, 4, 7, 6, 1, -7 },
  { 135, 4, 7, 6, 1, -7 },
  { 139, 4, 7, 6, 1, -7 },
  { 143, 4, 7, 6, 1, -7 },
  { 147, 4, 7, 6, 1, -7 },
  { 151, 4, 7, 6, 1, -7 },
  { 155, 4, 7, 6, 1, -7 },
  { 159, 5, 7, 6, 1, -7 },
  { 164, 4, 7, 6, 1, -7 },
  { 168, 4, 7, 6, 1, -7 },
  { 172, 4, 7, 6, 1, -7 },
  { 176, 4, 7, 6, 1, -7 },
  { 180, 4, 7, 6, 1, -7 },
  { 184, 4, 9, 6, 1, -7 },
  { 189, 4, 7, 6, 1, -7 },
  { 193, 5, 7, 6, 0, -7 },
  { 198, 6, 7, 6, 0, -7 },
  { 204, 4, 7, 6, 1, -7 },
  { 208, 6, 7, 6, 0, -7 },
  { 214, 6, 7, 6, 0, -7 },
  { 220, 6, 7, 6, 0, -7 },
  { 226, 6, 7, 6, 0, -7 },
  { 232, 6, 7, 6, 0, -7 },
  { 238, 3, 9, 6, 2, -8 },
  { 242, 4, 9, 6, 1, -8 },
  { 247, 3, 9, 6, 1, -8 },
  { 251, 6, 4, 6, 0, -7 },
  { 254, 4, 1, 6, 1, 1 },
  { 255, 1, 2, 6, 2, -8 },
  { 256, 5, 5, 6, 1, -5 },
  { 260, 4, 7, 6, 1, -7 },
  { 264, 4, 5, 6, 1, -5 },
  { 267, 4, 7, 6, 1, -7 },
  { 271, 4, 5, 6, 1, -5 },
  { 274, 4, 7, 6, 1, -7 },
  { 278, 5, 8, 6, 1, -6 },
  { 283, 4, 7, 6, 1, -7 },
  { 287, 4, 7, 6, 1, -7 },
  { 291, 4, 9, 6, 1, -7 },
  { 296, 5, 7, 6, 1, -7 },
  { 301, 4, 7, 6, 1, -7 },
  { 305, 4, 5, 6, 1, -5 },
  { 308, 4, 5, 6, 1, -5 },
  { 311, 4, 5, 6, 1, -5 },
  { 314, 4, 7, 6, 1, -5 },
  { 318, 4, 7, 6, 1, -5 },
  { 322, 5, 5, 6, 1, -5 },
  { 326, 4, 5, 6, 1, -5 },
  { 329, 5, 7, 6, 0, -7 },
  { 334, 4, 5, 6, 1, -5 },
  { 337, 4, 5, 6, 1, -5 },
  { 340, 6, 5, 6, 0, -5 },
  { 344, 4, 5, 6, 1, -5 },
  { 347, 4, 7, 6, 1, -5 },
  { 351, 4, 5, 6, 1, -5 },
  { 354, 4, 9, 6, 1, -8 },
  { 359, 1, 9, 6, 3, -8 },
  { 361, 4, 9, 6, 1, -8 },
  { 366, 4, 2, 6, 1, -4 },
};

const GFXfont IBMPlexMono_Regular10pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular10pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _IBMPLEXMONO_REGULAR10PT7B_H_
