#ifndef _IBMPLEXMONO_REGULAR64PT7B_H_
#define _IBMPLEXMONO_REGULAR64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular64pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x30,
  0x0C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC7, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0x8F, 0xC0, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0x3F, 0xFF, 0x01, 0xFF, 0xF3, 0xFF, 0xF0, 0x1F, 0xFF, 0x3F,
  0xFF, 0x01, 0xFF, 0xF3, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0xFF, 0xFC, 0x07, 0xFF, 0xCF, 0xFF, 0x80,
  0x7F, 0xFC, 0xFF, 0xF8, 0x0F, 0xFF, 0xCF, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x0F, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF1,
  0xE7, 0xFC, 0x1F, 0xC1, 0xE0, 0xFE, 0x1F, 0x81, 0xE0, 0x7F, 0x3F, 0x01,
  0xE0, 0x3E, 0x3E, 0x01, 0xE0, 0x1C, 0x3E, 0x01, 0xE0, 0x10, 0x3E, 0x01,
  0xE0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x3F, 0x01, 0xE0, 0x00, 0x1F, 0xC1,
  0xE0, 0x00, 0x1F, 0xE1, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xE3, 0xFE, 0x00, 0x01, 0xE0, 0xFE, 0x00, 0x01, 0xE0, 0x3F, 0x00, 0x01,
  0xE0, 0x3F, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x01,
  0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x1F, 0x18, 0x01,
  0xE0, 0x1F, 0x3C, 0x01, 0xE0, 0x3F, 0x7E, 0x01, 0xE0, 0x3F, 0xFF, 0x01,
  0xE0, 0x7E, 0x3F, 0xC1, 0xE0, 0xFE, 0x3F, 0xF1, 0xE7, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0xFF, 0xE0, 0x00, 0x1E, 0x1F, 0xFF, 0x00, 0x03, 0xE3,
  0xF0, 0xF8, 0x00, 0x3C, 0x3C, 0x07, 0xC0, 0x07, 0xC7, 0x80, 0x3C, 0x00,
  0x78, 0x78, 0x01, 0xE0, 0x0F, 0x87, 0x80, 0x1E, 0x00, 0xF0, 0xF8, 0x01,
  0xE0, 0x1F, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0x3E, 0x0F,
  0x80, 0x1E, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0x1E, 0x0F,
  0x80, 0x78, 0x01, 0xE0, 0xF8, 0x07, 0x80, 0x1E, 0x1F, 0x00, 0x78, 0x03,
  0xC1, 0xE0, 0x03, 0xC0, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x83, 0xC0, 0x01,
  0xFF, 0xF0, 0x40, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3E, 0x1F, 0x07, 0xC0,
  0x07, 0xC1, 0xE0, 0x3E, 0x00, 0x7C, 0x3C, 0x01, 0xE0, 0x0F, 0x83, 0xC0,
  0x1E, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x1F, 0x07, 0x80, 0x0F, 0x01, 0xE0,
  0x78, 0x00, 0xF0, 0x3E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x78, 0x00, 0xF0,
  0x7C, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x78, 0x00, 0xF0, 0xF8, 0x07, 0x80,
  0x0F, 0x0F, 0x00, 0x7C, 0x00, 0xF1, 0xF0, 0x03, 0xC0, 0x1E, 0x1E, 0x00,
  0x3C, 0x01, 0xE3, 0xE0, 0x01, 0xE0, 0x3E, 0x7C, 0x00, 0x1F, 0x07, 0xC7,
  0xC0, 0x00, 0xFF, 0xF8, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00,
  0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xF8, 0x03, 0xFE, 0x1F, 0xDF,
  0x80, 0x7F, 0xC7, 0xE3, 0xF8, 0x0F, 0x01, 0xF8, 0x3F, 0x81, 0xE0, 0x3E,
  0x03, 0xF8, 0x3C, 0x0F, 0xC0, 0x3F, 0x0F, 0x81, 0xF0, 0x03, 0xF1, 0xE0,
  0x3E, 0x00, 0x3F, 0x3C, 0x07, 0xC0, 0x03, 0xF7, 0x80, 0xF8, 0x00, 0x7F,
  0xF0, 0x1F, 0x00, 0x07, 0xFE, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x7C, 0x00,
  0x07, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0xE7, 0xE0, 0x7F, 0xC0, 0x7C, 0xFE,
  0x07, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xC0, 0x3F, 0xFC, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0xF8,
  0x01, 0xCF, 0xC0, 0x7C, 0x07, 0xEF, 0xFC, 0x3E, 0x1F, 0xF7, 0xFF, 0xDF,
  0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0E, 0x00, 0x07, 0x00,
  0x02, 0x00, 0x01, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFD, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x1F,
  0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x3E,
  0x03, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0x03, 0xFC, 0x0F, 0xFE, 0x07, 0xF8,
  0x1F, 0xFC, 0x0F, 0xF0, 0x3F, 0xF8, 0x1F, 0xE0, 0x7F, 0xF0, 0x1F, 0xC0,
  0xFF, 0xE0, 0x1F, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x0F,
  0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07,
  0xF1, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x38,
  0x01, 0xF8, 0x00, 0x10, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x01,
  0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F,
  0x0E, 0x00, 0x00, 0x7E, 0x08, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0xFE, 0x1F, 0x00, 0x01, 0xF8, 0x38, 0x00, 0x07, 0xE0, 0x40, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC4, 0x00, 0x00, 0x3F, 0x38,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x9F, 0xE0,
  0x01, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x03,
  0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3E,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x7F, 0x80, 0x0F, 0x0F, 0xFF, 0x00, 0xF9, 0xFF,
  0xFE, 0x07, 0xDF, 0xFF, 0xF8, 0x3E, 0xFF, 0xFF, 0xE1, 0xFF, 0x01, 0xFF,
  0x8F, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF0, 0x60, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x20, 0x00, 0x03, 0xF3,
  0x80, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0x8F, 0xE0,
  0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xFC, 0x1F, 0xE0, 0x03, 0xE1, 0xFF, 0xE0, 0x1F,
  0x8F, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF, 0xC1, 0xF3, 0xFF, 0xFF, 0x87, 0xDF,
  0x01, 0xFF, 0x3F, 0xE0, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x1F, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0,
  0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x7F, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xC0, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFC, 0x7E,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x77, 0xCF, 0xFC, 0x07, 0xFF, 0x1F,
  0xFF, 0xFE, 0xF8, 0x3F, 0xFF, 0xF3, 0xE0, 0x7F, 0xFF, 0x9F, 0x80, 0x7F,
  0xF8, 0x7C, 0x00, 0x7F, 0x81, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFD, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC7, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0x8F,
  0xC0, 0x1F, 0x83, 0xFC, 0x3F, 0xE7, 0xFE, 0x7F, 0xE7, 0xFE, 0x3F, 0xE3,
  0xFC, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF1, 0xFE, 0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83,
  0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFE, 0x03,
  0xFC, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0x81, 0xFC, 0x00, 0x7F, 0x07,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x79, 0xF0, 0x03,
  0xE1, 0xE7, 0x80, 0x3F, 0xE7, 0xDE, 0x01, 0xFF, 0xDF, 0xF8, 0x0F, 0xFF,
  0x7F, 0xE0, 0x7F, 0x0F, 0xFF, 0x81, 0xF0, 0x0F, 0xFE, 0x07, 0x80, 0x1F,
  0xF8, 0x3E, 0x00, 0x7F, 0xE0, 0xF8, 0x01, 0xFF, 0x83, 0xE0, 0x07, 0xFE,
  0x0F, 0x80, 0x1F, 0xF8, 0x3E, 0x00, 0x7F, 0xE0, 0xF8, 0x01, 0xFF, 0x83,
  0xE0, 0x07, 0xFE, 0x0F, 0x80, 0x1F, 0xF8, 0x3E, 0x00, 0x7F, 0xE0, 0xF8,
  0x01, 0xFF, 0x83, 0xE0, 0x07, 0xFE, 0x0F, 0x80, 0x1F, 0xF8, 0x3E, 0x00,
  0x7F, 0xE0, 0x7C, 0x03, 0xFF, 0x81, 0xF0, 0x0F, 0xDE, 0x07, 0xF8, 0xFF,
  0x78, 0x0F, 0xFF, 0x7D, 0xE0, 0x1F, 0xF9, 0xF7, 0xC0, 0x3F, 0xC7, 0xDF,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x7C, 0x00, 0x1F, 0xE3, 0xE0, 0x00,
  0x3F, 0x1F, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3F,
  0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0x7C,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC1, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x03,
  0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x08, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x02, 0x0F, 0xC0, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x7F, 0xC3, 0xE0,
  0x00, 0xFE, 0x1F, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x3F, 0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0xFE, 0x1F, 0x00,
  0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xFC,
  0x00, 0x01, 0x87, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x1E, 0xF8,
  0x7F, 0xFF, 0xF7, 0xC1, 0xFF, 0xFF, 0x3E, 0x07, 0xFF, 0xF1, 0xF0, 0x0F,
  0xFF, 0x0F, 0x80, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xBF, 0x00,
  0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0xFC, 0xFF, 0x80, 0x00, 0xFC, 0xFF, 0x80, 0x00, 0xFD, 0xFF, 0xC0, 0x00,
  0xFF, 0xF7, 0xE0, 0x00, 0xFF, 0xE7, 0xE0, 0x00, 0xFF, 0xC3, 0xF0, 0x00,
  0xFF, 0x83, 0xF8, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFB, 0xE0, 0x0F, 0x7F, 0xEF, 0x80, 0x3D, 0xFF, 0x9E, 0x01, 0xF7,
  0xFE, 0x7C, 0x07, 0x9F, 0xF8, 0xF0, 0x3E, 0x7F, 0xE3, 0xE0, 0xF1, 0xFF,
  0x8F, 0x83, 0xC7, 0xFE, 0x1E, 0x1F, 0x1F, 0xF8, 0x7C, 0x78, 0x7F, 0xE0,
  0xF3, 0xE1, 0xFF, 0x83, 0xEF, 0x07, 0xFE, 0x0F, 0xBC, 0x1F, 0xF8, 0x1F,
  0xF0, 0x7F, 0xE0, 0x7F, 0x81, 0xFF, 0x80, 0xFE, 0x07, 0xFE, 0x03, 0xF0,
  0x1F, 0xF8, 0x07, 0xC0, 0x7F, 0xE0, 0x1E, 0x01, 0xFF, 0x80, 0x78, 0x07,
  0xFE, 0x00, 0xE0, 0x1F, 0xF8, 0x03, 0x00, 0x7F, 0xE0, 0x04, 0x01, 0xFF,
  0x80, 0x20, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7C, 0xFF, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xBE, 0x00, 0x1F,
  0xFB, 0xE0, 0x01, 0xFF, 0xBF, 0x00, 0x1F, 0xF9, 0xF0, 0x01, 0xFF, 0x9F,
  0x00, 0x1F, 0xF8, 0xF8, 0x01, 0xFF, 0x8F, 0x80, 0x1F, 0xF8, 0xFC, 0x01,
  0xFF, 0x87, 0xC0, 0x1F, 0xF8, 0x7C, 0x01, 0xFF, 0x83, 0xE0, 0x1F, 0xF8,
  0x3E, 0x01, 0xFF, 0x83, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0,
  0x1F, 0xF8, 0x0F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0xC1, 0xFF,
  0x80, 0x7C, 0x1F, 0xF8, 0x07, 0xC1, 0xFF, 0x80, 0x3E, 0x1F, 0xF8, 0x03,
  0xE1, 0xFF, 0x80, 0x3F, 0x1F, 0xF8, 0x01, 0xF1, 0xFF, 0x80, 0x1F, 0x1F,
  0xF8, 0x00, 0xF9, 0xFF, 0x80, 0x0F, 0x9F, 0xF8, 0x00, 0xFD, 0xFF, 0x80,
  0x07, 0xDF, 0xF8, 0x00, 0x7D, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x03,
  0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x7C, 0x00, 0x0F, 0xF3, 0xE0, 0x00, 0x1F, 0xDF, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xEF, 0x80, 0x01,
  0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC,
  0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0x7C, 0x00, 0x0F, 0xF3, 0xE0, 0x00, 0x1F, 0xDF,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xCF, 0x80,
  0x01, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x3E, 0x01, 0xF0, 0x01,
  0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0,
  0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80,
  0x00, 0xFE, 0x3F, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x18, 0x3E, 0x00,
  0x00, 0x10, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x18, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0x7E, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0xC0, 0x01, 0xFC, 0x3F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x01, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x07, 0x9F, 0x00,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x00, 0x1E, 0x7C,
  0x03, 0xF0, 0x07, 0x9F, 0x00, 0xFE, 0x03, 0xE7, 0xC0, 0x3F, 0x80, 0xF9,
  0xF0, 0x1F, 0xE0, 0x3E, 0x3C, 0x07, 0xF8, 0x0F, 0x8F, 0x01, 0xFE, 0x03,
  0xE3, 0xC0, 0x7F, 0xC0, 0xF8, 0xF0, 0x1E, 0xF0, 0x3E, 0x3E, 0x0F, 0xBC,
  0x0F, 0x8F, 0x83, 0xCF, 0x03, 0xC3, 0xE0, 0xF3, 0xE0, 0xF0, 0xF8, 0x3C,
  0xF8, 0x3C, 0x3E, 0x0F, 0x1E, 0x0F, 0x0F, 0x87, 0x87, 0x83, 0xC3, 0xE1,
  0xE1, 0xE0, 0xF0, 0xF8, 0x78, 0x7C, 0x7C, 0x3E, 0x1E, 0x0F, 0x1F, 0x07,
  0x8F, 0x83, 0xC7, 0xC1, 0xE3, 0xC0, 0xF1, 0xF0, 0x78, 0xF0, 0x3C, 0x7C,
  0x1E, 0x3C, 0x0F, 0x9F, 0x07, 0x8F, 0x01, 0xE7, 0xC1, 0xF7, 0xC0, 0x79,
  0xE0, 0x7D, 0xE0, 0x1E, 0x78, 0x1F, 0x78, 0x07, 0xDE, 0x07, 0xDE, 0x01,
  0xF7, 0x81, 0xF7, 0x80, 0x3D, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xE0, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x07, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x98, 0x00, 0x00,
  0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x18, 0x1F,
  0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3C,
  0x0C, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x1C, 0x00, 0x07, 0xC0,
  0x10, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x7F, 0x07, 0xE0, 0x01, 0xBE, 0x0F, 0xF0, 0x1F, 0x7F, 0xCF, 0xFF, 0xFC,
  0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0x0F, 0xFF, 0xE0, 0xFE, 0x0F, 0xFF, 0x80,
  0xFC, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x03, 0xE0, 0xFF, 0xF0, 0x1F,
  0x1F, 0xFF, 0xC0, 0xF9, 0xFF, 0xFF, 0x07, 0xCF, 0xFF, 0xFC, 0x3E, 0xF0,
  0x1F, 0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0xFE, 0x3E, 0xF0, 0x1F, 0xF1, 0xF3, 0xFF, 0xFF, 0x0F, 0x9F, 0xFF, 0xF0,
  0x7C, 0x7F, 0xFF, 0x03, 0xE0, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x18, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x83, 0xE0, 0x00, 0x0C, 0x3F, 0x00, 0x01, 0xF3, 0xF8, 0x00,
  0x3F, 0x1F, 0xC0, 0x07, 0xE0, 0xFF, 0x01, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x07, 0xF0, 0x1F, 0x01, 0xFF, 0xE1, 0xF0, 0x7F, 0xFF, 0x1F, 0x0F, 0xFF,
  0xF9, 0xF1, 0xFF, 0xFF, 0xDF, 0x1F, 0xE0, 0x3D, 0xF3, 0xF8, 0x00, 0xFF,
  0x3F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x3D, 0xF1, 0xFF, 0xFF, 0xDF,
  0x0F, 0xFF, 0xF9, 0xF0, 0x7F, 0xFF, 0x1F, 0x01, 0xFF, 0xE1, 0xF0, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x7F,
  0x81, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3F, 0x7C,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0x03, 0xF0, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0x7E, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xE0, 0x1F,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0x00, 0xFE, 0x3C,
  0x00, 0x00, 0x3F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7E, 0x7F, 0x80, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x1F, 0xC0, 0x3E, 0x0F, 0xFE, 0x07, 0xC7, 0xFF, 0xF0, 0xF9, 0xFF, 0xFF,
  0x1F, 0x3F, 0xFF, 0xE3, 0xEF, 0x01, 0xFE, 0x7D, 0x80, 0x0F, 0xCF, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x3E, 0x00,
  0x03, 0xF8, 0xF8, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x07,
  0xE0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8, 0x3F, 0x80, 0x03,
  0xE1, 0xFC, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0x3E, 0x7F, 0x80, 0x00, 0xFB,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFD, 0xF8, 0x00, 0x3F, 0xE3,
  0xF0, 0x00, 0xFF, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x03, 0xF8,
  0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x7F, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0x1F, 0xC0, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x03, 0xF0,
  0xF8, 0xFF, 0x07, 0xFC, 0xF9, 0xFF, 0x8F, 0xFC, 0xFB, 0xFF, 0x9F, 0xFE,
  0xFB, 0xFF, 0x9F, 0xFE, 0xFB, 0x0F, 0xF8, 0x7E, 0xFC, 0x07, 0xF0, 0x3F,
  0xFC, 0x07, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F,
  0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F,
  0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F,
  0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F,
  0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F,
  0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F,
  0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F,
  0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F,
  0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x1F,
  0x00, 0x0F, 0xE0, 0x1F, 0x07, 0xFF, 0x03, 0xE3, 0xFF, 0xF8, 0x7C, 0xFF,
  0xFF, 0x8F, 0x9F, 0xFF, 0xF1, 0xF7, 0x80, 0xFF, 0x3E, 0xC0, 0x07, 0xE7,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xC0, 0x7F, 0x81, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xFC, 0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xC1,
  0xFF, 0xE0, 0x3E, 0x3F, 0xFF, 0x81, 0xF3, 0xFF, 0xFE, 0x0F, 0x9F, 0xFF,
  0xF8, 0x7D, 0xE0, 0x3F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC,
  0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x1F,
  0xCF, 0xF0, 0x01, 0xFC, 0x7D, 0xE0, 0x3F, 0xE3, 0xE7, 0xFF, 0xFE, 0x1F,
  0x3F, 0xFF, 0xE0, 0xF8, 0xFF, 0xFE, 0x07, 0xC1, 0xFF, 0xE0, 0x3E, 0x03,
  0xF8, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xFE, 0x1F, 0x07, 0xFF, 0xF1, 0xF0, 0xFF, 0xFF, 0x9F,
  0x1F, 0xFF, 0xFD, 0xF1, 0xFE, 0x03, 0xDF, 0x3F, 0x80, 0x0F, 0xF3, 0xF0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F,
  0x3F, 0x80, 0x0F, 0xF1, 0xFE, 0x03, 0xDF, 0x1F, 0xFF, 0xFD, 0xF0, 0xFF,
  0xFF, 0x9F, 0x07, 0xFF, 0xF1, 0xF0, 0x1F, 0xFE, 0x1F, 0x00, 0x7F, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xB8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0x80,
  0x3F, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x38, 0x3E, 0x00, 0x00,
  0x40, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x40, 0x00, 0x03, 0xE3, 0x80, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3E,
  0xFF, 0x00, 0x03, 0xF9, 0xFF, 0x80, 0x3F, 0xC3, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0x7F, 0xC0,
  0xF7, 0xCF, 0xFF, 0xFD, 0xF1, 0xFF, 0xFE, 0x7C, 0x3F, 0xFF, 0x1F, 0x07,
  0xFF, 0x87, 0xC0, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03,
  0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x1E, 0x1F, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x03,
  0xF0, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xE0,
  0x0F, 0xE0, 0x0F, 0x78, 0x03, 0xF8, 0x07, 0xDE, 0x01, 0xEE, 0x01, 0xF7,
  0x80, 0x7B, 0x80, 0x7D, 0xE0, 0x1E, 0xF0, 0x1E, 0x7C, 0x07, 0x3C, 0x07,
  0x9F, 0x01, 0xCF, 0x01, 0xE3, 0xC0, 0xF3, 0xC0, 0x78, 0xF0, 0x3C, 0x70,
  0x1E, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F, 0x03, 0x87, 0x83, 0xC3, 0xC0, 0xE1,
  0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3E, 0x1E, 0x0E, 0x0F, 0x07, 0x87,
  0x83, 0x83, 0xC1, 0xE1, 0xC0, 0xF0, 0xF0, 0x78, 0x70, 0x3C, 0x3C, 0x1E,
  0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x01, 0xC7, 0x81, 0xE3, 0xC0, 0x71, 0xE0,
  0x3C, 0xE0, 0x1E, 0x78, 0x0F, 0x38, 0x07, 0x9E, 0x03, 0xDE, 0x01, 0xE7,
  0x80, 0xF7, 0x80, 0x39, 0xC0, 0x3D, 0xE0, 0x0E, 0xF0, 0x0F, 0x78, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF8,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0x7E,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x0F,
  0x80, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x3E, 0x3C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x0C, 0x07, 0xFC, 0x00, 0x0F, 0x0F, 0xFE, 0x00, 0x0F,
  0x0F, 0xFF, 0x00, 0x1F, 0x1F, 0xFF, 0x80, 0x1E, 0x1F, 0x1F, 0xC0, 0x1E,
  0x3E, 0x0F, 0xC0, 0x3E, 0x3C, 0x07, 0xE0, 0x3C, 0x3C, 0x03, 0xF0, 0x7C,
  0x7C, 0x01, 0xF8, 0xFC, 0x78, 0x00, 0xFF, 0xF8, 0x78, 0x00, 0xFF, 0xF8,
  0x78, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x1F, 0xE0, 0x30, 0x00, 0x0F, 0x80,
};

const GFXglyph IBMPlexMono_Regular64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 10, 46, 38, 14, -45 },
  { 59, 16, 18, 38, 11, -47 },
  { 95, 36, 45, 38, 1, -45 },
  { 298, 32, 60, 38, 3, -52 },
  { 538, 36, 46, 38, 1, -45 },
  { 745, 35, 46, 38, 2, -45 },
  { 947, 5, 18, 38, 17, -47 },
  { 959, 19, 58, 38, 13, -49 },
  { 1097, 18, 58, 38, 7, -49 },
  { 1228, 33, 32, 38, 3, -36 },
  { 1360, 30, 31, 38, 4, -35 },
  { 1477, 12, 18, 38, 13, -9 },
  { 1504, 18, 5, 38, 10, -22 },
  { 1516, 10, 9, 38, 14, -8 },
  { 1528, 27, 58, 38, 6, -49 },
  { 1724, 31, 46, 38, 4, -45 },
  { 1903, 32, 45, 38, 3, -45 },
  { 2083, 30, 45, 38, 4, -45 },
  { 2252, 30, 46, 38, 3, -45 },
  { 2425, 34, 45, 38, 2, -45 },
  { 2617, 29, 46, 38, 5, -45 },
  { 2784, 30, 46, 38, 4, -45 },
  { 2957, 30, 45, 38, 4, -45 },
  { 3126, 31, 46, 38, 4, -45 },
  { 3305, 30, 45, 38, 4, -45 },
  { 3474, 10, 34, 38, 14, -33 },
  { 3517, 12, 42, 38, 13, -33 },
  { 3580, 28, 37, 38, 5, -38 },
  { 3710, 30, 17, 38, 4, -28 },
  { 3774, 28, 37, 38, 5, -38 },
  { 3904, 28, 46, 38, 5, -45 },
  { 4065, 30, 52, 38, 4, -45 },
  { 4260, 34, 45, 38, 2, -45 },
  { 4452, 29, 45, 38, 6, -45 },
  { 4616, 30, 46, 38, 4, -45 },
  { 4789, 29, 45, 38, 6, -45 },
  { 4953, 27, 45, 38, 6, -45 },
  { 5105, 28, 45, 38, 6, -45 },
  { 5263, 29, 46, 38, 4, -45 },
  { 5430, 28, 45, 38, 5, -45 },
  { 5588, 28, 45, 38, 5, -45 },
  { 5746, 26, 46, 38, 5, -45 },
  { 5896, 32, 45, 38, 5, -45 },
  { 6076, 26, 45, 38, 8, -45 },
  { 6223, 30, 45, 38, 4, -45 },
  { 6392, 28, 45, 38, 5, -45 },
  { 6550, 31, 46, 38, 4, -45 },
  { 6729, 29, 45, 38, 6, -45 },
  { 6893, 31, 57, 38, 4, -45 },
  { 7114, 29, 45, 38, 6, -45 },
  { 7278, 32, 46, 38, 3, -45 },
  { 7462, 35, 45, 38, 2, -45 },
  { 7659, 28, 46, 38, 5, -45 },
  { 7820, 34, 45, 38, 2, -45 },
  { 8012, 34, 45, 38, 2, -45 },
  { 8204, 35, 45, 38, 2, -45 },
  { 8401, 36, 45, 38, 1, -45 },
  { 8604, 32, 45, 38, 3, -45 },
  { 8784, 18, 58, 38, 14, -49 },
  { 8915, 27, 58, 38, 6, -49 },
  { 9111, 18, 58, 38, 6, -49 },
  { 9242, 33, 26, 38, 3, -45 },
  { 9350, 31, 5, 38, 4, 6 },
  { 9370, 10, 12, 38, 12, -49 },
  { 9385, 31, 35, 38, 4, -34 },
  { 9521, 29, 48, 38, 6, -47 },
  { 9695, 28, 35, 38, 5, -34 },
  { 9818, 28, 48, 38, 4, -47 },
  { 9986, 30, 35, 38, 4, -34 },
  { 10118, 30, 47, 38, 5, -47 },
  { 10295, 32, 52, 38, 4, -38 },
  { 10503, 27, 47, 38, 6, -47 },
  { 10662, 28, 48, 38, 7, -48 },
  { 10830, 23, 61, 38, 6, -48 },
  { 11006, 30, 47, 38, 7, -47 },
  { 11183, 28, 47, 38, 5, -47 },
  { 11348, 32, 34, 38, 3, -34 },
  { 11484, 27, 34, 38, 6, -34 },
  { 11599, 30, 35, 38, 4, -34 },
  { 11731, 29, 47, 38, 6, -34 },
  { 11902, 28, 47, 38, 4, -34 },
  { 12067, 31, 33, 38, 5, -33 },
  { 12195, 30, 35, 38, 4, -34 },
  { 12327, 32, 45, 38, 2, -45 },
  { 12507, 26, 34, 38, 6, -33 },
  { 12618, 30, 33, 38, 4, -33 },
  { 12742, 34, 33, 38, 2, -33 },
  { 12883, 31, 33, 38, 4, -33 },
  { 13011, 32, 46, 38, 3, -33 },
  { 13195, 28, 33, 38, 5, -33 },
  { 13311, 25, 58, 38, 7, -49 },
  { 13493, 4, 58, 38, 17, -49 },
  { 13522, 25, 58, 38, 7, -49 },
  { 13704, 32, 15, 38, 3, -27 },
};

const GFXfont IBMPlexMono_Regular64pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular64pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular64pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _IBMPLEXMONO_REGULAR64PT7B_H_
