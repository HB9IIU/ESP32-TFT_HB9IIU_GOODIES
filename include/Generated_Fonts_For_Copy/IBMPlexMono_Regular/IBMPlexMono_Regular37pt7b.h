#ifndef _IBMPLEXMONO_REGULAR37PT7B_H_
#define _IBMPLEXMONO_REGULAR37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular37pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x38, 0xE3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0xE1, 0xF8, 0x7E,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0x00, 0xC3,
  0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x86, 0x00, 0x1C, 0x30, 0x01,
  0xC3, 0x80, 0x0E, 0x1C, 0x0F, 0xF0, 0xFF, 0x7F, 0x87, 0xFB, 0xFC, 0x3F,
  0xC0, 0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C,
  0x38, 0x1F, 0xE1, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0xFF, 0x03, 0x87, 0x00,
  0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0C, 0x00, 0x30, 0xE0, 0x03, 0x87,
  0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x03, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xF3,
  0x9F, 0x78, 0xE3, 0xDC, 0x38, 0x67, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0,
  0x1E, 0x38, 0x03, 0xEE, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xF8, 0x03, 0x8F, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1D, 0x03,
  0x87, 0x60, 0xE1, 0xFC, 0x38, 0xF7, 0xCE, 0x78, 0xFF, 0xFE, 0x1F, 0xFE,
  0x01, 0xFE, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1F, 0x00, 0x3B, 0xFC, 0x03, 0x9F, 0xF0, 0x19, 0xC3, 0x81, 0xCE, 0x0E,
  0x1C, 0x60, 0x70, 0xE3, 0x03, 0x8E, 0x18, 0x1C, 0x70, 0xE0, 0xE7, 0x07,
  0x0E, 0x30, 0x1F, 0xF3, 0x80, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x7F, 0x80, 0xE7, 0xFE, 0x06, 0x38, 0x70, 0x71, 0x81, 0x83,
  0x1C, 0x0C, 0x38, 0xE0, 0x61, 0x87, 0x03, 0x1C, 0x18, 0x18, 0xC0, 0xE1,
  0xCE, 0x07, 0xFE, 0xE0, 0x1F, 0xE7, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xE1, 0xE0, 0x3C, 0x0E, 0x03, 0x80, 0x80,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x3F, 0x1F, 0x83, 0xF3, 0xFC, 0x3F, 0x79, 0xE3, 0x87, 0x0F,
  0x38, 0xE0, 0x73, 0x8E, 0x07, 0xB0, 0xE0, 0x3F, 0x0E, 0x01, 0xF0, 0xE0,
  0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x3B, 0x87, 0xFF, 0x9C, 0x3F, 0xF1, 0xE0,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x06, 0x03, 0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0xF0, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01,
  0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70,
  0x0C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x38, 0x30, 0x77, 0xE6, 0x7E, 0x7F, 0xFF, 0xA1, 0xFF, 0x80, 0x07, 0x80,
  0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0E, 0x70, 0x03, 0x87, 0x00, 0xF0, 0x70,
  0x1C, 0x0F, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x7D, 0xF7, 0x9E, 0x73, 0xCF, 0x38, 0xE3, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x3C, 0x38, 0x07, 0x9C, 0x00, 0xE7,
  0x00, 0x39, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x87,
  0x87, 0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0E, 0x70, 0x03, 0x8E, 0x01, 0xE3,
  0xE0, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x7D, 0xC0, 0x3E, 0x70, 0x1F, 0x1C, 0x0F, 0x87,
  0x03, 0xC1, 0xC0, 0x60, 0x70, 0x10, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFF,
  0x01, 0xFF, 0xE0, 0xF0, 0x7C, 0x78, 0x07, 0x1C, 0x01, 0xEF, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x01,
  0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x0F,
  0xFF, 0x87, 0x83, 0xE7, 0x80, 0x71, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x3F,
  0xE0, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x76, 0x00, 0x3F, 0x80, 0x3D, 0xE0, 0x7C, 0x7F, 0xFC, 0x1F, 0xFC,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0x70, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03,
  0x87, 0x00, 0x30, 0x70, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x01,
  0xC0, 0x70, 0x18, 0x07, 0x03, 0x80, 0x70, 0x70, 0x07, 0x06, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x7F, 0xFF, 0x3F, 0xFF,
  0x9F, 0xFF, 0xCE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x31, 0xF8, 0x19, 0xFF, 0x0D, 0xFF, 0xC7, 0x81, 0xF3,
  0x80, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xE6, 0x00, 0x77, 0x80, 0x79, 0xE0, 0x78, 0x7F, 0xF8, 0x1F,
  0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x7E, 0x07, 0x3F, 0xE1, 0xDF, 0xFC, 0x7C, 0x0F, 0x9E, 0x01, 0xEF,
  0x00, 0x3B, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x1D, 0xC0,
  0x0F, 0x70, 0x03, 0x9E, 0x01, 0xE3, 0xC0, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E,
  0xE0, 0x03, 0xB8, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF0, 0x3E, 0x78,
  0x07, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x8E, 0x01,
  0xE3, 0xC0, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xC0, 0xF1,
  0xC0, 0x0E, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x01, 0xDC, 0x00, 0xF7, 0xC0, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x78, 0x07,
  0x9C, 0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x3D, 0xC0, 0x0F, 0x78, 0x07, 0xCF, 0x03, 0x63, 0xFF, 0xB8, 0x7F,
  0xCE, 0x07, 0xE7, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xE0, 0x00,
  0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0xFF, 0xFF, 0xDE, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x7D, 0xE7, 0x9C, 0xF3, 0xCE, 0x38, 0xC0, 0x00, 0x01,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07,
  0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x1E, 0x70, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xFC, 0x03,
  0xF0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0x80, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC1, 0xE3,
  0x80, 0x7B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0xF3, 0x60, 0xFD, 0xB0, 0xFE,
  0xF8, 0x70, 0xFC, 0x70, 0x3E, 0x38, 0x1F, 0x1C, 0x0F, 0x8E, 0x07, 0xC7,
  0x03, 0xE3, 0x81, 0xF1, 0xC0, 0xF8, 0xE0, 0x6C, 0x78, 0x76, 0x1F, 0xDB,
  0x0F, 0xED, 0xC3, 0xE6, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xDC, 0x00, 0x39, 0xC0, 0x03, 0x9C,
  0x00, 0x39, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70,
  0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x81, 0xC0, 0x38, 0x1F,
  0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3,
  0x80, 0x1E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9C, 0x03, 0xCE, 0x00, 0xF7, 0x00,
  0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x07, 0xB8, 0x07, 0x9F,
  0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xF3, 0x80, 0x3D, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3D, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xFE,
  0x07, 0xFF, 0x87, 0x83, 0xE7, 0x80, 0x73, 0x80, 0x3F, 0xC0, 0x0D, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x67, 0x00, 0x7B, 0xC0, 0x38, 0xF0, 0x7C, 0x3F, 0xFC, 0x0F,
  0xFC, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x7C,
  0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E,
  0xE0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F,
  0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xFE,
  0x07, 0xFF, 0x87, 0xC1, 0xE3, 0x80, 0x7B, 0xC0, 0x1D, 0xC0, 0x0C, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xF8, 0x01, 0xDC, 0x00,
  0xEE, 0x00, 0x77, 0x80, 0x3B, 0xC0, 0x3C, 0xF8, 0x3E, 0x3F, 0xF7, 0x0F,
  0xFB, 0x83, 0xF1, 0xC0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x39,
  0x00, 0x7E, 0x01, 0xFE, 0x03, 0x9E, 0x0F, 0x3F, 0xFC, 0x3F, 0xF0, 0x1F,
  0x80, 0xE0, 0x03, 0xF8, 0x01, 0xEE, 0x00, 0xF3, 0x80, 0x78, 0xE0, 0x1C,
  0x38, 0x0F, 0x0E, 0x07, 0x83, 0x83, 0xC0, 0xE1, 0xE0, 0x38, 0x70, 0x0E,
  0x38, 0x03, 0x9E, 0x00, 0xEF, 0xC0, 0x3F, 0xF8, 0x0F, 0xCE, 0x03, 0xE3,
  0xC0, 0xF0, 0x78, 0x38, 0x0E, 0x0E, 0x03, 0xC3, 0x80, 0x70, 0xE0, 0x1E,
  0x38, 0x03, 0xCE, 0x00, 0x73, 0x80, 0x1E, 0xE0, 0x03, 0xB8, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x81, 0xFE, 0xE0, 0xDF, 0x70, 0xEF, 0x9C, 0x67, 0xCE, 0x73, 0xE3,
  0x39, 0xF1, 0xD8, 0xF8, 0xFC, 0x7C, 0x3C, 0x3E, 0x1E, 0x1F, 0x07, 0x0F,
  0x83, 0x07, 0xC1, 0x83, 0xE0, 0x81, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xC0,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xEE, 0x07,
  0xEE, 0x07, 0xEE, 0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE3, 0x87, 0xE3, 0x87,
  0xE3, 0x87, 0xE1, 0xC7, 0xE1, 0xC7, 0xE0, 0xE7, 0xE0, 0xE7, 0xE0, 0xE7,
  0xE0, 0x77, 0xE0, 0x77, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x0F, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8,
  0x7C, 0x38, 0x07, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0F, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x3D, 0xC0,
  0x0E, 0x70, 0x03, 0x8E, 0x01, 0xE3, 0xE0, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC,
  0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xDC, 0x01, 0xEE,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x01, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xE1, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x38, 0x07, 0x9C, 0x00,
  0xE7, 0x00, 0x39, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x77, 0x00, 0x3D, 0xC0, 0x0E, 0x70, 0x03, 0x8E, 0x01,
  0xE3, 0xE0, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0xFF,
  0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xDC, 0x01, 0xEE, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x01,
  0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF, 0xC1, 0xC1, 0xC0, 0xE0, 0xF0, 0x70,
  0x38, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0xF3, 0x80, 0x39,
  0xC0, 0x1E, 0xE0, 0x07, 0x70, 0x01, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x83,
  0xFF, 0xF1, 0xF0, 0x3E, 0x78, 0x03, 0xDC, 0x00, 0x47, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xFE,
  0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1D, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xF7, 0xC0, 0xF8, 0xFF,
  0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x0F, 0x78, 0x1E, 0x3F, 0xFE, 0x1F,
  0xFC, 0x0F, 0xF0, 0xF0, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x80,
  0x0E, 0x38, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x1C,
  0x03, 0x81, 0xC0, 0x38, 0x1E, 0x03, 0x80, 0xE0, 0x78, 0x0E, 0x07, 0x00,
  0xE0, 0x70, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0xE0,
  0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x06, 0x70,
  0x00, 0x67, 0x0F, 0x06, 0x70, 0xF0, 0x67, 0x0F, 0x06, 0x70, 0xF8, 0xE7,
  0x1F, 0x8E, 0x71, 0xD8, 0xE7, 0x19, 0x8E, 0x71, 0x98, 0xE7, 0x19, 0xCE,
  0x33, 0x9C, 0xE3, 0x38, 0xCE, 0x33, 0x0C, 0xC3, 0x30, 0xEC, 0x3F, 0x0E,
  0xC3, 0xF0, 0xEC, 0x3F, 0x06, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0,
  0x7C, 0xF0, 0x00, 0xF7, 0x80, 0x0E, 0x38, 0x01, 0xC1, 0xC0, 0x3C, 0x1E,
  0x03, 0x80, 0xE0, 0x78, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x03, 0x9E, 0x00,
  0x3D, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0x9C, 0x00, 0x78, 0xE0, 0x07, 0x0F,
  0x00, 0xE0, 0x70, 0x1E, 0x07, 0x81, 0xC0, 0x3C, 0x3C, 0x01, 0xC3, 0x80,
  0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0x9E,
  0x00, 0x38, 0x70, 0x03, 0xC3, 0xC0, 0x1C, 0x0E, 0x01, 0xE0, 0x78, 0x0E,
  0x01, 0xC0, 0xE0, 0x0F, 0x07, 0x00, 0x38, 0x70, 0x01, 0xE7, 0x80, 0x07,
  0x38, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0x9C, 0x00, 0x73, 0x80,
  0x1C, 0x38, 0x03, 0x87, 0x00, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x00, 0xE0,
  0xE0, 0x1E, 0x38, 0x01, 0xC6, 0x00, 0x1D, 0xC0, 0x03, 0x90, 0x00, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x63, 0x87, 0x0C, 0x38, 0x60,
  0xC0, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE0, 0xF0, 0x78, 0x70, 0x0F,
  0x08, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xE0, 0x1C, 0xF0, 0x07, 0x3C, 0x01, 0xC7, 0x00, 0xF1, 0xE0,
  0x7C, 0x7F, 0xF7, 0xCF, 0xF8, 0xF0, 0xFC, 0x3C, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC3, 0xE0, 0xCF, 0xF8, 0xDF, 0xFC, 0xD8, 0x3E, 0xE0, 0x1E, 0xE0, 0x0E,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1E, 0xD8, 0x3E, 0xDF, 0xFC, 0xCF, 0xF8,
  0xC3, 0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x3F, 0xFC, 0x3C, 0x1E, 0x78, 0x0F,
  0x70, 0x06, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x02, 0x78, 0x07, 0x3C, 0x1E, 0x3F, 0xFE,
  0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x07, 0xC3, 0x8F,
  0xF9, 0xCF, 0xFE, 0xEF, 0x83, 0x77, 0x80, 0x7B, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3B, 0x80, 0x1D, 0xE0, 0x1E, 0xF8, 0x17, 0x3F, 0xFB, 0x8F, 0xF9, 0xC1,
  0xF0, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x38,
  0x03, 0x9C, 0x00, 0xE7, 0x00, 0x19, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x43, 0x80, 0x38,
  0xF8, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0xFF, 0x80,
  0xFF, 0xC0, 0x7F, 0xE0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x81, 0xFA, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0x03, 0xC1,
  0xC0, 0x38, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83,
  0xC0, 0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x38, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xFF, 0x9C,
  0x00, 0x7B, 0x00, 0x07, 0xE0, 0x00, 0xEF, 0x00, 0x79, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC0, 0xFF, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE3, 0xE1, 0xDF, 0xF3, 0xFF,
  0xF7, 0xC1, 0xEE, 0x01, 0xDC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x9F, 0xFE, 0x7F, 0xF1, 0xFF,
  0x80, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x0F, 0x70, 0x0F, 0x38, 0x0F,
  0x1C, 0x0F, 0x0E, 0x0F, 0x07, 0x0E, 0x03, 0x8E, 0x01, 0xCE, 0x00, 0xFF,
  0x80, 0x7F, 0xE0, 0x3E, 0x78, 0x1E, 0x1E, 0x0E, 0x07, 0x07, 0x03, 0xC3,
  0x80, 0xF1, 0xC0, 0x3C, 0xE0, 0x0E, 0x70, 0x07, 0xB8, 0x01, 0xE0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x0F, 0x3B, 0xE7, 0xEF, 0xFD, 0xFF,
  0xC7, 0x87, 0xE1, 0xE1, 0xF8, 0x30, 0x7E, 0x0C, 0x1F, 0x83, 0x07, 0xE0,
  0xC1, 0xF8, 0x30, 0x7E, 0x0C, 0x1F, 0x83, 0x07, 0xE0, 0xC1, 0xF8, 0x30,
  0x7E, 0x0C, 0x1F, 0x83, 0x07, 0xE0, 0xC1, 0xF8, 0x30, 0x7E, 0x0C, 0x1C,
  0xE3, 0xE1, 0xDF, 0xF3, 0xFF, 0xF7, 0xC1, 0xEE, 0x01, 0xDC, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x38,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x78, 0x07, 0x9C,
  0x00, 0xE7, 0x00, 0x39, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1D, 0xC0, 0x07, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x80, 0x78, 0xF0, 0x3C,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0xC3, 0xE0, 0xCF, 0xF8, 0xDF,
  0xFC, 0xD8, 0x3E, 0xE0, 0x1E, 0xE0, 0x0E, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0,
  0x1E, 0xD8, 0x3E, 0xDF, 0xFC, 0xCF, 0xF8, 0xC3, 0xE0, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07,
  0xC3, 0x8F, 0xF9, 0xCF, 0xFE, 0xEF, 0x83, 0x77, 0x80, 0x7B, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3B, 0x80, 0x1D, 0xE0, 0x1E, 0xF8, 0x17, 0x3F, 0xFB, 0x8F,
  0xF9, 0xC1, 0xF0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0xFF, 0x0F, 0xFF, 0xC7, 0xFF,
  0xF3, 0xFC, 0x1D, 0x80, 0x07, 0x40, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0x80, 0xF3, 0x80,
  0x11, 0xC0, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1D, 0xC0, 0x0F, 0xF8, 0x0F,
  0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0F, 0x70, 0x0F,
  0x7C, 0x37, 0x3F, 0xF7, 0x1F, 0xE7, 0x0F, 0x87, 0xF0, 0x01, 0xDC, 0x00,
  0xE7, 0x00, 0x38, 0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC1, 0xC0, 0x60,
  0x70, 0x38, 0x1C, 0x0E, 0x03, 0x83, 0x00, 0xE1, 0xC0, 0x18, 0x70, 0x07,
  0x18, 0x01, 0xCE, 0x00, 0x33, 0x80, 0x0E, 0xC0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x76, 0x0F,
  0x07, 0x60, 0xD8, 0x66, 0x1D, 0x86, 0x71, 0x98, 0x67, 0x19, 0x8E, 0x71,
  0x9C, 0xE3, 0x19, 0xCE, 0x33, 0x8C, 0xC3, 0x30, 0xCC, 0x33, 0x0C, 0xC3,
  0xB0, 0xEC, 0x3B, 0x0E, 0xC3, 0xF0, 0x7C, 0x1E, 0x07, 0xC1, 0xE0, 0x78,
  0x1E, 0x07, 0x80, 0xF0, 0x03, 0xCE, 0x01, 0xE3, 0xC0, 0x70, 0x78, 0x38,
  0x0E, 0x1C, 0x03, 0xCF, 0x00, 0x7B, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0x38, 0x03, 0xCF, 0x00, 0xE1,
  0xE0, 0x70, 0x38, 0x38, 0x07, 0x1E, 0x01, 0xEF, 0x00, 0x3C, 0xE0, 0x01,
  0xDC, 0x00, 0x77, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC1,
  0xC0, 0x70, 0x70, 0x38, 0x0C, 0x0E, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x1C,
  0x60, 0x07, 0x38, 0x00, 0xCE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x3C, 0x3F, 0xE0, 0xFC, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x7F, 0xC1, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0xFC,
  0x1F, 0xF0, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x00, 0x1E, 0x00, 0xCF, 0xC0, 0x33, 0xF8, 0x1D, 0xCF,
  0x07, 0x61, 0xE1, 0xB8, 0x3C, 0xEE, 0x07, 0xFB, 0x00, 0xFC, 0xC0, 0x1E,
  0x00,
};

const GFXglyph IBMPlexMono_Regular37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 26, 22, 8, -26 },
  { 21, 10, 10, 22, 6, -27 },
  { 34, 21, 26, 22, 1, -26 },
  { 103, 18, 34, 22, 2, -30 },
  { 180, 21, 26, 22, 1, -26 },
  { 249, 20, 26, 22, 1, -26 },
  { 314, 3, 10, 22, 10, -27 },
  { 318, 10, 33, 22, 8, -28 },
  { 360, 11, 33, 22, 4, -28 },
  { 406, 19, 18, 22, 2, -21 },
  { 449, 18, 19, 22, 2, -21 },
  { 492, 6, 10, 22, 8, -5 },
  { 500, 10, 3, 22, 6, -13 },
  { 504, 6, 5, 22, 8, -5 },
  { 508, 16, 33, 22, 3, -28 },
  { 574, 18, 26, 22, 2, -26 },
  { 633, 18, 26, 22, 2, -26 },
  { 692, 18, 26, 22, 2, -26 },
  { 751, 17, 26, 22, 2, -26 },
  { 807, 20, 26, 22, 1, -26 },
  { 872, 17, 26, 22, 3, -26 },
  { 928, 18, 26, 22, 2, -26 },
  { 987, 18, 26, 22, 2, -26 },
  { 1046, 18, 26, 22, 2, -26 },
  { 1105, 18, 26, 22, 2, -26 },
  { 1164, 6, 20, 22, 8, -20 },
  { 1179, 6, 25, 22, 8, -20 },
  { 1198, 16, 21, 22, 3, -22 },
  { 1240, 18, 11, 22, 2, -17 },
  { 1265, 16, 21, 22, 3, -22 },
  { 1307, 16, 26, 22, 3, -26 },
  { 1359, 17, 30, 22, 2, -26 },
  { 1423, 20, 26, 22, 1, -26 },
  { 1488, 17, 26, 22, 3, -26 },
  { 1544, 17, 26, 22, 3, -26 },
  { 1600, 16, 26, 22, 4, -26 },
  { 1652, 16, 26, 22, 3, -26 },
  { 1704, 17, 26, 22, 3, -26 },
  { 1760, 17, 26, 22, 2, -26 },
  { 1816, 16, 26, 22, 3, -26 },
  { 1868, 16, 26, 22, 3, -26 },
  { 1920, 15, 26, 22, 3, -26 },
  { 1969, 18, 26, 22, 3, -26 },
  { 2028, 16, 26, 22, 4, -26 },
  { 2080, 17, 26, 22, 3, -26 },
  { 2136, 16, 26, 22, 3, -26 },
  { 2188, 18, 26, 22, 2, -26 },
  { 2247, 17, 26, 22, 3, -26 },
  { 2303, 18, 32, 22, 2, -26 },
  { 2375, 17, 26, 22, 3, -26 },
  { 2431, 18, 26, 22, 2, -26 },
  { 2490, 20, 26, 22, 1, -26 },
  { 2555, 16, 26, 22, 3, -26 },
  { 2607, 20, 26, 22, 1, -26 },
  { 2672, 20, 26, 22, 1, -26 },
  { 2737, 20, 26, 22, 1, -26 },
  { 2802, 21, 26, 22, 1, -26 },
  { 2871, 18, 26, 22, 2, -26 },
  { 2930, 11, 33, 22, 8, -28 },
  { 2976, 16, 33, 22, 3, -28 },
  { 3042, 10, 33, 22, 4, -28 },
  { 3084, 19, 15, 22, 2, -26 },
  { 3120, 18, 3, 22, 2, 3 },
  { 3127, 6, 7, 22, 7, -29 },
  { 3133, 18, 19, 22, 2, -19 },
  { 3176, 16, 27, 22, 4, -27 },
  { 3230, 16, 19, 22, 3, -19 },
  { 3268, 17, 27, 22, 2, -27 },
  { 3326, 18, 19, 22, 2, -19 },
  { 3369, 17, 27, 22, 3, -27 },
  { 3427, 19, 29, 22, 2, -22 },
  { 3496, 15, 27, 22, 4, -27 },
  { 3547, 16, 27, 22, 4, -27 },
  { 3601, 14, 34, 22, 3, -27 },
  { 3661, 17, 27, 22, 4, -27 },
  { 3719, 16, 27, 22, 3, -27 },
  { 3773, 18, 19, 22, 2, -19 },
  { 3816, 15, 19, 22, 4, -19 },
  { 3852, 18, 19, 22, 2, -19 },
  { 3895, 16, 26, 22, 4, -19 },
  { 3947, 17, 26, 22, 2, -19 },
  { 4003, 18, 19, 22, 3, -19 },
  { 4046, 17, 19, 22, 2, -19 },
  { 4087, 18, 26, 22, 1, -26 },
  { 4146, 16, 19, 22, 3, -19 },
  { 4184, 18, 19, 22, 2, -19 },
  { 4227, 20, 19, 22, 1, -19 },
  { 4275, 18, 19, 22, 2, -19 },
  { 4318, 18, 26, 22, 2, -19 },
  { 4377, 16, 19, 22, 3, -19 },
  { 4415, 14, 33, 22, 4, -28 },
  { 4473, 2, 33, 22, 10, -28 },
  { 4482, 14, 33, 22, 4, -28 },
  { 4540, 18, 9, 22, 2, -16 },
};

const GFXfont IBMPlexMono_Regular37pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular37pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular37pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _IBMPLEXMONO_REGULAR37PT7B_H_
