#ifndef _IBMPLEXMONO_REGULAR6PT7B_H_
#define _IBMPLEXMONO_REGULAR6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x6F, 0xAC, 0x5F, 0x3A, 0x80, 0xFF, 0xF0, 0xF3, 0xF0,
  0x80, 0x6A, 0x90, 0xFC, 0xEA, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x5A,
  0xA0, 0xF7, 0xF0, 0xC9, 0x30, 0xE5, 0x70, 0xE5, 0xF0, 0x3E, 0xB0, 0xE8,
  0xF0, 0x6A, 0xF0, 0xE5, 0x20, 0xF7, 0xF0, 0xF5, 0xA0, 0xA0, 0xB0, 0x69,
  0xFC, 0xA6, 0xE5, 0x20, 0xFF, 0xE6, 0x55, 0xD0, 0xFF, 0xF2, 0x70, 0xFF,
  0xEF, 0xEE, 0xF2, 0xF0, 0xB7, 0xD0, 0xE9, 0x70, 0x64, 0xF0, 0xEF, 0xAB,
  0xBF, 0xD0, 0xBF, 0xD0, 0xF6, 0xF0, 0xFA, 0xF6, 0xD6, 0xFB, 0xF1, 0xF0,
  0xE9, 0x20, 0xB6, 0xF0, 0xB5, 0xA0, 0xBF, 0xD0, 0xA9, 0xD0, 0xB6, 0x44,
  0xE9, 0x70, 0xEA, 0xB0, 0xAA, 0x50, 0xFC, 0x54, 0xE0, 0x80, 0xEF, 0x80,
  0xBF, 0xF3, 0x80, 0x3E, 0xF0, 0xFF, 0x80, 0x7D, 0x70, 0x3E, 0xEE, 0xBF,
  0x2B, 0x75, 0xC0, 0xBB, 0xC9, 0x70, 0xFF, 0x80, 0xFC, 0xF7, 0x80, 0xFE,
  0xF6, 0xB0, 0xEB, 0x80, 0xEF, 0x80, 0x5D, 0x30, 0xFC, 0xB5, 0x00, 0xFE,
  0x80, 0xAA, 0x80, 0xB5, 0x60, 0xEC, 0x6A, 0xB0, 0xFC, 0xAB, 0xA0, 0xE0,
};

const GFXglyph IBMPlexMono_Regular6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 3, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 1, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 1, 6, 4, 1, -5 },
  { 16, 3, 3, 4, 0, -3 },
  { 18, 3, 3, 4, 0, -3 },
  { 20, 1, 2, 4, 1, -1 },
  { 21, 2, 1, 4, 1, -2 },
  { 22, 1, 1, 4, 1, -1 },
  { 23, 2, 6, 4, 1, -5 },
  { 25, 3, 4, 4, 0, -4 },
  { 27, 3, 4, 4, 0, -4 },
  { 29, 3, 4, 4, 0, -4 },
  { 31, 3, 4, 4, 0, -4 },
  { 33, 3, 4, 4, 0, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 0, -4 },
  { 43, 3, 4, 4, 0, -4 },
  { 45, 1, 3, 4, 1, -3 },
  { 46, 1, 4, 4, 1, -3 },
  { 47, 2, 4, 4, 1, -4 },
  { 48, 3, 2, 4, 0, -3 },
  { 49, 2, 4, 4, 1, -4 },
  { 50, 3, 4, 4, 0, -4 },
  { 52, 3, 5, 4, 0, -4 },
  { 54, 3, 4, 4, 0, -4 },
  { 56, 2, 4, 4, 1, -4 },
  { 57, 3, 4, 4, 0, -4 },
  { 59, 2, 4, 4, 1, -4 },
  { 60, 2, 4, 4, 1, -4 },
  { 61, 2, 4, 4, 1, -4 },
  { 62, 3, 4, 4, 0, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 3, 4, 4, 0, -4 },
  { 68, 3, 4, 4, 0, -4 },
  { 70, 2, 4, 4, 1, -4 },
  { 71, 2, 4, 4, 1, -4 },
  { 72, 3, 4, 4, 0, -4 },
  { 74, 3, 4, 4, 0, -4 },
  { 76, 3, 4, 4, 0, -4 },
  { 78, 2, 4, 4, 1, -4 },
  { 79, 3, 5, 4, 0, -4 },
  { 81, 2, 4, 4, 1, -4 },
  { 82, 3, 4, 4, 0, -4 },
  { 84, 3, 4, 4, 0, -4 },
  { 86, 3, 4, 4, 0, -4 },
  { 88, 3, 4, 4, 0, -4 },
  { 90, 3, 4, 4, 0, -4 },
  { 92, 3, 4, 4, 0, -4 },
  { 94, 4, 4, 4, 0, -4 },
  { 96, 3, 4, 4, 0, -4 },
  { 98, 2, 6, 4, 1, -5 },
  { 100, 2, 6, 4, 1, -5 },
  { 102, 1, 6, 4, 1, -5 },
  { 103, 3, 2, 4, 0, -4 },
  { 104, 3, 1, 4, 0, 0 },
  { 105, 1, 1, 4, 1, -5 },
  { 106, 3, 3, 4, 0, -3 },
  { 108, 2, 4, 4, 1, -4 },
  { 109, 3, 3, 4, 0, -3 },
  { 111, 3, 4, 4, 0, -4 },
  { 113, 3, 3, 4, 0, -3 },
  { 115, 3, 4, 4, 0, -4 },
  { 117, 3, 5, 4, 0, -4 },
  { 119, 2, 4, 4, 1, -4 },
  { 120, 2, 4, 4, 1, -4 },
  { 121, 2, 5, 4, 1, -4 },
  { 123, 2, 4, 4, 1, -4 },
  { 124, 3, 4, 4, 0, -4 },
  { 126, 3, 3, 4, 0, -3 },
  { 128, 2, 3, 4, 1, -3 },
  { 129, 3, 3, 4, 0, -3 },
  { 131, 2, 4, 4, 1, -3 },
  { 132, 3, 4, 4, 0, -3 },
  { 134, 3, 3, 4, 0, -3 },
  { 136, 3, 3, 4, 0, -3 },
  { 138, 3, 4, 4, 0, -4 },
  { 140, 2, 3, 4, 1, -3 },
  { 141, 3, 3, 4, 0, -3 },
  { 143, 3, 3, 4, 0, -3 },
  { 145, 3, 3, 4, 0, -3 },
  { 147, 3, 4, 4, 0, -3 },
  { 149, 2, 3, 4, 1, -3 },
  { 150, 2, 6, 4, 1, -5 },
  { 152, 1, 6, 4, 1, -5 },
  { 153, 2, 6, 4, 1, -5 },
  { 155, 3, 1, 4, 0, -2 },
};

const GFXfont IBMPlexMono_Regular6pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular6pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _IBMPLEXMONO_REGULAR6PT7B_H_
