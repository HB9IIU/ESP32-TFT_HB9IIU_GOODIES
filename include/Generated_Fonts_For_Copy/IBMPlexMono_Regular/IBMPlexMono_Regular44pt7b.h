#ifndef _IBMPLEXMONO_REGULAR44PT7B_H_
#define _IBMPLEXMONO_REGULAR44PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular44pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x8E, 0x38, 0xE3,
  0x8C, 0x30, 0xC3, 0x0C, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7,
  0x80, 0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x3F, 0x87, 0xF0, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x38, 0x38,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x87,
  0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70,
  0x70, 0x1F, 0xF8, 0x3F, 0xEF, 0xF8, 0x3F, 0xF7, 0xFC, 0x1F, 0xF8, 0x0E,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xC1, 0xC0, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE0,
  0x3C, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xF0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xFF, 0x07, 0xCE, 0x7E, 0x3C, 0x38, 0x7C, 0xE0, 0xE0, 0xE7, 0x83,
  0x81, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xE0, 0xE0, 0x03, 0x83, 0x80,
  0x0F, 0x0E, 0x00, 0x3F, 0x38, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xE7, 0xE0, 0x03, 0x87, 0xC0, 0x0E,
  0x0F, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07,
  0x30, 0x38, 0x3D, 0xE0, 0xE0, 0xFF, 0xC3, 0x87, 0x8F, 0xCE, 0x7E, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x07, 0x9F, 0xF0,
  0x03, 0x9F, 0xFC, 0x03, 0x8E, 0x1E, 0x01, 0xCE, 0x07, 0x81, 0xC7, 0x01,
  0xC1, 0xE3, 0x80, 0xE0, 0xE1, 0xC0, 0x70, 0xF0, 0xE0, 0x38, 0x70, 0x70,
  0x1C, 0x78, 0x38, 0x1E, 0x38, 0x0E, 0x1E, 0x38, 0x07, 0xFF, 0x1C, 0x01,
  0xFF, 0x10, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0xF1, 0xFF, 0x80, 0x71, 0xE1, 0xE0, 0x78, 0xE0,
  0x70, 0x38, 0x70, 0x38, 0x3C, 0x70, 0x0C, 0x1C, 0x38, 0x07, 0x1C, 0x1C,
  0x03, 0x8E, 0x0E, 0x01, 0x8E, 0x03, 0x81, 0xC7, 0x01, 0xC0, 0xE7, 0x00,
  0xF0, 0xF3, 0x80, 0x3F, 0xF3, 0x80, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0x87, 0xC0, 0x0E,
  0x03, 0xC0, 0x1E, 0x01, 0x80, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x1F,
  0xF0, 0x7F, 0x3C, 0xF0, 0x7F, 0x78, 0x78, 0x70, 0x78, 0x3C, 0x70, 0xF0,
  0x1E, 0x70, 0xF0, 0x0E, 0x70, 0xF0, 0x0F, 0x70, 0xF0, 0x07, 0xE0, 0xF0,
  0x03, 0xE0, 0xF0, 0x01, 0xE0, 0x70, 0x01, 0xF0, 0x78, 0x03, 0x78, 0x3E,
  0x0E, 0x3C, 0x3F, 0xFE, 0x1E, 0x1F, 0xFC, 0x0F, 0x07, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x30, 0x1C, 0x0E, 0xFE, 0x38, 0xFD, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC8, 0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xC7, 0x80, 0x0F, 0x07, 0x00, 0x3C,
  0x0F, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x0C, 0x00, 0x80, 0x10, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C,
  0x7C, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xE0, 0xF8, 0x1E, 0x01, 0xF0, 0xF0,
  0x03, 0xC3, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x39, 0xE0, 0x00,
  0xE7, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC1, 0xE0, 0xFF,
  0x07, 0xC3, 0xFC, 0x3F, 0x0F, 0xF0, 0x7C, 0x3F, 0xC1, 0xE0, 0xF7, 0x00,
  0x03, 0xDC, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x80, 0x03,
  0x9E, 0x00, 0x0E, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x07,
  0x80, 0x7C, 0x0F, 0x83, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xF7, 0x00,
  0x0F, 0x9C, 0x00, 0x7C, 0x70, 0x03, 0xE1, 0xC0, 0x1F, 0x07, 0x00, 0xF8,
  0x1C, 0x01, 0xC0, 0x70, 0x02, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7C,
  0x1F, 0x87, 0x80, 0x3C, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x8C, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7E, 0x0F, 0xC3,
  0xC0, 0x1E, 0x3C, 0x00, 0x78, 0x40, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x79, 0x00, 0x03, 0x9C, 0x00, 0x3D,
  0xF0, 0x03, 0xE7, 0xE0, 0x7E, 0x1F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0,
  0xE0, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x78, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0xFC, 0x07, 0xBF, 0xF8, 0x7F, 0xFF, 0xC7,
  0xE0, 0x7E, 0x7C, 0x01, 0xE1, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF2, 0x00, 0x0F, 0x70, 0x01, 0xEF, 0x80, 0x1E, 0x7E, 0x07, 0xC3, 0xFF,
  0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x8F, 0xE0, 0x39, 0xFF, 0xC3, 0xDF, 0xFF, 0x1F, 0xC0, 0xFC,
  0xFC, 0x01, 0xE7, 0xC0, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x00, 0xEF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0E, 0xF0, 0x00, 0x73,
  0x80, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xE0, 0x7C, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x01, 0xEE,
  0x00, 0x1E, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0xFC, 0x3E,
  0x00, 0xF0, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00,
  0x79, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x8F, 0x00, 0x1C, 0x1C, 0x00, 0xF0,
  0x3C, 0x0F, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0x7C,
  0x0F, 0x83, 0xC0, 0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF7,
  0x80, 0x07, 0x9F, 0x00, 0x3E, 0x3F, 0x03, 0xF0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x7C, 0x0F, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0x73, 0xC0, 0x03, 0xDE, 0x00,
  0x0E, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xBC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7D, 0xE0, 0x07, 0xCF, 0xC0, 0xEE, 0x3F, 0xFE,
  0xF0, 0x7F, 0xE7, 0x80, 0xFC, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0x3C, 0x7E, 0x7E, 0x7E,
  0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x78, 0x78, 0x70, 0xF0, 0xF0,
  0xE0, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x3C, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1F, 0x03, 0xE7, 0xC0, 0x3E, 0xF0, 0x03, 0xDC, 0x00, 0x7D, 0x80,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x81, 0xF0, 0x7C, 0x3C, 0x01, 0xE3, 0x80, 0x0E, 0x70,
  0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0x7F, 0x03, 0xC7, 0xE0, 0x7F, 0x7E,
  0x0F, 0xF7, 0xE1, 0xF0, 0xFE, 0x1E, 0x07, 0xE1, 0xC0, 0x7E, 0x1C, 0x07,
  0xE1, 0xC0, 0x7E, 0x3C, 0x07, 0xE3, 0xC0, 0x7E, 0x1C, 0x07, 0xE1, 0xC0,
  0x7E, 0x1C, 0x07, 0xE1, 0xC0, 0x7E, 0x1E, 0x0F, 0xE0, 0xFB, 0xFE, 0x0F,
  0xF7, 0xF0, 0x7E, 0x77, 0x00, 0x80, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xF7, 0x00, 0x00, 0xF7, 0x00, 0x00, 0xE7, 0x80, 0x01,
  0xE7, 0x80, 0x01, 0xE3, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xC3, 0xC0, 0x03,
  0xC1, 0xC0, 0x03, 0xC1, 0xC0, 0x03, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07,
  0x80, 0xE0, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1E, 0x00, 0x38, 0x1C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x00, 0xFC, 0xF0, 0x03, 0xCF,
  0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x1C, 0xF0, 0x03, 0xCF, 0x00, 0xF8, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0x00, 0x7C, 0xF0, 0x01, 0xEF, 0x00,
  0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x01, 0xEF, 0x00, 0x7C, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xF0, 0x3F, 0x07, 0xC1, 0xE0, 0x1F, 0x1E, 0x00, 0x78, 0xE0, 0x01, 0xEF,
  0x00, 0x0C, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x61, 0xC0,
  0x03, 0xCF, 0x00, 0x3C, 0x3C, 0x03, 0xE1, 0xF8, 0x3E, 0x07, 0xFF, 0xE0,
  0x1F, 0xFE, 0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0x01, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x07,
  0xCF, 0x01, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F,
  0x07, 0xC1, 0xE0, 0x0F, 0x1E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x00, 0x04,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x1F, 0xFF,
  0x80, 0xFF, 0xDC, 0x07, 0xFE, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xBC, 0x00,
  0x1D, 0xE0, 0x00, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xCF,
  0x00, 0x3E, 0x3C, 0x03, 0x71, 0xF8, 0x3B, 0x87, 0xFF, 0x9C, 0x1F, 0xF8,
  0xE0, 0x3F, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1,
  0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x3D, 0xE0, 0x1E, 0x3E, 0x0F,
  0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xC0, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xB8, 0x00, 0x79, 0xC0, 0x07, 0x8E, 0x00, 0x78, 0x70, 0x07, 0xC3, 0x80,
  0x7C, 0x1C, 0x07, 0xC0, 0xE0, 0x3C, 0x07, 0x03, 0xC0, 0x38, 0x3C, 0x01,
  0xC3, 0xE0, 0x0E, 0x3E, 0x00, 0x71, 0xF0, 0x03, 0x9F, 0x80, 0x1D, 0xFE,
  0x00, 0xFE, 0xF0, 0x07, 0xE3, 0xC0, 0x3F, 0x1F, 0x01, 0xF0, 0x78, 0x0F,
  0x01, 0xE0, 0x70, 0x0F, 0x83, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xE0, 0x07,
  0x87, 0x00, 0x1E, 0x38, 0x00, 0xF9, 0xC0, 0x03, 0xCE, 0x00, 0x0F, 0x70,
  0x00, 0x7F, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xEE, 0x07,
  0x7E, 0xF0, 0x77, 0xE7, 0x07, 0x7E, 0x70, 0xE7, 0xE3, 0x8E, 0x7E, 0x39,
  0xC7, 0xE3, 0xDC, 0x7E, 0x1D, 0xC7, 0xE1, 0xF8, 0x7E, 0x0F, 0x87, 0xE0,
  0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0x70, 0x7E, 0x06, 0x07, 0xE0, 0x20, 0x7E,
  0x04, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x70, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFB, 0x80, 0x3F, 0x78, 0x07, 0xE7, 0x00, 0xFC, 0xF0,
  0x1F, 0x9E, 0x03, 0xF1, 0xC0, 0x7E, 0x3C, 0x0F, 0xC3, 0x81, 0xF8, 0x78,
  0x3F, 0x0F, 0x07, 0xE0, 0xE0, 0xFC, 0x1E, 0x1F, 0x81, 0xC3, 0xF0, 0x3C,
  0x7E, 0x07, 0x8F, 0xC0, 0x71, 0xF8, 0x0F, 0x3F, 0x00, 0xE7, 0xE0, 0x1E,
  0xFC, 0x03, 0xDF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x03,
  0xE0, 0xF8, 0x1E, 0x01, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x9E, 0x00,
  0x1E, 0x78, 0x00, 0x79, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0xDC, 0x00, 0x0F,
  0x70, 0x00, 0x3D, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x70, 0x00,
  0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x07, 0x80, 0x7C, 0x0F, 0x83, 0xE0, 0x3F,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xE0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xE0, 0xF8,
  0x1E, 0x01, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x78,
  0x00, 0x39, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0xDC, 0x00, 0x0F, 0x70, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D,
  0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xE0,
  0x00, 0xE7, 0x80, 0x03, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03,
  0xC1, 0xE0, 0x1F, 0x07, 0xE0, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00,
  0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xCF,
  0xFF, 0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80,
  0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFF,
  0x0F, 0xC0, 0x7E, 0x3C, 0x00, 0x7D, 0xE0, 0x00, 0xC7, 0x80, 0x02, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x80, 0x00, 0xFF, 0x80, 0x07, 0x9F, 0x00, 0x3E, 0x7F, 0x03, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x0F, 0x3C, 0x01, 0xE7,
  0xC0, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xC0, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3B, 0xC0, 0x00, 0xF3, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xCF,
  0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0x78,
  0x01, 0xE0, 0x70, 0x03, 0xC0, 0xF0, 0x07, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xE0, 0x0F, 0x03, 0xC0, 0x0E, 0x07,
  0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0xF1, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xCF, 0x00, 0x03, 0xDC, 0x00,
  0x07, 0xB8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70,
  0x00, 0x0E, 0xE0, 0x78, 0x1D, 0xE0, 0xF8, 0x3B, 0xC1, 0xF0, 0x77, 0x87,
  0xE0, 0xE7, 0x0F, 0xC1, 0xCE, 0x1D, 0x83, 0x9C, 0x3B, 0x87, 0x38, 0x67,
  0x0E, 0x71, 0xCE, 0x3C, 0xE3, 0x9C, 0x71, 0xC7, 0x1C, 0xE3, 0x8E, 0x39,
  0xC7, 0x18, 0x73, 0x8E, 0x70, 0xE7, 0x1C, 0xE1, 0xCE, 0x3D, 0xC1, 0xDC,
  0x7B, 0x83, 0xB8, 0x7E, 0x07, 0x70, 0xFC, 0x0E, 0xE1, 0xF8, 0x1F, 0xC3,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x00, 0x78, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x78,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xE0,
  0x01, 0xE3, 0xC0, 0x01, 0xE3, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xF7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE3, 0xC0,
  0x03, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x07,
  0x9E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC0, 0xF0, 0x03,
  0xE0, 0x7C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x3C, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xCF, 0x00, 0x0F, 0x1C, 0x00, 0x38, 0x78, 0x01,
  0xE0, 0xE0, 0x07, 0x03, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x1E, 0x07, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0x9C, 0x00, 0x0F,
  0xF0, 0x00, 0x1C, 0x80, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x20, 0xE3, 0xC3, 0xC3, 0x83, 0x87, 0x07, 0x04, 0x03, 0xF8,
  0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0xF8, 0x1F, 0x07, 0x80, 0x78, 0x18,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0x3E, 0x00, 0xE3, 0xC0,
  0x07, 0x1E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1,
  0xE0, 0x0B, 0x87, 0xC1, 0xDF, 0xBF, 0xFC, 0x7C, 0xFF, 0xC1, 0xE1, 0xFC,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0xFC, 0x0F, 0x3F, 0xF0, 0xF7, 0xFF, 0x8F, 0xE0, 0xFC,
  0xF8, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00,
  0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0,
  0x01, 0xEF, 0x80, 0x3C, 0xFE, 0x0F, 0xCF, 0x7F, 0xF8, 0xF3, 0xFF, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0x03, 0xC3,
  0xC0, 0x3C, 0xF0, 0x03, 0x9C, 0x00, 0x47, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x11, 0xE0, 0x07, 0x3E,
  0x01, 0xF3, 0xE0, 0x7C, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x0F,
  0xC3, 0x87, 0xFC, 0x71, 0xFF, 0xCE, 0x7C, 0x0D, 0xDF, 0x00, 0xFB, 0xC0,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x77, 0x80, 0x1E, 0xF8, 0x07, 0xCF, 0x81,
  0xB8, 0xFF, 0xE7, 0x0F, 0xF8, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x81, 0xF0, 0x7C, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x70,
  0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x04, 0x78, 0x00, 0xE3, 0xC0, 0x1F, 0x1F, 0x07,
  0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0x40, 0x07, 0xFF,
  0x00, 0x7F, 0xFE, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xF0, 0x38, 0x01, 0xE1,
  0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF0,
  0x0F, 0x03, 0xE0, 0x7C, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x60, 0x01, 0xE7, 0x00,
  0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07,
  0xBF, 0x00, 0x3E, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x0F,
  0xC3, 0xCF, 0xF8, 0xF7, 0xFF, 0x3D, 0x83, 0xEF, 0x80, 0x7F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF0, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x03, 0xEE, 0x00, 0x7C, 0xE0, 0x0F, 0x8E, 0x01, 0xE0, 0xE0, 0x3C, 0x0E,
  0x07, 0x80, 0xE0, 0xF0, 0x0E, 0x1E, 0x00, 0xE3, 0xC0, 0x0E, 0x7C, 0x00,
  0xEF, 0xE0, 0x0F, 0xFF, 0x00, 0xF8, 0xF0, 0x0F, 0x07, 0x80, 0xE0, 0x3C,
  0x0E, 0x03, 0xE0, 0xE0, 0x1E, 0x0E, 0x00, 0xF0, 0xE0, 0x07, 0x8E, 0x00,
  0x7C, 0xE0, 0x03, 0xCE, 0x00, 0x1E, 0xE0, 0x00, 0xF0, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF3, 0xC1, 0xF3, 0xDF, 0x8F, 0xEF, 0xFF, 0x7F,
  0xBE, 0x3D, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0x7F, 0x03, 0x81, 0xFC,
  0x0E, 0x07, 0xF0, 0x38, 0x1F, 0xC0, 0xE0, 0x7F, 0x03, 0x81, 0xFC, 0x0E,
  0x07, 0xF0, 0x38, 0x1F, 0xC0, 0xE0, 0x7F, 0x03, 0x81, 0xFC, 0x0E, 0x07,
  0xF0, 0x38, 0x1F, 0xC0, 0xE0, 0x7F, 0x03, 0x81, 0xFC, 0x0E, 0x07, 0xF0,
  0x38, 0x1F, 0xC0, 0xE0, 0x7F, 0x03, 0x81, 0xC0, 0xF0, 0xFC, 0x3C, 0xFF,
  0x8F, 0x7F, 0xF3, 0xD8, 0x3E, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1C,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0, 0x7C, 0x0F, 0x83, 0xC0,
  0x1E, 0x3C, 0x00, 0x71, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0x77,
  0x80, 0x03, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0xF8, 0x00,
  0x3B, 0xC0, 0x01, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0xF3, 0x80, 0x07, 0x9E,
  0x00, 0x38, 0x78, 0x03, 0xC3, 0xE0, 0x7C, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x3F, 0x80, 0xF0, 0xFC, 0x0F, 0x3F, 0xF0, 0xF7, 0xFF, 0x8F, 0xE0,
  0xFC, 0xF8, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0E, 0xF0,
  0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x80, 0x3C, 0xFE, 0x0F, 0xCF, 0x7F, 0xF8, 0xF3, 0xFF,
  0x0F, 0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xF0, 0xE1, 0xFF, 0x1C, 0x7F, 0xF3, 0x9F, 0x03, 0x77, 0xC0, 0x3E, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1D, 0xE0, 0x07, 0xBE, 0x01, 0xF3, 0xE0,
  0x6E, 0x3F, 0xF9, 0xC3, 0xFE, 0x38, 0x3F, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0xFF, 0xC0,
  0x7B, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC3, 0xE0, 0x3E, 0x38, 0x00, 0xF7, 0x80, 0x04, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x74, 0x00, 0x07, 0x60, 0x00, 0xFF, 0x80, 0x0F, 0x7E, 0x03, 0xE3,
  0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3D,
  0xE0, 0x1F, 0x7C, 0x0D, 0xCF, 0xFF, 0x71, 0xFF, 0x9C, 0x1F, 0x80, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0x9C, 0x00, 0x3C, 0xF0, 0x01, 0xC7, 0x80, 0x0E,
  0x1C, 0x00, 0xF0, 0xF0, 0x07, 0x07, 0x80, 0x38, 0x1C, 0x03, 0xC0, 0xF0,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x0F, 0x00, 0xF0, 0x70, 0x03, 0x83, 0x80,
  0x1C, 0x38, 0x00, 0xF1, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x00, 0xF7,
  0x00, 0x03, 0xB8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0xF0, 0x3C, 0x07, 0x70, 0x3C, 0x07, 0x70, 0x3E, 0x07, 0x70, 0x3E, 0x07,
  0x70, 0x76, 0x0E, 0x70, 0x76, 0x0E, 0x70, 0x76, 0x0E, 0x70, 0x67, 0x0E,
  0x38, 0x67, 0x0E, 0x38, 0xE3, 0x0E, 0x38, 0xE3, 0x0E, 0x38, 0xE3, 0x0C,
  0x38, 0xC3, 0x9C, 0x38, 0xC3, 0x9C, 0x19, 0xC3, 0x9C, 0x19, 0xC1, 0x9C,
  0x1D, 0xC1, 0x9C, 0x1D, 0x81, 0xD8, 0x1D, 0x81, 0xD8, 0x1D, 0x81, 0xD8,
  0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF8, 0xF0, 0x00, 0xFB,
  0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x7C, 0x07, 0x81, 0xE0, 0x78, 0x07, 0x83,
  0x80, 0x1E, 0x3C, 0x00, 0xF3, 0xC0, 0x03, 0xDC, 0x00, 0x0F, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0xF3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x07, 0x81, 0xE0, 0x78,
  0x07, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0xFB, 0xC0, 0x03, 0xE0, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x3C, 0x00, 0x70,
  0x70, 0x03, 0xC1, 0xE0, 0x0E, 0x07, 0x80, 0x38, 0x0E, 0x01, 0xE0, 0x3C,
  0x07, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0xE0, 0x07, 0x83, 0x80, 0x0E, 0x1E,
  0x00, 0x3C, 0x70, 0x00, 0x73, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0xB8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x81,
  0xFF, 0xC1, 0xFF, 0xE0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xF0, 0x3F,
  0xF0, 0x1F, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3F, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xF0, 0x3F, 0xF8, 0x3C, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0x80,
  0x18, 0x7F, 0x00, 0x71, 0xFE, 0x01, 0xCE, 0x3C, 0x06, 0x38, 0x78, 0x39,
  0xC0, 0xE0, 0xE7, 0x03, 0xC7, 0x18, 0x07, 0xFC, 0xE0, 0x0F, 0xE1, 0x80,
  0x0F, 0x00,
};

const GFXglyph IBMPlexMono_Regular44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 6, 31, 26, 10, -31 },
  { 25, 11, 12, 26, 8, -33 },
  { 42, 25, 31, 26, 1, -31 },
  { 139, 22, 39, 26, 2, -35 },
  { 247, 25, 32, 26, 1, -31 },
  { 347, 24, 32, 26, 1, -31 },
  { 443, 3, 12, 26, 12, -33 },
  { 448, 13, 39, 26, 9, -33 },
  { 512, 12, 39, 26, 5, -33 },
  { 571, 23, 22, 26, 2, -25 },
  { 635, 21, 21, 26, 3, -24 },
  { 691, 8, 12, 26, 9, -6 },
  { 703, 13, 3, 26, 7, -15 },
  { 708, 6, 6, 26, 10, -6 },
  { 713, 18, 39, 26, 4, -33 },
  { 801, 22, 32, 26, 2, -31 },
  { 889, 22, 31, 26, 2, -31 },
  { 975, 21, 31, 26, 3, -31 },
  { 1057, 21, 32, 26, 2, -31 },
  { 1141, 24, 31, 26, 1, -31 },
  { 1234, 20, 32, 26, 3, -31 },
  { 1314, 21, 32, 26, 3, -31 },
  { 1398, 20, 31, 26, 3, -31 },
  { 1476, 22, 32, 26, 2, -31 },
  { 1564, 21, 31, 26, 3, -31 },
  { 1646, 6, 23, 26, 10, -23 },
  { 1664, 8, 29, 26, 9, -23 },
  { 1693, 19, 25, 26, 4, -26 },
  { 1753, 21, 11, 26, 3, -19 },
  { 1782, 19, 25, 26, 4, -26 },
  { 1842, 19, 31, 26, 3, -31 },
  { 1916, 20, 36, 26, 3, -31 },
  { 2006, 24, 31, 26, 1, -31 },
  { 2099, 20, 31, 26, 4, -31 },
  { 2177, 21, 32, 26, 3, -31 },
  { 2261, 20, 31, 26, 4, -31 },
  { 2339, 19, 31, 26, 4, -31 },
  { 2413, 19, 31, 26, 4, -31 },
  { 2487, 21, 32, 26, 2, -31 },
  { 2571, 19, 31, 26, 4, -31 },
  { 2645, 19, 31, 26, 4, -31 },
  { 2719, 18, 32, 26, 3, -31 },
  { 2791, 21, 31, 26, 4, -31 },
  { 2873, 19, 31, 26, 5, -31 },
  { 2947, 20, 31, 26, 3, -31 },
  { 3025, 19, 31, 26, 4, -31 },
  { 3099, 22, 32, 26, 2, -31 },
  { 3187, 20, 31, 26, 4, -31 },
  { 3265, 22, 38, 26, 2, -31 },
  { 3370, 20, 31, 26, 4, -31 },
  { 3448, 22, 32, 26, 2, -31 },
  { 3536, 24, 31, 26, 1, -31 },
  { 3629, 19, 32, 26, 4, -31 },
  { 3705, 23, 31, 26, 2, -31 },
  { 3795, 23, 31, 26, 2, -31 },
  { 3885, 24, 31, 26, 1, -31 },
  { 3978, 25, 31, 26, 1, -31 },
  { 4075, 22, 31, 26, 2, -31 },
  { 4161, 12, 39, 26, 10, -33 },
  { 4220, 18, 39, 26, 4, -33 },
  { 4308, 13, 39, 26, 4, -33 },
  { 4372, 22, 18, 26, 2, -31 },
  { 4422, 21, 3, 26, 3, 4 },
  { 4430, 7, 9, 26, 8, -35 },
  { 4438, 21, 24, 26, 3, -23 },
  { 4501, 20, 34, 26, 4, -33 },
  { 4586, 19, 24, 26, 4, -23 },
  { 4643, 19, 34, 26, 3, -33 },
  { 4724, 20, 24, 26, 3, -23 },
  { 4784, 21, 33, 26, 3, -33 },
  { 4871, 22, 35, 26, 3, -26 },
  { 4968, 18, 33, 26, 4, -33 },
  { 5043, 19, 33, 26, 5, -33 },
  { 5122, 16, 42, 26, 4, -33 },
  { 5206, 20, 33, 26, 5, -33 },
  { 5289, 19, 33, 26, 4, -33 },
  { 5368, 22, 23, 26, 2, -23 },
  { 5432, 18, 23, 26, 4, -23 },
  { 5484, 21, 24, 26, 3, -23 },
  { 5547, 20, 32, 26, 4, -23 },
  { 5627, 19, 32, 26, 3, -23 },
  { 5703, 22, 23, 26, 3, -23 },
  { 5767, 20, 24, 26, 3, -23 },
  { 5827, 21, 31, 26, 2, -31 },
  { 5909, 18, 24, 26, 4, -23 },
  { 5963, 21, 23, 26, 3, -23 },
  { 6024, 24, 23, 26, 1, -23 },
  { 6093, 21, 23, 26, 3, -23 },
  { 6154, 22, 32, 26, 2, -23 },
  { 6242, 19, 23, 26, 4, -23 },
  { 6297, 17, 39, 26, 5, -33 },
  { 6380, 3, 39, 26, 12, -33 },
  { 6395, 17, 39, 26, 5, -33 },
  { 6478, 22, 10, 26, 2, -18 },
};

const GFXfont IBMPlexMono_Regular44pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular44pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular44pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _IBMPLEXMONO_REGULAR44PT7B_H_
