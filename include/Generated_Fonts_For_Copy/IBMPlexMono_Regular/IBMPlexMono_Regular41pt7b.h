#ifndef _IBMPLEXMONO_REGULAR41PT7B_H_
#define _IBMPLEXMONO_REGULAR41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular41pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x0C, 0x30, 0xC1, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0x7C, 0xE1,
  0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC,
  0x3F, 0x87, 0x80, 0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80,
  0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0xFF, 0x87, 0xFD, 0xFF, 0x0F, 0xFB, 0xFE,
  0x1F, 0xF0, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC3,
  0x80, 0x03, 0x87, 0x01, 0xFF, 0x0F, 0xF3, 0xFC, 0x1F, 0xE7, 0xF8, 0x3F,
  0xC0, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x07, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xCE, 0x7E,
  0x3C, 0x70, 0xF3, 0xC3, 0x83, 0x5E, 0x1C, 0x10, 0xE0, 0xE0, 0x07, 0x07,
  0x00, 0x3C, 0x38, 0x01, 0xE1, 0xC0, 0x07, 0xCE, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0x3F, 0x00, 0x38,
  0x78, 0x01, 0xC1, 0xC0, 0x0E, 0x0F, 0x00, 0x70, 0x78, 0x03, 0x83, 0xC8,
  0x1C, 0x1E, 0xE0, 0xE0, 0xEF, 0x87, 0x0F, 0x3F, 0x39, 0xF0, 0xFF, 0xFF,
  0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x0E, 0x7F, 0x80, 0x39, 0xFF,
  0x80, 0x77, 0x87, 0x01, 0xCE, 0x07, 0x07, 0x1C, 0x0E, 0x0E, 0x38, 0x1C,
  0x38, 0x70, 0x38, 0x70, 0xE0, 0x71, 0xC1, 0xC0, 0xE3, 0x83, 0xC3, 0x8E,
  0x03, 0xFF, 0x1C, 0x03, 0xFC, 0x40, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0x1F, 0xF8, 0x1C, 0x78, 0x70,
  0x38, 0xE0, 0x70, 0xE1, 0x80, 0xE1, 0xC3, 0x01, 0xC7, 0x06, 0x03, 0x8E,
  0x0C, 0x07, 0x38, 0x1C, 0x0E, 0x70, 0x3C, 0x39, 0xC0, 0x3F, 0xF3, 0x80,
  0x3F, 0xCE, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x07, 0x80, 0x70, 0x08, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x03, 0xF1, 0xFC, 0x0F, 0xCF, 0x78,
  0x3F, 0x78, 0xF0, 0xE1, 0xC1, 0xE3, 0x8F, 0x03, 0xCE, 0x3C, 0x07, 0xB0,
  0xE0, 0x1E, 0xC3, 0x80, 0x3F, 0x0F, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x78,
  0x07, 0xE1, 0xF0, 0x73, 0xC3, 0xFF, 0xC7, 0x07, 0xFE, 0x1E, 0x07, 0xE0,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x01, 0x01, 0xC0, 0x5F, 0x0E, 0x1E, 0xFF, 0x77, 0xFB, 0xFF, 0xFF,
  0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0E,
  0x78, 0x00, 0xF1, 0xC0, 0x0F, 0x07, 0x00, 0x70, 0x3C, 0x07, 0x80, 0xF0,
  0x18, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x3F, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x78,
  0x78, 0x70, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF,
  0xFF, 0x7C, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xF0, 0x7C, 0x3C, 0x03, 0xC3, 0x80, 0x1E,
  0x78, 0x00, 0xE7, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0xF0, 0x7F, 0x0F, 0x87, 0xF0, 0xF8, 0x7F, 0x0F,
  0x87, 0xF0, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x77, 0x00, 0x07, 0x70,
  0x00, 0xF7, 0x00, 0x0F, 0x78, 0x00, 0xE3, 0x80, 0x1E, 0x3C, 0x03, 0xC1,
  0xF0, 0x7C, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0x70, 0x01, 0xF3, 0x80, 0x1F,
  0x1C, 0x01, 0xF0, 0xE0, 0x1F, 0x07, 0x00, 0x70, 0x38, 0x03, 0x01, 0xC0,
  0x10, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3E, 0x07,
  0xC7, 0x80, 0x79, 0xE0, 0x07, 0x38, 0x00, 0xF1, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x07, 0xE7, 0x80, 0x3C,
  0x70, 0x03, 0xC4, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC8, 0x00, 0x7B, 0x80, 0x0F, 0xF8, 0x03, 0xCF,
  0x81, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0xC0, 0x01,
  0xEF, 0x00, 0x07, 0x3C, 0x00, 0x38, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x0F,
  0x00, 0x38, 0x3C, 0x00, 0xE0, 0xF0, 0x07, 0x03, 0xC0, 0x3C, 0x0F, 0x00,
  0xE0, 0x3C, 0x07, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0xE0, 0x0F, 0x07, 0x00,
  0x3C, 0x1C, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0xFC, 0x07, 0x3F, 0xE0,
  0xEF, 0xFF, 0x1F, 0x03, 0xE3, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC8, 0x00, 0x7B,
  0x80, 0x1E, 0xF8, 0x03, 0xCF, 0x81, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0xFE, 0x0F, 0x3F, 0xF1, 0xFF, 0xFF, 0x3B,
  0x03, 0xF7, 0xC0, 0x1E, 0xF0, 0x01, 0xDC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7B, 0x80, 0x0E, 0x78,
  0x03, 0xC7, 0x81, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1D, 0xC0,
  0x07, 0xB8, 0x00, 0xE7, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC3, 0xE0, 0x7E, 0x3C, 0x01, 0xE7, 0x80, 0x0E, 0x78,
  0x00, 0xE7, 0x80, 0x0E, 0x78, 0x00, 0xE3, 0x80, 0x0E, 0x3C, 0x01, 0xC1,
  0xE0, 0x7C, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x83, 0xE0, 0x7C,
  0x78, 0x01, 0xE7, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x77, 0x00, 0x0F, 0x78, 0x01, 0xE3, 0xE0,
  0x7E, 0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0xFF, 0xFC, 0x3E, 0x07, 0xC7, 0x80, 0x39, 0xE0, 0x03, 0xB8,
  0x00, 0x77, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xDF, 0x03, 0xF9, 0xFF, 0xEE, 0x1F,
  0xF9, 0xC0, 0xFC, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7B, 0xFF, 0xFF, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0x7C, 0x3C, 0x7E,
  0x7E, 0x7E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0x70, 0x70,
  0xE0, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00,
  0x38, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0E,
  0x00, 0x02, 0x00, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8,
  0x3E, 0x78, 0x07, 0x9C, 0x00, 0xFF, 0x00, 0x3C, 0x80, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x07, 0xC0, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC3, 0x80, 0x38, 0xE0, 0x07,
  0x9C, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x79, 0xDC, 0x1F, 0x9F, 0x87, 0xFB,
  0xF0, 0xE1, 0xFE, 0x3C, 0x1F, 0xC7, 0x01, 0xF8, 0xE0, 0x3F, 0x1C, 0x07,
  0xE3, 0x80, 0xFC, 0x70, 0x1F, 0x8E, 0x03, 0xF1, 0xC0, 0x7E, 0x38, 0x1F,
  0xC7, 0x83, 0xF8, 0x7F, 0xBF, 0x0F, 0xF7, 0xE0, 0xFC, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00,
  0x1C, 0xF0, 0x00, 0x71, 0xC0, 0x03, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x38,
  0x78, 0x00, 0xE0, 0xE0, 0x07, 0x83, 0x80, 0x1C, 0x0F, 0x00, 0x70, 0x1C,
  0x03, 0xC0, 0x70, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x70, 0x03, 0xC3, 0xC0, 0x07, 0x0F, 0x00,
  0x1E, 0x38, 0x00, 0x79, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0xDC, 0x00, 0x0F,
  0xF0, 0x00, 0x1C, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0x80, 0x7C,
  0xE0, 0x07, 0xB8, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8,
  0x00, 0xEE, 0x00, 0x7B, 0x80, 0x1C, 0xE0, 0x0E, 0x3F, 0xFF, 0x0F, 0xFF,
  0x83, 0xFF, 0xFC, 0xE0, 0x0F, 0xB8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x03, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0x83, 0xC3, 0xC0, 0x3C, 0xF0, 0x03, 0xDE,
  0x00, 0x3B, 0x80, 0x08, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x02, 0x1E, 0x00, 0x3B, 0xC0, 0x0F, 0x3C, 0x03, 0xC3, 0xE0, 0xF8, 0x7F,
  0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE3, 0x80, 0xFC, 0xE0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0E,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1E,
  0xE0, 0x0F, 0x38, 0x0F, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x0F, 0x83, 0xE3, 0xC0, 0x1E, 0x78, 0x03, 0xDE, 0x00,
  0x3B, 0xC0, 0x04, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xF0, 0x01,
  0xDE, 0x00, 0x39, 0xC0, 0x0F, 0x3C, 0x03, 0xE3, 0xE0, 0xFC, 0x7F, 0xFB,
  0x87, 0xFE, 0x70, 0x3F, 0x0E, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0E, 0x78, 0x0F, 0x3E, 0x0F,
  0x0F, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0x00, 0xF0, 0x00, 0xF7, 0x80, 0x0F,
  0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x78, 0x07, 0x83, 0xC0,
  0x78, 0x1E, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x87, 0xC0, 0x3C, 0x3C, 0x01,
  0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x7B, 0xF0, 0x03, 0xDF, 0xC0, 0x1F, 0xDE,
  0x00, 0xFE, 0x78, 0x07, 0xE1, 0xE0, 0x3E, 0x0F, 0x01, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0x78, 0x07, 0x83, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x03,
  0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x80,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x1D, 0xFB, 0x83, 0xBF, 0x70, 0x67, 0xE7, 0x1C, 0xFC,
  0xE3, 0x9F, 0x9C, 0xE3, 0xF1, 0xDC, 0x7E, 0x3B, 0x0F, 0xC3, 0xE1, 0xF8,
  0x7C, 0x3F, 0x0F, 0x07, 0xE0, 0xE0, 0xFC, 0x18, 0x1F, 0x81, 0x03, 0xF0,
  0x20, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0E, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFB, 0x80,
  0x7E, 0xF0, 0x1F, 0x9C, 0x07, 0xE7, 0x81, 0xF8, 0xE0, 0x7E, 0x38, 0x1F,
  0x8F, 0x07, 0xE1, 0xC1, 0xF8, 0x78, 0x7E, 0x0E, 0x1F, 0x83, 0x87, 0xE0,
  0xF1, 0xF8, 0x1C, 0x7E, 0x07, 0x9F, 0x80, 0xE7, 0xE0, 0x39, 0xF8, 0x0F,
  0x7E, 0x01, 0xDF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x81, 0xF0, 0x7C, 0x3C, 0x03, 0xC3, 0x80, 0x1E, 0x78, 0x00, 0xE7, 0x80,
  0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x77, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x80, 0x0F,
  0x78, 0x00, 0xE3, 0x80, 0x1E, 0x3C, 0x03, 0xC1, 0xF0, 0x7C, 0x0F, 0xFF,
  0x80, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF,
  0xF3, 0x80, 0x3E, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x03, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xF0, 0x7C, 0x3C, 0x03,
  0xC3, 0x80, 0x1E, 0x78, 0x00, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xF7, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x77,
  0x00, 0x0F, 0x70, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xE3, 0x80, 0x1E,
  0x3C, 0x03, 0xC1, 0xF0, 0x7C, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x01, 0xFC,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x70, 0x07, 0xCE, 0x00, 0x3D, 0xC0, 0x07, 0xB8, 0x00, 0x77, 0x00,
  0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xEE, 0x00,
  0x3D, 0xC0, 0x1F, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1C, 0x1E,
  0x03, 0x81, 0xC0, 0x70, 0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x78, 0x38, 0x07,
  0x87, 0x00, 0xF0, 0xE0, 0x0F, 0x1C, 0x00, 0xE3, 0x80, 0x1E, 0x70, 0x01,
  0xEE, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xE0,
  0x3E, 0x7C, 0x01, 0xF7, 0x80, 0x06, 0x70, 0x00, 0x47, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x20, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xE7, 0xE0, 0x7E, 0x3F, 0xFF, 0xC0, 0xFF,
  0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x3D, 0xC0, 0x0F, 0x78, 0x03,
  0x8F, 0x03, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x78,
  0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x78,
  0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xC0, 0x3C, 0x07,
  0x00, 0x70, 0x1C, 0x01, 0xC0, 0xF0, 0x07, 0x83, 0x80, 0x0E, 0x0E, 0x00,
  0x38, 0x78, 0x00, 0xF1, 0xC0, 0x03, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C,
  0xF0, 0x00, 0x7B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x77,
  0x00, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00,
  0x01, 0xDC, 0x00, 0x07, 0x70, 0x78, 0x1D, 0xC1, 0xF0, 0xE7, 0x07, 0xC3,
  0x9C, 0x1F, 0x0E, 0x70, 0xEC, 0x39, 0xC3, 0xB0, 0xE3, 0x8E, 0xE3, 0x8E,
  0x33, 0x8E, 0x38, 0xCE, 0x38, 0xE7, 0x18, 0xE3, 0x9C, 0x73, 0x8E, 0x71,
  0xCE, 0x39, 0x87, 0x38, 0xEE, 0x1C, 0xC3, 0xB8, 0x33, 0x0E, 0xE0, 0xFC,
  0x3B, 0x83, 0xF0, 0xFC, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0x7C, 0x1F,
  0x01, 0xF0, 0x78, 0x00, 0x3C, 0x70, 0x00, 0x70, 0xF0, 0x01, 0xE0, 0xF0,
  0x07, 0x81, 0xE0, 0x0E, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x70, 0x03, 0xC1,
  0xE0, 0x03, 0xC7, 0x80, 0x07, 0x8E, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xDE, 0x00, 0x07, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0x38, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x1E,
  0x00, 0xF0, 0x78, 0x00, 0xE0, 0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xEF, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0xF1, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF0, 0x07, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x0E, 0x1E, 0x00, 0x1E, 0x38,
  0x00, 0x1C, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00,
  0x39, 0xE0, 0x03, 0xC7, 0x00, 0x1C, 0x3C, 0x01, 0xE0, 0xE0, 0x0E, 0x07,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80, 0x0E, 0x38,
  0x00, 0x7B, 0xC0, 0x01, 0xDC, 0x00, 0x0F, 0x20, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x23, 0x8F, 0x1C, 0x38, 0xE1, 0xC2,
  0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0x81, 0xF0, 0xF0, 0x0F,
  0x02, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0xFF,
  0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xF8, 0x07, 0x8E, 0x00, 0x78, 0xE0,
  0x07, 0x8E, 0x00, 0x78, 0xE0, 0x0F, 0x8F, 0x81, 0xB8, 0x7F, 0xFB, 0xF3,
  0xFF, 0x3F, 0x0F, 0xC1, 0xF0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x7E, 0x0E, 0x7F, 0xE3, 0xBF, 0xFC, 0xEC, 0x1F, 0x3C, 0x01,
  0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xBC, 0x01, 0xEE, 0xC1, 0xF3, 0xBF, 0xFC, 0xE7, 0xFE, 0x38, 0x7E,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x1E, 0x3C, 0x03,
  0xDE, 0x00, 0x67, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x11, 0xE0,
  0x07, 0x3C, 0x03, 0xCF, 0x81, 0xE1, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x7E,
  0x3C, 0x3F, 0xE7, 0x8F, 0xFE, 0xF3, 0xE0, 0x7E, 0x78, 0x07, 0xDE, 0x00,
  0x7B, 0x80, 0x0F, 0x70, 0x01, 0xEE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0x7B, 0x80, 0x0F, 0x78, 0x01,
  0xE7, 0x80, 0x7C, 0xF8, 0x1F, 0x8F, 0xFE, 0xF0, 0xFF, 0x9E, 0x07, 0xE3,
  0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0x80,
  0x3C, 0xE0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x0C, 0x78, 0x03, 0xC7, 0xC0, 0xF8, 0x7F, 0xFE, 0x07, 0xFF,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x3F,
  0x60, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x3C, 0x0F, 0x87, 0x80, 0x78, 0x78,
  0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x80, 0x38, 0x78, 0x07, 0x83,
  0xC0, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x70, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xF8, 0x01, 0xF7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0xFF, 0xE0, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0xF8, 0x39, 0xFF, 0x1D, 0xFF,
  0xCE, 0xC1, 0xF7, 0x80, 0x7B, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF7, 0xFF, 0xEF,
  0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xEF, 0xFF, 0x9F, 0xFF,
  0x3F, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x3E, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0xF0, 0x1E, 0x0F,
  0x03, 0xC0, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF3, 0xE0, 0x0F, 0x7C, 0x00,
  0xFF, 0xE0, 0x0F, 0xEE, 0x00, 0xFC, 0xF0, 0x0F, 0x87, 0x80, 0xF0, 0x3C,
  0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00,
  0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x1F, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE3, 0xC3, 0xCE, 0x7E, 0x7E, 0xEF, 0xEF, 0xFF, 0x0E, 0x8F,
  0xF0, 0xF0, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0, 0x70,
  0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07,
  0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x7E, 0x07, 0x07, 0xE0,
  0x70, 0x7E, 0x07, 0x07, 0xE0, 0x70, 0x70, 0xE1, 0xF0, 0x73, 0xFE, 0x3B,
  0xFF, 0x9D, 0x83, 0xEF, 0x00, 0xF7, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x38, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0x07, 0xC7, 0x80, 0x38, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xFC, 0x00, 0x73, 0x80, 0x0E, 0x78, 0x03, 0x87, 0xC1, 0xF0, 0x7F,
  0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0xE1, 0xF8, 0x39, 0xFF, 0x8E, 0xFF,
  0xF3, 0xB0, 0x7C, 0xF0, 0x07, 0xB8, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0E, 0xF0, 0x07, 0xBB, 0x07, 0xCE, 0xFF,
  0xF3, 0x9F, 0xF8, 0xE1, 0xF8, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xF1, 0xE1, 0xFF, 0x3C, 0x7F, 0xF7, 0x9F, 0x03, 0xF3, 0xC0, 0x3E,
  0xF0, 0x03, 0xDC, 0x00, 0x7B, 0x80, 0x0F, 0x70, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0x7B,
  0xC0, 0x0F, 0x3C, 0x03, 0xE7, 0xC0, 0xFC, 0x7F, 0xF7, 0x87, 0xFC, 0xF0,
  0x3F, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0xFF, 0xC3, 0xFF,
  0xFC, 0xFF, 0xFF, 0xDF, 0xF0, 0x3D, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xC0, 0x03, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xF8, 0xF0, 0x1F, 0x78,
  0x01, 0x9C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x1D,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x01, 0xF7, 0xFF, 0xF8, 0x7F, 0xFC, 0x07,
  0xF8, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xBE, 0x0F, 0xDF, 0xFD, 0xE7, 0xFE, 0xF0, 0xFC, 0x78,
  0xE0, 0x00, 0xFC, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x80, 0x38,
  0x70, 0x07, 0x0E, 0x01, 0xE1, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xE0,
  0x78, 0x38, 0x07, 0x07, 0x00, 0xE1, 0xC0, 0x1E, 0x38, 0x01, 0xC7, 0x00,
  0x39, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0xE0, 0x78, 0x1F, 0x81, 0xE0, 0x76, 0x07, 0xC1, 0xDC, 0x1B,
  0x07, 0x70, 0x6C, 0x1D, 0xC3, 0xB0, 0x77, 0x0E, 0xC1, 0x9C, 0x33, 0x86,
  0x30, 0xCE, 0x38, 0xC3, 0x18, 0xE3, 0x9C, 0x63, 0x8E, 0x71, 0x8E, 0x39,
  0x87, 0x30, 0xE6, 0x1C, 0xC3, 0x98, 0x33, 0x06, 0xE0, 0xDC, 0x1B, 0x83,
  0x70, 0x6C, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xC0, 0x78, 0x1F, 0x01, 0xE0,
  0x78, 0x00, 0xF3, 0xC0, 0x1E, 0x1C, 0x03, 0xC1, 0xE0, 0x38, 0x0F, 0x07,
  0x80, 0x78, 0xF0, 0x03, 0x8E, 0x00, 0x3D, 0xC0, 0x01, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3D, 0xE0, 0x07,
  0x9E, 0x00, 0x70, 0xF0, 0x0E, 0x07, 0x81, 0xE0, 0x3C, 0x3C, 0x03, 0xC3,
  0x80, 0x1E, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0x77, 0x00, 0x07, 0x78, 0x00,
  0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0xC0, 0x1C, 0x1C, 0x03, 0xC1, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x07, 0x07, 0x00, 0x70, 0xF0, 0x07,
  0x8E, 0x00, 0x38, 0xE0, 0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFC, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x01, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xFF, 0x00, 0x7F,
  0x03, 0xFF, 0x07, 0x80, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0,
  0x0F, 0x00, 0x31, 0xFC, 0x03, 0x3F, 0xC0, 0x73, 0x9E, 0x07, 0x70, 0xF0,
  0x67, 0x07, 0x8E, 0x60, 0x3F, 0xEE, 0x01, 0xFC, 0x60, 0x0F, 0x80,
};

const GFXglyph IBMPlexMono_Regular41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 6, 29, 25, 9, -29 },
  { 23, 11, 11, 25, 7, -30 },
  { 39, 23, 29, 25, 1, -29 },
  { 123, 21, 37, 25, 2, -33 },
  { 221, 23, 29, 25, 1, -29 },
  { 305, 22, 29, 25, 1, -29 },
  { 385, 3, 11, 25, 11, -30 },
  { 390, 12, 37, 25, 8, -31 },
  { 446, 12, 37, 25, 4, -31 },
  { 502, 21, 20, 25, 2, -23 },
  { 555, 19, 21, 25, 3, -23 },
  { 605, 8, 12, 25, 8, -6 },
  { 617, 12, 3, 25, 6, -14 },
  { 622, 6, 5, 25, 9, -5 },
  { 626, 17, 37, 25, 4, -31 },
  { 705, 20, 29, 25, 2, -29 },
  { 778, 21, 29, 25, 2, -29 },
  { 855, 19, 29, 25, 3, -29 },
  { 924, 19, 29, 25, 2, -29 },
  { 993, 22, 29, 25, 1, -29 },
  { 1073, 19, 29, 25, 3, -29 },
  { 1142, 19, 29, 25, 3, -29 },
  { 1211, 19, 29, 25, 3, -29 },
  { 1280, 20, 29, 25, 2, -29 },
  { 1353, 19, 29, 25, 3, -29 },
  { 1422, 6, 21, 25, 9, -21 },
  { 1438, 8, 27, 25, 8, -21 },
  { 1465, 18, 24, 25, 3, -25 },
  { 1519, 19, 11, 25, 3, -18 },
  { 1546, 18, 24, 25, 3, -25 },
  { 1600, 18, 29, 25, 3, -29 },
  { 1666, 19, 34, 25, 3, -29 },
  { 1747, 22, 29, 25, 1, -29 },
  { 1827, 18, 29, 25, 4, -29 },
  { 1893, 19, 29, 25, 3, -29 },
  { 1962, 18, 29, 25, 4, -29 },
  { 2028, 17, 29, 25, 4, -29 },
  { 2090, 18, 29, 25, 4, -29 },
  { 2156, 19, 29, 25, 2, -29 },
  { 2225, 18, 29, 25, 3, -29 },
  { 2291, 18, 29, 25, 3, -29 },
  { 2357, 17, 29, 25, 3, -29 },
  { 2419, 21, 29, 25, 3, -29 },
  { 2496, 17, 29, 25, 5, -29 },
  { 2558, 19, 29, 25, 3, -29 },
  { 2627, 18, 29, 25, 3, -29 },
  { 2693, 20, 29, 25, 2, -29 },
  { 2766, 18, 29, 25, 4, -29 },
  { 2832, 20, 36, 25, 2, -29 },
  { 2922, 19, 29, 25, 4, -29 },
  { 2991, 20, 29, 25, 2, -29 },
  { 3064, 23, 29, 25, 1, -29 },
  { 3148, 18, 29, 25, 3, -29 },
  { 3214, 22, 29, 25, 1, -29 },
  { 3294, 22, 29, 25, 1, -29 },
  { 3374, 23, 29, 25, 1, -29 },
  { 3458, 23, 29, 25, 1, -29 },
  { 3542, 21, 29, 25, 2, -29 },
  { 3619, 12, 37, 25, 9, -31 },
  { 3675, 17, 37, 25, 4, -31 },
  { 3754, 11, 37, 25, 4, -31 },
  { 3805, 21, 17, 25, 2, -29 },
  { 3850, 20, 3, 25, 2, 4 },
  { 3858, 6, 8, 25, 8, -32 },
  { 3864, 20, 21, 25, 3, -21 },
  { 3917, 18, 30, 25, 4, -30 },
  { 3985, 18, 21, 25, 3, -21 },
  { 4033, 19, 30, 25, 2, -30 },
  { 4105, 19, 21, 25, 3, -21 },
  { 4155, 19, 30, 25, 3, -30 },
  { 4227, 20, 32, 25, 3, -24 },
  { 4307, 17, 30, 25, 4, -30 },
  { 4371, 18, 31, 25, 4, -31 },
  { 4441, 15, 39, 25, 4, -31 },
  { 4515, 20, 30, 25, 4, -30 },
  { 4590, 18, 30, 25, 3, -30 },
  { 4658, 20, 21, 25, 2, -21 },
  { 4711, 17, 21, 25, 4, -21 },
  { 4756, 19, 21, 25, 3, -21 },
  { 4806, 18, 29, 25, 4, -21 },
  { 4872, 19, 29, 25, 2, -21 },
  { 4941, 20, 21, 25, 3, -21 },
  { 4994, 18, 21, 25, 3, -21 },
  { 5042, 20, 29, 25, 2, -29 },
  { 5115, 17, 21, 25, 4, -21 },
  { 5160, 19, 21, 25, 3, -21 },
  { 5210, 22, 21, 25, 1, -21 },
  { 5268, 20, 21, 25, 2, -21 },
  { 5321, 20, 29, 25, 2, -21 },
  { 5394, 18, 21, 25, 3, -21 },
  { 5442, 16, 37, 25, 4, -31 },
  { 5516, 3, 37, 25, 11, -31 },
  { 5530, 16, 37, 25, 4, -31 },
  { 5604, 20, 9, 25, 2, -17 },
};

const GFXfont IBMPlexMono_Regular41pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular41pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular41pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _IBMPLEXMONO_REGULAR41PT7B_H_
