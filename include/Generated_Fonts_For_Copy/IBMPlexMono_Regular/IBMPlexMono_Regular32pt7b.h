#ifndef _IBMPLEXMONO_REGULAR32PT7B_H_
#define _IBMPLEXMONO_REGULAR32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular32pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x71, 0x8C, 0x42, 0x10, 0x80, 0x00,
  0x1D, 0xFF, 0xB8, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7,
  0x03, 0x8E, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x0C, 0x30, 0x03, 0x0C, 0x01,
  0xC7, 0x00, 0x71, 0xC1, 0xF8, 0x7F, 0x7E, 0x1F, 0xC1, 0x86, 0x00, 0x63,
  0x80, 0x38, 0xE0, 0x0E, 0x30, 0x3F, 0x0F, 0xEF, 0xC3, 0xF8, 0x30, 0xC0,
  0x1C, 0x70, 0x07, 0x1C, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x60, 0x06,
  0x38, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F, 0xF0, 0x3F, 0xFC,
  0x79, 0x9E, 0x71, 0x8F, 0xE1, 0x84, 0xE1, 0x80, 0xE1, 0x80, 0x61, 0x80,
  0x71, 0x80, 0x3F, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x01, 0x9E, 0x01, 0x8E,
  0x01, 0x87, 0x01, 0x87, 0x01, 0x87, 0x41, 0x86, 0xE1, 0x8E, 0x79, 0x9E,
  0x3F, 0xF8, 0x0F, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3E, 0x01,
  0xDF, 0xC0, 0x6E, 0x38, 0x33, 0x06, 0x1C, 0xC1, 0x86, 0x30, 0x63, 0x8C,
  0x18, 0xC3, 0x06, 0x70, 0xE3, 0x98, 0x1F, 0xCE, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x06, 0x7F, 0x03, 0x18, 0xE0, 0xCC, 0x18, 0x63, 0x07, 0x38, 0xC1,
  0xCC, 0x30, 0x77, 0x0C, 0x19, 0x81, 0x8E, 0xE0, 0x7F, 0x30, 0x07, 0x80,
  0x07, 0xC0, 0x0F, 0xF8, 0x07, 0x1E, 0x07, 0x06, 0x03, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x07, 0x83, 0xE7,
  0xE1, 0xF7, 0x38, 0xC7, 0x0E, 0x63, 0x83, 0xB1, 0x80, 0xF8, 0xC0, 0x3C,
  0x70, 0x1E, 0x38, 0x0B, 0x0E, 0x0D, 0xC3, 0xFC, 0x70, 0xFC, 0x1C, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0x83, 0x03, 0x03, 0x03, 0x81, 0x81, 0x80, 0xC0,
  0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x1C, 0x06, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0x70, 0xF0,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x70, 0x18, 0x0C, 0x07, 0x03, 0x83, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x0E, 0x19, 0xF7,
  0x7F, 0x7F, 0xFC, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0xDC, 0x00, 0xEE, 0x00,
  0xE3, 0x80, 0x60, 0xE0, 0x70, 0x30, 0x10, 0x10, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x7B, 0xDC, 0xEF, 0x73, 0x98, 0xC0, 0xFF, 0xFF, 0xC0, 0x77,
  0xFE, 0xE0, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x00,
  0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xDC, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC7, 0x0F, 0x8F, 0x1F, 0x1E, 0x3E, 0x38,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0E, 0xC0, 0x19, 0xC0, 0x71,
  0xC1, 0xC1, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x1D, 0xC0,
  0x39, 0xC0, 0x71, 0xC0, 0xE1, 0xC0, 0xC1, 0xC0, 0x81, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x7F, 0xFF,
  0x7F, 0xFF, 0x0F, 0xC0, 0x7F, 0xE1, 0xE0, 0xE3, 0x80, 0xEE, 0x01, 0xC4,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x7F, 0xE1,
  0xE1, 0xE7, 0x80, 0xE2, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x0E, 0x80, 0x1B, 0x80, 0x77, 0x81, 0xC7, 0xFF, 0x03,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1B, 0x80, 0x1D,
  0xC0, 0x1C, 0xE0, 0x0C, 0x70, 0x0E, 0x38, 0x0E, 0x1C, 0x06, 0x0E, 0x07,
  0x07, 0x03, 0x03, 0x83, 0x81, 0xC3, 0x80, 0xE1, 0x80, 0x71, 0xC0, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x3F, 0xFC, 0x7F, 0xF8, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x73, 0xE0, 0xDF, 0xF1, 0xE0, 0xF3, 0x80, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x40, 0x1F, 0xC0,
  0x73, 0xC1, 0xE3, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x73, 0xE0,
  0xDF, 0xF3, 0xE0, 0xF7, 0x80, 0xEE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0E, 0xC0, 0x1D, 0xC0, 0x71, 0xC1, 0xE1, 0xFF, 0x80, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x6C, 0x01, 0xD8, 0x03,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xE0,
  0xF3, 0x80, 0xEE, 0x00, 0xFC, 0x01, 0xD8, 0x03, 0xB8, 0x06, 0x38, 0x38,
  0x3F, 0xE0, 0x7F, 0xC1, 0xC1, 0xE6, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3B, 0xC1, 0xE3, 0xFF, 0x81, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xEE, 0x00, 0xDC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1D, 0xC0, 0x7B, 0xC1, 0xF3,
  0xFE, 0xE1, 0xF1, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3B, 0xFF, 0x70, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3D, 0xEE, 0x77, 0xB9, 0xCC, 0x60, 0x00, 0x08, 0x00, 0xC0,
  0x1E, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x06, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xC0, 0x02, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0x0E,
  0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x06, 0x00, 0x20,
  0x00, 0x0F, 0xE0, 0x7F, 0xC3, 0x83, 0x9C, 0x07, 0x60, 0x1E, 0x80, 0x30,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xE0, 0x3F, 0x00, 0xF0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0xE1, 0x80, 0xE6,
  0x00, 0xCC, 0x01, 0xD8, 0x7B, 0xF1, 0xFB, 0xC3, 0x0F, 0x8E, 0x1F, 0x18,
  0x1E, 0x30, 0x3C, 0x60, 0x78, 0xC0, 0xF1, 0x81, 0xE3, 0x07, 0xC7, 0x0F,
  0x87, 0xEF, 0x87, 0xDB, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1E,
  0x00, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x6C, 0x00, 0x77, 0x00, 0x39, 0x80, 0x18, 0xC0, 0x1C, 0x70, 0x0E, 0x38,
  0x06, 0x0C, 0x03, 0x07, 0x03, 0x83, 0x81, 0x80, 0xC0, 0xFF, 0xF0, 0xFF,
  0xF8, 0x70, 0x0C, 0x30, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCC, 0x00, 0x6E,
  0x00, 0x3F, 0x00, 0x1C, 0xFF, 0xC3, 0xFF, 0xCE, 0x07, 0xB8, 0x0E, 0xE0,
  0x1B, 0x80, 0x7E, 0x01, 0xF8, 0x06, 0xE0, 0x3B, 0x81, 0xCF, 0xFE, 0x3F,
  0xFC, 0xE0, 0x3B, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x0E, 0xFF, 0xF3, 0xFF, 0x80, 0x07, 0xE0, 0x3F, 0xF0, 0xF0,
  0xF1, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x08, 0xE0, 0x1C, 0xE0, 0x39, 0xE1, 0xE1, 0xFF, 0x80, 0xFC,
  0x00, 0xFF, 0x83, 0xFF, 0x8E, 0x07, 0x38, 0x0E, 0xE0, 0x1B, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x6E, 0x03, 0xB8, 0x1C,
  0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xBF,
  0xFE, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0xFF, 0xBF, 0xFE, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0xE0,
  0x3F, 0xF0, 0xF0, 0xF3, 0x80, 0xE7, 0x00, 0xFC, 0x01, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x0F, 0xFE, 0x1F, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0E, 0xE0, 0x1D, 0xC0, 0x79, 0xC1, 0xF1,
  0xFE, 0xE1, 0xF9, 0xC0, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xF0, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8,
  0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x1F, 0x01, 0xDC, 0x0E, 0xF0, 0xE3, 0xFE, 0x07, 0xE0, 0xC0, 0x0E,
  0xC0, 0x1C, 0xC0, 0x38, 0xC0, 0x70, 0xC0, 0xE0, 0xC1, 0xE0, 0xC1, 0xC0,
  0xC3, 0x80, 0xC7, 0x00, 0xCF, 0x00, 0xDF, 0x00, 0xFB, 0x80, 0xFB, 0x80,
  0xF1, 0xC0, 0xE0, 0xE0, 0xC0, 0xE0, 0xC0, 0x70, 0xC0, 0x38, 0xC0, 0x38,
  0xC0, 0x1C, 0xC0, 0x1E, 0xC0, 0x0F, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0xC3, 0x7D, 0x8E, 0xFB, 0x19, 0xF7, 0x33, 0xE6, 0xC7, 0xCF,
  0x8F, 0x8F, 0x1F, 0x1C, 0x3E, 0x18, 0x7C, 0x20, 0xF8, 0x41, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xC0,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xD8, 0x1F, 0x70, 0x7D, 0xC1,
  0xF3, 0x07, 0xCE, 0x1F, 0x18, 0x7C, 0x71, 0xF1, 0xC7, 0xC3, 0x9F, 0x0E,
  0x7C, 0x19, 0xF0, 0x77, 0xC0, 0xDF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0,
  0x7F, 0x00, 0xF0, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x00,
  0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0E, 0xC0,
  0x19, 0xC0, 0x71, 0xC1, 0xC1, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0xE3, 0xFF,
  0xEE, 0x03, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xFF, 0xFF, 0xBF, 0xF8, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00,
  0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xDC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0E, 0xC0, 0x19, 0xC0, 0x71,
  0xC1, 0xC1, 0xFF, 0x01, 0xFC, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0xF8, 0x03, 0xF0, 0xFF, 0xE1, 0xFF, 0xF3, 0x80, 0xE7, 0x00, 0xEE, 0x01,
  0xDC, 0x01, 0xB8, 0x03, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x73, 0xFF, 0xE7,
  0xFF, 0x0E, 0x38, 0x1C, 0x38, 0x38, 0x70, 0x70, 0x70, 0xE0, 0x61, 0xC0,
  0xE3, 0x80, 0xE7, 0x01, 0xCE, 0x01, 0xDC, 0x03, 0xC0, 0x07, 0xF0, 0x1F,
  0xFC, 0x3C, 0x1F, 0x38, 0x07, 0x70, 0x02, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x60, 0x07, 0xF0, 0x07, 0x7C,
  0x1E, 0x1F, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1B, 0x80, 0x6E,
  0x03, 0x9C, 0x1C, 0x3F, 0xF0, 0x7F, 0x00, 0xE0, 0x03, 0xB0, 0x01, 0xDC,
  0x00, 0xCE, 0x00, 0xE3, 0x00, 0x71, 0xC0, 0x30, 0xE0, 0x38, 0x70, 0x1C,
  0x18, 0x0C, 0x0E, 0x06, 0x07, 0x07, 0x01, 0x83, 0x80, 0xE1, 0x80, 0x71,
  0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x07, 0x30, 0x03, 0xB8, 0x00, 0xD8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3B, 0x00, 0x1D, 0x87, 0x0E, 0xC3, 0x86, 0x61,
  0xE3, 0x31, 0xB1, 0x98, 0xD8, 0xCC, 0x6C, 0x66, 0x37, 0x33, 0xB9, 0x99,
  0xD8, 0xCC, 0xEC, 0x66, 0x76, 0x33, 0x1B, 0x1F, 0x8F, 0x87, 0xC7, 0x83,
  0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x03, 0xB8, 0x03, 0x8E, 0x01, 0xC7,
  0x01, 0xC1, 0xC1, 0xC0, 0x70, 0xE0, 0x38, 0xE0, 0x0E, 0x60, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3B, 0x80, 0x1C,
  0xE0, 0x1C, 0x70, 0x1C, 0x1C, 0x0E, 0x07, 0x0E, 0x03, 0x8E, 0x00, 0xE7,
  0x00, 0x77, 0x00, 0x1C, 0xE0, 0x03, 0xF8, 0x00, 0xE7, 0x00, 0x70, 0xE0,
  0x1C, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xC0, 0x38, 0x60, 0x0E, 0x38,
  0x01, 0xDC, 0x00, 0x77, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xF0, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30, 0xFF, 0xFF, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0xEE,
  0x00, 0x63, 0x80, 0x71, 0xC0, 0x30, 0x70, 0x38, 0x18, 0x38, 0x0E, 0x18,
  0x03, 0x1C, 0x01, 0xCC, 0x00, 0x6E, 0x00, 0x38, 0xFF, 0xFF, 0xFF, 0xFC,
  0x67, 0x1C, 0x63, 0x88, 0x0F, 0xC0, 0x3F, 0xF0, 0x70, 0x70, 0x60, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0x18,
  0xE0, 0x18, 0xE0, 0x18, 0xE0, 0x18, 0xE0, 0x38, 0x70, 0x78, 0x7F, 0xDF,
  0x1F, 0x0F, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x39, 0xF0, 0xEF, 0xF3, 0xE1, 0xEE, 0x03, 0xB8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x3B, 0xE1, 0xEE, 0xFF, 0x39, 0xF0, 0x0F, 0xC0, 0x7F, 0xC3,
  0x87, 0x9C, 0x06, 0xE0, 0x13, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x11, 0xC0, 0x77, 0x87, 0x8F, 0xFC,
  0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC3, 0xE3, 0x3F, 0xCD, 0xE0, 0xB7, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0x70, 0x1D, 0xE0, 0xB3, 0xFC, 0xC3, 0xE3, 0x07, 0xE0, 0x3F, 0xE0,
  0xF0, 0xE3, 0x80, 0xE6, 0x00, 0xCC, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x8E, 0x01, 0xCF, 0x0F,
  0x0F, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xFC, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x1F, 0xFF, 0xBF,
  0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x07, 0xD0, 0x1F, 0xF0, 0x38, 0x38, 0x70,
  0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x38, 0x38, 0x1F,
  0xF0, 0x0F, 0xC0, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x1F,
  0xFE, 0x60, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x0E, 0x7F,
  0xFC, 0x1F, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0xF8, 0xEF, 0xF7, 0xC3, 0xB8, 0x0F, 0xC0, 0x7E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xFF, 0xCF, 0xF8, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x0F,
  0xE0, 0x39, 0xC0, 0xE3, 0x83, 0x87, 0x0E, 0x0E, 0x38, 0x1C, 0xE0, 0x3B,
  0xC0, 0x7D, 0xC0, 0xF1, 0xC1, 0xC3, 0xC3, 0x83, 0x87, 0x03, 0x8E, 0x03,
  0x9C, 0x07, 0xB8, 0x07, 0x70, 0x07, 0xFF, 0x03, 0xFC, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF,
  0xCE, 0x3D, 0xBE, 0xFF, 0x8D, 0x3E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xF0,
  0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x87, 0x0F, 0x0E, 0x1E, 0x1C, 0x3C, 0x38,
  0x78, 0x70, 0xF0, 0xE1, 0xE1, 0xC3, 0xC3, 0x86, 0xE7, 0xC7, 0x7F, 0xBE,
  0x1D, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x18,
  0x07, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xDC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x76, 0x00,
  0xCE, 0x03, 0x8E, 0x0E, 0x0F, 0xF8, 0x07, 0xE0, 0xE7, 0xC3, 0xBF, 0xCF,
  0x87, 0xB8, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xEF, 0x87, 0xBB, 0xFC,
  0xE7, 0xC3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x0F, 0x8C, 0xFF, 0x37, 0x82, 0xDC, 0x07, 0xE0, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1D,
  0xC0, 0x77, 0x82, 0xCF, 0xF3, 0x0F, 0x8C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF, 0x1F, 0xFF, 0x7F, 0x07, 0x60,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0xF0, 0xE0, 0xF3, 0x80, 0x47,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x01, 0xF8, 0x00,
  0x38, 0x00, 0x74, 0x00, 0xEC, 0x01, 0xFE, 0x07, 0x1F, 0xFC, 0x0F, 0xE0,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1D, 0xC1, 0xE7, 0xF7, 0x1F, 0x38,
  0xE0, 0x0E, 0xC0, 0x1D, 0x80, 0x33, 0x80, 0xE3, 0x01, 0xC6, 0x03, 0x0E,
  0x0E, 0x0C, 0x1C, 0x18, 0x30, 0x38, 0xE0, 0x31, 0xC0, 0x63, 0x00, 0xEE,
  0x00, 0xD8, 0x01, 0xB0, 0x03, 0xE0, 0x03, 0x80, 0xC1, 0xC1, 0xE0, 0xE0,
  0xF8, 0x78, 0x7C, 0x2C, 0x36, 0x36, 0x3B, 0x1B, 0x19, 0x8D, 0x8C, 0xC6,
  0x46, 0x62, 0x33, 0x33, 0x19, 0x8D, 0x8C, 0xC6, 0xC6, 0x63, 0x61, 0x61,
  0xA0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x00, 0xF0, 0x0E, 0xE0,
  0x38, 0xE0, 0xE0, 0xE1, 0xC1, 0xC7, 0x01, 0xDC, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0x80, 0x0F, 0x80, 0x1B, 0x80, 0x77, 0x01, 0xC7, 0x07, 0x07, 0x0E,
  0x0F, 0x38, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x0E, 0x60, 0x0E, 0x70,
  0x0C, 0x30, 0x1C, 0x38, 0x18, 0x38, 0x38, 0x18, 0x30, 0x1C, 0x30, 0x0C,
  0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x7E,
  0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x3F, 0xC1, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x80, 0x38, 0x7F, 0x83, 0xFC, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0xFE, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x07, 0xF8, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x01, 0xFC, 0x0F, 0xE1, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x3F, 0xC1,
  0xFE, 0x00, 0x1C, 0x07, 0x7E, 0x06, 0x67, 0x06, 0xE3, 0x86, 0xC1, 0xCC,
  0xC0, 0xFC, 0xC0, 0x78,
};

const GFXglyph IBMPlexMono_Regular32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 22, 19, 7, -22 },
  { 15, 8, 9, 19, 6, -24 },
  { 24, 18, 22, 19, 1, -22 },
  { 74, 16, 28, 19, 2, -25 },
  { 130, 18, 22, 19, 1, -22 },
  { 180, 17, 22, 19, 1, -22 },
  { 227, 3, 9, 19, 8, -24 },
  { 231, 9, 28, 19, 7, -24 },
  { 263, 10, 28, 19, 3, -24 },
  { 298, 17, 16, 19, 1, -18 },
  { 332, 15, 16, 19, 2, -18 },
  { 362, 5, 9, 19, 7, -4 },
  { 368, 9, 2, 19, 5, -11 },
  { 371, 5, 4, 19, 7, -4 },
  { 374, 13, 28, 19, 3, -24 },
  { 420, 15, 22, 19, 2, -22 },
  { 462, 16, 22, 19, 2, -22 },
  { 506, 15, 22, 19, 2, -22 },
  { 548, 15, 22, 19, 2, -22 },
  { 590, 17, 22, 19, 1, -22 },
  { 637, 15, 22, 19, 2, -22 },
  { 679, 15, 22, 19, 2, -22 },
  { 721, 15, 22, 19, 2, -22 },
  { 763, 15, 22, 19, 2, -22 },
  { 805, 15, 22, 19, 2, -22 },
  { 847, 5, 17, 19, 7, -17 },
  { 858, 5, 22, 19, 7, -17 },
  { 872, 13, 19, 19, 3, -19 },
  { 903, 15, 8, 19, 2, -14 },
  { 918, 13, 19, 19, 3, -19 },
  { 949, 14, 22, 19, 2, -22 },
  { 988, 15, 26, 19, 2, -22 },
  { 1037, 17, 22, 19, 1, -22 },
  { 1084, 14, 22, 19, 3, -22 },
  { 1123, 15, 22, 19, 2, -22 },
  { 1165, 14, 22, 19, 3, -22 },
  { 1204, 14, 22, 19, 3, -22 },
  { 1243, 14, 22, 19, 3, -22 },
  { 1282, 15, 22, 19, 2, -22 },
  { 1324, 14, 22, 19, 3, -22 },
  { 1363, 14, 22, 19, 3, -22 },
  { 1402, 13, 22, 19, 2, -22 },
  { 1438, 16, 22, 19, 3, -22 },
  { 1482, 13, 22, 19, 4, -22 },
  { 1518, 15, 22, 19, 2, -22 },
  { 1560, 14, 22, 19, 3, -22 },
  { 1599, 15, 22, 19, 2, -22 },
  { 1641, 14, 22, 19, 3, -22 },
  { 1680, 15, 27, 19, 2, -22 },
  { 1731, 15, 22, 19, 3, -22 },
  { 1773, 16, 22, 19, 1, -22 },
  { 1817, 17, 22, 19, 1, -22 },
  { 1864, 14, 22, 19, 3, -22 },
  { 1903, 17, 22, 19, 1, -22 },
  { 1950, 17, 22, 19, 1, -22 },
  { 1997, 17, 22, 19, 1, -22 },
  { 2044, 18, 22, 19, 1, -22 },
  { 2094, 16, 22, 19, 2, -22 },
  { 2138, 9, 28, 19, 7, -24 },
  { 2170, 13, 28, 19, 3, -24 },
  { 2216, 9, 28, 19, 3, -24 },
  { 2248, 17, 13, 19, 1, -22 },
  { 2276, 15, 2, 19, 2, 3 },
  { 2280, 5, 6, 19, 6, -25 },
  { 2284, 16, 17, 19, 2, -17 },
  { 2318, 14, 24, 19, 3, -24 },
  { 2360, 14, 17, 19, 3, -17 },
  { 2390, 14, 24, 19, 2, -24 },
  { 2432, 15, 17, 19, 2, -17 },
  { 2464, 15, 24, 19, 2, -24 },
  { 2509, 16, 25, 19, 2, -19 },
  { 2559, 13, 24, 19, 3, -24 },
  { 2598, 14, 24, 19, 3, -24 },
  { 2640, 12, 30, 19, 3, -24 },
  { 2685, 15, 24, 19, 3, -24 },
  { 2730, 14, 24, 19, 3, -24 },
  { 2772, 15, 17, 19, 2, -17 },
  { 2804, 13, 17, 19, 3, -17 },
  { 2832, 15, 17, 19, 2, -17 },
  { 2864, 14, 23, 19, 3, -17 },
  { 2905, 14, 23, 19, 2, -17 },
  { 2946, 16, 17, 19, 2, -17 },
  { 2980, 15, 17, 19, 2, -17 },
  { 3012, 16, 22, 19, 1, -22 },
  { 3056, 13, 17, 19, 3, -17 },
  { 3084, 15, 17, 19, 2, -17 },
  { 3116, 17, 17, 19, 1, -17 },
  { 3153, 15, 17, 19, 2, -17 },
  { 3185, 16, 23, 19, 2, -17 },
  { 3231, 13, 17, 19, 3, -17 },
  { 3259, 13, 28, 19, 3, -24 },
  { 3305, 3, 28, 19, 8, -24 },
  { 3316, 13, 28, 19, 3, -24 },
  { 3362, 16, 7, 19, 2, -13 },
};

const GFXfont IBMPlexMono_Regular32pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular32pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _IBMPLEXMONO_REGULAR32PT7B_H_
