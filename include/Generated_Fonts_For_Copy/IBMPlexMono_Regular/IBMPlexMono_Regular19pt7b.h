#ifndef _IBMPLEXMONO_REGULAR19PT7B_H_
#define _IBMPLEXMONO_REGULAR19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular19pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB4, 0x92, 0x01, 0xF6, 0xCE, 0x73, 0x9C, 0x80, 0x0C, 0x81,
  0x90, 0x26, 0x04, 0xC7, 0x9E, 0x32, 0x06, 0x40, 0x88, 0xF3, 0xC2, 0x60,
  0x48, 0x19, 0x03, 0x20, 0x08, 0x04, 0x0F, 0xCD, 0x34, 0x96, 0x41, 0x20,
  0xF0, 0x1F, 0x04, 0xC2, 0x21, 0x18, 0x8F, 0x4C, 0xFC, 0x10, 0x08, 0x00,
  0x78, 0x69, 0x8B, 0x13, 0x62, 0x44, 0xD8, 0xF2, 0x00, 0x00, 0xDE, 0x12,
  0x66, 0xC4, 0x98, 0xB1, 0x3C, 0x3C, 0x1E, 0x06, 0x60, 0x80, 0x10, 0x03,
  0x00, 0x20, 0x0E, 0x3B, 0x64, 0x46, 0x98, 0x71, 0x06, 0x31, 0x63, 0xC6,
  0xF8, 0x19, 0x88, 0x84, 0x62, 0x10, 0x84, 0x21, 0x84, 0x20, 0x86, 0x18,
  0xC0, 0x83, 0x04, 0x18, 0x20, 0x82, 0x0C, 0x20, 0x82, 0x18, 0x43, 0x08,
  0xC0, 0x08, 0x02, 0x00, 0x83, 0x26, 0x7F, 0xC3, 0x01, 0x60, 0xC8, 0x63,
  0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x00,
  0x6F, 0x6D, 0x00, 0xF8, 0x7D, 0x80, 0x03, 0x02, 0x06, 0x04, 0x04, 0x0C,
  0x08, 0x18, 0x10, 0x10, 0x30, 0x20, 0x60, 0x40, 0x40, 0xC0, 0x80, 0x3E,
  0x31, 0x90, 0x78, 0x3C, 0x0E, 0x67, 0x33, 0x81, 0xC0, 0xE0, 0xD0, 0x6C,
  0x63, 0xE0, 0x1C, 0x0F, 0x06, 0xC3, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x7F, 0xC0, 0x3E, 0x31, 0xB0, 0x60, 0x30,
  0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x0F, 0xF8, 0x3E, 0x31,
  0xB0, 0x40, 0x30, 0x10, 0x18, 0x70, 0x06, 0x01, 0x80, 0xE0, 0x78, 0x63,
  0xE0, 0x07, 0x03, 0xC0, 0xB0, 0x6C, 0x33, 0x08, 0xC6, 0x33, 0x0C, 0x83,
  0x3F, 0xF0, 0x30, 0x0C, 0x03, 0x00, 0x7F, 0xB0, 0x10, 0x08, 0x04, 0x02,
  0xF1, 0x8C, 0x03, 0x01, 0x80, 0xD0, 0x7C, 0x63, 0xE0, 0x0E, 0x0C, 0x0C,
  0x04, 0x06, 0x02, 0xF3, 0x85, 0x83, 0xC0, 0xE0, 0x50, 0x6C, 0x23, 0xE0,
  0xFF, 0xE0, 0xF0, 0x60, 0x60, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x06, 0x06,
  0x03, 0x03, 0x00, 0x3E, 0x30, 0x90, 0x78, 0x34, 0x1B, 0x08, 0x78, 0xC3,
  0xC0, 0xE0, 0x70, 0x2C, 0x33, 0xE0, 0x3E, 0x30, 0x90, 0x78, 0x1C, 0x0E,
  0x0D, 0x86, 0x7F, 0x01, 0x01, 0x81, 0x81, 0x83, 0x80, 0x7D, 0x80, 0x00,
  0x7D, 0x80, 0x7D, 0x80, 0x00, 0x6F, 0x6D, 0x00, 0x01, 0x07, 0x1C, 0x30,
  0xE0, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xF8, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x06, 0x1C, 0x70, 0xC0, 0x80,
  0x3E, 0x31, 0x90, 0x70, 0x30, 0x30, 0x70, 0x20, 0x10, 0x00, 0x00, 0x07,
  0x03, 0x81, 0xC0, 0x1E, 0x31, 0x90, 0x68, 0x1C, 0xEE, 0xCF, 0x63, 0xB1,
  0xD8, 0xEC, 0x73, 0xE8, 0x04, 0x01, 0x00, 0x7C, 0x1C, 0x07, 0x01, 0x60,
  0x58, 0x32, 0x08, 0x82, 0x31, 0x8C, 0x7F, 0x10, 0x6C, 0x1B, 0x02, 0x80,
  0xC0, 0xFC, 0x82, 0x83, 0x83, 0x83, 0x82, 0xFC, 0x83, 0x81, 0x81, 0x81,
  0x83, 0xFE, 0x1F, 0x10, 0xD8, 0x28, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x20, 0x18, 0x24, 0x31, 0xF0, 0xFC, 0x86, 0x83, 0x83, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x83, 0x83, 0x86, 0xFC, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1E, 0x31, 0x90, 0x78,
  0x0C, 0x06, 0x03, 0x01, 0x8F, 0xC1, 0xE0, 0xD0, 0x6C, 0x73, 0xD8, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0xFF, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0x3F, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xC3,
  0x63, 0x3C, 0x81, 0xC1, 0xA1, 0x91, 0x89, 0x85, 0x83, 0xE1, 0x90, 0xCC,
  0x43, 0x20, 0x90, 0x68, 0x18, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xE1, 0xF0, 0xF8, 0xBE, 0x5D, 0x6E,
  0xE7, 0x33, 0x91, 0xC8, 0xE0, 0x70, 0x38, 0x1C, 0x08, 0xC3, 0xC3, 0xE3,
  0xA3, 0xB3, 0x93, 0x93, 0x9B, 0x8B, 0x8F, 0x87, 0x87, 0x87, 0x3E, 0x31,
  0x90, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xD0, 0x6C, 0x63,
  0xE0, 0xFE, 0x83, 0x81, 0x81, 0x81, 0x83, 0xFE, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x1E, 0x31, 0x90, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0xD0, 0x6C, 0x63, 0xE0, 0x40, 0x20, 0x0E, 0xFE, 0x83, 0x81, 0x81,
  0x81, 0x83, 0xFE, 0x88, 0x8C, 0x84, 0x86, 0x83, 0x83, 0x3F, 0x30, 0xF0,
  0x58, 0x0C, 0x03, 0x00, 0x7C, 0x03, 0x00, 0x80, 0x60, 0x7C, 0x33, 0xE0,
  0xFF, 0xE0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0xC6, 0x7C, 0xC0, 0xF0, 0x2C, 0x19, 0x06,
  0x61, 0x18, 0xC2, 0x30, 0xC8, 0x32, 0x05, 0x81, 0x60, 0x70, 0x1C, 0x00,
  0x80, 0xE0, 0x38, 0x0E, 0x32, 0x8C, 0xA7, 0x2D, 0x4B, 0x5A, 0xD6, 0xBC,
  0xA7, 0x29, 0x8E, 0x63, 0x80, 0x60, 0x64, 0x18, 0xC6, 0x0C, 0xC0, 0xB0,
  0x1C, 0x01, 0x80, 0x70, 0x1B, 0x02, 0x30, 0xC2, 0x30, 0x6E, 0x06, 0xC0,
  0x6C, 0x18, 0xC3, 0x18, 0xC1, 0x90, 0x16, 0x03, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0xFF, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x60,
  0x20, 0x30, 0x30, 0x10, 0x18, 0x18, 0x0F, 0xF8, 0xFF, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFC, 0x80, 0xC0, 0x40,
  0x40, 0x60, 0x20, 0x30, 0x10, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x06,
  0x02, 0x03, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0xF8, 0x0C, 0x07, 0x03, 0x60, 0x88, 0x63, 0x10, 0x6C, 0x0A, 0x03, 0xFF,
  0x80, 0x99, 0x30, 0x3C, 0x21, 0x80, 0x40, 0x23, 0xF2, 0x0B, 0x05, 0x86,
  0x45, 0x1C, 0xC0, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xC2, 0x83, 0x81, 0x81,
  0x81, 0x81, 0x83, 0xC2, 0xBC, 0x3C, 0x42, 0xC3, 0x80, 0x80, 0x80, 0x80,
  0xC2, 0x43, 0x3C, 0x01, 0x80, 0xC0, 0x60, 0x33, 0xDB, 0x1D, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x68, 0x36, 0x39, 0xEC, 0x1E, 0x31, 0x90, 0x78, 0x3F,
  0xFE, 0x03, 0x00, 0x82, 0x61, 0x8F, 0x00, 0x0F, 0x84, 0x02, 0x01, 0x0F,
  0xF8, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x83, 0xFC, 0x01,
  0xCF, 0x86, 0x31, 0x84, 0x41, 0x18, 0x42, 0x30, 0x78, 0x60, 0x10, 0x03,
  0xF9, 0x02, 0xC0, 0xF0, 0x23, 0xF0, 0x80, 0x80, 0x80, 0x80, 0x9C, 0xE6,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x18, 0x1C, 0x00, 0x00,
  0xF8, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x0E, 0x1C,
  0x00, 0x0F, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02,
  0x05, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x36, 0x33, 0x31, 0xB0, 0xF8,
  0x66, 0x33, 0x18, 0xCC, 0x36, 0x0C, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFF, 0xBB, 0xE6, 0x62, 0x31,
  0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0xC4, 0x40, 0x9C, 0xE6, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x1E, 0x31, 0x90, 0x78, 0x3C, 0x0E,
  0x07, 0x06, 0x83, 0x63, 0x0F, 0x00, 0xBC, 0xC2, 0x83, 0x81, 0x81, 0x81,
  0x81, 0x83, 0xC2, 0xBC, 0x80, 0x80, 0x80, 0x80, 0x3D, 0xB1, 0xD0, 0x78,
  0x3C, 0x1E, 0x0F, 0x06, 0x83, 0x63, 0x9E, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0xFB, 0xC7, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x3F,
  0xE0, 0x3E, 0x30, 0xD0, 0x0C, 0x03, 0xC0, 0x38, 0x07, 0x03, 0x61, 0x9F,
  0x00, 0x18, 0x0C, 0x06, 0x1F, 0xF1, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x00, 0xF8, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0xC7, 0x7B, 0xC0, 0xA0, 0xD8, 0x4C, 0x22, 0x31, 0x90, 0x48, 0x2C, 0x1C,
  0x06, 0x00, 0x8C, 0xE3, 0x39, 0x4A, 0x52, 0x94, 0xB4, 0xA5, 0x29, 0xCA,
  0x63, 0x98, 0xC0, 0xC1, 0xB1, 0x8C, 0x83, 0xC0, 0xC0, 0xE0, 0x58, 0x64,
  0x63, 0x60, 0xC0, 0xC0, 0xA0, 0xD8, 0x4C, 0x22, 0x31, 0x90, 0x58, 0x28,
  0x1C, 0x06, 0x02, 0x03, 0x01, 0x03, 0x80, 0xFF, 0x02, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0x40, 0xC0, 0xFF, 0x1E, 0x60, 0xC0, 0x81, 0x01, 0x02, 0x04,
  0xF0, 0x30, 0x20, 0x41, 0x02, 0x0C, 0x18, 0x1E, 0xFF, 0xFF, 0x80, 0xF8,
  0x10, 0x20, 0xC1, 0x86, 0x08, 0x18, 0x0E, 0x60, 0x81, 0x81, 0x83, 0x02,
  0x04, 0xF8, 0x70, 0xA4, 0x63, 0x70, 0xE0,
};

const GFXglyph IBMPlexMono_Regular19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 5, 5, 11, 3, -14 },
  { 10, 11, 13, 11, 0, -13 },
  { 28, 9, 17, 11, 1, -15 },
  { 48, 11, 13, 11, 0, -13 },
  { 66, 11, 13, 11, 0, -13 },
  { 84, 1, 5, 11, 5, -14 },
  { 85, 5, 17, 11, 4, -14 },
  { 96, 6, 17, 11, 2, -14 },
  { 109, 10, 9, 11, 1, -11 },
  { 121, 9, 9, 11, 1, -10 },
  { 132, 3, 6, 11, 4, -3 },
  { 135, 5, 1, 11, 3, -6 },
  { 136, 3, 3, 11, 4, -3 },
  { 138, 8, 17, 11, 2, -14 },
  { 155, 9, 13, 11, 1, -13 },
  { 170, 10, 13, 11, 1, -13 },
  { 187, 9, 13, 11, 1, -13 },
  { 202, 9, 13, 11, 1, -13 },
  { 217, 10, 13, 11, 1, -13 },
  { 234, 9, 13, 11, 1, -13 },
  { 249, 9, 13, 11, 1, -13 },
  { 264, 9, 13, 11, 1, -13 },
  { 279, 9, 13, 11, 1, -13 },
  { 294, 9, 13, 11, 1, -13 },
  { 309, 3, 11, 11, 4, -11 },
  { 314, 3, 14, 11, 4, -11 },
  { 320, 8, 11, 11, 2, -11 },
  { 331, 9, 5, 11, 1, -8 },
  { 337, 8, 11, 11, 2, -11 },
  { 348, 9, 13, 11, 1, -13 },
  { 363, 9, 15, 11, 1, -13 },
  { 380, 10, 13, 11, 1, -13 },
  { 397, 8, 13, 11, 2, -13 },
  { 410, 9, 13, 11, 1, -13 },
  { 425, 8, 13, 11, 2, -13 },
  { 438, 8, 13, 11, 2, -13 },
  { 451, 8, 13, 11, 2, -13 },
  { 464, 9, 13, 11, 1, -13 },
  { 479, 8, 13, 11, 2, -13 },
  { 492, 8, 13, 11, 2, -13 },
  { 505, 8, 13, 11, 1, -13 },
  { 518, 9, 13, 11, 2, -13 },
  { 533, 8, 13, 11, 2, -13 },
  { 546, 9, 13, 11, 1, -13 },
  { 561, 8, 13, 11, 2, -13 },
  { 574, 9, 13, 11, 1, -13 },
  { 589, 8, 13, 11, 2, -13 },
  { 602, 9, 16, 11, 1, -13 },
  { 620, 8, 13, 11, 2, -13 },
  { 633, 9, 13, 11, 1, -13 },
  { 648, 11, 13, 11, 0, -13 },
  { 666, 8, 13, 11, 2, -13 },
  { 679, 10, 13, 11, 1, -13 },
  { 696, 10, 13, 11, 1, -13 },
  { 713, 11, 13, 11, 0, -13 },
  { 731, 11, 13, 11, 0, -13 },
  { 749, 9, 13, 11, 1, -13 },
  { 764, 6, 17, 11, 4, -14 },
  { 777, 8, 17, 11, 2, -14 },
  { 794, 5, 17, 11, 2, -14 },
  { 805, 10, 8, 11, 1, -13 },
  { 815, 9, 1, 11, 1, 2 },
  { 817, 3, 4, 11, 4, -15 },
  { 819, 9, 10, 11, 1, -10 },
  { 831, 8, 14, 11, 2, -14 },
  { 845, 8, 10, 11, 2, -10 },
  { 855, 9, 14, 11, 1, -14 },
  { 871, 9, 10, 11, 1, -10 },
  { 883, 9, 14, 11, 1, -14 },
  { 899, 10, 15, 11, 1, -11 },
  { 918, 8, 14, 11, 2, -14 },
  { 932, 8, 14, 11, 2, -14 },
  { 946, 7, 18, 11, 2, -14 },
  { 962, 9, 14, 11, 2, -14 },
  { 978, 8, 14, 11, 2, -14 },
  { 992, 9, 10, 11, 1, -10 },
  { 1004, 8, 10, 11, 2, -10 },
  { 1014, 9, 10, 11, 1, -10 },
  { 1026, 8, 14, 11, 2, -10 },
  { 1040, 9, 14, 11, 1, -10 },
  { 1056, 10, 10, 11, 1, -10 },
  { 1069, 9, 10, 11, 1, -10 },
  { 1081, 9, 13, 11, 1, -13 },
  { 1096, 8, 10, 11, 2, -10 },
  { 1106, 9, 10, 11, 1, -10 },
  { 1118, 10, 10, 11, 1, -10 },
  { 1131, 9, 10, 11, 1, -10 },
  { 1143, 9, 14, 11, 1, -10 },
  { 1159, 8, 10, 11, 2, -10 },
  { 1169, 7, 17, 11, 2, -14 },
  { 1184, 1, 17, 11, 5, -14 },
  { 1187, 7, 17, 11, 2, -14 },
  { 1202, 9, 4, 11, 1, -8 },
};

const GFXfont IBMPlexMono_Regular19pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular19pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _IBMPLEXMONO_REGULAR19PT7B_H_
