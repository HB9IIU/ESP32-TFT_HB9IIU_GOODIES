#ifndef _IBMPLEXMONO_REGULAR70PT7B_H_
#define _IBMPLEXMONO_REGULAR70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular70pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x0E, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0x8F, 0xC0, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x7C, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFC,
  0x79, 0xFF, 0x80, 0xFF, 0x07, 0x83, 0xFC, 0x1F, 0xC0, 0x78, 0x1F, 0xE1,
  0xF8, 0x07, 0x80, 0x7E, 0x1F, 0x80, 0x78, 0x03, 0x83, 0xF0, 0x07, 0x80,
  0x10, 0x3F, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x3F, 0x00,
  0x78, 0x00, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x01, 0xFC, 0x07, 0x80,
  0x00, 0x1F, 0xE0, 0x78, 0x00, 0x00, 0xFF, 0x07, 0x80, 0x00, 0x07, 0xFE,
  0x78, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0x9F, 0xF8, 0x00, 0x00,
  0x78, 0x3F, 0xC0, 0x00, 0x07, 0x81, 0xFC, 0x00, 0x00, 0x78, 0x0F, 0xE0,
  0x00, 0x07, 0x80, 0x7E, 0x00, 0x00, 0x78, 0x07, 0xE0, 0x00, 0x07, 0x80,
  0x3E, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x3F, 0x00, 0x00,
  0x78, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x3F, 0x08, 0x00, 0x78, 0x03, 0xE1,
  0xC0, 0x07, 0x80, 0x7E, 0x3E, 0x00, 0x78, 0x07, 0xEF, 0xF0, 0x07, 0x80,
  0xFE, 0x7F, 0xC0, 0x78, 0x1F, 0xC3, 0xFE, 0x07, 0x83, 0xFC, 0x1F, 0xFC,
  0x79, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x0F, 0xFF, 0xC0, 0x00, 0x3E,
  0x1F, 0xFF, 0xE0, 0x00, 0x7C, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x3E, 0x01,
  0xF0, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x03, 0xE0, 0xF8,
  0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x1F, 0x80,
  0x78, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x7C,
  0x00, 0x3F, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0xF8, 0x00, 0x0F,
  0xFF, 0xC1, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0x87, 0xFF, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80,
  0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x1F, 0x00, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0x1E, 0x01, 0xF8, 0x1F,
  0x00, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x1F,
  0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x3E,
  0x00, 0x07, 0xE0, 0xFC, 0x3E, 0x00, 0x07, 0xFF, 0xF8, 0x7C, 0x00, 0x03,
  0xFF, 0xF0, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x01, 0xE8, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x1F,
  0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0x87, 0xF3, 0xF8, 0x07,
  0xFE, 0x3F, 0x87, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0xE0, 0x7C, 0x07, 0xE0,
  0x1F, 0x81, 0xF0, 0x1F, 0x80, 0x3F, 0x07, 0xC0, 0xFC, 0x00, 0xFE, 0x1E,
  0x03, 0xF0, 0x01, 0xFC, 0x78, 0x0F, 0xC0, 0x03, 0xF9, 0xE0, 0x3F, 0x00,
  0x07, 0xE7, 0x80, 0xFC, 0x00, 0x0F, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0xF0,
  0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xF0,
  0x1F, 0xC0, 0x00, 0xEF, 0xE0, 0x7F, 0x80, 0x0F, 0x1F, 0x80, 0xFF, 0x80,
  0xFC, 0x3F, 0x01, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFC,
  0x07, 0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xF0, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x7E, 0x01, 0xF8, 0x07,
  0xE7, 0xFC, 0x1F, 0x83, 0xFE, 0xFF, 0xFD, 0xF9, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x7F,
  0x83, 0xFC, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x3F, 0x00, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xFC,
  0x07, 0xF8, 0x0F, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0x80, 0xFF,
  0xF0, 0x1F, 0xE0, 0x3F, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0x00, 0xFC, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFD, 0xF8, 0x00, 0x00, 0xFF, 0x3F, 0x00,
  0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x03, 0xFC, 0x1F,
  0x80, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x0F, 0xF0,
  0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x01,
  0x80, 0x07, 0xE0, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x81, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0x80, 0x07,
  0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0x80, 0x00,
  0x3F, 0x80, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x10, 0x00, 0x00, 0x3F, 0x1C, 0x00, 0x00, 0x3F, 0x9E, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0x3E, 0x1F,
  0xFF, 0x80, 0x3E, 0x3F, 0xFF, 0xC0, 0x3E, 0x7F, 0xFF, 0xF0, 0x3E, 0xFF,
  0xFF, 0xF8, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x00,
  0x01, 0xFE, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x08, 0x00,
  0x00, 0x3F, 0x18, 0x00, 0x00, 0x7F, 0x3C, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xF0,
  0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x1F, 0xE0, 0x00, 0x7C, 0x3F, 0xFF, 0x00, 0x3F,
  0x1F, 0xFF, 0xE0, 0x0F, 0x8F, 0xFF, 0xFE, 0x03, 0xE7, 0xFF, 0xFF, 0xC1,
  0xFB, 0xE0, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0x1F, 0xBF, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8,
  0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x7D, 0xF8, 0x3F, 0xFF, 0xFE, 0x7C, 0x07,
  0xFF, 0xFF, 0x1F, 0x00, 0xFF, 0xFF, 0x8F, 0xC0, 0x0F, 0xFF, 0xC3, 0xE0,
  0x00, 0x7F, 0x81, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x8F, 0xC0, 0x0F, 0xC0, 0xFF,
  0x0F, 0xFC, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0xC3,
  0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC,
  0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xF0, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0x80,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF1, 0xF0,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x3E, 0xF8, 0x01, 0xFF, 0x1F, 0x7C,
  0x01, 0xFF, 0xCF, 0xBE, 0x01, 0xFF, 0xE7, 0xDF, 0x01, 0xFF, 0xFB, 0xEF,
  0x80, 0xFE, 0x0D, 0xF7, 0xC0, 0xFC, 0x03, 0xFB, 0xE0, 0x7C, 0x00, 0xFD,
  0xF0, 0x3E, 0x00, 0x3F, 0xF8, 0x1F, 0x00, 0x1F, 0xFC, 0x1F, 0x00, 0x0F,
  0xFE, 0x0F, 0x80, 0x07, 0xFF, 0x07, 0xC0, 0x03, 0xFF, 0x83, 0xE0, 0x01,
  0xFF, 0xC1, 0xF0, 0x00, 0xFF, 0xE0, 0xF8, 0x00, 0x7F, 0xF0, 0x7C, 0x00,
  0x3F, 0xF8, 0x3E, 0x00, 0x1F, 0xFC, 0x1F, 0x00, 0x0F, 0xFE, 0x0F, 0x80,
  0x07, 0xFF, 0x07, 0xE0, 0x03, 0xEF, 0x81, 0xF0, 0x01, 0xF7, 0xC0, 0xF8,
  0x01, 0xFB, 0xE0, 0x7E, 0x00, 0xFD, 0xF0, 0x3F, 0x00, 0xFE, 0xF8, 0x0F,
  0xE0, 0xDF, 0x7C, 0x07, 0xFF, 0xEF, 0xBE, 0x01, 0xFF, 0xE7, 0xDF, 0x00,
  0x7F, 0xF3, 0xE7, 0xC0, 0x1F, 0xF1, 0xF3, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x07, 0xF8, 0xFC, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x01, 0x83, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x60, 0x7E, 0x00, 0x00, 0x3C, 0x3F,
  0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0x80, 0x0F, 0xF8, 0x3F, 0x00, 0x07, 0xF8,
  0x7E, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x7F, 0x87, 0xE0, 0x03, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0x01, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xF0, 0xFF,
  0x00, 0x1D, 0xF8, 0x7F, 0xE0, 0x3E, 0xFC, 0x1F, 0xFF, 0xFE, 0x7E, 0x07,
  0xFF, 0xFE, 0x3F, 0x01, 0xFF, 0xFE, 0x1F, 0x80, 0x3F, 0xFE, 0x0F, 0xC0,
  0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x70, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xF8,
  0x7F, 0x00, 0x1F, 0xC3, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x07, 0xF3, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0x3F,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x1F, 0xE0, 0x00, 0x0F,
  0xCF, 0xFC, 0x00, 0x03, 0xF3, 0xFF, 0x80, 0x00, 0xFD, 0xFF, 0xE0, 0x00,
  0x3F, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0x3F, 0x00, 0x03, 0xFF, 0x8F, 0xE0,
  0x00, 0xFF, 0xC1, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x0F, 0xF0, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x03, 0xFB, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFB, 0xE0, 0x07, 0xDF, 0xFB, 0xF0, 0x07,
  0xDF, 0xF9, 0xF0, 0x0F, 0x9F, 0xF9, 0xF0, 0x0F, 0x9F, 0xF8, 0xF8, 0x0F,
  0x1F, 0xF8, 0xF8, 0x1F, 0x1F, 0xF8, 0xFC, 0x1F, 0x1F, 0xF8, 0x7C, 0x3E,
  0x1F, 0xF8, 0x7C, 0x3E, 0x1F, 0xF8, 0x3E, 0x3C, 0x1F, 0xF8, 0x3E, 0x7C,
  0x1F, 0xF8, 0x3F, 0x7C, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x07, 0xF0,
  0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x03, 0xC0,
  0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x01, 0x80, 0x1F, 0xF8, 0x01, 0x80,
  0x1F, 0xF8, 0x01, 0x80, 0x1F, 0xF8, 0x01, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x1F, 0xFB, 0xE0, 0x00, 0x7F, 0xEF, 0xC0, 0x01, 0xFF, 0x9F,
  0x00, 0x07, 0xFE, 0x7E, 0x00, 0x1F, 0xF9, 0xF8, 0x00, 0x7F, 0xE3, 0xE0,
  0x01, 0xFF, 0x8F, 0xC0, 0x07, 0xFE, 0x1F, 0x00, 0x1F, 0xF8, 0x7E, 0x00,
  0x7F, 0xE1, 0xF8, 0x01, 0xFF, 0x83, 0xE0, 0x07, 0xFE, 0x0F, 0xC0, 0x1F,
  0xF8, 0x1F, 0x00, 0x7F, 0xE0, 0x7E, 0x01, 0xFF, 0x81, 0xF8, 0x07, 0xFE,
  0x03, 0xE0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x1F, 0x01, 0xFF, 0x80,
  0x7E, 0x07, 0xFE, 0x01, 0xF8, 0x1F, 0xF8, 0x03, 0xE0, 0x7F, 0xE0, 0x0F,
  0xC1, 0xFF, 0x80, 0x1F, 0x07, 0xFE, 0x00, 0x7E, 0x1F, 0xF8, 0x01, 0xF8,
  0x7F, 0xE0, 0x03, 0xE1, 0xFF, 0x80, 0x0F, 0xC7, 0xFE, 0x00, 0x1F, 0x1F,
  0xF8, 0x00, 0x7E, 0x7F, 0xE0, 0x01, 0xF9, 0xFF, 0x80, 0x03, 0xE7, 0xFE,
  0x00, 0x0F, 0xDF, 0xF8, 0x00, 0x1F, 0x7F, 0xE0, 0x00, 0x7F, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xFC,
  0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00,
  0x07, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0xF9, 0xF8,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFC, 0x00, 0x07, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFF,
  0x03, 0xF8, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0x80, 0x00,
  0x0F, 0x87, 0xF0, 0x00, 0x00, 0xE0, 0xFC, 0x00, 0x00, 0x08, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x40, 0x00, 0x00, 0x3F, 0x1C, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x01, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F, 0xC3, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x00, 0x1F,
  0x8F, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x00, 0xFD, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0xF8, 0x03, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0xE0, 0x1F, 0x0F,
  0x80, 0x7F, 0x80, 0x7C, 0x3E, 0x01, 0xFE, 0x01, 0xF0, 0xF8, 0x07, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0xF0, 0x1F, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x3E,
  0x03, 0xFF, 0x01, 0xF0, 0xF8, 0x0F, 0x3C, 0x07, 0xC3, 0xE0, 0x3C, 0xF0,
  0x1F, 0x0F, 0x80, 0xF3, 0xE0, 0x7C, 0x3E, 0x07, 0xCF, 0x81, 0xF0, 0xFC,
  0x1F, 0x3E, 0x07, 0xC1, 0xF0, 0x78, 0x78, 0x1E, 0x07, 0xC1, 0xE1, 0xE0,
  0xF8, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x7C, 0x3E, 0x1F, 0x0F, 0x81, 0xF0,
  0xF8, 0x7C, 0x3E, 0x07, 0xC3, 0xC0, 0xF0, 0xF8, 0x1F, 0x0F, 0x03, 0xE3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7,
  0xC0, 0xF8, 0xF8, 0x1F, 0x1E, 0x01, 0xE3, 0xE0, 0x7C, 0xF8, 0x07, 0xCF,
  0x81, 0xF3, 0xE0, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7C, 0xF0, 0x0F, 0xBE,
  0x01, 0xF3, 0xC0, 0x3E, 0xF0, 0x03, 0xDF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x00, 0x1C, 0x08,
  0x00, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x08, 0x03, 0x81, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0,
  0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x03, 0xF0,
  0x06, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x7C, 0x0F, 0xF0, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x7C, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0x07, 0xFF, 0xE0, 0x1F, 0xC0,
  0x3F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0xF8, 0x3F, 0xFE, 0x01, 0xF0, 0xFF,
  0xFF, 0x03, 0xE3, 0xFF, 0xFF, 0x07, 0xCF, 0xFF, 0xFF, 0x0F, 0xBE, 0x03,
  0xFE, 0x1F, 0x70, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x7E, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x7F, 0x3E, 0xE0, 0x03, 0xFC, 0x7D, 0xF0, 0x1F, 0xF0, 0xF9, 0xFF,
  0xFF, 0xE1, 0xF1, 0xFF, 0xFF, 0x83, 0xE1, 0xFF, 0xFE, 0x07, 0xC1, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xE0, 0x3F, 0xC1, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0x04, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x08, 0x3E, 0x00, 0x00, 0x78, 0xFC, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x1F, 0x00, 0xFF, 0xF8, 0x3E, 0x07,
  0xFF, 0xF8, 0x7C, 0x1F, 0xFF, 0xF8, 0xF8, 0x7F, 0xFF, 0xF9, 0xF0, 0xFF,
  0x80, 0xFB, 0xE3, 0xFC, 0x00, 0x77, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0xEF, 0x87, 0xFC, 0x07, 0xDF, 0x0F,
  0xFF, 0xFF, 0x3E, 0x0F, 0xFF, 0xFC, 0x7C, 0x0F, 0xFF, 0xF0, 0xF8, 0x07,
  0xFF, 0xC1, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F,
  0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x10, 0x7E, 0x00, 0x00, 0x38, 0x3E,
  0x00, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x1F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x8F, 0xC0, 0x00, 0x0F,
  0xE7, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xEF, 0xF8,
  0x00, 0x0F, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x01, 0xFE, 0x00, 0xF8, 0x3F,
  0xFC, 0x07, 0xC3, 0xFF, 0xF8, 0x3E, 0x3F, 0xFF, 0xE1, 0xF3, 0xFF, 0xFF,
  0x8F, 0xBE, 0x03, 0xFE, 0x7D, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFE, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x03, 0xF1, 0xFE, 0x00, 0x01, 0xF9, 0xFF, 0x80, 0x00, 0xFD, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xF9, 0xFC, 0x00, 0x1F, 0xF8,
  0x7F, 0x00, 0x0F, 0xF8, 0x1F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7F,
  0x3F, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7E, 0x00, 0xFC, 0x3E, 0x3F, 0xC0, 0xFF, 0xCF, 0x9F, 0xF8, 0x7F,
  0xF3, 0xEF, 0xFF, 0x1F, 0xFE, 0xFB, 0xFF, 0xCF, 0xFF, 0xBF, 0xC3, 0xFF,
  0x07, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0xF8, 0x03,
  0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xE0,
  0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x07,
  0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x00,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8,
  0x03, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x7F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x07, 0xC1, 0xFF, 0xE0, 0x3E, 0x1F, 0xFF,
  0xC1, 0xF1, 0xFF, 0xFF, 0x0F, 0x9F, 0xFF, 0xFC, 0x7D, 0xF0, 0x1F, 0xF3,
  0xEE, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x7F, 0xFC, 0x03, 0xE1, 0xFF, 0xFE,
  0x07, 0xC7, 0xFF, 0xFE, 0x0F, 0x9F, 0xFF, 0xFE, 0x1F, 0x7C, 0x07, 0xFC,
  0x3E, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0xFE, 0x7D, 0xC0, 0x07, 0xF8, 0xFB, 0xE0, 0x3F, 0xE1, 0xF3, 0xFF, 0xFF,
  0xC3, 0xE3, 0xFF, 0xFF, 0x07, 0xC3, 0xFF, 0xFC, 0x0F, 0x83, 0xFF, 0xE0,
  0x1F, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0xF0, 0x7C, 0x0F, 0xFF, 0xF0, 0xF8, 0x3F, 0xFF, 0xF1, 0xF0, 0xFF,
  0xFF, 0xF3, 0xE1, 0xFF, 0x01, 0xF7, 0xC7, 0xF8, 0x00, 0xEF, 0x9F, 0xC0,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xDF, 0x0F,
  0xF8, 0x0F, 0xBE, 0x1F, 0xFF, 0xFE, 0x7C, 0x1F, 0xFF, 0xF8, 0xF8, 0x1F,
  0xFF, 0xE1, 0xF0, 0x0F, 0xFF, 0x83, 0xE0, 0x07, 0xF8, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xC0, 0x07,
  0xEF, 0xC0, 0x00, 0x01, 0xFB, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xF0, 0x07, 0xFE, 0x1F, 0x80,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x78, 0x3F, 0x00, 0x00, 0x30, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x20, 0x00,
  0x00, 0x3F, 0x38, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0xFE, 0x00,
  0x00, 0x7E, 0xFF, 0x80, 0x00, 0xFE, 0x7F, 0xF0, 0x07, 0xFC, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFC,
  0xFE, 0x00, 0x3B, 0xE7, 0xFC, 0x07, 0xDF, 0x1F, 0xFF, 0xFC, 0xF8, 0x7F,
  0xFF, 0xC7, 0xC1, 0xFF, 0xFC, 0x3E, 0x03, 0xFF, 0xC1, 0xF0, 0x07, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x1F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x00, 0xFC, 0x7C,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xE0,
  0x07, 0xDF, 0x00, 0x7F, 0x80, 0x1E, 0x7C, 0x01, 0xFE, 0x00, 0xF9, 0xF0,
  0x07, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0xE0, 0x0F, 0x9F, 0x00, 0xF3, 0xC0,
  0x3E, 0x7C, 0x03, 0xCF, 0x00, 0xF8, 0xF0, 0x0F, 0x3C, 0x03, 0xC3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x0F, 0x80, 0xF3, 0xC0, 0x3C, 0x3E, 0x07, 0xC7, 0x81,
  0xF0, 0xF8, 0x1E, 0x1E, 0x07, 0xC3, 0xE0, 0x78, 0x78, 0x1F, 0x0F, 0x81,
  0xE1, 0xE0, 0x7C, 0x1E, 0x07, 0x87, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x07,
  0x81, 0xF0, 0xF0, 0x3C, 0x1E, 0x07, 0xC3, 0xC0, 0xF0, 0xF8, 0x1F, 0x0F,
  0x03, 0xC3, 0xE0, 0x7C, 0x3C, 0x0F, 0x0F, 0x80, 0xF1, 0xF0, 0x1E, 0x3C,
  0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x03, 0xE7, 0x80, 0x7D, 0xF0,
  0x0F, 0xBC, 0x00, 0xF7, 0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x01, 0xFF, 0x00,
  0x00, 0xF0, 0xFF, 0xF0, 0x00, 0x7C, 0x7F, 0xFE, 0x00, 0x1F, 0x1F, 0xFF,
  0xC0, 0x07, 0xCF, 0xC7, 0xF8, 0x01, 0xE3, 0xE0, 0x7E, 0x00, 0xF9, 0xF0,
  0x0F, 0xC0, 0x3E, 0x7C, 0x01, 0xF8, 0x1F, 0x1E, 0x00, 0x7F, 0x8F, 0xCF,
  0x80, 0x0F, 0xFF, 0xE3, 0xE0, 0x01, 0xFF, 0xF8, 0xF0, 0x00, 0x3F, 0xFC,
  0x3C, 0x00, 0x03, 0xFE, 0x03, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph IBMPlexMono_Regular70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 10, 50, 42, 16, -49 },
  { 64, 18, 19, 42, 12, -52 },
  { 107, 40, 49, 42, 1, -49 },
  { 352, 36, 65, 42, 3, -57 },
  { 645, 40, 51, 42, 1, -50 },
  { 900, 38, 51, 42, 2, -50 },
  { 1143, 6, 19, 42, 18, -52 },
  { 1158, 21, 63, 42, 14, -53 },
  { 1324, 21, 63, 42, 7, -53 },
  { 1490, 36, 35, 42, 3, -40 },
  { 1648, 34, 35, 42, 4, -39 },
  { 1797, 13, 20, 42, 14, -10 },
  { 1830, 20, 5, 42, 11, -24 },
  { 1843, 10, 10, 42, 16, -9 },
  { 1856, 30, 63, 42, 6, -53 },
  { 2093, 34, 51, 42, 4, -50 },
  { 2310, 35, 49, 42, 4, -49 },
  { 2525, 33, 50, 42, 5, -50 },
  { 2732, 33, 51, 42, 3, -50 },
  { 2943, 37, 49, 42, 2, -49 },
  { 3170, 32, 50, 42, 5, -49 },
  { 3370, 34, 50, 42, 4, -49 },
  { 3583, 32, 49, 42, 5, -49 },
  { 3779, 34, 51, 42, 4, -50 },
  { 3996, 34, 50, 42, 4, -50 },
  { 4209, 10, 38, 42, 16, -37 },
  { 4257, 13, 47, 42, 14, -37 },
  { 4334, 30, 40, 42, 6, -41 },
  { 4484, 34, 19, 42, 4, -31 },
  { 4565, 30, 40, 42, 6, -41 },
  { 4715, 31, 51, 42, 5, -50 },
  { 4913, 33, 58, 42, 4, -50 },
  { 5153, 38, 49, 42, 2, -49 },
  { 5386, 32, 49, 42, 6, -49 },
  { 5582, 33, 51, 42, 5, -50 },
  { 5793, 31, 49, 42, 7, -49 },
  { 5983, 30, 49, 42, 6, -49 },
  { 6167, 31, 49, 42, 6, -49 },
  { 6357, 33, 51, 42, 4, -50 },
  { 6568, 30, 49, 42, 6, -49 },
  { 6752, 30, 49, 42, 6, -49 },
  { 6936, 29, 50, 42, 5, -49 },
  { 7118, 34, 49, 42, 6, -49 },
  { 7327, 29, 49, 42, 8, -49 },
  { 7505, 32, 49, 42, 5, -49 },
  { 7701, 30, 49, 42, 6, -49 },
  { 7885, 34, 51, 42, 4, -50 },
  { 8102, 32, 49, 42, 6, -49 },
  { 8298, 34, 62, 42, 4, -50 },
  { 8562, 32, 49, 42, 6, -49 },
  { 8758, 35, 51, 42, 3, -50 },
  { 8982, 38, 49, 42, 2, -49 },
  { 9215, 30, 50, 42, 6, -49 },
  { 9403, 36, 49, 42, 3, -49 },
  { 9624, 38, 49, 42, 2, -49 },
  { 9857, 38, 49, 42, 2, -49 },
  { 10090, 40, 49, 42, 1, -49 },
  { 10335, 36, 49, 42, 3, -49 },
  { 10556, 19, 63, 42, 16, -53 },
  { 10706, 30, 63, 42, 6, -53 },
  { 10943, 19, 63, 42, 7, -53 },
  { 11093, 36, 29, 42, 3, -49 },
  { 11224, 34, 5, 42, 4, 7 },
  { 11246, 11, 14, 42, 13, -55 },
  { 11266, 34, 38, 42, 5, -37 },
  { 11428, 31, 53, 42, 7, -52 },
  { 11634, 30, 38, 42, 6, -37 },
  { 11777, 31, 53, 42, 4, -52 },
  { 11983, 32, 38, 42, 5, -37 },
  { 12135, 33, 52, 42, 5, -52 },
  { 12350, 34, 56, 42, 5, -41 },
  { 12588, 29, 52, 42, 7, -52 },
  { 12777, 31, 52, 42, 7, -52 },
  { 12979, 25, 66, 42, 7, -52 },
  { 13186, 33, 52, 42, 7, -52 },
  { 13401, 30, 52, 42, 6, -52 },
  { 13596, 34, 37, 42, 4, -37 },
  { 13754, 29, 37, 42, 7, -37 },
  { 13889, 32, 38, 42, 5, -37 },
  { 14041, 31, 51, 42, 7, -37 },
  { 14239, 31, 51, 42, 4, -37 },
  { 14437, 34, 36, 42, 5, -36 },
  { 14590, 32, 38, 42, 5, -37 },
  { 14742, 34, 49, 42, 3, -49 },
  { 14951, 29, 37, 42, 6, -36 },
  { 15086, 34, 36, 42, 4, -36 },
  { 15239, 38, 36, 42, 2, -36 },
  { 15410, 34, 36, 42, 4, -36 },
  { 15563, 34, 50, 42, 4, -36 },
  { 15776, 30, 36, 42, 6, -36 },
  { 15911, 28, 63, 42, 7, -53 },
  { 16132, 4, 63, 42, 19, -53 },
  { 16164, 28, 63, 42, 7, -53 },
  { 16385, 34, 15, 42, 4, -29 },
};

const GFXfont IBMPlexMono_Regular70pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular70pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular70pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _IBMPLEXMONO_REGULAR70PT7B_H_
