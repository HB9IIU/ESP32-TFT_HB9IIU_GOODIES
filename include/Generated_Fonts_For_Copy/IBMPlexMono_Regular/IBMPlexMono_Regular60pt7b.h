#ifndef _IBMPLEXMONO_REGULAR60PT7B_H_
#define _IBMPLEXMONO_REGULAR60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular60pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xE0, 0x7F, 0xFC, 0xFF, 0xF8,
  0x1F, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xCF, 0xFF, 0x81, 0xFF,
  0xF3, 0xFF, 0xE0, 0x7F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xFE, 0x38, 0xFF, 0x07, 0xE0,
  0xE0, 0xFE, 0x3F, 0x03, 0x80, 0xFC, 0xF8, 0x0E, 0x01, 0xC3, 0xE0, 0x38,
  0x02, 0x0F, 0x80, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xF0, 0x0E, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x3E, 0x03, 0x80, 0x00,
  0xF8, 0x0E, 0x00, 0x03, 0xF0, 0x38, 0x00, 0x07, 0xF0, 0xE0, 0x00, 0x0F,
  0xF3, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x39,
  0xFF, 0x00, 0x00, 0xE0, 0xFE, 0x00, 0x03, 0x81, 0xF8, 0x00, 0x0E, 0x03,
  0xF0, 0x00, 0x38, 0x07, 0xC0, 0x00, 0xE0, 0x1F, 0x00, 0x03, 0x80, 0x7C,
  0x00, 0x0E, 0x01, 0xF0, 0x00, 0x38, 0x07, 0xC0, 0x00, 0xE0, 0x1F, 0x10,
  0x03, 0x80, 0x7C, 0xE0, 0x0E, 0x03, 0xF7, 0xC0, 0x38, 0x0F, 0xBF, 0x80,
  0xE0, 0x7E, 0x7F, 0x83, 0x83, 0xF0, 0xFF, 0x8E, 0x3F, 0xC1, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF1, 0xFF, 0xE0, 0x00, 0x78,
  0xFF, 0xFC, 0x00, 0x3E, 0x7E, 0x1F, 0x80, 0x0F, 0x1E, 0x01, 0xE0, 0x07,
  0xC7, 0x80, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x00, 0xF0, 0xF0, 0x03, 0xC0,
  0x3C, 0x3C, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x3C, 0x07, 0x83, 0xC0, 0x0F,
  0x03, 0xC0, 0xF0, 0x03, 0xC1, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x07, 0x80,
  0x7C, 0x3E, 0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x7E, 0x1F, 0x87, 0xC0, 0x0F,
  0xFF, 0xC1, 0xE0, 0x01, 0xFF, 0xE0, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x07,
  0xFF, 0x80, 0x07, 0x83, 0xFF, 0xF0, 0x03, 0xE1, 0xF8, 0x7E, 0x00, 0xF0,
  0x78, 0x07, 0x80, 0x7C, 0x3E, 0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x3C, 0x0F,
  0x83, 0xC0, 0x0F, 0x03, 0xC0, 0xF0, 0x03, 0xC1, 0xE0, 0x3C, 0x00, 0xF0,
  0x78, 0x0F, 0x00, 0x3C, 0x3C, 0x03, 0xC0, 0x0F, 0x0F, 0x00, 0xF0, 0x03,
  0xC7, 0x80, 0x3E, 0x01, 0xE3, 0xE0, 0x07, 0x80, 0x78, 0xF0, 0x01, 0xF8,
  0x7E, 0x7C, 0x00, 0x3F, 0xFF, 0x1E, 0x00, 0x07, 0xFF, 0x8F, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x0C, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07,
  0xFC, 0x1F, 0xFC, 0x03, 0xFE, 0x1F, 0x3F, 0x01, 0xFF, 0x1F, 0x0F, 0x80,
  0xF0, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x80, 0xF8, 0x3C, 0x0F, 0x80, 0x7E,
  0x1E, 0x07, 0xC0, 0x1F, 0x8F, 0x03, 0xE0, 0x07, 0xC7, 0x01, 0xF0, 0x01,
  0xF3, 0x80, 0xF0, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x3F, 0xE0, 0x3E, 0x00,
  0x0F, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0xFF, 0x01, 0xF0, 0x00, 0x6F, 0xC0, 0xFC, 0x00, 0xF3, 0xE0, 0x3F,
  0x81, 0xF0, 0xF8, 0x1F, 0xFF, 0xF0, 0x7E, 0x07, 0xFF, 0xF0, 0x1F, 0x80,
  0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x01, 0x00, 0x1E, 0x00, 0x2F, 0x80,
  0x78, 0x07, 0xFF, 0xC1, 0xE0, 0xFF, 0xFF, 0xE7, 0x9F, 0xFD, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0x00, 0x03, 0x00, 0x04, 0x00,
  0x08, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x78, 0x0F, 0xFF, 0x03, 0xF0,
  0x3F, 0xFC, 0x1F, 0xE0, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xC1, 0xFE, 0x0F,
  0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0x80, 0xFF, 0xF0, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xF0, 0xF8,
  0x00, 0x3F, 0x83, 0xE0, 0x01, 0xFC, 0x0F, 0x80, 0x0F, 0xE0, 0x3E, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xC0, 0x0F, 0x80, 0x02,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xC0, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0x18, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x01,
  0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x7E, 0x0C, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x10, 0x00, 0x03, 0xF3, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xC3, 0xFC, 0x07, 0xF8,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07,
  0xC7, 0x80, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xF0,
  0x07, 0x80, 0x01, 0xF0, 0x07, 0x80, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x07, 0x80, 0x1F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x3E, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x0F,
  0xE0, 0x03, 0xC3, 0xFF, 0xC0, 0x3C, 0xFF, 0xFE, 0x03, 0xDF, 0xFF, 0xF0,
  0x3D, 0xC0, 0x7F, 0x83, 0xF0, 0x01, 0xFC, 0x3E, 0x00, 0x0F, 0xE0, 0x40,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF1, 0x00, 0x00,
  0x3E, 0x18, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xC7,
  0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x0F, 0xE0, 0x07, 0xC3, 0xFF, 0xC0,
  0x7C, 0xFF, 0xFE, 0x07, 0xDF, 0xFF, 0xF8, 0xFB, 0xE0, 0x7F, 0x8F, 0xB0,
  0x00, 0xFC, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0xE0,
  0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7E, 0xF0, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0xFC, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0xFC, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F,
  0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x07,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0xDF, 0x3F, 0xE0, 0x7D,
  0xE1, 0xFF, 0xFF, 0xBE, 0x0F, 0xFF, 0xF3, 0xE0, 0x3F, 0xFC, 0x3E, 0x00,
  0xFF, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x1F, 0x87, 0xF8, 0xFF, 0x1F,
  0xE3, 0xFC, 0x7F, 0x8F, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x1F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xC0,
  0xFE, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xE1, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xE0,
  0x3F, 0x81, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x3C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1E, 0x78, 0x03, 0xF1, 0xE7, 0x80, 0x7F, 0x9E, 0xF8, 0x0F, 0xFD,
  0xEF, 0x81, 0xFF, 0xDF, 0xF0, 0x3F, 0x07, 0xFF, 0x03, 0xE0, 0x3F, 0xF0,
  0x3C, 0x01, 0xFF, 0x07, 0xC0, 0x1F, 0xF0, 0x7C, 0x01, 0xFF, 0x07, 0x80,
  0x1F, 0xF0, 0x78, 0x01, 0xFF, 0x07, 0x80, 0x1F, 0xF0, 0x78, 0x01, 0xFF,
  0x07, 0x80, 0x1F, 0xF0, 0x78, 0x01, 0xFF, 0x07, 0x80, 0x1F, 0xF0, 0x78,
  0x01, 0xFF, 0x07, 0xC0, 0x1F, 0xF0, 0x7C, 0x01, 0xFF, 0x03, 0xC0, 0x1F,
  0xF0, 0x3E, 0x03, 0xFF, 0x03, 0xF8, 0xFF, 0xF8, 0x1F, 0xFD, 0xFF, 0x80,
  0xFF, 0xDF, 0x78, 0x07, 0xF9, 0xF7, 0x80, 0x1C, 0x00, 0x78, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x03,
  0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0x0F, 0x80, 0x01, 0xF8,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x3F, 0x8F,
  0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F,
  0xCF, 0x80, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0xC0,
  0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x3F, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x87, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x08, 0x3E, 0x00, 0x01, 0xE3, 0xF0, 0x00, 0x1F,
  0x1F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0x80, 0x1F, 0xC1, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x9F, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE1, 0xF0, 0x03, 0xF8,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0xFC,
  0x00, 0xFE, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x83, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x0F, 0x7C, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x0F, 0x7C, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x1F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x0E, 0xF0, 0xFF, 0x03,
  0xCF, 0x07, 0xFF, 0xFC, 0xF0, 0x3F, 0xFF, 0x8F, 0x00, 0xFF, 0xF0, 0xF0,
  0x03, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x8C, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF0,
  0xFF, 0x03, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0xC3, 0xE0,
  0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x80, 0x3E, 0x00, 0xFC,
  0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F,
  0x8F, 0xE0, 0x00, 0x3E, 0x7F, 0xC0, 0x00, 0xFB, 0xFF, 0x00, 0x03, 0xEF,
  0xFE, 0x00, 0x0F, 0xFC, 0xFC, 0x00, 0x3F, 0xE3, 0xF0, 0x00, 0xFF, 0x87,
  0xE0, 0x03, 0xFC, 0x0F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x07, 0xE0,
  0x3E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0x80, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFC, 0xF8, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFB, 0xC0,
  0x3D, 0xFF, 0xBC, 0x03, 0xDF, 0xFB, 0xE0, 0x7D, 0xFF, 0x9E, 0x07, 0x9F,
  0xF9, 0xF0, 0x79, 0xFF, 0x8F, 0x0F, 0x1F, 0xF8, 0xF0, 0xF1, 0xFF, 0x8F,
  0x9F, 0x1F, 0xF8, 0x79, 0xE1, 0xFF, 0x87, 0xDE, 0x1F, 0xF8, 0x3F, 0xC1,
  0xFF, 0x83, 0xFC, 0x1F, 0xF8, 0x3F, 0xC1, 0xFF, 0x81, 0xF8, 0x1F, 0xF8,
  0x1F, 0x81, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0x60,
  0x1F, 0xF8, 0x06, 0x01, 0xFF, 0x80, 0x60, 0x1F, 0xF8, 0x04, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xDF, 0x00, 0x0F, 0xF3,
  0xC0, 0x03, 0xFC, 0xF8, 0x00, 0xFF, 0x3E, 0x00, 0x3F, 0xC7, 0xC0, 0x0F,
  0xF1, 0xF0, 0x03, 0xFC, 0x3C, 0x00, 0xFF, 0x0F, 0x80, 0x3F, 0xC3, 0xE0,
  0x0F, 0xF0, 0x7C, 0x03, 0xFC, 0x1F, 0x00, 0xFF, 0x03, 0xC0, 0x3F, 0xC0,
  0xF8, 0x0F, 0xF0, 0x3E, 0x03, 0xFC, 0x07, 0xC0, 0xFF, 0x01, 0xF0, 0x3F,
  0xC0, 0x3C, 0x0F, 0xF0, 0x0F, 0x83, 0xFC, 0x03, 0xE0, 0xFF, 0x00, 0x7C,
  0x3F, 0xC0, 0x1F, 0x0F, 0xF0, 0x03, 0xC3, 0xFC, 0x00, 0xF8, 0xFF, 0x00,
  0x3E, 0x3F, 0xC0, 0x07, 0xCF, 0xF0, 0x01, 0xF3, 0xFC, 0x00, 0x3C, 0xFF,
  0x00, 0x0F, 0xBF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF8, 0xF8, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xFC, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xF8,
  0x00, 0x1F, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E,
  0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0xC0,
  0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F,
  0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x7E, 0x00, 0x1F, 0xE3, 0xF0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3C, 0x7E, 0x00, 0x00, 0x41, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE1, 0x00, 0x00, 0x0F, 0x9E,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xC7, 0xF8,
  0x00, 0x7F, 0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3,
  0xF8, 0x07, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E,
  0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0,
  0x0F, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80,
  0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x1F, 0x78, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x07, 0xE0, 0x1E, 0x78, 0x07, 0xE0, 0x1E, 0x7C, 0x07, 0xE0, 0x1E,
  0x7C, 0x0F, 0xF0, 0x3E, 0x7C, 0x0F, 0xF0, 0x3E, 0x7C, 0x0F, 0xF0, 0x3E,
  0x7C, 0x0F, 0xF0, 0x3E, 0x3C, 0x0E, 0x70, 0x3C, 0x3C, 0x1E, 0x78, 0x3C,
  0x3C, 0x1E, 0x78, 0x3C, 0x3C, 0x1E, 0x78, 0x3C, 0x3C, 0x1E, 0x78, 0x3C,
  0x3C, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3E, 0x3C, 0x3C, 0x3C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3E, 0x78, 0x1E, 0x7C,
  0x3E, 0x78, 0x1E, 0x7C, 0x3E, 0x78, 0x1E, 0x7C, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0x78, 0x1E, 0xF0, 0x0F, 0x78,
  0x1E, 0xF0, 0x0F, 0x78, 0x1E, 0xF0, 0x0F, 0x78, 0x1F, 0xF0, 0x0F, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x07, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0x8F, 0x80, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xDC,
  0x00, 0x00, 0x0E, 0x10, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x08, 0x0E, 0x0F,
  0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x0C,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x7C, 0x03, 0x00, 0x03, 0xE0, 0x10, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x1F,
  0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xE0, 0xF8, 0x00, 0xFF, 0x07, 0xF0, 0x1E, 0x7F, 0x9F, 0xFF, 0xF3,
  0xFC, 0x7F, 0xFF, 0x0F, 0xE1, 0xFF, 0xE0, 0x3F, 0x01, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x1F, 0xC0, 0x3E, 0x3F, 0xFC, 0x0F, 0x9F, 0xFF,
  0x83, 0xEF, 0xFF, 0xF8, 0xFF, 0x80, 0xFE, 0x3F, 0x80, 0x0F, 0xCF, 0xC0,
  0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xF3, 0xF8, 0x00, 0xFC, 0xFF, 0x80,
  0xFE, 0x3E, 0xFF, 0xFF, 0x0F, 0x9F, 0xFF, 0x83, 0xE3, 0xFF, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x07, 0xE3, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x06, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0x0F, 0x80, 0x01, 0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x7E, 0x0F, 0xE0,
  0x7F, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0xFE, 0x07, 0xC0, 0xFF, 0xF1,
  0xF0, 0xFF, 0xFE, 0x7C, 0x7F, 0xFF, 0xDF, 0x1F, 0xC0, 0x7F, 0xCF, 0xC0,
  0x07, 0xF7, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0xFC, 0xFC, 0x00,
  0x7F, 0x1F, 0xC0, 0x7F, 0xC7, 0xFF, 0xFD, 0xF0, 0xFF, 0xFE, 0x7C, 0x0F,
  0xFF, 0x1F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0x01,
  0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x3C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x10, 0x7C, 0x00, 0x01, 0xC3, 0xE0, 0x00,
  0x3E, 0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x80,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xF3, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x7F,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0xFE, 0x7C, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x9F,
  0xC0, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0xF8, 0xFF, 0xF0,
  0xF9, 0xFF, 0xF8, 0xFB, 0xFF, 0xFC, 0xFB, 0x81, 0xFE, 0xFE, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x1F,
  0x8F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC0, 0xF8,
  0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xFC,
  0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0xFB, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xDF,
  0x80, 0x0F, 0xF8, 0xF8, 0x00, 0xFF, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3F,
  0x0F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xF8,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x07, 0xC3, 0xE7, 0xF8, 0x7F,
  0xCF, 0xBF, 0xF3, 0xFF, 0x3E, 0xFF, 0xDF, 0xFE, 0xFE, 0x1F, 0x60, 0xFB,
  0xF0, 0x3F, 0x03, 0xEF, 0x80, 0xFC, 0x07, 0xFE, 0x01, 0xE0, 0x1F, 0xF8,
  0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x01, 0xFF, 0x80, 0x78, 0x07, 0xFE, 0x01,
  0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x01, 0xFF, 0x80, 0x78,
  0x07, 0xFE, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x01,
  0xFF, 0x80, 0x78, 0x07, 0xFE, 0x01, 0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x7F,
  0xE0, 0x1E, 0x01, 0xFF, 0x80, 0x78, 0x07, 0xFE, 0x01, 0xE0, 0x1F, 0xF8,
  0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x01, 0xFF, 0x80, 0x78, 0x07, 0xFE, 0x01,
  0xE0, 0x1F, 0xF8, 0x07, 0x80, 0x7F, 0xE0, 0x1E, 0x01, 0xFF, 0x80, 0x78,
  0x07, 0xFE, 0x01, 0xE0, 0x1F, 0x00, 0x3F, 0x80, 0xF8, 0xFF, 0xF0, 0xF9,
  0xFF, 0xF8, 0xFB, 0xFF, 0xFC, 0xFB, 0x81, 0xFE, 0xFE, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0x01, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x78, 0x00,
  0x01, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x3E, 0x3F, 0xFC, 0x0F, 0x9F, 0xFF, 0x83, 0xEF,
  0xFF, 0xF8, 0xFF, 0x80, 0xFE, 0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xEF, 0xC0, 0x01, 0xF3, 0xF8, 0x00, 0xFC, 0xFF, 0x80, 0xFE, 0x3E,
  0xFF, 0xFF, 0x0F, 0x9F, 0xFF, 0x83, 0xE3, 0xFF, 0xC0, 0xF8, 0x1F, 0xC0,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF1, 0xF0, 0xFF, 0xFE, 0x7C, 0x7F, 0xFF,
  0xDF, 0x1F, 0xC0, 0x7F, 0xCF, 0xC0, 0x07, 0xF7, 0xE0, 0x00, 0xFD, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x7F, 0xC7, 0xFF,
  0xFD, 0xF0, 0xFF, 0xFE, 0x7C, 0x0F, 0xFF, 0x1F, 0x00, 0xFE, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xF0, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0x01, 0xEC, 0x00,
  0x00, 0x0F, 0x40, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC1, 0xFC, 0x03, 0xFC, 0x3E, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0xE1, 0xF0, 0x00, 0x08, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x10, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xBF,
  0x80, 0x03, 0xE3, 0xFC, 0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x81, 0xDF, 0x3F, 0xFF,
  0xDF, 0x1F, 0xFF, 0x9F, 0x0F, 0xFF, 0x1F, 0x01, 0xFC, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x78, 0x1F, 0x00, 0x07, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F,
  0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xF0,
  0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF8,
  0x07, 0xE0, 0x0F, 0xF8, 0x07, 0xF0, 0x1F, 0x78, 0x0F, 0xF0, 0x1E, 0x78,
  0x0F, 0x70, 0x1E, 0x78, 0x0E, 0x70, 0x1E, 0x78, 0x0E, 0x70, 0x1E, 0x78,
  0x0E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x1E, 0x38, 0x1C, 0x3C,
  0x1C, 0x38, 0x3C, 0x3C, 0x1C, 0x38, 0x3C, 0x3C, 0x1C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x1C, 0x3C, 0x1C,
  0x38, 0x1C, 0x38, 0x1E, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0x78, 0x1E, 0x70, 0x0E, 0x78, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0F, 0x70, 0x0F, 0xF0, 0x0F, 0x70, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0x3F, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x1F,
  0x8F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xBF,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00,
  0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E,
  0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80,
  0x03, 0xC0, 0x3E, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x78, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x30, 0x1F, 0xE0,
  0x00, 0xF0, 0xFF, 0xC0, 0x03, 0xC7, 0xFF, 0x80, 0x1E, 0x3E, 0x3F, 0x00,
  0x78, 0xF0, 0x7E, 0x01, 0xE3, 0xC0, 0xFC, 0x0F, 0x1E, 0x01, 0xF0, 0x3C,
  0x78, 0x03, 0xF1, 0xF1, 0xE0, 0x07, 0xFF, 0x8F, 0x00, 0x0F, 0xFC, 0x3C,
  0x00, 0x1F, 0xE0, 0x30, 0x00, 0x3F, 0x00,
};

const GFXglyph IBMPlexMono_Regular60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 8, 43, 36, 14, -42 },
  { 44, 16, 17, 36, 10, -44 },
  { 78, 34, 42, 36, 1, -42 },
  { 257, 30, 56, 36, 3, -49 },
  { 467, 34, 44, 36, 1, -43 },
  { 654, 33, 44, 36, 1, -43 },
  { 836, 4, 17, 36, 16, -44 },
  { 845, 18, 54, 36, 12, -46 },
  { 967, 18, 54, 36, 6, -46 },
  { 1089, 30, 30, 36, 3, -34 },
  { 1202, 28, 30, 36, 4, -33 },
  { 1307, 11, 16, 36, 12, -8 },
  { 1329, 18, 4, 36, 9, -21 },
  { 1338, 8, 8, 36, 14, -7 },
  { 1346, 26, 54, 36, 5, -46 },
  { 1522, 30, 44, 36, 3, -43 },
  { 1687, 30, 42, 36, 3, -42 },
  { 1845, 28, 43, 36, 4, -43 },
  { 1996, 28, 44, 36, 3, -43 },
  { 2150, 32, 42, 36, 2, -42 },
  { 2318, 28, 43, 36, 4, -42 },
  { 2469, 28, 43, 36, 4, -42 },
  { 2620, 28, 42, 36, 4, -42 },
  { 2767, 30, 44, 36, 3, -43 },
  { 2932, 28, 43, 36, 4, -43 },
  { 3083, 8, 32, 36, 14, -31 },
  { 3115, 11, 39, 36, 12, -31 },
  { 3169, 26, 35, 36, 5, -36 },
  { 3283, 28, 16, 36, 4, -26 },
  { 3339, 26, 35, 36, 5, -36 },
  { 3453, 26, 44, 36, 5, -43 },
  { 3596, 28, 50, 36, 4, -43 },
  { 3771, 32, 42, 36, 2, -42 },
  { 3939, 28, 42, 36, 5, -42 },
  { 4086, 28, 44, 36, 4, -43 },
  { 4240, 27, 42, 36, 6, -42 },
  { 4382, 26, 42, 36, 5, -42 },
  { 4519, 27, 42, 36, 5, -42 },
  { 4661, 28, 44, 36, 3, -43 },
  { 4815, 26, 42, 36, 5, -42 },
  { 4952, 26, 42, 36, 5, -42 },
  { 5089, 25, 43, 36, 4, -42 },
  { 5224, 30, 42, 36, 5, -42 },
  { 5382, 25, 42, 36, 7, -42 },
  { 5514, 28, 42, 36, 4, -42 },
  { 5661, 26, 42, 36, 5, -42 },
  { 5798, 30, 44, 36, 3, -43 },
  { 5963, 28, 42, 36, 5, -42 },
  { 6110, 30, 53, 36, 3, -43 },
  { 6309, 28, 42, 36, 5, -42 },
  { 6456, 30, 44, 36, 3, -43 },
  { 6621, 34, 42, 36, 1, -42 },
  { 6800, 26, 43, 36, 5, -42 },
  { 6940, 32, 42, 36, 2, -42 },
  { 7108, 32, 42, 36, 2, -42 },
  { 7276, 33, 42, 36, 2, -42 },
  { 7450, 34, 42, 36, 1, -42 },
  { 7629, 30, 42, 36, 3, -42 },
  { 7787, 17, 54, 36, 13, -46 },
  { 7902, 26, 54, 36, 5, -46 },
  { 8078, 17, 54, 36, 6, -46 },
  { 8193, 30, 25, 36, 3, -42 },
  { 8287, 28, 4, 36, 4, 6 },
  { 8301, 10, 12, 36, 11, -47 },
  { 8316, 29, 33, 36, 4, -32 },
  { 8436, 26, 45, 36, 6, -44 },
  { 8583, 26, 33, 36, 5, -32 },
  { 8691, 26, 45, 36, 4, -44 },
  { 8838, 28, 33, 36, 4, -32 },
  { 8954, 29, 44, 36, 4, -44 },
  { 9114, 30, 48, 36, 4, -35 },
  { 9294, 24, 44, 36, 6, -44 },
  { 9426, 27, 45, 36, 6, -45 },
  { 9578, 21, 57, 36, 6, -45 },
  { 9728, 28, 44, 36, 6, -44 },
  { 9882, 26, 44, 36, 5, -44 },
  { 10025, 30, 32, 36, 3, -32 },
  { 10145, 24, 32, 36, 6, -32 },
  { 10241, 28, 33, 36, 4, -32 },
  { 10357, 26, 44, 36, 6, -32 },
  { 10500, 26, 44, 36, 4, -32 },
  { 10643, 29, 31, 36, 5, -31 },
  { 10756, 27, 33, 36, 4, -32 },
  { 10868, 30, 42, 36, 2, -42 },
  { 11026, 24, 32, 36, 6, -31 },
  { 11122, 28, 31, 36, 4, -31 },
  { 11231, 32, 31, 36, 2, -31 },
  { 11355, 28, 31, 36, 4, -31 },
  { 11464, 30, 43, 36, 3, -31 },
  { 11626, 26, 31, 36, 5, -31 },
  { 11727, 24, 54, 36, 6, -46 },
  { 11889, 4, 54, 36, 16, -46 },
  { 11916, 24, 54, 36, 6, -46 },
  { 12078, 30, 13, 36, 3, -25 },
};

const GFXfont IBMPlexMono_Regular60pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular60pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular60pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _IBMPLEXMONO_REGULAR60PT7B_H_
