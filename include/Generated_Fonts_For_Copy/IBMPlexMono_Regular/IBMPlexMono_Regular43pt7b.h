#ifndef _IBMPLEXMONO_REGULAR43PT7B_H_
#define _IBMPLEXMONO_REGULAR43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular43pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9C, 0x70, 0xC3,
  0x0C, 0x30, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x70, 0xF0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE1, 0xE0, 0x7F, 0xC1, 0xFF, 0x7F,
  0xC1, 0xFF, 0x7F, 0xC1, 0xFF, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x03,
  0xC3, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80, 0xFF,
  0x83, 0xFE, 0xFF, 0x87, 0xFE, 0xFF, 0x87, 0xFE, 0x07, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x0F, 0x00, 0x0F,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xCE, 0x7E, 0x3C, 0x38, 0x78,
  0xE0, 0xE0, 0xF7, 0x83, 0x82, 0x1E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xE0,
  0xE0, 0x03, 0x83, 0x80, 0x0F, 0x0E, 0x00, 0x1F, 0xB8, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xE3, 0xE0,
  0x03, 0x87, 0x80, 0x0E, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0xF0, 0x03,
  0x83, 0xC8, 0x0E, 0x0F, 0x70, 0x38, 0x7B, 0xF0, 0xE1, 0xE3, 0xF3, 0x9F,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0x3F,
  0xC0, 0x0E, 0x7F, 0xE0, 0x0E, 0x70, 0xF0, 0x1C, 0xE0, 0x70, 0x1C, 0xE0,
  0x38, 0x38, 0xE0, 0x38, 0x78, 0xE0, 0x38, 0x70, 0xE0, 0x38, 0xF0, 0xE0,
  0x38, 0xE0, 0xE0, 0x71, 0xC0, 0x70, 0xF1, 0xC0, 0x7F, 0xE3, 0x80, 0x3F,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x03,
  0xCF, 0xFE, 0x03, 0x8F, 0x1E, 0x07, 0x1E, 0x07, 0x07, 0x1C, 0x07, 0x0E,
  0x1C, 0x07, 0x0E, 0x1C, 0x07, 0x1C, 0x1C, 0x07, 0x1C, 0x1C, 0x07, 0x38,
  0x1E, 0x07, 0x38, 0x0F, 0x0E, 0x70, 0x0F, 0xFE, 0x70, 0x07, 0xFC, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0x07, 0x80, 0x1E, 0x03, 0xC0, 0x1C, 0x01, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F,
  0xE0, 0x7E, 0x3C, 0xF0, 0x70, 0x78, 0x78, 0x70, 0x70, 0x3C, 0x70, 0xF0,
  0x1E, 0x60, 0xF0, 0x1F, 0x60, 0xF0, 0x0F, 0xE0, 0xF0, 0x07, 0xE0, 0xF0,
  0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x02, 0xF0, 0x7E, 0x0E, 0x78, 0x3F,
  0xFC, 0x3C, 0x1F, 0xF8, 0x3C, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x3C, 0x1C, 0x0E, 0xFE, 0x71,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xF3, 0xC0, 0x07, 0x87, 0x80, 0x1C,
  0x1E, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0x78, 0x0C, 0x00, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0x3E, 0x3E, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF0,
  0xF0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xF0, 0x3E, 0x07, 0xC1, 0xE0, 0x1E, 0x1E, 0x00, 0x78, 0xE0, 0x01, 0xCF,
  0x00, 0x0E, 0x78, 0x00, 0x7B, 0x80, 0x03, 0xDC, 0x00, 0x0E, 0xE0, 0x00,
  0x7F, 0x07, 0x83, 0xF8, 0x7C, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x07, 0xF0,
  0x78, 0x3F, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07,
  0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x00, 0x0E, 0x3C, 0x00, 0xF0, 0xF0,
  0x0F, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xEF, 0x00, 0x0F,
  0xBC, 0x00, 0x7C, 0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x0F, 0x00, 0xF8, 0x3C,
  0x00, 0xC0, 0xF0, 0x02, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x03,
  0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xE0, 0xF8, 0x78, 0x03, 0xCF,
  0x00, 0x3C, 0xF0, 0x01, 0xE6, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xC3, 0xF0, 0x7C,
  0x3C, 0x01, 0xE7, 0x80, 0x1E, 0x10, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3F,
  0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF2,
  0x00, 0x0F, 0x70, 0x00, 0xFF, 0x80, 0x1E, 0x7E, 0x07, 0xE3, 0xFF, 0xFC,
  0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xDE, 0x00, 0x07, 0x3C, 0x00, 0x1E,
  0x78, 0x00, 0x38, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x38, 0x1E, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x78,
  0x07, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0xE0, 0x07, 0x83,
  0xC0, 0x0F, 0x07, 0x00, 0x1E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE3, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x0F, 0xC0, 0x73, 0xFF, 0x07, 0x7F, 0xF8, 0x7E, 0x07, 0xC7, 0x80, 0x3E,
  0x10, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF2, 0x00, 0x0E, 0x70, 0x01, 0xEF, 0x80,
  0x3E, 0x7E, 0x07, 0xC3, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x8F, 0xC0, 0x73, 0xFF, 0x0F, 0x7F, 0xFC, 0xFE, 0x07,
  0xCF, 0x80, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70,
  0x01, 0xE7, 0x80, 0x3E, 0x3E, 0x07, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xF8, 0x7E, 0x07, 0xC3, 0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x01, 0xCF,
  0x00, 0x0F, 0x78, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x3C, 0x78, 0x01,
  0xC1, 0xF0, 0x3C, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x1F,
  0x03, 0xE1, 0xE0, 0x07, 0x9E, 0x00, 0x1E, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xE0,
  0x07, 0xCF, 0xC0, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xE0, 0x7C, 0x78, 0x03,
  0xC7, 0x00, 0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0x78,
  0x03, 0xF7, 0xE0, 0x7F, 0x3F, 0xFE, 0xE1, 0xFF, 0xCE, 0x03, 0xF1, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0x3C, 0x7E, 0x7E,
  0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0xF0,
  0xE0, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F, 0x03, 0xE7,
  0xC0, 0x3C, 0xF0, 0x03, 0xFC, 0x00, 0x79, 0x80, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xFE, 0x00,
  0x7F, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0x7C,
  0x3C, 0x01, 0xC7, 0x80, 0x1E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xF0, 0x3C,
  0xEE, 0x0F, 0xEF, 0xE0, 0xFF, 0x7E, 0x1E, 0x1F, 0xE1, 0xC0, 0xFE, 0x1C,
  0x0F, 0xE3, 0xC0, 0x7E, 0x38, 0x07, 0xE3, 0x80, 0x7E, 0x38, 0x07, 0xE3,
  0x80, 0x7E, 0x38, 0x07, 0xE3, 0xC0, 0xFE, 0x1C, 0x0F, 0xE1, 0xE0, 0xFE,
  0x1F, 0xF7, 0xE0, 0xFF, 0x7E, 0x07, 0xE7, 0x70, 0x10, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0xE7, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xC7, 0x80, 0x01, 0xC3, 0x80,
  0x03, 0xC3, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x81, 0xC0,
  0x07, 0x81, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1C, 0x00, 0x78,
  0x1C, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C,
  0x78, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x70, 0x07, 0xCE, 0x00, 0x3D,
  0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x00, 0x1E, 0xE0, 0x03, 0xDC, 0x00, 0x7B,
  0x80, 0x0F, 0x70, 0x01, 0xCE, 0x00, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0xF8, 0xE0, 0x07, 0xDC, 0x00, 0x7B, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7B, 0x80, 0x1F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC1, 0xF0, 0x7C, 0x3E, 0x01,
  0xE3, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x04, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x47, 0x80, 0x0F,
  0x3C, 0x00, 0xF3, 0xE0, 0x1E, 0x1F, 0x07, 0xC0, 0xFF, 0xFC, 0x07, 0xFF,
  0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x78, 0x0F,
  0x8F, 0x00, 0x79, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x77, 0x80, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x7C, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF,
  0xFE, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xF8, 0x3E, 0x1E, 0x01, 0xE3,
  0xC0, 0x0F, 0x38, 0x00, 0x77, 0x80, 0x04, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0x70, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x77, 0x80, 0x07, 0x78, 0x00, 0x73, 0x80, 0x07, 0x3C,
  0x00, 0xF3, 0xE0, 0x1F, 0x1F, 0x03, 0x70, 0xFF, 0xF7, 0x07, 0xFE, 0x70,
  0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3F, 0xC0, 0x0E, 0xF0, 0x07, 0x9E, 0x01, 0xE7, 0xC1, 0xF0, 0xFF,
  0xF8, 0x1F, 0xFC, 0x01, 0xFC, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x38,
  0x00, 0xF1, 0xC0, 0x0F, 0x8E, 0x00, 0xF8, 0x70, 0x07, 0x83, 0x80, 0x78,
  0x1C, 0x07, 0x80, 0xE0, 0x78, 0x07, 0x07, 0xC0, 0x38, 0x7C, 0x01, 0xC3,
  0xC0, 0x0E, 0x3C, 0x00, 0x73, 0xF0, 0x03, 0xBF, 0x80, 0x1F, 0xDE, 0x00,
  0xFE, 0xF0, 0x07, 0xE3, 0xC0, 0x3E, 0x0F, 0x01, 0xE0, 0x78, 0x0E, 0x01,
  0xE0, 0x70, 0x0F, 0x83, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x87,
  0x00, 0x1E, 0x38, 0x00, 0xF9, 0xC0, 0x03, 0xCE, 0x00, 0x0F, 0x70, 0x00,
  0x7C, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFE, 0xE0, 0x77,
  0xEE, 0x07, 0x7E, 0xF0, 0xE7, 0xE7, 0x0E, 0x7E, 0x70, 0xE7, 0xE3, 0x9C,
  0x7E, 0x39, 0xC7, 0xE3, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F,
  0x07, 0xE0, 0xF0, 0x7E, 0x0E, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0,
  0x40, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFD, 0xC0, 0x3F, 0xBC, 0x07, 0xF3, 0x80, 0xFE, 0x70, 0x1F,
  0xCF, 0x03, 0xF8, 0xE0, 0x7F, 0x1E, 0x0F, 0xE1, 0xC1, 0xFC, 0x38, 0x3F,
  0x87, 0x87, 0xF0, 0x70, 0xFE, 0x0F, 0x1F, 0xC0, 0xE3, 0xF8, 0x1C, 0x7F,
  0x03, 0xCF, 0xE0, 0x39, 0xFC, 0x07, 0xBF, 0x80, 0x77, 0xF0, 0x0E, 0xFE,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0, 0x3E, 0x07, 0xC1, 0xE0,
  0x1E, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0x7B,
  0x80, 0x03, 0xDC, 0x00, 0x1E, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xDC,
  0x00, 0x0E, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01,
  0xE7, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0xC0, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x70, 0x03, 0xEE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x0F, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xF0, 0x3E, 0x07, 0xC1, 0xE0, 0x1E, 0x1E, 0x00, 0x78, 0xE0,
  0x03, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0x7B, 0x80, 0x03, 0xDC, 0x00, 0x1E,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0xF7,
  0x00, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x3C, 0x00,
  0xF1, 0xF0, 0x0F, 0x07, 0xC0, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8E, 0x00, 0x7C, 0xE0, 0x01, 0xEE, 0x00, 0x1E,
  0xE0, 0x01, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01,
  0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x7C, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFC, 0x0E, 0x07, 0x00, 0xE0, 0x78, 0x0E, 0x03, 0xC0, 0xE0,
  0x3C, 0x0E, 0x01, 0xE0, 0xE0, 0x1E, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E,
  0x00, 0x78, 0xE0, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x01, 0xEE, 0x00, 0x1F,
  0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x7E, 0x07, 0xE3, 0xC0,
  0x0F, 0xBC, 0x00, 0x39, 0xE0, 0x00, 0x8F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE4, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0x9F, 0xC0, 0xFC, 0x3F,
  0xFF, 0xC0, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x7B, 0x80, 0x0F, 0x78, 0x01,
  0xEF, 0x80, 0x78, 0xF8, 0x1F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xF8,
  0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xDC, 0x00, 0x0E,
  0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x0E, 0x00, 0x3C, 0x3C,
  0x00, 0xF0, 0xF0, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x80, 0x78, 0x1E, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0x80,
  0x1C, 0x0E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E,
  0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77,
  0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70,
  0x3C, 0x0E, 0xE0, 0x78, 0x3D, 0xC1, 0xF8, 0x73, 0xC3, 0xF0, 0xE7, 0x87,
  0xE1, 0xC7, 0x0D, 0xC3, 0x8E, 0x19, 0x87, 0x1C, 0x73, 0x8E, 0x38, 0xE7,
  0x1C, 0x71, 0xCE, 0x38, 0xE3, 0x1C, 0x71, 0xCE, 0x18, 0xE3, 0x9C, 0x39,
  0xC7, 0x38, 0x73, 0x8E, 0x70, 0xE7, 0x1C, 0xC1, 0xDC, 0x3F, 0x81, 0xF8,
  0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x1F, 0x83,
  0xE0, 0x1F, 0x00, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0x81, 0xE0,
  0x07, 0x81, 0xE0, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0x80, 0x01, 0xE7, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xE7, 0x80,
  0x01, 0xE7, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x81, 0xE0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x1E, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0,
  0x07, 0x81, 0xE0, 0x03, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE7, 0x80,
  0x01, 0xE7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x77, 0x80, 0x03, 0xCE, 0x00, 0x0E, 0x3C, 0x00, 0x78, 0x70, 0x01,
  0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x1E, 0x07, 0x00,
  0x38, 0x38, 0x00, 0xF1, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0xBC, 0x00, 0x0E,
  0xE0, 0x00, 0x3C, 0x80, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x71, 0xE1, 0xE1, 0xC3, 0xC3, 0x83, 0x86, 0x03, 0xF8, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xF8, 0x1F, 0x07, 0x00, 0x78, 0x10, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xC0, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x0F,
  0x1C, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x1E, 0x06, 0x70, 0xFF,
  0xF3, 0xF3, 0xFF, 0x1F, 0x87, 0xE0, 0x7C, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC3, 0xF0, 0x79, 0xFF, 0x8F,
  0x7F, 0xF9, 0xF8, 0x1F, 0x3E, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x7C,
  0x01, 0xEF, 0xC0, 0xF9, 0xEF, 0xFF, 0x3C, 0xFF, 0x87, 0x87, 0xE0, 0x03,
  0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x78, 0x03, 0xDC, 0x00,
  0x6F, 0x00, 0x23, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x04, 0x70,
  0x01, 0xDE, 0x00, 0xF3, 0xE0, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x1F, 0x87, 0x8F, 0xFC, 0xF3, 0xFF, 0xDE, 0xFC, 0x1F, 0xDE, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x01, 0xF7, 0xE0, 0xFE, 0x7F, 0xFB,
  0xC7, 0xFE, 0x78, 0x3F, 0x0F, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF,
  0x83, 0xE0, 0x7C, 0x3C, 0x03, 0xC7, 0x80, 0x1E, 0x70, 0x00, 0xEF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0xC3,
  0xC0, 0x1E, 0x3E, 0x07, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xF6, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0xF8, 0x1F, 0x07, 0x80, 0x78, 0x78, 0x01, 0xC3, 0xC0, 0x0E, 0x1E, 0x00,
  0x70, 0xF0, 0x03, 0x87, 0x80, 0x1C, 0x1E, 0x01, 0xE0, 0xF8, 0x1E, 0x03,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF3, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0x7F,
  0xF8, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x0F, 0x83, 0xCF, 0xF8, 0xF7, 0xFF, 0x3F, 0x03, 0xEF, 0x80, 0x7B,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x03, 0xEE, 0x00, 0x78, 0xE0, 0x0F, 0x0E, 0x01, 0xE0, 0xE0,
  0x7C, 0x0E, 0x0F, 0x80, 0xE1, 0xF0, 0x0E, 0x3E, 0x00, 0xE7, 0xC0, 0x0E,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0x00, 0xF8, 0xF0, 0x0F, 0x07, 0x80,
  0xE0, 0x3C, 0x0E, 0x03, 0xE0, 0xE0, 0x1E, 0x0E, 0x00, 0xF0, 0xE0, 0x07,
  0x8E, 0x00, 0x3C, 0xE0, 0x03, 0xEE, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xC1, 0xE7, 0xBF, 0x3F, 0xBF, 0xFD, 0xFF, 0xF1, 0xF8, 0xFF, 0x07,
  0x83, 0xF8, 0x3C, 0x1F, 0xC1, 0xC0, 0xFE, 0x0E, 0x07, 0xF0, 0x70, 0x3F,
  0x83, 0x81, 0xFC, 0x1C, 0x0F, 0xE0, 0xE0, 0x7F, 0x07, 0x03, 0xF8, 0x38,
  0x1F, 0xC1, 0xC0, 0xFE, 0x0E, 0x07, 0xF0, 0x70, 0x3F, 0x83, 0x81, 0xFC,
  0x1C, 0x0F, 0xE0, 0xE0, 0x7F, 0x07, 0x03, 0xF8, 0x38, 0x1C, 0xF0, 0xF8,
  0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xF0, 0x3E, 0xF8, 0x07, 0xBC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF0,
  0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0x7C, 0x78, 0x03,
  0xC7, 0x00, 0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xF7, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x80, 0x3C, 0x3E, 0x07, 0xC1,
  0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0xF0, 0xFC, 0x1E, 0x7F, 0xE3,
  0xDF, 0xFE, 0x7E, 0x07, 0xCF, 0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xDF,
  0x00, 0x7B, 0xF0, 0x3E, 0x7B, 0xFF, 0xCF, 0x3F, 0xE1, 0xE1, 0xF8, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xE1, 0xE3,
  0xFF, 0x3C, 0xFF, 0xF7, 0xBF, 0x07, 0xF7, 0x80, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xEF, 0x00, 0x7D, 0xF8, 0x3F, 0x9F, 0xFE, 0xF1, 0xFF, 0x9E, 0x0F,
  0xC3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0xFF,
  0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xFE, 0x03, 0xB8, 0x00, 0x1D, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x01, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xE0, 0x3E, 0x78, 0x00, 0xC7, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x60, 0x00, 0xEF, 0x00, 0x1E, 0x7E, 0x03, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xDE, 0x01, 0xF7, 0xC1, 0xFC, 0xFF, 0xEF, 0x1F, 0xF3, 0xC1, 0xF8,
  0xF0, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xE7, 0x00, 0x1E, 0x78,
  0x01, 0xC3, 0x80, 0x1C, 0x38, 0x03, 0xC3, 0xC0, 0x38, 0x1C, 0x03, 0x81,
  0xE0, 0x78, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0F, 0x0F, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0x79, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0xE0, 0x3C, 0x0F, 0x70,
  0x3C, 0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x7E, 0x0E, 0x70, 0x7E, 0x0E, 0x70,
  0x6E, 0x0E, 0x70, 0x66, 0x0E, 0x70, 0x66, 0x0C, 0x30, 0xE7, 0x1C, 0x38,
  0xE7, 0x1C, 0x38, 0xC7, 0x1C, 0x38, 0xC3, 0x1C, 0x38, 0xC3, 0x1C, 0x39,
  0xC3, 0x98, 0x19, 0xC3, 0x98, 0x19, 0x83, 0xB8, 0x1D, 0x81, 0xB8, 0x1D,
  0x81, 0xB8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x0F,
  0x00, 0xF0, 0xF0, 0x00, 0xF7, 0x80, 0x1E, 0x3C, 0x03, 0xC3, 0xE0, 0x38,
  0x1E, 0x07, 0x80, 0xF0, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xC0, 0x07, 0x9E, 0x00, 0xF1, 0xE0, 0x0E, 0x0F, 0x01, 0xE0, 0x78, 0x3C,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0x3D,
  0xC0, 0x01, 0xE7, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0x70,
  0x03, 0x81, 0xC0, 0x1E, 0x07, 0x80, 0x78, 0x0E, 0x01, 0xC0, 0x3C, 0x0F,
  0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x07, 0x87, 0x00, 0x0E, 0x1C, 0x00,
  0x3C, 0xF0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x01,
  0xE0, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF,
  0x00, 0x7F, 0x03, 0xFF, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0xFF, 0xE0,
  0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0x80, 0x18, 0x7F, 0x00, 0x73, 0xFE, 0x03,
  0x8E, 0x3C, 0x0E, 0x70, 0x78, 0x79, 0xC0, 0xF1, 0xC6, 0x01, 0xFF, 0x38,
  0x03, 0xF8, 0x60, 0x07, 0x80,
};

const GFXglyph IBMPlexMono_Regular43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 6, 30, 26, 10, -30 },
  { 24, 11, 12, 26, 7, -32 },
  { 41, 24, 30, 26, 1, -30 },
  { 131, 22, 38, 26, 2, -34 },
  { 236, 24, 30, 26, 1, -30 },
  { 326, 24, 30, 26, 1, -30 },
  { 416, 4, 12, 26, 11, -32 },
  { 422, 12, 39, 26, 9, -33 },
  { 481, 12, 39, 26, 5, -33 },
  { 540, 22, 21, 26, 2, -24 },
  { 598, 20, 21, 26, 3, -24 },
  { 651, 8, 12, 26, 9, -6 },
  { 663, 12, 3, 26, 7, -15 },
  { 668, 6, 6, 26, 10, -6 },
  { 673, 18, 39, 26, 4, -33 },
  { 761, 21, 30, 26, 2, -30 },
  { 840, 22, 30, 26, 2, -30 },
  { 923, 20, 30, 26, 3, -30 },
  { 998, 20, 30, 26, 2, -30 },
  { 1073, 23, 30, 26, 1, -30 },
  { 1160, 20, 30, 26, 3, -30 },
  { 1235, 20, 30, 26, 3, -30 },
  { 1310, 20, 30, 26, 3, -30 },
  { 1385, 21, 30, 26, 2, -30 },
  { 1464, 20, 30, 26, 3, -30 },
  { 1539, 6, 23, 26, 10, -23 },
  { 1557, 8, 29, 26, 9, -23 },
  { 1586, 18, 25, 26, 4, -26 },
  { 1643, 20, 12, 26, 3, -19 },
  { 1673, 18, 25, 26, 4, -26 },
  { 1730, 19, 30, 26, 3, -30 },
  { 1802, 20, 35, 26, 3, -30 },
  { 1890, 24, 30, 26, 1, -30 },
  { 1980, 19, 30, 26, 4, -30 },
  { 2052, 20, 30, 26, 3, -30 },
  { 2127, 19, 30, 26, 4, -30 },
  { 2199, 18, 30, 26, 4, -30 },
  { 2267, 19, 30, 26, 4, -30 },
  { 2339, 20, 30, 26, 2, -30 },
  { 2414, 19, 30, 26, 3, -30 },
  { 2486, 18, 30, 26, 4, -30 },
  { 2554, 18, 30, 26, 3, -30 },
  { 2622, 21, 30, 26, 4, -30 },
  { 2701, 18, 30, 26, 5, -30 },
  { 2769, 20, 30, 26, 3, -30 },
  { 2844, 19, 30, 26, 3, -30 },
  { 2916, 21, 30, 26, 2, -30 },
  { 2995, 19, 30, 26, 4, -30 },
  { 3067, 21, 37, 26, 2, -30 },
  { 3165, 20, 30, 26, 4, -30 },
  { 3240, 21, 30, 26, 2, -30 },
  { 3319, 24, 30, 26, 1, -30 },
  { 3409, 19, 30, 26, 3, -30 },
  { 3481, 22, 30, 26, 2, -30 },
  { 3564, 23, 30, 26, 1, -30 },
  { 3651, 24, 30, 26, 1, -30 },
  { 3741, 24, 30, 26, 1, -30 },
  { 3831, 22, 30, 26, 2, -30 },
  { 3914, 12, 39, 26, 10, -33 },
  { 3973, 18, 39, 26, 4, -33 },
  { 4061, 12, 39, 26, 4, -33 },
  { 4120, 22, 18, 26, 2, -30 },
  { 4170, 20, 3, 26, 3, 4 },
  { 4178, 7, 8, 26, 8, -33 },
  { 4185, 21, 22, 26, 3, -22 },
  { 4243, 19, 32, 26, 4, -32 },
  { 4319, 18, 22, 26, 4, -22 },
  { 4369, 19, 32, 26, 3, -32 },
  { 4445, 20, 22, 26, 3, -22 },
  { 4500, 20, 32, 26, 3, -32 },
  { 4580, 21, 34, 26, 3, -25 },
  { 4670, 18, 32, 26, 4, -32 },
  { 4742, 18, 32, 26, 5, -32 },
  { 4814, 16, 41, 26, 4, -32 },
  { 4896, 20, 32, 26, 5, -32 },
  { 4976, 19, 32, 26, 3, -32 },
  { 5052, 21, 22, 26, 2, -22 },
  { 5110, 18, 22, 26, 4, -22 },
  { 5160, 20, 22, 26, 3, -22 },
  { 5215, 19, 31, 26, 4, -22 },
  { 5289, 19, 31, 26, 3, -22 },
  { 5363, 21, 22, 26, 3, -22 },
  { 5421, 20, 22, 26, 3, -22 },
  { 5476, 21, 30, 26, 2, -30 },
  { 5555, 18, 22, 26, 4, -22 },
  { 5605, 20, 22, 26, 3, -22 },
  { 5660, 24, 22, 26, 1, -22 },
  { 5726, 20, 22, 26, 3, -22 },
  { 5781, 22, 31, 26, 2, -22 },
  { 5867, 18, 22, 26, 4, -22 },
  { 5917, 16, 39, 26, 5, -33 },
  { 5995, 3, 39, 26, 11, -33 },
  { 6010, 16, 39, 26, 5, -33 },
  { 6088, 22, 9, 26, 2, -18 },
};

const GFXfont IBMPlexMono_Regular43pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular43pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular43pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _IBMPLEXMONO_REGULAR43PT7B_H_
