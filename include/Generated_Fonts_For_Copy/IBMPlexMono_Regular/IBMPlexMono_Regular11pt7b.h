#ifndef _IBMPLEXMONO_REGULAR11PT7B_H_
#define _IBMPLEXMONO_REGULAR11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x47, 0xB6, 0x80, 0x28, 0xA6, 0xCA, 0x2B, 0x35, 0x14, 0x23,
  0xAB, 0x4E, 0x1C, 0xB5, 0x71, 0x00, 0x66, 0x9B, 0x98, 0x0D, 0xD5, 0x63,
  0x31, 0x24, 0x09, 0x7A, 0x68, 0x9D, 0xE0, 0x2A, 0x49, 0x24, 0x44, 0xC8,
  0x92, 0x49, 0x58, 0x10, 0x4F, 0xCC, 0x68, 0x21, 0x3E, 0x42, 0x00, 0x5A,
  0xE0, 0x70, 0x18, 0x84, 0x42, 0x11, 0x08, 0x84, 0x00, 0x74, 0x63, 0x1A,
  0xC6, 0x2E, 0x67, 0x28, 0x42, 0x10, 0x9F, 0x74, 0x82, 0x23, 0x32, 0x1F,
  0x74, 0xC4, 0xC1, 0x06, 0x7E, 0x18, 0x62, 0x92, 0x4B, 0xF0, 0x82, 0xFC,
  0x21, 0xE8, 0x86, 0x2E, 0x32, 0x21, 0xE8, 0xC6, 0x2E, 0xFC, 0x44, 0x22,
  0x10, 0x88, 0xF4, 0x62, 0xE9, 0xC6, 0x3E, 0x74, 0x63, 0x17, 0x88, 0x4C,
  0x70, 0x70, 0x70, 0x5A, 0x09, 0xB1, 0x83, 0x04, 0xF8, 0x3E, 0x83, 0x06,
  0x36, 0x40, 0x74, 0x42, 0x62, 0x01, 0x8C, 0x74, 0x6F, 0x9C, 0xE6, 0xF0,
  0x70, 0x10, 0xC2, 0x8A, 0x49, 0xF4, 0x61, 0xF4, 0x63, 0xE8, 0xC6, 0x3E,
  0x74, 0x61, 0x08, 0x42, 0x2E, 0xF4, 0xE3, 0x18, 0xC6, 0x7E, 0xFC, 0x21,
  0xF8, 0x42, 0x1F, 0xFC, 0x21, 0xF8, 0x42, 0x10, 0x74, 0x61, 0x0B, 0xC6,
  0x2F, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xF9, 0x08, 0x42, 0x10, 0x9F, 0x71,
  0x11, 0x11, 0x97, 0x8C, 0xA9, 0xCE, 0x4A, 0x51, 0x84, 0x21, 0x08, 0x42,
  0x1F, 0x8C, 0xF7, 0xDA, 0xE6, 0x31, 0x8E, 0x73, 0x5A, 0xD6, 0x73, 0x74,
  0xE3, 0x18, 0xC6, 0x6E, 0xF4, 0x63, 0x1F, 0x42, 0x10, 0x74, 0xE3, 0x18,
  0xC6, 0x6E, 0x21, 0x80, 0xF4, 0x63, 0x1F, 0x52, 0x51, 0x39, 0x14, 0x1C,
  0x0C, 0x1C, 0x4E, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x8C, 0x63, 0x18,
  0xC6, 0x2E, 0xC5, 0x14, 0x92, 0x28, 0xA3, 0x04, 0x86, 0x19, 0x6D, 0x75,
  0xB6, 0xD3, 0xC5, 0x22, 0x84, 0x30, 0xA4, 0xB1, 0xC5, 0x12, 0x8A, 0x10,
  0x41, 0x04, 0xF8, 0x44, 0x44, 0x22, 0x1F, 0xF8, 0x88, 0x88, 0x88, 0x8F,
  0x84, 0x10, 0x82, 0x10, 0x82, 0x10, 0xC0, 0xE4, 0x92, 0x49, 0x3C, 0x10,
  0xA4, 0x91, 0x88, 0xF8, 0x90, 0x74, 0x85, 0xE9, 0x74, 0x84, 0x3D, 0x18,
  0xC6, 0x3E, 0x74, 0x61, 0x08, 0xB8, 0x08, 0x5B, 0x38, 0xC6, 0x6D, 0x74,
  0x7F, 0x08, 0xB8, 0x39, 0x3E, 0x42, 0x10, 0x9F, 0x1B, 0xA5, 0x27, 0x41,
  0xF1, 0xF8, 0x84, 0x2D, 0xB8, 0xC6, 0x31, 0x20, 0x38, 0x42, 0x10, 0x9F,
  0x10, 0xF1, 0x11, 0x11, 0x1F, 0x84, 0x27, 0x6E, 0x5A, 0x51, 0xE1, 0x08,
  0x42, 0x10, 0x9F, 0xDD, 0x6B, 0x5A, 0xD4, 0xB6, 0xE3, 0x18, 0xC4, 0x74,
  0x63, 0x18, 0xB8, 0xF4, 0x63, 0x18, 0xFA, 0x10, 0x6C, 0xE3, 0x19, 0xB4,
  0x21, 0xDB, 0x10, 0x84, 0x7C, 0x74, 0xF8, 0x38, 0xB8, 0x20, 0x8F, 0xC8,
  0x20, 0x82, 0x07, 0x8C, 0x63, 0x19, 0xB4, 0x8C, 0xA4, 0xA6, 0x10, 0x96,
  0x5B, 0x5D, 0x6D, 0x20, 0x8A, 0x98, 0xC5, 0x44, 0x8C, 0xA4, 0xA6, 0x11,
  0x18, 0xF8, 0x88, 0x88, 0x7C, 0x34, 0x22, 0xC2, 0x24, 0x43, 0xFF, 0xC0,
  0xE2, 0x24, 0x36, 0x42, 0x2E, 0xCD, 0x64,
};

const GFXglyph IBMPlexMono_Regular11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 3, 3, 7, 2, -8 },
  { 5, 6, 8, 7, 0, -8 },
  { 11, 5, 10, 7, 1, -9 },
  { 18, 6, 8, 7, 0, -8 },
  { 24, 6, 8, 7, 0, -8 },
  { 30, 1, 3, 7, 3, -8 },
  { 31, 3, 10, 7, 2, -8 },
  { 35, 3, 10, 7, 1, -8 },
  { 39, 6, 5, 7, 0, -6 },
  { 43, 5, 5, 7, 1, -6 },
  { 47, 2, 4, 7, 2, -2 },
  { 48, 3, 1, 7, 2, -4 },
  { 49, 2, 2, 7, 2, -2 },
  { 50, 5, 10, 7, 1, -8 },
  { 57, 5, 8, 7, 1, -8 },
  { 62, 5, 8, 7, 1, -8 },
  { 67, 5, 8, 7, 1, -8 },
  { 72, 5, 8, 7, 1, -8 },
  { 77, 6, 8, 7, 0, -8 },
  { 83, 5, 8, 7, 1, -8 },
  { 88, 5, 8, 7, 1, -8 },
  { 93, 5, 8, 7, 1, -8 },
  { 98, 5, 8, 7, 1, -8 },
  { 103, 5, 8, 7, 1, -8 },
  { 108, 2, 6, 7, 2, -6 },
  { 110, 2, 8, 7, 2, -6 },
  { 112, 5, 6, 7, 1, -6 },
  { 116, 5, 3, 7, 1, -5 },
  { 118, 5, 6, 7, 1, -6 },
  { 122, 5, 8, 7, 1, -8 },
  { 127, 5, 9, 7, 1, -8 },
  { 133, 6, 8, 7, 0, -8 },
  { 139, 5, 8, 7, 1, -8 },
  { 144, 5, 8, 7, 1, -8 },
  { 149, 5, 8, 7, 1, -8 },
  { 154, 5, 8, 7, 1, -8 },
  { 159, 5, 8, 7, 1, -8 },
  { 164, 5, 8, 7, 1, -8 },
  { 169, 5, 8, 7, 1, -8 },
  { 174, 5, 8, 7, 1, -8 },
  { 179, 4, 8, 7, 1, -8 },
  { 183, 5, 8, 7, 1, -8 },
  { 188, 5, 8, 7, 1, -8 },
  { 193, 5, 8, 7, 1, -8 },
  { 198, 5, 8, 7, 1, -8 },
  { 203, 5, 8, 7, 1, -8 },
  { 208, 5, 8, 7, 1, -8 },
  { 213, 5, 10, 7, 1, -8 },
  { 220, 5, 8, 7, 1, -8 },
  { 225, 6, 8, 7, 0, -8 },
  { 231, 6, 8, 7, 0, -8 },
  { 237, 5, 8, 7, 1, -8 },
  { 242, 6, 8, 7, 0, -8 },
  { 248, 6, 8, 7, 0, -8 },
  { 254, 6, 8, 7, 0, -8 },
  { 260, 6, 8, 7, 0, -8 },
  { 266, 5, 8, 7, 1, -8 },
  { 271, 4, 10, 7, 2, -8 },
  { 276, 5, 10, 7, 1, -8 },
  { 283, 3, 10, 7, 1, -8 },
  { 287, 6, 5, 7, 0, -8 },
  { 291, 5, 1, 7, 1, 1 },
  { 292, 2, 2, 7, 2, -9 },
  { 293, 5, 6, 7, 1, -6 },
  { 297, 5, 8, 7, 1, -8 },
  { 302, 5, 6, 7, 1, -6 },
  { 306, 5, 8, 7, 1, -8 },
  { 311, 5, 6, 7, 1, -6 },
  { 315, 5, 8, 7, 1, -8 },
  { 320, 5, 9, 7, 1, -7 },
  { 326, 5, 8, 7, 1, -8 },
  { 331, 5, 8, 7, 1, -8 },
  { 336, 4, 10, 7, 1, -8 },
  { 341, 5, 8, 7, 1, -8 },
  { 346, 5, 8, 7, 1, -8 },
  { 351, 5, 6, 7, 1, -6 },
  { 355, 5, 6, 7, 1, -6 },
  { 359, 5, 6, 7, 1, -6 },
  { 363, 5, 8, 7, 1, -6 },
  { 368, 5, 8, 7, 1, -6 },
  { 373, 5, 6, 7, 1, -6 },
  { 377, 5, 6, 7, 1, -6 },
  { 381, 6, 8, 7, 0, -8 },
  { 387, 5, 6, 7, 1, -6 },
  { 391, 5, 6, 7, 1, -6 },
  { 395, 6, 6, 7, 0, -6 },
  { 400, 5, 6, 7, 1, -6 },
  { 404, 5, 8, 7, 1, -6 },
  { 409, 5, 6, 7, 1, -6 },
  { 413, 4, 10, 7, 1, -8 },
  { 418, 1, 10, 7, 3, -8 },
  { 420, 4, 10, 7, 1, -8 },
  { 425, 5, 3, 7, 1, -5 },
};

const GFXfont IBMPlexMono_Regular11pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular11pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular11pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _IBMPLEXMONO_REGULAR11PT7B_H_
