#ifndef _IBMPLEXMONO_REGULAR18PT7B_H_
#define _IBMPLEXMONO_REGULAR18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular18pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x40, 0x7E, 0xDE, 0xF7, 0xBD, 0x80, 0x0D, 0x81,
  0x30, 0x24, 0x04, 0x87, 0x9E, 0x32, 0x04, 0xC0, 0x98, 0xF3, 0xC2, 0x40,
  0xC8, 0x19, 0x02, 0x60, 0x08, 0x04, 0x0F, 0x8D, 0x3C, 0x96, 0x41, 0x20,
  0xD0, 0x1E, 0x04, 0x82, 0x61, 0x38, 0x9E, 0x48, 0xF8, 0x10, 0x08, 0x00,
  0x78, 0x52, 0x3C, 0xCB, 0x36, 0x49, 0x1E, 0x80, 0x00, 0x0E, 0x1E, 0x49,
  0x12, 0x45, 0x19, 0xC3, 0x80, 0x1E, 0x0C, 0xC2, 0x00, 0x80, 0x20, 0x0C,
  0x03, 0x8D, 0x32, 0x45, 0xB0, 0xC4, 0x11, 0x8E, 0x3C, 0xC0, 0xF8, 0x19,
  0x18, 0x8C, 0x42, 0x10, 0x84, 0x21, 0x84, 0x30, 0x83, 0xC1, 0x0C, 0x21,
  0x84, 0x21, 0x08, 0x42, 0x31, 0x18, 0x98, 0x08, 0x04, 0x02, 0x1D, 0x73,
  0xE0, 0xE0, 0xD0, 0x44, 0x43, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8,
  0x40, 0x20, 0x10, 0x08, 0x00, 0x7B, 0x48, 0xF8, 0xFC, 0x02, 0x0C, 0x10,
  0x20, 0x81, 0x06, 0x08, 0x10, 0x40, 0x83, 0x04, 0x08, 0x30, 0x40, 0x3C,
  0x31, 0x90, 0x58, 0x2C, 0x1E, 0xCF, 0x77, 0x83, 0xC1, 0xE0, 0x90, 0x4C,
  0x63, 0xC0, 0x1C, 0x1E, 0x1B, 0x19, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x87, 0xF8, 0x3C, 0x31, 0xB0, 0xC0, 0x20, 0x10, 0x18,
  0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0x0F, 0xF8, 0x3C, 0x43, 0xC3, 0x03,
  0x03, 0x02, 0x3C, 0x03, 0x01, 0x01, 0x81, 0xC3, 0x7C, 0x06, 0x07, 0x06,
  0x82, 0x43, 0x21, 0x11, 0x09, 0x84, 0x82, 0x7F, 0xC0, 0x80, 0x40, 0x20,
  0x7F, 0x20, 0x10, 0x08, 0x04, 0x02, 0xF1, 0x8C, 0x02, 0x01, 0x80, 0xD0,
  0x5C, 0x63, 0xE0, 0x0E, 0x0C, 0x0C, 0x0C, 0x06, 0x02, 0xF3, 0x8D, 0x82,
  0xC1, 0xE0, 0xD0, 0x4C, 0x63, 0xE0, 0xFF, 0xE0, 0xF0, 0xC0, 0x60, 0x20,
  0x30, 0x10, 0x18, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x00, 0x3E, 0x31, 0xB0,
  0x58, 0x24, 0x13, 0x18, 0x70, 0xC6, 0xC1, 0xE0, 0xF0, 0x68, 0x63, 0xE0,
  0x3E, 0x31, 0xB0, 0x58, 0x3C, 0x1E, 0x0D, 0x8C, 0x7A, 0x03, 0x01, 0x01,
  0x81, 0x83, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xDA, 0x40,
  0x02, 0x0C, 0x63, 0x0C, 0x18, 0x1C, 0x0C, 0x06, 0x04, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x81, 0x81, 0xC0, 0xE0, 0x60, 0xC7, 0x38, 0xC1, 0x00,
  0x3E, 0x63, 0xC1, 0x01, 0x03, 0x07, 0x1C, 0x18, 0x18, 0x00, 0x00, 0x18,
  0x18, 0x3E, 0x63, 0x41, 0xC1, 0xCF, 0x99, 0x91, 0x91, 0x91, 0x91, 0xCF,
  0x40, 0x40, 0x60, 0x1E, 0x1C, 0x0E, 0x05, 0x06, 0x83, 0x61, 0x11, 0x88,
  0xC6, 0x7F, 0x20, 0xB0, 0x78, 0x38, 0x08, 0xFC, 0x86, 0x82, 0x82, 0x82,
  0x86, 0xFC, 0x82, 0x83, 0x83, 0x83, 0x82, 0xFC, 0x1E, 0x11, 0x90, 0x68,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x10, 0x64, 0x61, 0xE0, 0xF8,
  0x86, 0x82, 0x82, 0x83, 0x83, 0x83, 0x83, 0x83, 0x82, 0x82, 0x86, 0xF8,
  0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F, 0xC0, 0x81, 0x02, 0x04, 0x0F, 0xE0,
  0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x3E, 0x63, 0x41, 0xC0, 0xC0, 0xC0, 0xC0, 0xCF, 0xC1, 0xC1, 0x41,
  0x63, 0x3D, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xFF, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0xC1, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x8F, 0xE0, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0xC3, 0x46, 0x3C, 0x83, 0x86, 0x8C, 0x88, 0x98, 0xB0, 0xF0, 0xD8,
  0x8C, 0x84, 0x86, 0x83, 0x83, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC1, 0xF1, 0xF8, 0xFE, 0xFD, 0x5E,
  0xAF, 0x67, 0x93, 0xC9, 0xE0, 0xF0, 0x78, 0x3C, 0x18, 0xE1, 0xE1, 0xF1,
  0xD1, 0xD1, 0xD9, 0xC9, 0xC9, 0xCD, 0xC5, 0xC7, 0xC3, 0xC3, 0x3C, 0x31,
  0x90, 0x58, 0x2C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x90, 0x4C, 0x63,
  0xC0, 0xFC, 0x82, 0x83, 0x83, 0x83, 0x82, 0xFC, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x3C, 0x31, 0x90, 0x58, 0x2C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x90, 0x4C, 0x63, 0xE0, 0x40, 0x20, 0x1E, 0xFC, 0x82, 0x83, 0x83,
  0x83, 0x82, 0xFC, 0x98, 0x88, 0x8C, 0x86, 0x86, 0x83, 0x3E, 0x31, 0xF0,
  0x58, 0x0C, 0x03, 0x00, 0xF8, 0x06, 0x01, 0x80, 0xE0, 0x78, 0x63, 0xE0,
  0xFF, 0xC1, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01,
  0x00, 0x40, 0x10, 0x04, 0x00, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC1, 0x41, 0x41, 0x63, 0x3E, 0x81, 0xE0, 0xF0, 0x48, 0x24, 0x33,
  0x18, 0x88, 0x44, 0x36, 0x1A, 0x05, 0x03, 0x81, 0xC0, 0x80, 0xC0, 0x60,
  0x33, 0x19, 0xCC, 0xAE, 0x57, 0xAB, 0xF5, 0xF3, 0xB8, 0xCC, 0x66, 0x30,
  0x60, 0xC8, 0x23, 0x18, 0x4C, 0x1A, 0x03, 0x80, 0x40, 0x38, 0x1B, 0x04,
  0x43, 0x19, 0x82, 0xC0, 0xC0, 0xC0, 0x6C, 0x18, 0x86, 0x18, 0x81, 0xB0,
  0x34, 0x03, 0x80, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0xFF,
  0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18,
  0x0F, 0xF8, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x1F,
  0x81, 0x81, 0x02, 0x06, 0x04, 0x08, 0x08, 0x10, 0x30, 0x20, 0x40, 0x40,
  0x81, 0x81, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x3F,
  0x18, 0x0A, 0x0D, 0x84, 0x46, 0x32, 0x0A, 0x06, 0xFF, 0x80, 0xCC, 0x80,
  0x3C, 0x21, 0x20, 0xC0, 0x67, 0xF6, 0x1B, 0x0D, 0x86, 0x7D, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xBC, 0xC6, 0x82, 0x83, 0x83, 0x83, 0x82, 0xC6, 0xBC,
  0x3D, 0x8E, 0x14, 0x08, 0x10, 0x21, 0x63, 0x3C, 0x01, 0x01, 0x01, 0x01,
  0x3D, 0x63, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x63, 0x3D, 0x3E, 0x31, 0x90,
  0x58, 0x3F, 0xFE, 0x01, 0x00, 0xC2, 0x3E, 0x00, 0x0F, 0x84, 0x02, 0x01,
  0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF0, 0x03,
  0x9F, 0x18, 0xC8, 0x64, 0x33, 0x18, 0xF0, 0x80, 0x40, 0x3F, 0x90, 0x78,
  0x1C, 0x1B, 0xF8, 0x81, 0x02, 0x04, 0x0B, 0xD8, 0xE0, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x20, 0x18, 0x18, 0x00, 0x00, 0xF8, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0x0C, 0x30, 0x00, 0xFC, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0xF8, 0x80, 0x80, 0x80, 0x80, 0x83, 0x8C, 0x98,
  0xB0, 0xF8, 0xCC, 0x84, 0x86, 0x83, 0xF8, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0xB3, 0x66, 0xE2, 0x71, 0x38,
  0x9C, 0x4E, 0x27, 0x13, 0x89, 0x80, 0xBD, 0x8E, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x82, 0x3E, 0x31, 0x90, 0x58, 0x3C, 0x1E, 0x0D, 0x04, 0xC6, 0x3E,
  0x00, 0xBC, 0xC6, 0x82, 0x83, 0x83, 0x83, 0x82, 0xC6, 0xBC, 0x80, 0x80,
  0x80, 0x80, 0x3D, 0x63, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x63, 0x3D, 0x01,
  0x01, 0x01, 0x01, 0xFB, 0x8E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0xFF, 0x00, 0x3E, 0x61, 0x40, 0x60, 0x3E, 0x01, 0x01, 0xC1, 0x3E, 0x10,
  0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1F,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE3, 0x7A, 0xC1, 0xA0, 0x90, 0xCC,
  0x42, 0x21, 0xB0, 0x50, 0x28, 0x18, 0x00, 0x88, 0xCE, 0x65, 0x32, 0x99,
  0x5E, 0xA9, 0x94, 0xC6, 0x63, 0x00, 0xC1, 0xB1, 0x0D, 0x83, 0x81, 0x80,
  0xE0, 0xD8, 0xC6, 0xC1, 0x80, 0xC1, 0xA0, 0x90, 0xCC, 0x42, 0x21, 0xB0,
  0x50, 0x38, 0x18, 0x04, 0x06, 0x02, 0x0F, 0x00, 0xFE, 0x0C, 0x30, 0xC3,
  0x04, 0x10, 0x60, 0xFE, 0x1E, 0x40, 0x81, 0x81, 0x81, 0x06, 0x70, 0x18,
  0x10, 0x60, 0x83, 0x04, 0x08, 0x0F, 0xFF, 0xFF, 0xF0, 0x30, 0x60, 0x83,
  0x04, 0x08, 0x0F, 0x30, 0x40, 0x80, 0x81, 0x83, 0x06, 0x78, 0x70, 0xAC,
  0xE2, 0x50, 0xE0,
};

const GFXglyph IBMPlexMono_Regular18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 5, 5, 11, 3, -13 },
  { 10, 11, 13, 11, 0, -13 },
  { 28, 9, 17, 11, 1, -15 },
  { 48, 10, 13, 11, 0, -13 },
  { 65, 10, 13, 11, 0, -13 },
  { 82, 1, 5, 11, 5, -13 },
  { 83, 5, 16, 11, 4, -14 },
  { 93, 5, 16, 11, 2, -14 },
  { 103, 9, 9, 11, 1, -10 },
  { 114, 9, 9, 11, 1, -10 },
  { 125, 3, 5, 11, 4, -2 },
  { 127, 5, 1, 11, 3, -6 },
  { 128, 3, 2, 11, 4, -2 },
  { 129, 7, 16, 11, 2, -14 },
  { 143, 9, 13, 11, 1, -13 },
  { 158, 9, 13, 11, 1, -13 },
  { 173, 9, 13, 11, 1, -13 },
  { 188, 8, 13, 11, 1, -13 },
  { 201, 9, 13, 11, 1, -13 },
  { 216, 9, 13, 11, 1, -13 },
  { 231, 9, 13, 11, 1, -13 },
  { 246, 9, 13, 11, 1, -13 },
  { 261, 9, 13, 11, 1, -13 },
  { 276, 9, 13, 11, 1, -13 },
  { 291, 3, 9, 11, 4, -9 },
  { 295, 3, 12, 11, 4, -9 },
  { 300, 7, 10, 11, 2, -10 },
  { 309, 9, 5, 11, 1, -8 },
  { 315, 7, 10, 11, 2, -10 },
  { 324, 8, 13, 11, 1, -13 },
  { 337, 8, 15, 11, 1, -13 },
  { 352, 9, 13, 11, 1, -13 },
  { 367, 8, 13, 11, 2, -13 },
  { 380, 9, 13, 11, 1, -13 },
  { 395, 8, 13, 11, 2, -13 },
  { 408, 7, 13, 11, 2, -13 },
  { 420, 8, 13, 11, 2, -13 },
  { 433, 8, 13, 11, 1, -13 },
  { 446, 8, 13, 11, 1, -13 },
  { 459, 7, 13, 11, 2, -13 },
  { 471, 8, 13, 11, 1, -13 },
  { 484, 8, 13, 11, 2, -13 },
  { 497, 8, 13, 11, 2, -13 },
  { 510, 9, 13, 11, 1, -13 },
  { 525, 8, 13, 11, 1, -13 },
  { 538, 9, 13, 11, 1, -13 },
  { 553, 8, 13, 11, 2, -13 },
  { 566, 9, 16, 11, 1, -13 },
  { 584, 8, 13, 11, 2, -13 },
  { 597, 9, 13, 11, 1, -13 },
  { 612, 10, 13, 11, 0, -13 },
  { 629, 8, 13, 11, 1, -13 },
  { 642, 9, 13, 11, 1, -13 },
  { 657, 9, 13, 11, 1, -13 },
  { 672, 10, 13, 11, 0, -13 },
  { 689, 11, 13, 11, 0, -13 },
  { 707, 9, 13, 11, 1, -13 },
  { 722, 5, 16, 11, 4, -14 },
  { 732, 7, 16, 11, 2, -14 },
  { 746, 5, 16, 11, 2, -14 },
  { 756, 9, 7, 11, 1, -13 },
  { 764, 9, 1, 11, 1, 2 },
  { 766, 3, 3, 11, 3, -14 },
  { 768, 9, 9, 11, 1, -9 },
  { 779, 8, 13, 11, 2, -13 },
  { 792, 7, 9, 11, 2, -9 },
  { 800, 8, 13, 11, 1, -13 },
  { 813, 9, 9, 11, 1, -9 },
  { 824, 9, 13, 11, 1, -13 },
  { 839, 9, 14, 11, 1, -10 },
  { 855, 7, 13, 11, 2, -13 },
  { 867, 8, 13, 11, 2, -13 },
  { 880, 6, 17, 11, 2, -13 },
  { 893, 8, 13, 11, 2, -13 },
  { 906, 8, 13, 11, 1, -13 },
  { 919, 9, 9, 11, 1, -9 },
  { 930, 7, 9, 11, 2, -9 },
  { 938, 9, 9, 11, 1, -9 },
  { 949, 8, 13, 11, 2, -9 },
  { 962, 8, 13, 11, 1, -9 },
  { 975, 9, 9, 11, 1, -9 },
  { 986, 8, 9, 11, 1, -9 },
  { 995, 8, 13, 11, 1, -13 },
  { 1008, 7, 9, 11, 2, -9 },
  { 1016, 9, 9, 11, 1, -9 },
  { 1027, 9, 9, 11, 1, -9 },
  { 1038, 9, 9, 11, 1, -9 },
  { 1049, 9, 13, 11, 1, -9 },
  { 1064, 7, 9, 11, 2, -9 },
  { 1072, 7, 16, 11, 2, -14 },
  { 1086, 1, 16, 11, 5, -14 },
  { 1088, 7, 16, 11, 2, -14 },
  { 1102, 9, 4, 11, 1, -7 },
};

const GFXfont IBMPlexMono_Regular18pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular18pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular18pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _IBMPLEXMONO_REGULAR18PT7B_H_
