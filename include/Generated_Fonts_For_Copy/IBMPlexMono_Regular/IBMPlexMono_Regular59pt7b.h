#ifndef _IBMPLEXMONO_REGULAR59PT7B_H_
#define _IBMPLEXMONO_REGULAR59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular59pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x9F,
  0x00, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x80,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x7C,
  0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFE, 0x7F, 0xF8, 0x0F,
  0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x1E, 0x07, 0xC0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0xFF, 0xF8,
  0x1F, 0xFE, 0x7F, 0xFC, 0x0F, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x9F, 0xFE,
  0x03, 0xFF, 0xC0, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x3E, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x81, 0xFE,
  0x39, 0xFF, 0x07, 0xE0, 0xE0, 0xFE, 0x3F, 0x03, 0x81, 0xF8, 0xF8, 0x0E,
  0x03, 0xC3, 0xE0, 0x38, 0x04, 0x1F, 0x00, 0xE0, 0x00, 0x7C, 0x03, 0x80,
  0x01, 0xF0, 0x0E, 0x00, 0x07, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x3E, 0x03, 0x80, 0x00, 0xF8, 0x0E, 0x00, 0x03, 0xF8, 0x38, 0x00, 0x07,
  0xF0, 0xE0, 0x00, 0x0F, 0xFB, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x38, 0xFF, 0x00, 0x00, 0xE0, 0xFC, 0x00, 0x03, 0x81,
  0xF8, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x38, 0x0F, 0x80, 0x00, 0xE0, 0x1E,
  0x00, 0x03, 0x80, 0x7C, 0x00, 0x0E, 0x01, 0xF0, 0x00, 0x38, 0x07, 0x84,
  0x00, 0xE0, 0x3E, 0x38, 0x03, 0x80, 0xF9, 0xF0, 0x0E, 0x03, 0xEF, 0xE0,
  0x38, 0x1F, 0x1F, 0xC0, 0xE0, 0xFC, 0x3F, 0xE3, 0x9F, 0xE0, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xC7, 0xFF, 0x80, 0x03,
  0xE7, 0xFF, 0xE0, 0x01, 0xE7, 0xE1, 0xF8, 0x01, 0xE3, 0xC0, 0x3C, 0x00,
  0xF1, 0xE0, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x80, 0x78, 0xF0, 0x03, 0xC0,
  0x78, 0x78, 0x01, 0xE0, 0x3C, 0x3C, 0x00, 0xF0, 0x3C, 0x1E, 0x00, 0x78,
  0x3E, 0x0F, 0x00, 0x3C, 0x1E, 0x07, 0x80, 0x1E, 0x1F, 0x01, 0xE0, 0x1E,
  0x0F, 0x00, 0xF0, 0x0F, 0x0F, 0x80, 0x7E, 0x1F, 0x87, 0x80, 0x1F, 0xFF,
  0x87, 0xC0, 0x07, 0xFF, 0x83, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x3F, 0xFE, 0x00, 0x3C, 0x3F, 0xFF, 0x00,
  0x3E, 0x1F, 0x07, 0xC0, 0x1E, 0x1F, 0x01, 0xE0, 0x1F, 0x0F, 0x00, 0x78,
  0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x81, 0xE0, 0x0F,
  0x07, 0x80, 0xF0, 0x07, 0x83, 0xC0, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x01,
  0xE1, 0xE0, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x00, 0x79, 0xF0, 0x07, 0xC0,
  0x78, 0xF0, 0x01, 0xF0, 0x7C, 0xF8, 0x00, 0xFF, 0xFC, 0x78, 0x00, 0x3F,
  0xFE, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x18, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x3F, 0xF0, 0x07, 0xF8, 0x3F, 0x7C, 0x03, 0xFC, 0x3F, 0x3F, 0x01,
  0xFE, 0x3F, 0x0F, 0xC0, 0xF0, 0x1F, 0x03, 0xE0, 0x70, 0x1F, 0x00, 0xF8,
  0x78, 0x0F, 0x80, 0x3E, 0x3C, 0x07, 0xC0, 0x1F, 0x9E, 0x03, 0xC0, 0x07,
  0xEF, 0x03, 0xE0, 0x01, 0xF7, 0x81, 0xF0, 0x00, 0x7F, 0x80, 0xF8, 0x00,
  0x1F, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0x80,
  0x01, 0xFC, 0x07, 0xE0, 0x01, 0xFF, 0x01, 0xF8, 0x01, 0xCF, 0xC0, 0x7F,
  0x03, 0xE3, 0xF0, 0x3F, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0xE0, 0x3E, 0x01,
  0xFF, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x01, 0x00, 0x1E, 0x00, 0x6F, 0xC0, 0x78, 0x0F, 0xBF, 0xE1, 0xE1,
  0xFE, 0xFF, 0xF7, 0xBF, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0,
  0x1F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x02, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x7F, 0x1F,
  0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07,
  0x80, 0xF0, 0x3E, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x79,
  0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x3F, 0x81, 0xFF, 0x81, 0xFC,
  0x0F, 0xFC, 0x0F, 0xE0, 0x7F, 0xE0, 0x7F, 0x03, 0xFF, 0x03, 0xF8, 0x1F,
  0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x07,
  0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFB, 0xE0, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0xFE, 0x3E, 0x00, 0x07,
  0xF0, 0xF8, 0x00, 0x3F, 0x83, 0xE0, 0x01, 0xFC, 0x0F, 0x80, 0x0F, 0xE0,
  0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x38, 0x03, 0xE0, 0x00, 0xC0, 0x0F,
  0x80, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0xFF,
  0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0xF8,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7C, 0x10, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xE0,
  0x00, 0x7C, 0x0C, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE1, 0x00, 0x00, 0x3E, 0x30, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xFC, 0x3F,
  0xC0, 0x7F, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x03,
  0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x80,
  0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x1F, 0xE0, 0x07, 0x8F, 0xFF, 0x00, 0xF3, 0xFF, 0xF8,
  0x1E, 0xFF, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x7E, 0x00, 0x3F, 0x8F, 0x80,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x10, 0x00, 0x03, 0xE3,
  0x00, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x01,
  0xF8, 0x7F, 0x80, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xC7, 0xFF, 0xC0, 0x7C, 0xFF, 0xFE,
  0x07, 0x9F, 0xFF, 0xF0, 0xFB, 0xC0, 0x7F, 0x8F, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x78, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E,
  0xF0, 0x00, 0x0F, 0xDE, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7E, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xC0,
  0x07, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x80,
  0x7F, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1E, 0xF8, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xE3, 0xFC, 0x07, 0xBE, 0x1F, 0xFF, 0xF3,
  0xE0, 0xFF, 0xFE, 0x3E, 0x03, 0xFF, 0xC7, 0xC0, 0x0F, 0xF0, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFC, 0xF8, 0x1F, 0x07, 0xF9, 0xFF, 0x3F, 0xE7,
  0xFC, 0xFF, 0x8F, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x1F,
  0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xE3, 0xF0, 0x01, 0xF9,
  0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xC4, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFE, 0x07,
  0xF0, 0x3F, 0x00, 0x3F, 0x07, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x3C,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01,
  0xF7, 0x80, 0x3E, 0x1F, 0xF0, 0x1F, 0xF3, 0xFC, 0x07, 0xFE, 0x7F, 0x80,
  0xFF, 0xEF, 0xF0, 0x3F, 0x0D, 0xFE, 0x07, 0xC0, 0x7F, 0xC1, 0xF0, 0x0F,
  0xF8, 0x3E, 0x00, 0xFF, 0x07, 0x80, 0x1F, 0xE0, 0xF0, 0x03, 0xFC, 0x1E,
  0x00, 0x7F, 0x83, 0xC0, 0x0F, 0xF0, 0x78, 0x01, 0xFE, 0x0F, 0x00, 0x3F,
  0xC1, 0xE0, 0x07, 0xF8, 0x3C, 0x00, 0xFF, 0x07, 0x80, 0x1F, 0xE0, 0xF0,
  0x03, 0xFC, 0x1F, 0x00, 0x7F, 0x83, 0xE0, 0x1F, 0xF0, 0x3E, 0x03, 0xFE,
  0x07, 0xF3, 0xBF, 0xC0, 0x7F, 0xF7, 0xFC, 0x07, 0xFC, 0xF7, 0x80, 0x7F,
  0x1E, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0,
  0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x0F, 0x80, 0x07, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00,
  0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xF0, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x1C, 0x7C, 0x00, 0x01, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0x03, 0xE0, 0x00, 0x1C, 0x3E, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x07, 0xF0,
  0x3F, 0x80, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xF8, 0x03, 0xFC, 0x3E, 0x00, 0x3F, 0x8F,
  0x80, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7E,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x03,
  0xF8, 0xF8, 0x03, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8,
  0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1C, 0x3E, 0x00, 0x01,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F,
  0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0xFF, 0x0F,
  0xF0, 0x3D, 0xF0, 0x7F, 0xFF, 0x9F, 0x03, 0xFF, 0xF9, 0xF0, 0x1F, 0xFE,
  0x1F, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x18, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00,
  0x3F, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x3F, 0x81, 0xFC, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x1F,
  0x8F, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x1F,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0x7C, 0x0F, 0xC0,
  0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x3E, 0x7F, 0x80, 0x01, 0xF3, 0xFE, 0x00, 0x0F, 0xBF,
  0xF0, 0x00, 0x7F, 0xEF, 0xC0, 0x03, 0xFF, 0x3F, 0x00, 0x1F, 0xF1, 0xF8,
  0x00, 0xFF, 0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0x7E, 0x03, 0xE0,
  0x01, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C,
  0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3D, 0xFF, 0x78, 0x0F, 0xBF, 0xEF, 0x81,
  0xE7, 0xFC, 0xF0, 0x7C, 0xFF, 0x9F, 0x0F, 0x1F, 0xF1, 0xE1, 0xE3, 0xFE,
  0x3C, 0x78, 0x7F, 0xC7, 0xCF, 0x0F, 0xF8, 0x7B, 0xE1, 0xFF, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x1F, 0xC0, 0xFF, 0x81, 0xF8, 0x1F, 0xF0,
  0x3E, 0x03, 0xFE, 0x07, 0xC0, 0x7F, 0xC0, 0x78, 0x0F, 0xF8, 0x0E, 0x01,
  0xFF, 0x00, 0xC0, 0x3F, 0xE0, 0x10, 0x07, 0xFC, 0x02, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x78, 0x00, 0x7F, 0xDF, 0x00, 0x1F, 0xF7, 0xC0, 0x07,
  0xFC, 0xF8, 0x01, 0xFF, 0x3E, 0x00, 0x7F, 0xC7, 0x80, 0x1F, 0xF1, 0xF0,
  0x07, 0xFC, 0x7C, 0x01, 0xFF, 0x0F, 0x80, 0x7F, 0xC3, 0xE0, 0x1F, 0xF0,
  0x78, 0x07, 0xFC, 0x1F, 0x01, 0xFF, 0x07, 0xC0, 0x7F, 0xC0, 0xF8, 0x1F,
  0xF0, 0x3E, 0x07, 0xFC, 0x07, 0x81, 0xFF, 0x01, 0xF0, 0x7F, 0xC0, 0x3C,
  0x1F, 0xF0, 0x0F, 0x87, 0xFC, 0x03, 0xE1, 0xFF, 0x00, 0x7C, 0x7F, 0xC0,
  0x1F, 0x1F, 0xF0, 0x03, 0xC7, 0xFC, 0x00, 0xF9, 0xFF, 0x00, 0x3E, 0x7F,
  0xC0, 0x07, 0xDF, 0xF0, 0x01, 0xF7, 0xFC, 0x00, 0x3D, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x79,
  0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x07,
  0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0x80,
  0x03, 0xF9, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E,
  0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0xC0,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x8F, 0x80, 0x03, 0xF9, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xDF, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x0F,
  0x80, 0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xFC, 0x7C,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x81, 0xFE,
  0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x1C, 0x7E, 0x00, 0x00, 0x43, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x80, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x3F, 0x3F, 0x80,
  0x03, 0xF0, 0xFF, 0x80, 0x7F, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x7B, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x3F, 0x0F, 0xE0,
  0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x7C, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x1F, 0x78, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00,
  0xFB, 0xC0, 0x3F, 0x01, 0xE7, 0x80, 0x7E, 0x03, 0xCF, 0x01, 0xFC, 0x07,
  0x9F, 0x03, 0xF8, 0x0F, 0x3E, 0x07, 0xF8, 0x1E, 0x7C, 0x0F, 0xF0, 0x3C,
  0xF8, 0x1D, 0xE0, 0x78, 0xF0, 0x7B, 0xC0, 0xF1, 0xE0, 0xF7, 0x81, 0xE3,
  0xC1, 0xE7, 0x83, 0xC7, 0x83, 0xCF, 0x0F, 0x8F, 0x0F, 0x1E, 0x1F, 0x1E,
  0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0xF0, 0xF0,
  0xE0, 0xF1, 0xE1, 0xE3, 0xC1, 0xE3, 0xC3, 0xE7, 0x83, 0xC7, 0x87, 0xCF,
  0x03, 0xCF, 0x0F, 0x9E, 0x07, 0x9E, 0x0F, 0x78, 0x0F, 0x3C, 0x1E, 0xF0,
  0x1E, 0x78, 0x3D, 0xE0, 0x3C, 0xF0, 0x7B, 0xC0, 0x3D, 0xE0, 0xF7, 0x80,
  0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x03,
  0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0xFC, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3E, 0xFC,
  0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03,
  0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00,
  0x7E, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07,
  0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0x7E, 0x1F, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3D, 0xF0,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x07, 0xCC, 0x00, 0x00, 0x18,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x38, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x7C, 0x1E, 0x07,
  0x83, 0xC0, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0x81, 0xFE, 0x07, 0xE0, 0x07, 0xE0,
  0x7C, 0x00, 0x3F, 0x01, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0x00, 0x1F, 0x0F, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00,
  0x6F, 0x07, 0xF0, 0x1E, 0xFF, 0x3F, 0xFF, 0xC7, 0xF1, 0xFF, 0xF8, 0x7F,
  0x0F, 0xFF, 0x01, 0xF0, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x0F, 0xE0, 0x0F, 0x0F, 0xFF, 0x03, 0xC7, 0xFF, 0xE0, 0xF3,
  0xFF, 0xFC, 0x3D, 0xE0, 0x7F, 0x8F, 0xE0, 0x07, 0xF3, 0xF0, 0x00, 0xFC,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x3E, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xCF, 0xC0,
  0x03, 0xF3, 0xF8, 0x01, 0xFC, 0xF7, 0x81, 0xFE, 0x3C, 0xFF, 0xFF, 0x0F,
  0x1F, 0xFF, 0x83, 0xC3, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFE,
  0x07, 0xF0, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x7C,
  0x00, 0x04, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x04, 0x3E, 0x00, 0x07, 0x9F, 0x00, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xFC,
  0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0x81, 0xF0,
  0x3F, 0xF8, 0x7C, 0x3F, 0xFF, 0x9F, 0x1F, 0xFF, 0xE7, 0xCF, 0xF0, 0x3D,
  0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x7F,
  0x3F, 0xC0, 0x77, 0xC7, 0xFF, 0xF9, 0xF0, 0xFF, 0xFE, 0x7C, 0x0F, 0xFE,
  0x1F, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x00,
  0x3F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x43, 0xE0,
  0x00, 0x1C, 0x3E, 0x00, 0x03, 0xC7, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x7E,
  0x07, 0xF0, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0x9F, 0xF0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0,
  0x3F, 0x80, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x87, 0x00, 0x00, 0xFC, 0xF0, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x9F,
  0xC0, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x80,
  0xF8, 0xFF, 0xE0, 0xF9, 0xFF, 0xF8, 0xFB, 0xFF, 0xF8, 0xFF, 0x81, 0xFC,
  0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF8, 0xF8,
  0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F,
  0x80, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x0F,
  0x83, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF9, 0xFC,
  0x00, 0x0F, 0xBF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF9, 0xF8, 0x00,
  0xFF, 0x0F, 0x80, 0x0F, 0xE0, 0x7C, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xFC,
  0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF8, 0x0F, 0xC7, 0xCF, 0xF0, 0xFF, 0x3E, 0xFF, 0x8F, 0xFD, 0xFF,
  0xFE, 0xFF, 0xEF, 0xE1, 0xF6, 0x1F, 0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0x3E,
  0x03, 0xFF, 0x01, 0xF0, 0x0F, 0xF8, 0x0F, 0x80, 0x7F, 0xC0, 0x7C, 0x03,
  0xFE, 0x01, 0xE0, 0x1F, 0xF0, 0x0F, 0x00, 0xFF, 0x80, 0x78, 0x07, 0xFC,
  0x03, 0xC0, 0x3F, 0xE0, 0x1E, 0x01, 0xFF, 0x00, 0xF0, 0x0F, 0xF8, 0x07,
  0x80, 0x7F, 0xC0, 0x3C, 0x03, 0xFE, 0x01, 0xE0, 0x1F, 0xF0, 0x0F, 0x00,
  0xFF, 0x80, 0x78, 0x07, 0xFC, 0x03, 0xC0, 0x3F, 0xE0, 0x1E, 0x01, 0xFF,
  0x00, 0xF0, 0x0F, 0xF8, 0x07, 0x80, 0x7F, 0xC0, 0x3C, 0x03, 0xFE, 0x01,
  0xE0, 0x1F, 0xF0, 0x0F, 0x00, 0xFF, 0x80, 0x78, 0x07, 0xFC, 0x03, 0xC0,
  0x3F, 0xE0, 0x1E, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0xF8, 0xFF, 0xE0, 0xF9,
  0xFF, 0xF8, 0xFB, 0xFF, 0xF8, 0xFF, 0x81, 0xFC, 0xFE, 0x00, 0x7E, 0xFC,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0x01, 0xF0, 0x01, 0xF8, 0x3E,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x3E, 0x78, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x81, 0xFE, 0x07, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3C, 0x3F, 0xFC,
  0x0F, 0x1F, 0xFF, 0x83, 0xCF, 0xFF, 0xF0, 0xF7, 0x81, 0xFE, 0x3F, 0x80,
  0x1F, 0xCF, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xBC,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xDE, 0x07,
  0xF8, 0xF3, 0xFF, 0xFC, 0x3C, 0x7F, 0xFE, 0x0F, 0x0F, 0xFF, 0x03, 0xC0,
  0xFE, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xE1, 0xF0, 0xFF, 0xFE, 0x7C,
  0x7F, 0xFF, 0x9F, 0x3F, 0xC0, 0xF7, 0xCF, 0xC0, 0x07, 0xF7, 0xE0, 0x00,
  0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xDF,
  0x80, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFF, 0x01, 0xDF, 0x1F, 0xFF, 0xE7,
  0xC3, 0xFF, 0xF9, 0xF0, 0x3F, 0xF8, 0x7C, 0x03, 0xF8, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0x00, 0xF9, 0xE0, 0x00, 0x0F, 0xB8, 0x00, 0x00, 0xFB, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC1, 0xFC, 0x03, 0xFC,
  0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xE1, 0xF0, 0x00, 0x08, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF9, 0x00, 0x00, 0x1F, 0x30, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xF8,
  0x00, 0x3F, 0x3F, 0xE0, 0x1F, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0xCF, 0xE0, 0x3B,
  0xE3, 0xFF, 0xFD, 0xF0, 0xFF, 0xFC, 0xF8, 0x3F, 0xFC, 0x7C, 0x07, 0xF8,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF0,
  0x0F, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xC0, 0x7C,
  0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x01,
  0xF0, 0xF0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x9E,
  0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0xF0, 0x07, 0xE0, 0x1E, 0xF0, 0x07, 0xE0, 0x1E, 0xF0, 0x0F,
  0xE0, 0x1E, 0xF8, 0x0F, 0xE0, 0x1E, 0x78, 0x0E, 0xE0, 0x1E, 0x78, 0x0E,
  0xF0, 0x1E, 0x78, 0x0E, 0xF0, 0x1C, 0x78, 0x1E, 0x70, 0x3C, 0x78, 0x1E,
  0x70, 0x3C, 0x78, 0x1C, 0x70, 0x3C, 0x38, 0x1C, 0x78, 0x3C, 0x3C, 0x1C,
  0x78, 0x3C, 0x3C, 0x3C, 0x38, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x3C, 0x38,
  0x38, 0x78, 0x3C, 0x38, 0x3C, 0x78, 0x3C, 0x38, 0x3C, 0x78, 0x1C, 0x78,
  0x1C, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x1E, 0x70, 0x1C, 0x70, 0x1E, 0x70,
  0x1E, 0x70, 0x1E, 0x70, 0x1E, 0x70, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0,
  0x0E, 0xF0, 0x0E, 0xE0, 0x0E, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xF8,
  0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x7E,
  0x07, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x3E, 0x0F, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0xFC,
  0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x1E, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8,
  0x0F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x80,
  0x78, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x80, 0x00,
  0x3E, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0xFF,
  0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x30, 0x3F, 0xC0, 0x03, 0xC3, 0xFF, 0x00, 0x1E, 0x3F, 0xFC,
  0x00, 0xF3, 0xE3, 0xF0, 0x07, 0x9E, 0x0F, 0x80, 0x79, 0xE0, 0x3E, 0x03,
  0xCF, 0x00, 0xF8, 0x3C, 0x78, 0x03, 0xE3, 0xE3, 0x80, 0x0F, 0xFE, 0x3C,
  0x00, 0x3F, 0xF1, 0xE0, 0x00, 0xFF, 0x03, 0x00, 0x03, 0xE0, 0x00,
};

const GFXglyph IBMPlexMono_Regular59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 9, 42, 35, 13, -41 },
  { 49, 15, 16, 35, 10, -44 },
  { 79, 33, 41, 35, 1, -41 },
  { 249, 30, 55, 35, 3, -48 },
  { 456, 33, 43, 35, 1, -42 },
  { 634, 33, 43, 35, 1, -42 },
  { 812, 5, 16, 35, 15, -44 },
  { 822, 17, 53, 35, 12, -45 },
  { 935, 17, 53, 35, 6, -45 },
  { 1048, 30, 29, 35, 3, -34 },
  { 1157, 28, 28, 35, 4, -32 },
  { 1255, 11, 16, 35, 12, -8 },
  { 1277, 17, 4, 35, 9, -20 },
  { 1286, 9, 8, 35, 13, -7 },
  { 1295, 25, 53, 35, 5, -45 },
  { 1461, 29, 43, 35, 3, -42 },
  { 1617, 30, 41, 35, 3, -41 },
  { 1771, 28, 42, 35, 4, -42 },
  { 1918, 28, 43, 35, 3, -42 },
  { 2069, 31, 41, 35, 2, -41 },
  { 2228, 27, 42, 35, 4, -41 },
  { 2370, 28, 42, 35, 4, -41 },
  { 2517, 27, 41, 35, 4, -41 },
  { 2656, 29, 43, 35, 3, -42 },
  { 2812, 28, 42, 35, 4, -42 },
  { 2959, 9, 31, 35, 13, -30 },
  { 2994, 11, 38, 35, 12, -30 },
  { 3047, 25, 34, 35, 5, -35 },
  { 3154, 28, 16, 35, 4, -26 },
  { 3210, 25, 34, 35, 5, -35 },
  { 3317, 25, 43, 35, 5, -42 },
  { 3452, 27, 49, 35, 4, -42 },
  { 3618, 32, 41, 35, 2, -41 },
  { 3782, 27, 41, 35, 5, -41 },
  { 3921, 28, 43, 35, 4, -42 },
  { 4072, 26, 41, 35, 6, -41 },
  { 4206, 26, 41, 35, 5, -41 },
  { 4340, 26, 41, 35, 5, -41 },
  { 4474, 28, 43, 35, 3, -42 },
  { 4625, 26, 41, 35, 5, -41 },
  { 4759, 25, 41, 35, 5, -41 },
  { 4888, 24, 42, 35, 4, -41 },
  { 5014, 29, 41, 35, 5, -41 },
  { 5163, 25, 41, 35, 7, -41 },
  { 5292, 27, 41, 35, 4, -41 },
  { 5431, 26, 41, 35, 5, -41 },
  { 5565, 29, 43, 35, 3, -42 },
  { 5721, 27, 41, 35, 5, -41 },
  { 5860, 29, 52, 35, 3, -42 },
  { 6049, 27, 41, 35, 5, -41 },
  { 6188, 29, 43, 35, 3, -42 },
  { 6344, 33, 41, 35, 1, -41 },
  { 6514, 26, 42, 35, 5, -41 },
  { 6651, 31, 41, 35, 2, -41 },
  { 6810, 31, 41, 35, 2, -41 },
  { 6969, 32, 41, 35, 2, -41 },
  { 7133, 33, 41, 35, 1, -41 },
  { 7303, 30, 41, 35, 3, -41 },
  { 7457, 17, 53, 35, 13, -45 },
  { 7570, 25, 53, 35, 5, -45 },
  { 7736, 16, 53, 35, 6, -45 },
  { 7842, 30, 24, 35, 3, -41 },
  { 7932, 28, 4, 35, 4, 6 },
  { 7946, 9, 11, 35, 11, -46 },
  { 7959, 28, 32, 35, 4, -31 },
  { 8071, 26, 45, 35, 6, -44 },
  { 8218, 25, 32, 35, 5, -31 },
  { 8318, 26, 45, 35, 4, -44 },
  { 8465, 27, 32, 35, 4, -31 },
  { 8573, 28, 44, 35, 4, -44 },
  { 8727, 29, 47, 35, 4, -34 },
  { 8898, 24, 44, 35, 6, -44 },
  { 9030, 26, 44, 35, 6, -44 },
  { 9173, 22, 56, 35, 5, -44 },
  { 9327, 28, 44, 35, 6, -44 },
  { 9481, 26, 44, 35, 5, -44 },
  { 9624, 29, 31, 35, 3, -31 },
  { 9737, 24, 31, 35, 6, -31 },
  { 9830, 28, 32, 35, 4, -31 },
  { 9942, 26, 43, 35, 6, -31 },
  { 10082, 26, 43, 35, 4, -31 },
  { 10222, 28, 30, 35, 5, -30 },
  { 10327, 27, 32, 35, 4, -31 },
  { 10435, 29, 41, 35, 2, -41 },
  { 10584, 25, 31, 35, 5, -30 },
  { 10681, 28, 30, 35, 4, -30 },
  { 10786, 32, 30, 35, 2, -30 },
  { 10906, 28, 30, 35, 4, -30 },
  { 11011, 29, 42, 35, 3, -30 },
  { 11164, 25, 30, 35, 5, -30 },
  { 11258, 23, 53, 35, 6, -45 },
  { 11411, 4, 53, 35, 16, -45 },
  { 11438, 23, 53, 35, 6, -45 },
  { 11591, 29, 13, 35, 3, -24 },
};

const GFXfont IBMPlexMono_Regular59pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular59pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular59pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _IBMPLEXMONO_REGULAR59PT7B_H_
