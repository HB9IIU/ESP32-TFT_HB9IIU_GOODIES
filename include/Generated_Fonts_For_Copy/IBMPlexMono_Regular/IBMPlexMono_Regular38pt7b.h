#ifndef _IBMPLEXMONO_REGULAR38PT7B_H_
#define _IBMPLEXMONO_REGULAR38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular38pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x30, 0x84, 0x20,
  0x00, 0x00, 0x03, 0xDF, 0xFF, 0xFC, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xE0, 0x00, 0xE1, 0xC0, 0x06, 0x0C,
  0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07,
  0x0C, 0x00, 0x70, 0x60, 0x7F, 0x87, 0xFB, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE,
  0x07, 0x0E, 0x00, 0x30, 0x60, 0x01, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1,
  0xC0, 0xFF, 0x0F, 0xF7, 0xF8, 0x7F, 0xBF, 0x83, 0xFC, 0x0C, 0x38, 0x00,
  0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0C, 0x18,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xE3,
  0x3E, 0x78, 0x61, 0xEE, 0x0C, 0x19, 0xC1, 0x80, 0x38, 0x30, 0x07, 0x06,
  0x00, 0xF0, 0xC0, 0x1F, 0x18, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xE0, 0x03, 0xFE, 0x00, 0x33, 0xE0, 0x06, 0x1E, 0x00, 0xC3, 0xC0, 0x18,
  0x38, 0x03, 0x07, 0x40, 0x60, 0xEC, 0x0C, 0x3F, 0xE1, 0x87, 0x3E, 0x33,
  0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x3B, 0xFC, 0x01, 0x9F,
  0xF0, 0x1D, 0xE3, 0xC1, 0xCE, 0x0E, 0x0E, 0x60, 0x70, 0xE3, 0x03, 0x87,
  0x18, 0x1C, 0x70, 0xE0, 0xE3, 0x87, 0x8F, 0x38, 0x1F, 0xF1, 0xC0, 0xFF,
  0x10, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFC,
  0x07, 0x9F, 0xF0, 0x31, 0xC3, 0xC3, 0x8E, 0x0E, 0x18, 0x60, 0x71, 0xC3,
  0x03, 0x8C, 0x18, 0x1C, 0xE0, 0xE0, 0xE6, 0x07, 0x0F, 0x70, 0x1F, 0xF7,
  0x00, 0xFF, 0x38, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x00, 0x3C, 0x3C, 0x01, 0xC0, 0xF0, 0x1E, 0x02, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x1F, 0x0F, 0xE0, 0xF8, 0xF7, 0x87, 0xCF, 0x3C, 0x30, 0x70,
  0xF1, 0x87, 0x03, 0xCC, 0x38, 0x0F, 0x61, 0xC0, 0x3F, 0x0E, 0x00, 0xF0,
  0x70, 0x03, 0x83, 0xC0, 0x3E, 0x0F, 0x83, 0x78, 0x3F, 0xF9, 0xE0, 0xFF,
  0x87, 0x83, 0xF0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0xE0, 0x38, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x38, 0x3F,
  0xE7, 0x3F, 0xFF, 0xFF, 0xE3, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x3B, 0x80, 0x0F, 0x78, 0x03, 0xC7, 0x00, 0x70, 0x70, 0x1C, 0x0F, 0x07,
  0x80, 0xE0, 0x20, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x3E, 0xF9, 0xF3, 0xC7, 0x8E, 0x3C, 0x70, 0xE1, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0x83,
  0x80, 0x78, 0xF0, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0xF0, 0x01, 0xDE,
  0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x0E, 0x1F, 0xC3, 0xE3, 0xF8,
  0x7C, 0x7F, 0x07, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3B, 0xC0, 0x07, 0x38,
  0x00, 0xE7, 0x00, 0x1C, 0xF0, 0x07, 0x0E, 0x01, 0xE1, 0xF0, 0x78, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x07, 0xB8, 0x01, 0xE7, 0x00, 0x78, 0xE0, 0x1E, 0x1C, 0x07,
  0x83, 0x80, 0x60, 0x70, 0x08, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x78, 0x07, 0x9C,
  0x00, 0xEF, 0x00, 0x38, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFC, 0x03, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF0, 0x3C, 0x78, 0x07,
  0x8C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x01, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x40, 0x03,
  0xD8, 0x00, 0xEF, 0x00, 0x79, 0xF0, 0x7C, 0x3F, 0xFF, 0x07, 0xFF, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x77, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0x01, 0xC7,
  0x00, 0x38, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0xE0,
  0x70, 0x1C, 0x07, 0x03, 0x80, 0x70, 0x38, 0x07, 0x07, 0x00, 0x70, 0x60,
  0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x3F, 0xFF,
  0x3F, 0xFF, 0x9F, 0xFF, 0xCE, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0xFC, 0x0E, 0xFF, 0x86,
  0xFF, 0xE3, 0xE0, 0xF9, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x74, 0x00, 0x3B, 0x00, 0x3F, 0xC0, 0x1C, 0xF8,
  0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x8F, 0x81, 0xCF, 0xF8, 0x77,
  0xFF, 0x1F, 0x83, 0xE7, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x77, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xDC, 0x00, 0xF3, 0x80, 0x38,
  0xF8, 0x3E, 0x1F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00,
  0x7B, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x03, 0xF8,
  0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x1E, 0x07, 0xC7, 0x80, 0x3C, 0xE0, 0x07,
  0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x03, 0xC7, 0x00, 0x70, 0xF0, 0x3C,
  0x07, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0x03, 0xE3, 0xC0, 0x1E,
  0x70, 0x01, 0xDE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0x9E, 0x00, 0xF3, 0xE0, 0x7C, 0x3F, 0xFF, 0x83, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E,
  0x78, 0x03, 0x9C, 0x00, 0xF7, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x83, 0xF3, 0xFF,
  0xDC, 0x7F, 0xEF, 0x07, 0xE3, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0xFF, 0xFF, 0xE0, 0x78, 0xF9, 0xF3, 0xE7, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x7C, 0xF9, 0xE3, 0xC7, 0x1E,
  0x38, 0x70, 0xE0, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x38,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x04,
  0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1E, 0x70, 0x0F,
  0xF0, 0x07, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x7C, 0x03, 0xF8, 0x03, 0xE0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0x78, 0x3C, 0x38, 0x07, 0x8E, 0x00, 0xE7, 0x00, 0x1D,
  0xC0, 0x07, 0x70, 0x79, 0xD8, 0x3F, 0x76, 0x1F, 0xFF, 0x87, 0x0F, 0xE1,
  0xC1, 0xF8, 0xE0, 0x7E, 0x38, 0x1F, 0x8E, 0x07, 0xE3, 0x81, 0xF8, 0xE0,
  0x7E, 0x38, 0x1D, 0x8E, 0x07, 0x61, 0xC1, 0xD8, 0x7F, 0xF7, 0x0F, 0xDD,
  0xC3, 0xF7, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0E, 0x70,
  0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x01, 0xC1, 0xC0, 0x0E,
  0x0E, 0x00, 0x70, 0x70, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x78, 0x03, 0x83, 0x80,
  0x1E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x1E, 0x70, 0x00, 0x73,
  0x80, 0x03, 0xBC, 0x00, 0x1E, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xC0, 0x7C, 0xF0, 0x07, 0x3C, 0x01, 0xCF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0,
  0x07, 0xBC, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x38, 0xFF, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE3, 0xC0, 0x3C, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x3E, 0xFF,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x80, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0x87, 0xC1, 0xE7, 0x80, 0x7B, 0x80, 0x1D, 0xC0, 0x0D, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x33, 0x80, 0x1D, 0xE0, 0x1E, 0x7C, 0x1E, 0x1F, 0xFE, 0x07,
  0xFE, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1C, 0x0F,
  0x8E, 0x01, 0xE7, 0x00, 0x73, 0x80, 0x3D, 0xC0, 0x0E, 0xE0, 0x07, 0x70,
  0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00,
  0xF7, 0x00, 0x73, 0x80, 0x79, 0xC0, 0xF8, 0xFF, 0xFC, 0x7F, 0xF8, 0x3F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8,
  0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3C, 0x3C, 0x07, 0x9E, 0x00, 0xF7,
  0x00, 0x19, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x1F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xDE, 0x00, 0xF3,
  0xC0, 0x7C, 0xF8, 0x37, 0x1F, 0xFD, 0xC3, 0xFE, 0x70, 0x3E, 0x1C, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF,
  0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x76, 0x00, 0xFC, 0x01,
  0xFC, 0x07, 0xBC, 0x1E, 0x3F, 0xFC, 0x3F, 0xE0, 0x3F, 0x80, 0xE0, 0x03,
  0xFC, 0x00, 0x73, 0x80, 0x1E, 0x70, 0x07, 0x8E, 0x01, 0xE1, 0xC0, 0x78,
  0x38, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0xF0, 0x1C, 0x3C, 0x03, 0x8F, 0x00,
  0x71, 0xC0, 0x0E, 0x7C, 0x01, 0xDF, 0xC0, 0x3F, 0xB8, 0x07, 0xE7, 0x80,
  0xF8, 0x78, 0x1E, 0x0F, 0x03, 0x80, 0xF0, 0x70, 0x0E, 0x0E, 0x01, 0xE1,
  0xC0, 0x1E, 0x38, 0x01, 0xC7, 0x00, 0x3C, 0xE0, 0x03, 0x9C, 0x00, 0x7B,
  0x80, 0x07, 0x80, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF0, 0x6F, 0xDC, 0x77, 0xEE,
  0x3B, 0xF3, 0x19, 0xF9, 0xDC, 0xFC, 0xEC, 0x7E, 0x3E, 0x3F, 0x1F, 0x1F,
  0x87, 0x0F, 0xC3, 0x87, 0xE1, 0x83, 0xF0, 0x41, 0xF8, 0x20, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xE0, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0x70, 0x1F, 0xB8, 0x0F, 0xDE, 0x07, 0xE7, 0x03, 0xF3,
  0x81, 0xF8, 0xE0, 0xFC, 0x70, 0x7E, 0x3C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F,
  0xC1, 0xC7, 0xE0, 0xE3, 0xF0, 0x79, 0xF8, 0x1C, 0xFC, 0x0E, 0x7E, 0x03,
  0xBF, 0x01, 0xDF, 0x80, 0xEF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8,
  0x03, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0x83,
  0xC0, 0x78, 0xF0, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0xF0, 0x01, 0xDE,
  0x00, 0x3B, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3B, 0xC0, 0x07, 0x38,
  0x00, 0xE7, 0x00, 0x1C, 0xF0, 0x07, 0x0F, 0x01, 0xE1, 0xF0, 0x78, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF3, 0xC0, 0x3E, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x0F,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0x83, 0xC0, 0x78, 0xF0, 0x07, 0x1C, 0x00,
  0x73, 0x80, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3B, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xF0, 0x07,
  0x0F, 0x01, 0xE1, 0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xE0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFC,
  0x00, 0x3F, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xC0, 0x3E,
  0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x0F, 0xBF, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFF, 0xE0, 0xF0, 0xF0, 0x3C, 0x1C, 0x0F, 0x07, 0x83, 0xC0, 0xE0,
  0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x00, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0x3C,
  0x01, 0xEF, 0x00, 0x3C, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x1E,
  0x03, 0xE7, 0x80, 0x3C, 0xE0, 0x03, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF4, 0x00, 0x1F, 0xC0, 0x03, 0xBC, 0x00, 0xF3, 0xE0,
  0x7C, 0x3F, 0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x3C, 0xF8, 0x3E, 0x3F,
  0xFE, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x77, 0x00, 0x07, 0x70,
  0x00, 0xF7, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E, 0x3C, 0x01, 0xE1,
  0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xF0, 0x78, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07,
  0x00, 0x78, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x9C, 0x00, 0x1D,
  0xC0, 0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x07,
  0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x07, 0x07, 0x70, 0xF8,
  0x77, 0x0F, 0x87, 0x70, 0xF8, 0x77, 0x0D, 0x87, 0x71, 0xD8, 0x77, 0x1D,
  0xC6, 0x71, 0xDC, 0x63, 0x19, 0xC6, 0x31, 0x8C, 0x63, 0x38, 0xCE, 0x33,
  0x8E, 0xE3, 0xB8, 0xEE, 0x3B, 0x0E, 0xE3, 0xB0, 0x6E, 0x3F, 0x06, 0xE3,
  0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xE0, 0x7E, 0x3E, 0x03, 0xC0, 0xF0, 0x00,
  0x7B, 0xC0, 0x07, 0x8F, 0x00, 0x38, 0x38, 0x03, 0x81, 0xE0, 0x3C, 0x07,
  0x01, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0xE0, 0x03, 0x8E, 0x00, 0x1E, 0xF0,
  0x00, 0x77, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xDC, 0x00, 0x1C, 0x70, 0x01, 0xE3, 0xC0,
  0x0E, 0x0E, 0x00, 0xF0, 0x78, 0x0F, 0x01, 0xC0, 0x70, 0x07, 0x07, 0x80,
  0x3C, 0x38, 0x00, 0xE3, 0x80, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0x9E, 0x00, 0x3C, 0x70, 0x01, 0xC3, 0xC0, 0x1E, 0x0E, 0x00,
  0xE0, 0x78, 0x0E, 0x01, 0xC0, 0xF0, 0x0F, 0x07, 0x00, 0x38, 0x78, 0x00,
  0xE3, 0x80, 0x07, 0xBC, 0x00, 0x1D, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xDC, 0x00, 0x73, 0xC0, 0x0E,
  0x38, 0x03, 0x83, 0x80, 0x70, 0x70, 0x1C, 0x07, 0x07, 0x00, 0xE0, 0xE0,
  0x0E, 0x38, 0x01, 0xC7, 0x00, 0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x3A, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x63, 0xC7, 0x0E,
  0x38, 0x70, 0x80, 0x07, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0xC1, 0xE0, 0xF8,
  0xE0, 0x1E, 0x10, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x03,
  0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF8, 0xF0, 0x0E, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x38, 0xF0, 0x3E, 0x3F, 0xF9, 0xF7, 0xFE, 0x7C, 0x7E, 0x0F,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE3, 0xF0, 0x73, 0xFC, 0x3B, 0xFF, 0x1F,
  0x07, 0xCF, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07,
  0x70, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80,
  0x1D, 0xE0, 0x1E, 0xF8, 0x3E, 0x77, 0xFE, 0x39, 0xFE, 0x1C, 0x7E, 0x00,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0x83, 0xE7, 0x80, 0x73, 0x80,
  0x11, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x0C, 0xF0, 0x0F, 0x3C, 0x0F,
  0x0F, 0xFF, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x07, 0xE3, 0x8F, 0xF9, 0xCF, 0xFE, 0xE7, 0xC1, 0xF7, 0x80, 0x7B, 0x80,
  0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xF0, 0x0F, 0x3E, 0x0F,
  0x9F, 0xFD, 0xC7, 0xFC, 0xE0, 0xFC, 0x70, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0x83, 0xE7, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x08, 0xE0, 0x0F, 0x7C, 0x0F, 0x1F, 0xFF, 0x07, 0xFF, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x3F, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x1F, 0xB0, 0x1F, 0xFC, 0x0F, 0xFF, 0x87, 0xC1, 0xE1, 0xC0, 0x3C, 0x70,
  0x07, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x3C, 0x7C, 0x1E, 0x0F, 0xFF,
  0x01, 0xFF, 0x80, 0x3F, 0x80, 0x18, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFD, 0x80, 0x0F, 0xE0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xC1, 0xFF, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE3, 0xE1, 0xDF, 0xF3, 0xBF, 0xF7,
  0xC1, 0xEF, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x70, 0x01, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xBF, 0xFD, 0xFF, 0xEF, 0xFC, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x07, 0xB8, 0x03, 0x8E, 0x03, 0xC3,
  0x81, 0xE0, 0xE0, 0xF0, 0x38, 0x78, 0x0E, 0x3C, 0x03, 0x9E, 0x00, 0xEF,
  0x80, 0x3F, 0xF0, 0x0F, 0x9E, 0x03, 0xC3, 0x80, 0xE0, 0x70, 0x38, 0x1E,
  0x0E, 0x03, 0xC3, 0x80, 0x70, 0xE0, 0x1E, 0x38, 0x03, 0xCE, 0x00, 0x7B,
  0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE7, 0x87, 0x9D, 0xF9, 0xFB, 0xBF, 0x7F, 0x78, 0xE8, 0xEE,
  0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC,
  0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8,
  0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0,
  0x70, 0x70, 0xE3, 0xE1, 0xDF, 0xF3, 0xBF, 0xF7, 0xC1, 0xEF, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x70, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83,
  0xE7, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1E,
  0xE0, 0x0E, 0x7C, 0x1F, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFE, 0x00, 0xE3,
  0xF0, 0x73, 0xFC, 0x3B, 0xFF, 0x1F, 0x07, 0xCF, 0x00, 0xF7, 0x00, 0x3B,
  0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xEE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xE0, 0x1E, 0xF8, 0x3E, 0x77,
  0xFE, 0x39, 0xFE, 0x1C, 0x7E, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xE3, 0x8F, 0xF9, 0xCF, 0xFE, 0xE7, 0xC1, 0xF7, 0x80, 0x7B, 0x80, 0x1D,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xF0, 0x0F, 0x3E, 0x0F, 0x9F,
  0xFD, 0xC7, 0xFC, 0xE0, 0xFC, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0xFF,
  0x87, 0xFF, 0xE7, 0xFF, 0xFB, 0xFC, 0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x07, 0xF0, 0x0F, 0xFE,
  0x0F, 0xFF, 0xCF, 0x01, 0xF7, 0x00, 0x23, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x78,
  0x00, 0x1D, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x0F, 0x3F, 0xFF, 0x8F, 0xFF,
  0x80, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07,
  0x70, 0x07, 0x78, 0x0F, 0x7C, 0x1F, 0x3F, 0xF7, 0x1F, 0xE7, 0x0F, 0xC7,
  0xF0, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x8E,
  0x01, 0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0xE0,
  0xE0, 0x38, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x33, 0x80, 0x0E, 0xE0,
  0x03, 0xB8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0xE0, 0x70, 0x3F,
  0x07, 0x81, 0x98, 0x3E, 0x0C, 0xC1, 0xB0, 0x66, 0x0D, 0x87, 0x38, 0x6C,
  0x39, 0xC7, 0x61, 0xCE, 0x33, 0x8E, 0x71, 0x8C, 0x61, 0x8C, 0x63, 0x0C,
  0x63, 0x18, 0x67, 0x18, 0xC3, 0x38, 0xEE, 0x1D, 0x87, 0x70, 0xEC, 0x1B,
  0x07, 0x60, 0xD8, 0x1B, 0x06, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0x78, 0x03, 0xC7, 0x00, 0x70, 0xF0, 0x1E, 0x0F, 0x07, 0x80,
  0xE0, 0xE0, 0x1E, 0x38, 0x01, 0xEF, 0x00, 0x1D, 0xC0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3B, 0x80, 0x0E, 0x78, 0x03,
  0xC7, 0x80, 0x70, 0x70, 0x1C, 0x0F, 0x07, 0x80, 0xF1, 0xE0, 0x0E, 0x78,
  0x00, 0xF0, 0xE0, 0x00, 0xEE, 0x00, 0x39, 0xC0, 0x07, 0x3C, 0x01, 0xC3,
  0x80, 0x38, 0x70, 0x07, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x01,
  0xC1, 0xC0, 0x38, 0x38, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x70, 0x00,
  0xEE, 0x00, 0x1D, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0x3F,
  0xFF, 0x9F, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x7F, 0xC0, 0xFE, 0x01,
  0xFF, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFF,
  0x83, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xFF, 0x00, 0xFE, 0x07, 0xFC, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF,
  0x00, 0x0E, 0x00, 0xC7, 0xF0, 0x1C, 0xFF, 0x03, 0x38, 0xE0, 0x67, 0x0E,
  0x1C, 0xC1, 0xE7, 0x38, 0x1F, 0xE7, 0x01, 0xF8, 0xC0, 0x1E, 0x00,
};

const GFXglyph IBMPlexMono_Regular38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 5, 27, 23, 9, -27 },
  { 18, 9, 11, 23, 7, -28 },
  { 31, 21, 27, 23, 1, -27 },
  { 102, 19, 35, 23, 2, -31 },
  { 186, 21, 27, 23, 1, -27 },
  { 257, 21, 27, 23, 1, -27 },
  { 328, 3, 11, 23, 10, -28 },
  { 333, 11, 34, 23, 8, -29 },
  { 380, 11, 34, 23, 4, -29 },
  { 427, 19, 19, 23, 2, -22 },
  { 473, 18, 19, 23, 2, -21 },
  { 516, 7, 10, 23, 8, -5 },
  { 525, 11, 3, 23, 6, -13 },
  { 530, 5, 5, 23, 9, -5 },
  { 534, 16, 34, 23, 3, -29 },
  { 602, 19, 27, 23, 2, -27 },
  { 667, 19, 27, 23, 2, -27 },
  { 732, 18, 27, 23, 2, -27 },
  { 793, 18, 27, 23, 2, -27 },
  { 854, 20, 27, 23, 1, -27 },
  { 922, 17, 27, 23, 3, -27 },
  { 980, 18, 27, 23, 2, -27 },
  { 1041, 18, 27, 23, 2, -27 },
  { 1102, 19, 27, 23, 2, -27 },
  { 1167, 18, 27, 23, 2, -27 },
  { 1228, 5, 20, 23, 9, -20 },
  { 1241, 7, 25, 23, 8, -20 },
  { 1263, 17, 22, 23, 3, -23 },
  { 1310, 18, 11, 23, 2, -17 },
  { 1335, 17, 22, 23, 3, -23 },
  { 1382, 16, 27, 23, 3, -27 },
  { 1436, 18, 31, 23, 2, -27 },
  { 1506, 21, 27, 23, 1, -27 },
  { 1577, 18, 27, 23, 3, -27 },
  { 1638, 17, 27, 23, 3, -27 },
  { 1696, 17, 27, 23, 4, -27 },
  { 1754, 17, 27, 23, 3, -27 },
  { 1812, 17, 27, 23, 3, -27 },
  { 1870, 18, 27, 23, 2, -27 },
  { 1931, 17, 27, 23, 3, -27 },
  { 1989, 17, 27, 23, 3, -27 },
  { 2047, 15, 27, 23, 3, -27 },
  { 2098, 19, 27, 23, 3, -27 },
  { 2163, 15, 27, 23, 5, -27 },
  { 2214, 17, 27, 23, 3, -27 },
  { 2272, 17, 27, 23, 3, -27 },
  { 2330, 19, 27, 23, 2, -27 },
  { 2395, 18, 27, 23, 3, -27 },
  { 2456, 19, 33, 23, 2, -27 },
  { 2535, 18, 27, 23, 3, -27 },
  { 2596, 19, 27, 23, 2, -27 },
  { 2661, 21, 27, 23, 1, -27 },
  { 2732, 17, 27, 23, 3, -27 },
  { 2790, 20, 27, 23, 1, -27 },
  { 2858, 20, 27, 23, 1, -27 },
  { 2926, 21, 27, 23, 1, -27 },
  { 2997, 21, 27, 23, 1, -27 },
  { 3068, 19, 27, 23, 2, -27 },
  { 3133, 10, 34, 23, 9, -29 },
  { 3176, 16, 34, 23, 3, -29 },
  { 3244, 10, 34, 23, 4, -29 },
  { 3287, 19, 16, 23, 2, -27 },
  { 3325, 19, 3, 23, 2, 4 },
  { 3333, 6, 7, 23, 7, -29 },
  { 3339, 18, 20, 23, 3, -20 },
  { 3384, 17, 28, 23, 4, -28 },
  { 3444, 17, 20, 23, 3, -20 },
  { 3487, 17, 28, 23, 2, -28 },
  { 3547, 17, 20, 23, 3, -20 },
  { 3590, 18, 28, 23, 3, -28 },
  { 3653, 18, 31, 23, 3, -23 },
  { 3723, 15, 28, 23, 4, -28 },
  { 3776, 17, 29, 23, 4, -29 },
  { 3838, 13, 37, 23, 4, -29 },
  { 3899, 18, 28, 23, 4, -28 },
  { 3962, 17, 28, 23, 3, -28 },
  { 4022, 19, 20, 23, 2, -20 },
  { 4070, 15, 20, 23, 4, -20 },
  { 4108, 17, 20, 23, 3, -20 },
  { 4151, 17, 28, 23, 4, -20 },
  { 4211, 17, 28, 23, 2, -20 },
  { 4271, 18, 20, 23, 3, -20 },
  { 4316, 17, 20, 23, 3, -20 },
  { 4359, 19, 27, 23, 1, -27 },
  { 4424, 16, 20, 23, 3, -20 },
  { 4464, 18, 20, 23, 2, -20 },
  { 4509, 21, 20, 23, 1, -20 },
  { 4562, 19, 20, 23, 2, -20 },
  { 4610, 19, 28, 23, 2, -20 },
  { 4677, 17, 20, 23, 3, -20 },
  { 4720, 15, 34, 23, 4, -29 },
  { 4784, 3, 34, 23, 10, -29 },
  { 4797, 15, 34, 23, 4, -29 },
  { 4861, 19, 9, 23, 2, -16 },
};

const GFXfont IBMPlexMono_Regular38pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular38pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular38pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _IBMPLEXMONO_REGULAR38PT7B_H_
