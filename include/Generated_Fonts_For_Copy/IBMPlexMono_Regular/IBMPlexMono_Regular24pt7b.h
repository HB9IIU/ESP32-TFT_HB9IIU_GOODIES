#ifndef _IBMPLEXMONO_REGULAR24PT7B_H_
#define _IBMPLEXMONO_REGULAR24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular24pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x22, 0x20, 0x00, 0x7F, 0x70, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xC0, 0x06, 0x30, 0x18, 0xC0, 0x62, 0x01, 0x98, 0x06,
  0x61, 0xF1, 0xF7, 0xC7, 0xC3, 0x10, 0x0C, 0x40, 0x33, 0x0F, 0xCF, 0xBE,
  0x3E, 0x18, 0xC0, 0x62, 0x01, 0x98, 0x06, 0x60, 0x11, 0x80, 0x02, 0x00,
  0x20, 0x1F, 0x83, 0xFE, 0x72, 0x76, 0x22, 0x62, 0x06, 0x20, 0x72, 0x03,
  0xF0, 0x1F, 0xE0, 0x3F, 0x02, 0x30, 0x23, 0x02, 0x34, 0x23, 0xF2, 0x73,
  0xFE, 0x1F, 0x80, 0x20, 0x02, 0x00, 0x3C, 0x0D, 0xF8, 0x66, 0x21, 0xB0,
  0xCC, 0xC3, 0x31, 0x89, 0x87, 0xE6, 0x0F, 0x20, 0x00, 0x00, 0x03, 0xC0,
  0xDF, 0x86, 0x63, 0x19, 0x0C, 0xC4, 0x33, 0x18, 0xD8, 0x7E, 0xC0, 0xF0,
  0x1E, 0x01, 0xFC, 0x1C, 0x60, 0xC2, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x0E, 0x7C, 0x77, 0x73, 0x31, 0x91, 0x86, 0x8C, 0x1C, 0x60, 0x63, 0x87,
  0x8F, 0xEE, 0x3C, 0x38, 0xFF, 0xFC, 0x0E, 0x30, 0xC1, 0x86, 0x0C, 0x10,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x10, 0x20, 0x60, 0x60, 0xC0, 0xC0,
  0xE0, 0xC1, 0x83, 0x06, 0x18, 0x30, 0xC3, 0x04, 0x10, 0x41, 0x04, 0x30,
  0xC3, 0x18, 0x63, 0x18, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xE6,
  0x77, 0xFF, 0x0F, 0x80, 0xF0, 0x0D, 0x81, 0x9C, 0x30, 0xC1, 0x06, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x77, 0x6E, 0xCC, 0xFF, 0xFC, 0x7F, 0x70,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01,
  0x00, 0xC0, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x06, 0x01,
  0x00, 0xC0, 0x00, 0x0F, 0x83, 0xFC, 0x30, 0xE6, 0x06, 0x60, 0x36, 0x03,
  0xC0, 0x3C, 0x63, 0xC7, 0x3C, 0x63, 0xC0, 0x36, 0x03, 0x60, 0x36, 0x06,
  0x30, 0xE3, 0xFC, 0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x3B, 0x07, 0x30, 0xE3,
  0x04, 0x30, 0x43, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x07, 0xFF, 0x7F, 0xF0, 0x1F, 0x0F, 0xF3, 0x87, 0x60,
  0x68, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x30, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0x87, 0xF9, 0xC3, 0x90,
  0x30, 0x06, 0x00, 0xC0, 0x30, 0x7C, 0x0F, 0x80, 0x1C, 0x01, 0x80, 0x30,
  0x06, 0x80, 0xF8, 0x39, 0xFE, 0x1F, 0x00, 0x01, 0xC0, 0x3C, 0x02, 0xC0,
  0x6C, 0x0C, 0xC0, 0xCC, 0x18, 0xC1, 0x0C, 0x30, 0xC6, 0x0C, 0x60, 0xCC,
  0x0C, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x7F, 0xCF, 0xF9,
  0x00, 0x20, 0x04, 0x00, 0x80, 0x33, 0xC7, 0xFC, 0xE1, 0xC0, 0x1C, 0x01,
  0x80, 0x30, 0x07, 0x81, 0xB8, 0x73, 0xFC, 0x1F, 0x00, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x07, 0x00, 0xC0, 0x33, 0xC6, 0xFE, 0xE1, 0xD8, 0x1F, 0x01,
  0xE0, 0x3C, 0x07, 0x81, 0xB8, 0x73, 0xFC, 0x1F, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0x40, 0x68, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xE0, 0x18,
  0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x38, 0x00, 0x1F, 0x83, 0xFE,
  0x70, 0xE6, 0x07, 0x60, 0x36, 0x06, 0x30, 0xE1, 0xFC, 0x1F, 0xC7, 0x06,
  0x60, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0x70, 0x73, 0xFE, 0x1F, 0x80, 0x1F,
  0x0F, 0xF3, 0x87, 0x60, 0x6C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xE1, 0x6F,
  0xF8, 0xFB, 0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x3C, 0x00, 0x7F,
  0x70, 0x00, 0x00, 0x00, 0x7F, 0x70, 0x7F, 0x70, 0x00, 0x00, 0x00, 0x77,
  0x6E, 0xCC, 0x00, 0x40, 0x30, 0x3C, 0x3C, 0x1C, 0x1C, 0x0E, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xC0, 0x10, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x0F, 0x00, 0xE0, 0x0C, 0x03, 0x03, 0x83, 0xC1, 0xC1, 0xC0, 0xE0, 0x20,
  0x00, 0x1F, 0x1F, 0xE6, 0x1F, 0x03, 0x40, 0xC0, 0x30, 0x1C, 0x1E, 0x0E,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x78, 0x1C, 0x00, 0x0F,
  0x83, 0xFC, 0x30, 0xE6, 0x06, 0x60, 0x26, 0x3B, 0x47, 0xB4, 0xE7, 0xCC,
  0x3C, 0xC3, 0xCC, 0x3C, 0xC3, 0x4C, 0x34, 0x7F, 0x67, 0xB6, 0x00, 0x60,
  0x03, 0x80, 0x1F, 0xC0, 0xFC, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1B, 0x00,
  0x98, 0x0C, 0xC0, 0x63, 0x02, 0x18, 0x30, 0xC1, 0x86, 0x0F, 0xF8, 0xFF,
  0xC6, 0x06, 0x30, 0x1B, 0x80, 0xD8, 0x06, 0xC0, 0x38, 0xFF, 0x1F, 0xF3,
  0x07, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x37, 0xFC, 0xFF, 0x98, 0x1B, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x37, 0xFE, 0xFF, 0x80, 0x1F, 0x07, 0xF1,
  0xC3, 0x70, 0x3C, 0x05, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x05, 0xC0, 0xDC, 0x31, 0xFC, 0x1F, 0x00, 0xFF, 0x1F, 0xF3,
  0x07, 0x60, 0x6C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x0F, 0x81, 0xB0, 0x77, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x07, 0xFE, 0xFF, 0xD8, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x0F, 0x83, 0xFC, 0x30, 0xE6,
  0x06, 0x60, 0x56, 0x00, 0xE0, 0x0C, 0x00, 0xC3, 0xFC, 0x3F, 0xE0, 0x36,
  0x03, 0x60, 0x36, 0x07, 0x70, 0xB3, 0xFB, 0x1F, 0x30, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC3, 0xFF, 0xFF, 0xC0, 0x7F, 0xDF, 0xF0, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xF0, 0x6E, 0x39,
  0xFC, 0x3E, 0x00, 0xC0, 0x7C, 0x0C, 0xC1, 0xCC, 0x38, 0xC3, 0x0C, 0x60,
  0xCC, 0x0D, 0xC0, 0xFE, 0x0F, 0x60, 0xE3, 0x0C, 0x38, 0xC1, 0x8C, 0x1C,
  0xC0, 0xCC, 0x06, 0xC0, 0x70, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xFF, 0xFF, 0xC0, 0xC0, 0xFC, 0x1F, 0x87, 0xD8, 0xFB, 0x17, 0x26, 0xE6,
  0x9C, 0xF3, 0x8E, 0x71, 0x8E, 0x11, 0xC4, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xD8, 0x76, 0x1D, 0x87,
  0x31, 0xCC, 0x71, 0x9C, 0x67, 0x19, 0xC3, 0x70, 0xDC, 0x1F, 0x07, 0xC1,
  0xC0, 0x0F, 0x83, 0xFC, 0x30, 0xE6, 0x06, 0x60, 0x36, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x03, 0x60, 0x36, 0x06, 0x30, 0xE3,
  0xFC, 0x0F, 0x80, 0xFF, 0x9F, 0xFB, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0xFF, 0xDF, 0xF3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x00, 0x0F, 0x83, 0xFC, 0x30, 0xE6, 0x06, 0x60, 0x36, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x36, 0x03, 0x60, 0x36, 0x06,
  0x30, 0xE3, 0xFC, 0x0F, 0x80, 0x60, 0x06, 0x00, 0x7E, 0x03, 0xE0, 0xFF,
  0x9F, 0xFB, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xFF, 0xDF,
  0xF3, 0x18, 0x61, 0x8C, 0x31, 0x83, 0x30, 0x76, 0x06, 0xC0, 0x60, 0x1F,
  0x83, 0xFE, 0x70, 0x76, 0x02, 0x60, 0x06, 0x00, 0x70, 0x03, 0xF0, 0x1F,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0x00, 0x3C, 0x03, 0x70, 0x63, 0xFE, 0x1F,
  0x80, 0xFF, 0xFF, 0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x36, 0x1D,
  0xFE, 0x3F, 0x00, 0xC0, 0x3E, 0x01, 0x98, 0x0C, 0xC0, 0xE6, 0x06, 0x38,
  0x30, 0xC1, 0x86, 0x18, 0x30, 0xC0, 0xC6, 0x06, 0x20, 0x33, 0x00, 0x98,
  0x06, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0xC0, 0x1E, 0x00, 0xB0, 0x05,
  0x80, 0x2C, 0x63, 0x63, 0x9B, 0x1C, 0xD9, 0xA6, 0xCD, 0x32, 0x69, 0x92,
  0x6C, 0x93, 0x67, 0x9B, 0x3C, 0x59, 0xE2, 0x8E, 0x1C, 0x70, 0xE0, 0xE0,
  0x3B, 0x03, 0x9C, 0x18, 0x61, 0x81, 0x8C, 0x0E, 0xC0, 0x3E, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0x60, 0x33, 0x03, 0x8C, 0x18, 0x71, 0x81, 0x8C,
  0x06, 0xC0, 0x38, 0xE0, 0x1D, 0xC0, 0x63, 0x03, 0x8E, 0x0C, 0x18, 0x60,
  0x31, 0x80, 0xCC, 0x01, 0xB0, 0x07, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x07, 0xFF, 0xE0, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30,
  0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80,
  0x30, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0xC0, 0xFF, 0xFC, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x1F, 0xFF, 0xE0, 0x07, 0x00, 0xF0, 0x0D, 0x81, 0x98, 0x18, 0xC3,
  0x0C, 0x20, 0x66, 0x06, 0xC0, 0x34, 0x01, 0xFF, 0xFF, 0xFF, 0x4E, 0x63,
  0x10, 0x3E, 0x0F, 0xF3, 0x86, 0x60, 0xC0, 0x08, 0x7F, 0x3F, 0xE6, 0x04,
  0xC0, 0x98, 0x73, 0xFB, 0xBE, 0x30, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x33, 0xC6, 0xFE, 0xE1, 0xD8, 0x1F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x3F, 0x0E, 0xDF, 0xD9, 0xE0, 0x1F, 0x0F, 0xE7, 0x1F, 0x83,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x5C, 0x33, 0xF8, 0x7C, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC7, 0x99, 0xFB, 0x70, 0xEC, 0x0D,
  0x81, 0xF0, 0x3E, 0x06, 0xC0, 0xD8, 0x1B, 0x87, 0x3F, 0xE3, 0xCC, 0x1F,
  0x0F, 0xF1, 0x83, 0x60, 0x3F, 0xFF, 0xFF, 0xF0, 0x06, 0x00, 0xC0, 0x5C,
  0x39, 0xFE, 0x0F, 0x80, 0x07, 0xE1, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x3F, 0xFF, 0xFF, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x1C, 0x7E, 0x3F, 0xC6, 0x1D,
  0x81, 0xB0, 0x33, 0x0E, 0x7F, 0x87, 0xE1, 0x80, 0x20, 0x07, 0xFC, 0x7F,
  0xF0, 0x1C, 0x01, 0xC0, 0x7F, 0xFD, 0xFE, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0xF3, 0x7E, 0xE1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30, 0x0C, 0x07, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00,
  0x03, 0xFD, 0xFE, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x37, 0xFB, 0xF8, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x01, 0x00, 0x20, 0x74, 0x1C, 0x86, 0x11, 0x82, 0x60, 0x5E,
  0x0E, 0xC1, 0x8C, 0x20, 0xC4, 0x1C, 0x81, 0xD0, 0x1C, 0xFC, 0x3F, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xDC, 0xED, 0xDF, 0xE7,
  0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x63, 0xCF, 0x37, 0xEE, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x1F, 0x0F, 0xF3, 0x87, 0x60, 0x6C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xDC, 0x39, 0xFE, 0x0F, 0x80, 0xCF, 0x1B,
  0xFB, 0x87, 0x60, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xFC, 0x3B,
  0x7F, 0x67, 0x8C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x1E, 0x67,
  0xED, 0xC3, 0xB0, 0x36, 0x07, 0xC0, 0xF8, 0x1B, 0x03, 0x60, 0x6E, 0x1C,
  0xFF, 0x8F, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0xF8, 0xFF,
  0x3C, 0x68, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x03,
  0xFF, 0x7F, 0xE0, 0x3F, 0x0F, 0xFB, 0x83, 0x60, 0x0E, 0x00, 0xFF, 0x07,
  0xF0, 0x06, 0x00, 0x7C, 0x19, 0xFF, 0x1F, 0x80, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0x07, 0xF0, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD8, 0x77, 0xEC,
  0xF3, 0xC0, 0x78, 0x1B, 0x03, 0x30, 0x66, 0x18, 0x43, 0x0C, 0x41, 0x98,
  0x1B, 0x03, 0x40, 0x78, 0x07, 0x00, 0xC6, 0x1E, 0x38, 0xB1, 0xC5, 0x9A,
  0x2C, 0xD3, 0x24, 0x99, 0x26, 0xC9, 0x36, 0x78, 0xA3, 0xC5, 0x1C, 0x38,
  0x61, 0xC0, 0x60, 0x73, 0x06, 0x38, 0xC1, 0x98, 0x0F, 0x00, 0x70, 0x07,
  0x00, 0xF8, 0x19, 0x83, 0x0C, 0x30, 0x6E, 0x07, 0xC0, 0x36, 0x03, 0x60,
  0x63, 0x06, 0x30, 0xC1, 0x0C, 0x18, 0x81, 0x98, 0x0D, 0x80, 0xF0, 0x07,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x07, 0xC0, 0x78, 0x00, 0xFF, 0xFF,
  0xF0, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0F, 0xFF,
  0xFF, 0x1F, 0x8F, 0xC4, 0x02, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x0C, 0x7C,
  0x3E, 0x01, 0x80, 0x40, 0x20, 0x20, 0x30, 0x10, 0x08, 0x04, 0x03, 0xF1,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7E, 0x03, 0x01, 0x80,
  0xC0, 0xC0, 0x40, 0x60, 0x30, 0x0F, 0xC7, 0xE6, 0x03, 0x01, 0x80, 0x60,
  0x10, 0x0C, 0x06, 0x03, 0x1F, 0x8F, 0x80, 0x38, 0x17, 0xC3, 0x66, 0x34,
  0x72, 0xC3, 0xEC, 0x1C,
};

const GFXglyph IBMPlexMono_Regular24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 6, 7, 14, 4, -18 },
  { 16, 14, 17, 14, 0, -17 },
  { 46, 12, 21, 14, 1, -19 },
  { 78, 14, 17, 14, 0, -17 },
  { 108, 13, 17, 14, 1, -17 },
  { 136, 2, 7, 14, 6, -18 },
  { 138, 7, 21, 14, 5, -18 },
  { 157, 6, 21, 14, 3, -18 },
  { 173, 12, 12, 14, 1, -14 },
  { 191, 12, 12, 14, 1, -13 },
  { 209, 4, 6, 14, 5, -3 },
  { 212, 7, 2, 14, 4, -8 },
  { 214, 4, 3, 14, 5, -3 },
  { 216, 10, 21, 14, 2, -18 },
  { 243, 12, 17, 14, 1, -17 },
  { 269, 12, 17, 14, 1, -17 },
  { 295, 11, 17, 14, 2, -17 },
  { 319, 11, 17, 14, 1, -17 },
  { 343, 12, 17, 14, 1, -17 },
  { 369, 11, 17, 14, 2, -17 },
  { 393, 11, 17, 14, 2, -17 },
  { 417, 11, 17, 14, 2, -17 },
  { 441, 12, 17, 14, 1, -17 },
  { 467, 11, 17, 14, 2, -17 },
  { 491, 4, 13, 14, 5, -13 },
  { 498, 4, 16, 14, 5, -13 },
  { 506, 10, 14, 14, 2, -14 },
  { 524, 12, 7, 14, 1, -11 },
  { 535, 10, 14, 14, 2, -14 },
  { 553, 10, 17, 14, 2, -17 },
  { 575, 12, 20, 14, 1, -17 },
  { 605, 13, 17, 14, 1, -17 },
  { 633, 11, 17, 14, 2, -17 },
  { 657, 11, 17, 14, 2, -17 },
  { 681, 11, 17, 14, 2, -17 },
  { 705, 10, 17, 14, 2, -17 },
  { 727, 11, 17, 14, 2, -17 },
  { 751, 12, 17, 14, 1, -17 },
  { 777, 10, 17, 14, 2, -17 },
  { 799, 10, 17, 14, 2, -17 },
  { 821, 10, 17, 14, 2, -17 },
  { 843, 12, 17, 14, 2, -17 },
  { 869, 10, 17, 14, 3, -17 },
  { 891, 11, 17, 14, 2, -17 },
  { 915, 10, 17, 14, 2, -17 },
  { 937, 12, 17, 14, 1, -17 },
  { 963, 11, 17, 14, 2, -17 },
  { 987, 12, 21, 14, 1, -17 },
  { 1019, 11, 17, 14, 2, -17 },
  { 1043, 12, 17, 14, 1, -17 },
  { 1069, 13, 17, 14, 1, -17 },
  { 1097, 10, 17, 14, 2, -17 },
  { 1119, 13, 17, 14, 1, -17 },
  { 1147, 13, 17, 14, 1, -17 },
  { 1175, 13, 17, 14, 1, -17 },
  { 1203, 14, 17, 14, 0, -17 },
  { 1233, 12, 17, 14, 1, -17 },
  { 1259, 7, 21, 14, 5, -18 },
  { 1278, 10, 21, 14, 2, -18 },
  { 1305, 7, 21, 14, 2, -18 },
  { 1324, 12, 10, 14, 1, -17 },
  { 1339, 12, 2, 14, 1, 2 },
  { 1342, 4, 5, 14, 4, -19 },
  { 1345, 11, 12, 14, 2, -12 },
  { 1362, 11, 18, 14, 2, -18 },
  { 1387, 10, 12, 14, 2, -12 },
  { 1402, 11, 18, 14, 1, -18 },
  { 1427, 11, 12, 14, 2, -12 },
  { 1444, 11, 18, 14, 2, -18 },
  { 1469, 11, 19, 14, 2, -14 },
  { 1496, 10, 18, 14, 2, -18 },
  { 1519, 10, 18, 14, 3, -18 },
  { 1542, 9, 23, 14, 2, -18 },
  { 1568, 11, 18, 14, 3, -18 },
  { 1593, 10, 18, 14, 2, -18 },
  { 1616, 12, 12, 14, 1, -12 },
  { 1634, 10, 12, 14, 2, -12 },
  { 1649, 11, 12, 14, 2, -12 },
  { 1666, 11, 17, 14, 2, -12 },
  { 1690, 11, 17, 14, 1, -12 },
  { 1714, 11, 12, 14, 2, -12 },
  { 1731, 11, 12, 14, 2, -12 },
  { 1748, 12, 17, 14, 1, -17 },
  { 1774, 10, 12, 14, 2, -12 },
  { 1789, 11, 12, 14, 2, -12 },
  { 1806, 13, 12, 14, 1, -12 },
  { 1826, 12, 12, 14, 1, -12 },
  { 1844, 12, 17, 14, 1, -12 },
  { 1870, 10, 12, 14, 2, -12 },
  { 1885, 9, 21, 14, 3, -18 },
  { 1909, 2, 21, 14, 6, -18 },
  { 1915, 9, 21, 14, 3, -18 },
  { 1939, 12, 6, 14, 1, -10 },
};

const GFXfont IBMPlexMono_Regular24pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular24pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular24pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _IBMPLEXMONO_REGULAR24PT7B_H_
