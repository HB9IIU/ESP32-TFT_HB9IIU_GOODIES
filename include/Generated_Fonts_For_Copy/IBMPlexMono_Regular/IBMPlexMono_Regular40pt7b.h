#ifndef _IBMPLEXMONO_REGULAR40PT7B_H_
#define _IBMPLEXMONO_REGULAR40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular40pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xDE, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1C,
  0x00, 0xE0, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01,
  0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x70, 0xE0, 0x7F, 0xC3,
  0xFD, 0xFF, 0x0F, 0xF7, 0xF8, 0x3F, 0xC0, 0xE0, 0xE0, 0x03, 0x87, 0x00,
  0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x03, 0xFC,
  0x1F, 0xEF, 0xF0, 0xFF, 0xBF, 0xC3, 0xFE, 0x07, 0x0E, 0x00, 0x18, 0x38,
  0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00,
  0xE1, 0xC0, 0x07, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xE7,
  0x3E, 0x78, 0x71, 0xF7, 0x87, 0x06, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70,
  0x70, 0x07, 0x87, 0x00, 0x3C, 0x70, 0x03, 0xF7, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x71, 0xE0, 0x07, 0x0F,
  0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x72, 0x07, 0x07, 0x70, 0x70,
  0xFF, 0x87, 0x1E, 0x7E, 0x73, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F,
  0xC0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x1C, 0xFF, 0x00, 0x67, 0xFE, 0x03, 0xBC, 0x38, 0x0C, 0xE0, 0x60,
  0x73, 0x81, 0xC3, 0x8E, 0x07, 0x0E, 0x38, 0x1C, 0x70, 0xE0, 0x71, 0xC3,
  0x81, 0x8E, 0x0F, 0x0E, 0x38, 0x1F, 0xF9, 0xC0, 0x3F, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFC, 0x03, 0x9F, 0xF8, 0x1C, 0x70,
  0xF0, 0x71, 0x81, 0xC3, 0x8E, 0x07, 0x0E, 0x38, 0x1C, 0x70, 0xE0, 0x71,
  0xC3, 0x81, 0xCE, 0x06, 0x07, 0x30, 0x1C, 0x3D, 0xC0, 0x7F, 0xE6, 0x00,
  0xFF, 0x38, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0,
  0x07, 0xC3, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x08, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0xF8, 0x3F, 0x03, 0xE3, 0xFE, 0x0F, 0x8E, 0x78, 0x30,
  0x78, 0xF0, 0xC3, 0xC1, 0xE3, 0x0F, 0x03, 0xDC, 0x38, 0x07, 0xF0, 0xE0,
  0x0F, 0x83, 0x80, 0x1E, 0x0F, 0x00, 0x38, 0x1C, 0x01, 0xF0, 0x7C, 0x1D,
  0xE0, 0xFF, 0xE3, 0xC1, 0xFF, 0x87, 0x81, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xF0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x60, 0x3F, 0x86, 0x1F, 0xFF,
  0x6F, 0xF3, 0xFF, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0xC0, 0x07, 0x9E, 0x00, 0x70, 0xE0, 0x0E, 0x07, 0x01, 0xE0, 0x78,
  0x1C, 0x03, 0x80, 0x80, 0x20, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x7C, 0xF1, 0xE7, 0xCF, 0x1E, 0x38,
  0x71, 0xC3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0x78,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xF0, 0xF8, 0x3C, 0x03,
  0xC3, 0x80, 0x1C, 0x78, 0x01, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00,
  0x0E, 0xF0, 0x00, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF0,
  0xF0, 0xFF, 0x0F, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0x70, 0x00, 0xE7, 0x80, 0x1E, 0x38, 0x01, 0xC3, 0xC0, 0x3C,
  0x1E, 0x07, 0x81, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x03, 0xE7,
  0x80, 0x7C, 0x78, 0x0F, 0x87, 0x80, 0x70, 0x78, 0x02, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0xF0, 0x07, 0xFF,
  0x03, 0xFF, 0xE1, 0xF0, 0x7C, 0x70, 0x07, 0xBC, 0x01, 0xEE, 0x00, 0x38,
  0x80, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0x80, 0x3C, 0x60,
  0x07, 0x84, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x40, 0x03, 0xD8, 0x00, 0x77, 0x80, 0x1E, 0x7C, 0x0F, 0x87, 0xFF,
  0xE0, 0x7F, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x39, 0xC0, 0x03, 0x8E,
  0x00, 0x1C, 0x70, 0x01, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xE0, 0xE0, 0x0E,
  0x07, 0x00, 0x70, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70,
  0x38, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE3, 0xFF, 0xF8, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x1F, 0x81, 0xDF, 0xF8, 0x7F,
  0xFF, 0x1F, 0x03, 0xE7, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC8, 0x00, 0xF6, 0x00, 0x3F,
  0xC0, 0x1E, 0x7C, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xC0, 0x1F, 0xC0, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x1F, 0x81,
  0xDF, 0xF8, 0xEF, 0xFF, 0x3B, 0x03, 0xEF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x3D, 0xE0, 0x1E, 0x3C, 0x0F, 0x8F, 0xFF, 0xC0, 0xFF, 0xE0,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0xEE, 0x00, 0x7B, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xE0, 0x7C, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x70, 0x01, 0xE7, 0x00,
  0x0E, 0x70, 0x01, 0xE7, 0x80, 0x1C, 0x38, 0x01, 0xC1, 0xE0, 0x78, 0x0F,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x03, 0xE0, 0x7C, 0x78, 0x01, 0xE7,
  0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xE7, 0x80, 0x1E, 0x7E, 0x07, 0xE3, 0xFF, 0xFC, 0x0F, 0xFF,
  0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xF1, 0xF0, 0x3C,
  0x78, 0x07, 0xBC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xF7, 0xC0,
  0xDC, 0xFF, 0xF7, 0x1F, 0xFB, 0x81, 0xF8, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x3C, 0xFD,
  0xFB, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x7C, 0xF1, 0xE7, 0xCF, 0x1E, 0x38, 0x71, 0xC3, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x70,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF0,
  0x07, 0xFE, 0x0F, 0xFF, 0xC7, 0x81, 0xE7, 0x80, 0x7F, 0x80, 0x1F, 0xC0,
  0x0E, 0x40, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x01, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0x03, 0xC3, 0xC0, 0x3C, 0x70, 0x03,
  0x8E, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x3C, 0xEE, 0x1F, 0xDD, 0xC3, 0xFF,
  0xB8, 0xF0, 0xF7, 0x1C, 0x0E, 0xC3, 0x81, 0xF8, 0x70, 0x3F, 0x0E, 0x07,
  0xE1, 0xC0, 0xEC, 0x38, 0x1D, 0x87, 0x03, 0xB0, 0xE0, 0x77, 0x1C, 0x0E,
  0xE3, 0xFF, 0xDC, 0x3F, 0xBB, 0x83, 0xF7, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0xC0,
  0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xC1, 0xE0, 0x07,
  0x03, 0x80, 0x1C, 0x0E, 0x00, 0xF0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1C, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x78, 0x00, 0x79, 0xC0,
  0x00, 0xE7, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0x80, 0x7C, 0xE0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x7B, 0x80,
  0x1E, 0xE0, 0x07, 0xB8, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x78, 0xFF, 0xFC,
  0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0x80, 0x3C, 0xE0, 0x07, 0xB8, 0x00, 0xEE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3B, 0x80,
  0x1E, 0xE0, 0x0F, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC3, 0xC0, 0x3C, 0xF0, 0x03,
  0x9C, 0x00, 0x7B, 0x80, 0x08, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x10,
  0xE0, 0x03, 0x9E, 0x00, 0x79, 0xE0, 0x1E, 0x3E, 0x0F, 0x83, 0xFF, 0xE0,
  0x3F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3,
  0x80, 0xF8, 0xE0, 0x0F, 0x38, 0x01, 0xCE, 0x00, 0x7B, 0x80, 0x0E, 0xE0,
  0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3B,
  0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x01, 0xEE, 0x00, 0x73, 0x80, 0x3C, 0xE0,
  0x3E, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xF7,
  0xFF, 0xFB, 0xFF, 0xFD, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xF7,
  0xFF, 0xFB, 0xFF, 0xFD, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xC0, 0x3F, 0xFE, 0x0F, 0x83, 0xC3, 0xC0, 0x3C, 0x70, 0x03, 0xDE, 0x00,
  0x33, 0x80, 0x08, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xF0, 0x03,
  0xDE, 0x00, 0x79, 0xE0, 0x1F, 0x3F, 0x06, 0xE3, 0xFF, 0xDC, 0x3F, 0xF3,
  0x81, 0xF8, 0x70, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x1F,
  0xFF, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x60, 0x07, 0xF0, 0x0F, 0x70, 0x0F, 0x7C, 0x3E, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x03,
  0xCF, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3,
  0xC0, 0x0F, 0x7E, 0x00, 0xFF, 0xF0, 0x0F, 0xE7, 0x00, 0xFC, 0x78, 0x0F,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x0E, 0x0F, 0x00, 0xF0,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFE, 0xE0, 0xDF, 0xB8, 0x77, 0xEE, 0x1D, 0xF9, 0xCE, 0x7E, 0x73, 0x9F,
  0x8C, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xE0,
  0xC1, 0xF8, 0x30, 0x7E, 0x0C, 0x1F, 0x82, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xEE,
  0x01, 0xFB, 0x80, 0x7E, 0xF0, 0x1F, 0x9C, 0x07, 0xE7, 0x01, 0xF8, 0xE0,
  0x7E, 0x38, 0x1F, 0x8F, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x0E, 0x1F,
  0x83, 0x87, 0xE0, 0xF1, 0xF8, 0x1C, 0x7E, 0x07, 0x1F, 0x80, 0xE7, 0xE0,
  0x39, 0xF8, 0x0F, 0x7E, 0x01, 0xDF, 0x80, 0x77, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x1F, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xF0, 0xF8, 0x3C, 0x03, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xE7, 0x00,
  0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x80, 0x1E,
  0x38, 0x01, 0xC3, 0xC0, 0x3C, 0x1E, 0x0F, 0x81, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0x1F, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0x80, 0x3E,
  0xE0, 0x07, 0xB8, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x0F, 0xBF, 0xFF, 0xCF, 0xFF,
  0xE3, 0xFF, 0xE0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x01, 0xF0, 0xF8, 0x3C, 0x03, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xE7,
  0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x80,
  0x1E, 0x38, 0x01, 0xC3, 0xC0, 0x3C, 0x1E, 0x0F, 0x81, 0xFF, 0xF8, 0x07,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF3, 0x80, 0x3E, 0xE0, 0x07, 0xB8, 0x00, 0xEE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x0F,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xE0, 0xE0, 0x38, 0x3C, 0x0E,
  0x07, 0x03, 0x81, 0xE0, 0xE0, 0x3C, 0x38, 0x07, 0x0E, 0x01, 0xE3, 0x80,
  0x38, 0xE0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x0F, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xE0, 0x7E, 0x78, 0x01, 0xE7, 0x80,
  0x0C, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF2, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x80, 0x1E, 0x7E, 0x07,
  0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xDC, 0x00, 0xE7, 0x00, 0x39, 0xE0, 0x1E, 0x7C, 0x0F, 0x0F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x1F, 0xE0, 0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x80, 0x07,
  0x9E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0xC0, 0x0F, 0x07,
  0x00, 0x38, 0x1C, 0x00, 0xE0, 0x78, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0F, 0x01, 0xC0, 0x3C, 0x0F, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0,
  0x07, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xF1, 0xC0, 0x01,
  0xCF, 0x00, 0x07, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x67, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0xE7, 0x00, 0x03, 0x9C, 0x1E, 0x0E, 0x70, 0x78, 0x39, 0xC1, 0xE0,
  0xE7, 0x0F, 0xC3, 0x9C, 0x3F, 0x0E, 0x70, 0xFC, 0x39, 0xC3, 0x30, 0xE3,
  0x0C, 0xC3, 0x0E, 0x73, 0x8C, 0x39, 0xCE, 0x70, 0xE7, 0x39, 0xC3, 0x98,
  0x67, 0x0E, 0x61, 0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x77,
  0x0E, 0xC0, 0xDC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x07,
  0xC0, 0xF8, 0x78, 0x00, 0x3D, 0xE0, 0x01, 0xE3, 0xC0, 0x0F, 0x07, 0x00,
  0x3C, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x70, 0x3C, 0x01, 0xE1, 0xE0,
  0x03, 0xC7, 0x00, 0x07, 0x3C, 0x00, 0x1E, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0x38, 0x00, 0x3C, 0x70, 0x01, 0xE1, 0xE0, 0x07, 0x03, 0x80,
  0x3C, 0x0F, 0x00, 0xE0, 0x1E, 0x07, 0x80, 0x38, 0x3C, 0x00, 0xF0, 0xE0,
  0x01, 0xC7, 0x80, 0x07, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xC0, 0x00,
  0xE7, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0x70, 0x03, 0x81,
  0xE0, 0x1E, 0x03, 0xC0, 0x70, 0x0F, 0x03, 0xC0, 0x1E, 0x1E, 0x00, 0x38,
  0x70, 0x00, 0xF3, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3B, 0xC0,
  0x03, 0x9C, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0x70, 0x1E, 0x07,
  0x81, 0xC0, 0x38, 0x3C, 0x03, 0xC3, 0x80, 0x1C, 0x70, 0x01, 0xE7, 0x00,
  0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x10, 0xE3, 0xE1, 0xC3, 0xC3, 0x83, 0x86, 0x07, 0xF0, 0x03,
  0xFF, 0x80, 0xFF, 0xF8, 0x3C, 0x0F, 0x0F, 0x00, 0xF0, 0x40, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F,
  0xFF, 0x8F, 0x80, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0,
  0x0F, 0x1F, 0x07, 0xE1, 0xFF, 0xDF, 0x9F, 0xF1, 0xF1, 0xFC, 0x1E, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x7C, 0x0E, 0x7F, 0xC3,
  0xBF, 0xF8, 0xFC, 0x1F, 0x3C, 0x03, 0xCE, 0x00, 0x7B, 0x80, 0x0E, 0xE0,
  0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07, 0xBC, 0x03, 0xEF, 0xC1, 0xF3,
  0xBF, 0xF8, 0xE7, 0xFC, 0x38, 0x7E, 0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xF0, 0xF8, 0x3E, 0x38, 0x03, 0x9E, 0x00, 0xC7, 0x00, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x11, 0xE0, 0x06, 0x38, 0x03, 0xCF, 0x83, 0xE1,
  0xFF, 0xF0, 0x3F, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0xF8, 0x70, 0xFF, 0x9C, 0x7F, 0xF7, 0x3E, 0x0F,
  0xDF, 0x00, 0xF7, 0x80, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x77, 0x00, 0x1D, 0xC0,
  0x07, 0x78, 0x01, 0xDE, 0x00, 0xF3, 0xE0, 0xFC, 0x7F, 0xF7, 0x0F, 0xF9,
  0xC0, 0xF8, 0x70, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xF0, 0x3C,
  0x78, 0x03, 0x9C, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x04, 0x78, 0x03, 0xCF, 0x83, 0xE1, 0xFF, 0xF0, 0x3F, 0xF8,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x81, 0xFB,
  0x00, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0x03, 0xC3, 0xC0, 0x3C, 0x70, 0x07,
  0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x80, 0x70, 0x78, 0x1E,
  0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE1, 0xF0, 0xE7, 0xFC, 0xEF, 0xFE, 0xFC, 0x1E, 0xF0, 0x0F, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xBF, 0xFE, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0xFF, 0xFB, 0xFF, 0xCF,
  0xFE, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0xFB, 0x80, 0x3C, 0x70, 0x0F, 0x0E, 0x03, 0xC1, 0xC0, 0xF0, 0x38,
  0x3C, 0x07, 0x0F, 0x00, 0xE3, 0xC0, 0x1C, 0xF8, 0x03, 0xBF, 0x00, 0x7F,
  0xF0, 0x0F, 0x8F, 0x01, 0xE0, 0xF0, 0x38, 0x1E, 0x07, 0x01, 0xE0, 0xE0,
  0x1E, 0x1C, 0x01, 0xE3, 0x80, 0x3C, 0x70, 0x03, 0xCE, 0x00, 0x3D, 0xC0,
  0x03, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE7, 0x83,
  0xCE, 0xFC, 0xFE, 0xEF, 0xEF, 0xEF, 0x0F, 0x8F, 0xE0, 0xF0, 0x7E, 0x0F,
  0x07, 0xE0, 0xE0, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0,
  0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E,
  0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07,
  0xE0, 0x60, 0x70, 0xE1, 0xF0, 0xE7, 0xFC, 0xEF, 0xFE, 0xFC, 0x1E, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x03, 0xF0, 0x03,
  0xFF, 0x03, 0xFF, 0xF0, 0xF0, 0x3C, 0x78, 0x07, 0x9C, 0x00, 0xEE, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1D, 0xC0, 0x0E, 0x78, 0x07, 0x8F,
  0x03, 0xC3, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0xE1, 0xF0, 0x39,
  0xFF, 0x0E, 0xFF, 0xE3, 0xF0, 0x7C, 0xF0, 0x0F, 0x38, 0x01, 0xEE, 0x00,
  0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1E, 0xF0, 0x0F, 0xBF,
  0x07, 0xCE, 0xFF, 0xE3, 0x9F, 0xF0, 0xE1, 0xF8, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xE1, 0xC3, 0xFE, 0x71, 0xFF, 0xDC, 0xF8, 0x3F,
  0x7C, 0x03, 0xDE, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xDC, 0x00, 0x77, 0x00,
  0x1D, 0xE0, 0x07, 0x78, 0x03, 0xCF, 0x83, 0xF1, 0xFF, 0xDC, 0x3F, 0xE7,
  0x03, 0xE1, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0xFF, 0x83, 0xFF,
  0xF1, 0xFF, 0xFE, 0x7F, 0x81, 0xDC, 0x00, 0x3A, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x03, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x07,
  0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF9, 0xF0, 0x3F, 0x70, 0x01, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1D, 0x00, 0x07, 0xF0,
  0x03, 0xFF, 0x01, 0xE7, 0xFF, 0xF8, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0x78, 0x3F, 0x7F, 0xF7, 0x3F, 0xE7, 0x0F, 0xC7,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3D, 0xC0, 0x0E, 0x70, 0x03, 0x8E,
  0x01, 0xE3, 0x80, 0x70, 0xE0, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x07, 0x38, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x78, 0x1F, 0x81, 0xE0, 0x76, 0x07, 0x81, 0x9C, 0x1E, 0x06, 0x70,
  0xFC, 0x39, 0xC3, 0x30, 0xE7, 0x0C, 0xC3, 0x9C, 0x33, 0x0E, 0x70, 0xCC,
  0x38, 0xC7, 0x38, 0xC3, 0x1C, 0x63, 0x0E, 0x61, 0x8C, 0x39, 0x86, 0x70,
  0xE6, 0x19, 0xC3, 0xB8, 0x77, 0x06, 0xE1, 0xD8, 0x1B, 0x03, 0x60, 0x6C,
  0x0D, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x01,
  0xE3, 0xC0, 0x1C, 0x3C, 0x03, 0xC1, 0xE0, 0x78, 0x0F, 0x07, 0x00, 0x70,
  0xE0, 0x07, 0x9E, 0x00, 0x3D, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3B, 0xC0, 0x07, 0x9E, 0x00,
  0xF0, 0xF0, 0x0E, 0x07, 0x01, 0xE0, 0x78, 0x3C, 0x03, 0xC3, 0x80, 0x1E,
  0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80,
  0x1C, 0x38, 0x01, 0xC3, 0xC0, 0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x0E,
  0x07, 0x00, 0xE0, 0x70, 0x0F, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00,
  0x39, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0,
  0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0x00,
  0x7F, 0x03, 0xFF, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF,
  0x80, 0x0F, 0x00, 0x71, 0xF8, 0x07, 0x3F, 0xC0, 0x77, 0x9E, 0x06, 0x70,
  0xF0, 0xE6, 0x07, 0x9E, 0xE0, 0x3F, 0xCE, 0x01, 0xF8, 0xE0, 0x0F, 0x00,
};

const GFXglyph IBMPlexMono_Regular40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 6, 28, 24, 9, -28 },
  { 22, 10, 11, 24, 7, -30 },
  { 36, 22, 28, 24, 1, -28 },
  { 113, 20, 36, 24, 2, -32 },
  { 203, 22, 28, 24, 1, -28 },
  { 280, 22, 28, 24, 1, -28 },
  { 357, 4, 11, 24, 10, -30 },
  { 363, 12, 36, 24, 8, -30 },
  { 417, 12, 36, 24, 4, -30 },
  { 471, 20, 20, 24, 2, -23 },
  { 521, 20, 19, 24, 2, -22 },
  { 569, 7, 11, 24, 8, -5 },
  { 579, 12, 3, 24, 6, -14 },
  { 584, 6, 5, 24, 9, -5 },
  { 588, 16, 36, 24, 4, -30 },
  { 660, 20, 28, 24, 2, -28 },
  { 730, 20, 28, 24, 2, -28 },
  { 800, 18, 28, 24, 3, -28 },
  { 863, 19, 28, 24, 2, -28 },
  { 930, 21, 28, 24, 1, -28 },
  { 1004, 18, 28, 24, 3, -28 },
  { 1067, 18, 28, 24, 3, -28 },
  { 1130, 18, 28, 24, 3, -28 },
  { 1193, 20, 28, 24, 2, -28 },
  { 1263, 18, 28, 24, 3, -28 },
  { 1326, 6, 21, 24, 9, -21 },
  { 1342, 7, 27, 24, 8, -21 },
  { 1366, 18, 23, 24, 3, -24 },
  { 1418, 20, 11, 24, 2, -18 },
  { 1446, 18, 23, 24, 3, -24 },
  { 1498, 17, 28, 24, 3, -28 },
  { 1558, 19, 32, 24, 2, -28 },
  { 1634, 22, 28, 24, 1, -28 },
  { 1711, 18, 28, 24, 4, -28 },
  { 1774, 19, 28, 24, 3, -28 },
  { 1841, 18, 28, 24, 4, -28 },
  { 1904, 17, 28, 24, 4, -28 },
  { 1964, 17, 28, 24, 4, -28 },
  { 2024, 19, 28, 24, 2, -28 },
  { 2091, 18, 28, 24, 3, -28 },
  { 2154, 18, 28, 24, 3, -28 },
  { 2217, 16, 28, 24, 3, -28 },
  { 2273, 20, 28, 24, 3, -28 },
  { 2343, 16, 28, 24, 5, -28 },
  { 2399, 18, 28, 24, 3, -28 },
  { 2462, 18, 28, 24, 3, -28 },
  { 2525, 20, 28, 24, 2, -28 },
  { 2595, 18, 28, 24, 4, -28 },
  { 2658, 20, 34, 24, 2, -28 },
  { 2743, 18, 28, 24, 4, -28 },
  { 2806, 20, 28, 24, 2, -28 },
  { 2876, 22, 28, 24, 1, -28 },
  { 2953, 18, 28, 24, 3, -28 },
  { 3016, 22, 28, 24, 1, -28 },
  { 3093, 22, 28, 24, 1, -28 },
  { 3170, 22, 28, 24, 1, -28 },
  { 3247, 22, 28, 24, 1, -28 },
  { 3324, 20, 28, 24, 2, -28 },
  { 3394, 11, 36, 24, 9, -30 },
  { 3444, 16, 36, 24, 4, -30 },
  { 3516, 11, 36, 24, 4, -30 },
  { 3566, 20, 16, 24, 2, -28 },
  { 3606, 20, 3, 24, 2, 4 },
  { 3614, 7, 8, 24, 7, -31 },
  { 3621, 19, 21, 24, 3, -21 },
  { 3671, 18, 30, 24, 4, -30 },
  { 3739, 18, 21, 24, 3, -21 },
  { 3787, 18, 30, 24, 2, -30 },
  { 3855, 18, 21, 24, 3, -21 },
  { 3903, 19, 30, 24, 3, -30 },
  { 3975, 19, 32, 24, 3, -24 },
  { 4051, 16, 30, 24, 4, -30 },
  { 4111, 18, 31, 24, 4, -31 },
  { 4181, 14, 39, 24, 4, -31 },
  { 4250, 19, 30, 24, 4, -30 },
  { 4322, 18, 30, 24, 3, -30 },
  { 4390, 20, 21, 24, 2, -21 },
  { 4443, 16, 21, 24, 4, -21 },
  { 4485, 18, 21, 24, 3, -21 },
  { 4533, 18, 29, 24, 4, -21 },
  { 4599, 18, 29, 24, 2, -21 },
  { 4665, 19, 21, 24, 3, -21 },
  { 4715, 18, 21, 24, 3, -21 },
  { 4763, 19, 28, 24, 2, -28 },
  { 4830, 16, 21, 24, 4, -21 },
  { 4872, 18, 21, 24, 3, -21 },
  { 4920, 22, 21, 24, 1, -21 },
  { 4978, 20, 21, 24, 2, -21 },
  { 5031, 20, 29, 24, 2, -21 },
  { 5104, 18, 21, 24, 3, -21 },
  { 5152, 16, 36, 24, 4, -30 },
  { 5224, 2, 36, 24, 11, -30 },
  { 5233, 16, 36, 24, 4, -30 },
  { 5305, 20, 9, 24, 2, -17 },
};

const GFXfont IBMPlexMono_Regular40pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular40pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular40pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _IBMPLEXMONO_REGULAR40PT7B_H_
