#ifndef _IBMPLEXMONO_REGULAR49PT7B_H_
#define _IBMPLEXMONO_REGULAR49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular49pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0x87, 0x0E, 0x1C, 0x38, 0x30, 0x60, 0xC1, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x03, 0xFF, 0x07, 0xFF, 0x3F, 0xF0,
  0x7F, 0xF3, 0xFF, 0x07, 0xFF, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0xFF, 0xC0, 0xFF, 0xCF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC1, 0xFF,
  0xC0, 0x3C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x3C,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x0F, 0xC7, 0x3F, 0x8F, 0x83,
  0x87, 0xE7, 0x81, 0xC1, 0xE3, 0xC0, 0xE0, 0x61, 0xE0, 0x70, 0x00, 0xF0,
  0x38, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0F,
  0x83, 0x80, 0x03, 0xF1, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0x3F,
  0x80, 0x03, 0x87, 0xC0, 0x01, 0xC1, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x70,
  0x3C, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x0F, 0x10, 0x0E, 0x07, 0x9C, 0x07,
  0x03, 0xDF, 0x03, 0x83, 0xDF, 0xC1, 0xC3, 0xE3, 0xF8, 0xE7, 0xF0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0x3F, 0xF8,
  0x01, 0xE7, 0x87, 0xC0, 0x1C, 0x70, 0x3C, 0x03, 0xCF, 0x01, 0xC0, 0x38,
  0xE0, 0x1C, 0x07, 0x8E, 0x01, 0xE0, 0x70, 0xE0, 0x1E, 0x0F, 0x0E, 0x01,
  0xE1, 0xE0, 0xE0, 0x1C, 0x1C, 0x0F, 0x01, 0xC3, 0xC0, 0x70, 0x3C, 0x38,
  0x07, 0x87, 0xC7, 0x80, 0x3F, 0xF8, 0x70, 0x01, 0xFF, 0x0F, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0xE0, 0xFF, 0x80, 0x1E, 0x1F, 0xFC, 0x01, 0xC3, 0xC3, 0xC0,
  0x3C, 0x78, 0x1E, 0x07, 0x87, 0x00, 0xE0, 0x70, 0x70, 0x0E, 0x0F, 0x07,
  0x00, 0xE0, 0xE0, 0x70, 0x0E, 0x1E, 0x07, 0x00, 0xE1, 0xC0, 0x70, 0x0E,
  0x3C, 0x07, 0x00, 0xE3, 0x80, 0x78, 0x1E, 0x78, 0x03, 0xC3, 0xC7, 0x00,
  0x1F, 0xFC, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0xF8,
  0x0F, 0x00, 0x1E, 0x00, 0xC0, 0x03, 0x80, 0x20, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x3F, 0xE0,
  0x7F, 0x0F, 0x3C, 0x0F, 0xE3, 0xC3, 0xC1, 0xE0, 0xF0, 0x3C, 0x3C, 0x1E,
  0x03, 0xC7, 0x03, 0xC0, 0x7C, 0xE0, 0xF0, 0x07, 0x9C, 0x1E, 0x00, 0x7B,
  0x83, 0xC0, 0x07, 0xF0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0xF8, 0x1E, 0x00, 0x3F, 0x83, 0xE0, 0x0C, 0xF8, 0x3F, 0x07, 0x8F,
  0x83, 0xFF, 0xE0, 0xF8, 0x3F, 0xF8, 0x0F, 0x81, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00,
  0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x01, 0x00, 0x3C, 0x02, 0x78, 0x1E, 0x07, 0xFF, 0x8F, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xF9, 0xE0,
  0x00, 0xF8, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x7C, 0x03,
  0xC0, 0x3C, 0x00, 0xF0, 0x0C, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C,
  0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00,
  0x7C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0x7E,
  0x1F, 0xF0, 0x7E, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xDE, 0x00, 0x1F, 0x9E, 0x00, 0x3F, 0x1E,
  0x00, 0x7E, 0x1E, 0x00, 0xFC, 0x1E, 0x00, 0xF8, 0x1E, 0x00, 0x70, 0x1E,
  0x00, 0x60, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x3F,
  0x07, 0x80, 0x1F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0x7C,
  0x20, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC1, 0xF8, 0x1F, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x0F, 0x04,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x80, 0x00, 0xF3,
  0x00, 0x01, 0xEF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0x1F, 0x80, 0xFE, 0x1F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x0E, 0x70, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x07,
  0x81, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x07, 0x00,
  0x1C, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0xF0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0F, 0x00,
  0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE1, 0xF8, 0x07, 0x1F, 0xFC, 0x1C, 0xFF, 0xF8, 0x77, 0xFF,
  0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF2, 0x00, 0x03, 0xD8, 0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xE0, 0x03,
  0xE7, 0xE0, 0x3F, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC3, 0xF0, 0x07, 0x9F, 0xFC, 0x1E, 0x7F, 0xFC, 0x3D, 0xFF,
  0xFC, 0x7F, 0x01, 0xFD, 0xEC, 0x00, 0xFB, 0xF0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xF7,
  0xC0, 0x03, 0xC7, 0xC0, 0x0F, 0x8F, 0xE0, 0x7E, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x01,
  0xFC, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x78, 0x00,
  0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x1F, 0x01, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x3F, 0x01, 0xF8, 0x7C, 0x00,
  0x7C, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7F, 0x01, 0xFC, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x1F,
  0x87, 0xC0, 0x0F, 0x9F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xFC,
  0x00, 0xFC, 0xFE, 0x07, 0x78, 0xFF, 0xFD, 0xE1, 0xFF, 0xF3, 0xC0, 0xFF,
  0xC7, 0x80, 0x7F, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x3E, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF8, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC3,
  0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xC0, 0x00, 0x1E,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x06, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF0, 0x3F, 0x3E, 0x00, 0xFB, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x78, 0x80, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x7C, 0x0F, 0x81, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x0F, 0x1C,
  0x00, 0x0E, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0x3D, 0xC0, 0x3C, 0x7B, 0x81,
  0xFE, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0x0F, 0xFC, 0x3C, 0x07, 0xF8, 0x78,
  0x0F, 0xF0, 0xE0, 0x1F, 0xE1, 0xC0, 0x3F, 0xC3, 0x80, 0x7F, 0x87, 0x00,
  0xFF, 0x0E, 0x01, 0xFE, 0x1C, 0x03, 0xFC, 0x38, 0x07, 0xF8, 0x70, 0x0F,
  0xF0, 0xE0, 0x1F, 0xE1, 0xE0, 0x3F, 0xC3, 0xC0, 0x7F, 0x83, 0xC1, 0xF7,
  0x07, 0xEF, 0xEE, 0x07, 0xFB, 0xDC, 0x07, 0xE7, 0xBC, 0x03, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x07,
  0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1E,
  0x03, 0xC0, 0x07, 0x80, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0x80, 0x07, 0x83, 0xC0,
  0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01,
  0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x8F, 0x00, 0x3F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C,
  0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF,
  0x00, 0x07, 0x9E, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xC0, 0x07, 0xC7, 0x80, 0x03, 0xCF, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x07,
  0xDE, 0x00, 0x3F, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0xFC, 0x0F, 0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x9F,
  0x00, 0x0F, 0x3C, 0x00, 0x1C, 0xF8, 0x00, 0x21, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x41, 0xE0, 0x00, 0xE3,
  0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xC7, 0xC0, 0x1F, 0x07, 0xE0, 0x7C, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF0, 0x0F,
  0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xFB,
  0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0,
  0x01, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xEF,
  0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00,
  0x0F, 0x3C, 0x00, 0x7C, 0xF0, 0x03, 0xE3, 0xC0, 0x3F, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x81, 0xF8, 0x1F, 0x87, 0xC0, 0x1F, 0x0F, 0x00, 0x1F, 0x3E, 0x00, 0x1E,
  0x78, 0x00, 0x1A, 0xF0, 0x00, 0x43, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xF7, 0xC0, 0x03,
  0xEF, 0x80, 0x0F, 0xCF, 0x80, 0x3F, 0x8F, 0xC0, 0xEF, 0x1F, 0xFF, 0x9E,
  0x1F, 0xFF, 0x3C, 0x1F, 0xFC, 0x78, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x70, 0x01, 0xEF, 0x00, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x3E,
  0x7E, 0x0F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xF8,
  0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x07,
  0xC0, 0xF0, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x7C,
  0x00, 0xF0, 0x7C, 0x00, 0xF0, 0xF8, 0x00, 0xF1, 0xF0, 0x00, 0xF3, 0xF8,
  0x00, 0xF7, 0xF8, 0x00, 0xF7, 0xFC, 0x00, 0xFF, 0x3E, 0x00, 0xFE, 0x1E,
  0x00, 0xFE, 0x1F, 0x00, 0xFC, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x07,
  0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x01,
  0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFD, 0xC0, 0x7F, 0xFB, 0xC0, 0xEF, 0xF7, 0x81, 0xDF, 0xE7, 0x07,
  0xBF, 0xCF, 0x0E, 0x7F, 0x8E, 0x3C, 0xFF, 0x1E, 0x71, 0xFE, 0x3C, 0xE3,
  0xFC, 0x3B, 0xC7, 0xF8, 0x7F, 0x0F, 0xF0, 0x7E, 0x1F, 0xE0, 0xF8, 0x3F,
  0xC1, 0xF0, 0x7F, 0x81, 0xE0, 0xFF, 0x03, 0x81, 0xFE, 0x03, 0x03, 0xFC,
  0x04, 0x07, 0xF8, 0x08, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xFC, 0x00, 0xFE, 0xF0, 0x07, 0xF7, 0x80, 0x3F, 0x9E, 0x01,
  0xFC, 0xF0, 0x0F, 0xE7, 0x80, 0x7F, 0x1E, 0x03, 0xF8, 0xF0, 0x1F, 0xC3,
  0xC0, 0xFE, 0x1E, 0x07, 0xF0, 0x70, 0x3F, 0x83, 0xC1, 0xFC, 0x1E, 0x0F,
  0xE0, 0x78, 0x7F, 0x03, 0xC3, 0xF8, 0x0F, 0x1F, 0xC0, 0x78, 0xFE, 0x03,
  0xC7, 0xF0, 0x0F, 0x3F, 0x80, 0x79, 0xFC, 0x01, 0xEF, 0xE0, 0x0F, 0x7F,
  0x00, 0x7B, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x83, 0xF8, 0x3E, 0x00, 0xF8, 0x3C, 0x00,
  0x7C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3E, 0x00,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0x7C,
  0x00, 0x7C, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF,
  0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x3E, 0x00, 0xF8,
  0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xF8, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xCF, 0x80, 0x0F, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x7C,
  0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0x7C, 0x00,
  0x7C, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x07, 0xC1, 0xF0,
  0x0F, 0x81, 0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0xF8, 0x07, 0x81, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F,
  0x80, 0x1F, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xF8, 0x0F, 0xE1, 0xF0, 0x01, 0xF8,
  0xF0, 0x00, 0x38, 0x78, 0x00, 0x08, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE2, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF7,
  0xE0, 0x00, 0xF9, 0xF8, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0xBE, 0x00, 0xF9,
  0xF8, 0x0F, 0xC7, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0xFF,
  0x80, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0,
  0x00, 0x3E, 0x78, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03,
  0xE0, 0x78, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xF0,
  0x07, 0x80, 0x3E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x00,
  0x78, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x3E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x78,
  0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0xBC, 0x0F, 0x81,
  0xE7, 0x03, 0xE0, 0x79, 0xC0, 0xFC, 0x1E, 0x70, 0x3F, 0x07, 0x9C, 0x1F,
  0xC1, 0xE7, 0x07, 0x70, 0x79, 0xE1, 0xDC, 0x1C, 0x78, 0x77, 0x87, 0x1E,
  0x1C, 0xE1, 0xC7, 0x8F, 0x38, 0x71, 0xE3, 0x8E, 0x1C, 0x78, 0xE3, 0xC7,
  0x1E, 0x38, 0xF1, 0xC7, 0x9E, 0x1C, 0xF0, 0xE7, 0x87, 0x3C, 0x39, 0xC1,
  0xCF, 0x0E, 0x70, 0x7B, 0xC3, 0x9C, 0x0E, 0xF0, 0xEF, 0x03, 0xBC, 0x3B,
  0x80, 0xEE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xF8,
  0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x01, 0xF0,
  0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x03, 0xE0,
  0x78, 0x00, 0x3C, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x7C, 0xF8, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x0F, 0x80, 0x1F,
  0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x1F,
  0x00, 0x1F, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0x7C, 0x03,
  0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00,
  0x1F, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0E,
  0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xE6, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0x30, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x0E,
  0x0F, 0x04, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3E,
  0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x38, 0x00, 0xF0, 0x10, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7E,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0xF0, 0x78, 0x01, 0x70, 0x7E,
  0x07, 0x7F, 0x3F, 0xFE, 0x3F, 0x1F, 0xFC, 0x1F, 0x07, 0xF0, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x3F, 0x81, 0xE7, 0xFF, 0x0F, 0x7F, 0xFC, 0x7F, 0x03, 0xF3,
  0xE0, 0x07, 0x9F, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xDF, 0x00, 0x1E, 0xF8,
  0x01, 0xE7, 0xF0, 0x3F, 0x3D, 0xFF, 0xF1, 0xE7, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF8, 0x3F, 0x07, 0xE1,
  0xE0, 0x0F, 0x1E, 0x00, 0x3D, 0xE0, 0x01, 0x8F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x03, 0x1E, 0x00, 0x3C, 0xF8,
  0x03, 0xE3, 0xF0, 0x3E, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x1F, 0x83, 0xC1, 0xFF, 0x8F, 0x1F, 0xFF, 0x3C,
  0x7E, 0x0E, 0xF3, 0xE0, 0x0F, 0xDF, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80,
  0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0xFC, 0x7E, 0x0E, 0xF1, 0xFF, 0xF3,
  0xC1, 0xFF, 0x8F, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x7C, 0x1F, 0x81, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x0F,
  0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x83, 0xC0, 0x01, 0xC7, 0x80, 0x07, 0x87, 0x80, 0x1E,
  0x07, 0xC0, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x01, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0xFE, 0x7F, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F,
  0x81, 0xE0, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x1E, 0x00, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1C, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x70,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x78,
  0x00, 0x1F, 0x7E, 0x00, 0x7E, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0xFC, 0x0F, 0x3F, 0xF0, 0xF7, 0xFF, 0x8F, 0x60,
  0x7C, 0xF8, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xEF,
  0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x03, 0xEF, 0x00, 0x1F, 0x1E, 0x00, 0x7C, 0x3C, 0x01,
  0xF0, 0x78, 0x07, 0xC0, 0xF0, 0x1F, 0x01, 0xE0, 0x7C, 0x03, 0xC1, 0xF0,
  0x07, 0x87, 0xC0, 0x0F, 0x1F, 0x00, 0x1E, 0x7E, 0x00, 0x3D, 0xFE, 0x00,
  0x7F, 0xBE, 0x00, 0xFE, 0x3C, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0x7C, 0x07,
  0x80, 0x7C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0xF8, 0x78,
  0x00, 0xF8, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xF3, 0xC0, 0x01, 0xF7, 0x80,
  0x01, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0xF8, 0xE7, 0xF1, 0xFC, 0xEF, 0xFB, 0xFE, 0xE8, 0x7E,
  0x1E, 0xF0, 0x7C, 0x0E, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C,
  0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C,
  0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C,
  0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C,
  0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C,
  0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0x00, 0xFC, 0x0F, 0x3F, 0xF0,
  0xF7, 0xFF, 0x8F, 0x60, 0x7C, 0xF8, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFC, 0x0F, 0x81,
  0xE0, 0x0F, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xE3, 0x80, 0x03,
  0xC7, 0x80, 0x0F, 0x07, 0x80, 0x3E, 0x0F, 0xC0, 0xF8, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0x9F, 0xFC, 0x3D,
  0xFF, 0xF1, 0xFC, 0x0F, 0xCF, 0x80, 0x1E, 0x7C, 0x00, 0x7B, 0xC0, 0x03,
  0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0x7C, 0x00, 0x7B, 0xE0, 0x07, 0x9F, 0xC0, 0xFC, 0xF7, 0xFF, 0xC7,
  0x9F, 0xFC, 0x3C, 0x3F, 0x81, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0xF1, 0xFF,
  0xF3, 0xC7, 0xE0, 0xEF, 0x3E, 0x00, 0xFD, 0xF0, 0x01, 0xF7, 0x80, 0x07,
  0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x0F,
  0x78, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0xC7, 0xE0, 0xEF, 0x1F,
  0xFF, 0x3C, 0x1F, 0xF8, 0xF0, 0x1F, 0x83, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFF, 0x8F, 0xF8, 0x0F, 0x3F, 0xF0, 0x1E, 0xF0, 0x00, 0x3D,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xF8, 0x0F, 0xE3, 0xE0, 0x03, 0xC7, 0x80,
  0x03, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF3, 0x00, 0x01, 0xEF, 0x00, 0x07, 0xBF,
  0x00, 0x1F, 0x1F, 0xC0, 0xFC, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xF7, 0x80, 0x3F, 0x7E, 0x0E, 0xF3, 0xFF, 0xEF, 0x1F, 0xFC, 0xF0, 0x7E,
  0x00, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x73, 0xC0, 0x01,
  0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00,
  0x70, 0x1E, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0xF0, 0x01, 0xC1, 0xE0, 0x03,
  0xC3, 0x80, 0x07, 0x8F, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x38, 0x00, 0x0E,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0xF0, 0x1F, 0x01, 0xEE, 0x03, 0xE0, 0x3D, 0xC0, 0x7C, 0x07, 0xB8,
  0x0F, 0xC0, 0xE7, 0x81, 0xB8, 0x1C, 0xF0, 0x77, 0x03, 0x9E, 0x0E, 0xE0,
  0x71, 0xC1, 0xCC, 0x0E, 0x38, 0x39, 0xC3, 0xC7, 0x07, 0x38, 0x70, 0xE0,
  0xC7, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0xC7, 0x0C, 0x38, 0x38, 0xE1, 0xC7,
  0x07, 0x1C, 0x38, 0xE0, 0xE3, 0x07, 0x3C, 0x1C, 0xE0, 0xE7, 0x03, 0x9C,
  0x0C, 0xE0, 0x73, 0x81, 0xDC, 0x0F, 0x70, 0x3B, 0x80, 0xEC, 0x07, 0x70,
  0x1F, 0x80, 0xEE, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x78, 0xF8, 0x01, 0xE0, 0xF0,
  0x07, 0xC0, 0xF0, 0x1F, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0xF0, 0x01, 0xE3,
  0xE0, 0x01, 0xE7, 0x80, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80,
  0x03, 0xC7, 0x80, 0x07, 0x8F, 0x80, 0x1E, 0x0F, 0x80, 0x78, 0x0F, 0x01,
  0xF0, 0x1F, 0x03, 0xC0, 0x1F, 0x0F, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0xF8,
  0x00, 0x3E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0x03, 0x83, 0xC0, 0x03,
  0xC3, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xEF, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF,
  0x80, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x7C, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x1F, 0xFE, 0x03,
  0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xC0,
  0x3F, 0xF8, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0xFF, 0x03, 0xFF,
  0xC0, 0x7F, 0xF0, 0x00, 0x0F, 0x80, 0x06, 0x1F, 0xC0, 0x07, 0x3F, 0xF0,
  0x0E, 0x78, 0xF0, 0x0E, 0x70, 0x78, 0x0E, 0x70, 0x3C, 0x1C, 0xE0, 0x1E,
  0x3C, 0xE0, 0x0F, 0xF8, 0xE0, 0x07, 0xF0, 0xE0, 0x03, 0xE0,
};

const GFXglyph IBMPlexMono_Regular49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 7, 34, 29, 11, -34 },
  { 31, 12, 14, 29, 9, -36 },
  { 52, 28, 34, 29, 1, -34 },
  { 171, 25, 46, 29, 2, -40 },
  { 315, 28, 36, 29, 1, -35 },
  { 441, 27, 36, 29, 1, -35 },
  { 563, 4, 14, 29, 13, -36 },
  { 570, 14, 44, 29, 10, -37 },
  { 647, 14, 44, 29, 5, -37 },
  { 724, 25, 24, 29, 2, -28 },
  { 799, 23, 23, 29, 3, -26 },
  { 866, 9, 14, 29, 10, -7 },
  { 882, 14, 4, 29, 8, -17 },
  { 889, 7, 7, 29, 11, -7 },
  { 896, 21, 44, 29, 4, -37 },
  { 1012, 24, 36, 29, 3, -35 },
  { 1120, 24, 34, 29, 3, -34 },
  { 1222, 23, 35, 29, 3, -35 },
  { 1323, 23, 36, 29, 2, -35 },
  { 1427, 26, 34, 29, 2, -34 },
  { 1538, 22, 35, 29, 4, -34 },
  { 1635, 23, 35, 29, 3, -34 },
  { 1736, 23, 34, 29, 3, -34 },
  { 1834, 24, 36, 29, 3, -35 },
  { 1942, 23, 35, 29, 3, -35 },
  { 2043, 7, 26, 29, 11, -26 },
  { 2066, 9, 33, 29, 10, -26 },
  { 2104, 21, 28, 29, 4, -29 },
  { 2178, 23, 12, 29, 3, -21 },
  { 2213, 21, 28, 29, 4, -29 },
  { 2287, 21, 35, 29, 4, -35 },
  { 2379, 23, 40, 29, 3, -35 },
  { 2494, 26, 34, 29, 2, -34 },
  { 2605, 23, 34, 29, 4, -34 },
  { 2703, 23, 36, 29, 3, -35 },
  { 2807, 22, 34, 29, 5, -34 },
  { 2901, 21, 34, 29, 4, -34 },
  { 2991, 22, 34, 29, 4, -34 },
  { 3085, 23, 36, 29, 3, -35 },
  { 3189, 21, 34, 29, 4, -34 },
  { 3279, 21, 34, 29, 4, -34 },
  { 3369, 20, 35, 29, 4, -34 },
  { 3457, 24, 34, 29, 4, -34 },
  { 3559, 20, 34, 29, 6, -34 },
  { 3644, 23, 34, 29, 3, -34 },
  { 3742, 21, 34, 29, 4, -34 },
  { 3832, 24, 36, 29, 3, -35 },
  { 3940, 23, 34, 29, 4, -34 },
  { 4038, 24, 43, 29, 3, -35 },
  { 4167, 23, 34, 29, 4, -34 },
  { 4265, 25, 36, 29, 2, -35 },
  { 4378, 27, 34, 29, 1, -34 },
  { 4493, 21, 35, 29, 4, -34 },
  { 4585, 26, 34, 29, 2, -34 },
  { 4696, 26, 34, 29, 2, -34 },
  { 4807, 27, 34, 29, 1, -34 },
  { 4922, 28, 34, 29, 1, -34 },
  { 5041, 25, 34, 29, 2, -34 },
  { 5148, 14, 44, 29, 11, -37 },
  { 5225, 21, 44, 29, 4, -37 },
  { 5341, 13, 44, 29, 5, -37 },
  { 5413, 25, 20, 29, 2, -34 },
  { 5476, 23, 4, 29, 3, 4 },
  { 5488, 8, 10, 29, 9, -39 },
  { 5498, 24, 27, 29, 3, -26 },
  { 5579, 21, 37, 29, 5, -36 },
  { 5677, 21, 27, 29, 4, -26 },
  { 5748, 22, 37, 29, 3, -36 },
  { 5850, 23, 27, 29, 3, -26 },
  { 5928, 23, 36, 29, 4, -36 },
  { 6032, 24, 38, 29, 3, -28 },
  { 6146, 20, 36, 29, 5, -36 },
  { 6236, 22, 37, 29, 5, -37 },
  { 6338, 17, 47, 29, 5, -37 },
  { 6438, 23, 36, 29, 5, -36 },
  { 6542, 21, 36, 29, 4, -36 },
  { 6637, 24, 26, 29, 3, -26 },
  { 6715, 20, 26, 29, 5, -26 },
  { 6780, 23, 27, 29, 3, -26 },
  { 6858, 21, 36, 29, 5, -26 },
  { 6953, 22, 36, 29, 3, -26 },
  { 7052, 23, 25, 29, 4, -25 },
  { 7124, 23, 27, 29, 3, -26 },
  { 7202, 24, 34, 29, 2, -34 },
  { 7304, 20, 26, 29, 5, -25 },
  { 7369, 23, 25, 29, 3, -25 },
  { 7441, 27, 25, 29, 1, -25 },
  { 7526, 23, 25, 29, 3, -25 },
  { 7598, 24, 35, 29, 3, -25 },
  { 7703, 21, 25, 29, 4, -25 },
  { 7769, 19, 44, 29, 5, -37 },
  { 7874, 3, 44, 29, 13, -37 },
  { 7891, 19, 44, 29, 5, -37 },
  { 7996, 24, 10, 29, 3, -20 },
};

const GFXfont IBMPlexMono_Regular49pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular49pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular49pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _IBMPLEXMONO_REGULAR49PT7B_H_
