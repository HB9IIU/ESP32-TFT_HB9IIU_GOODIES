#ifndef _IBMPLEXMONO_REGULAR52PT7B_H_
#define _IBMPLEXMONO_REGULAR52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular52pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE3,
  0xC7, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x83, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFB, 0xE0, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3C, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x7F, 0xF0, 0x3F, 0xF3, 0xFF, 0x83, 0xFF, 0x9F, 0xFC, 0x1F, 0xFC, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80,
  0x7F, 0xF0, 0x3F, 0xFB, 0xFF, 0x81, 0xFF, 0xDF, 0xFC, 0x1F, 0xFE, 0xFF,
  0xE0, 0xFF, 0xF0, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x70, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x0F, 0xE3, 0x9F, 0xC3, 0xE0, 0xE1, 0xF9, 0xF0, 0x38, 0x3F, 0x7C, 0x0E,
  0x07, 0x1E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x78,
  0x0E, 0x00, 0x1F, 0x03, 0x80, 0x07, 0xC0, 0xE0, 0x00, 0xF8, 0x38, 0x00,
  0x3F, 0x8E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xE7, 0xF0, 0x00,
  0x38, 0x7E, 0x00, 0x0E, 0x0F, 0x80, 0x03, 0x81, 0xE0, 0x00, 0xE0, 0x7C,
  0x00, 0x38, 0x1F, 0x00, 0x0E, 0x07, 0xC0, 0x03, 0x81, 0xF2, 0x00, 0xE0,
  0x7D, 0xC0, 0x38, 0x1E, 0xF8, 0x0E, 0x0F, 0xBF, 0x83, 0x87, 0xE7, 0xF8,
  0xE7, 0xF0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0xCF, 0xFF, 0x00, 0x1C, 0xF8, 0x78, 0x01, 0xE7, 0x81, 0xE0,
  0x0E, 0x78, 0x07, 0x00, 0xF3, 0xC0, 0x38, 0x07, 0x1E, 0x01, 0xC0, 0x78,
  0xF0, 0x0F, 0x07, 0x87, 0x80, 0x78, 0x3C, 0x3C, 0x03, 0x83, 0xC1, 0xE0,
  0x1C, 0x1E, 0x0F, 0x00, 0xE1, 0xE0, 0x3C, 0x0F, 0x0F, 0x01, 0xF0, 0xF0,
  0xF0, 0x07, 0xFF, 0x87, 0x80, 0x1F, 0xF0, 0x78, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x78, 0x3F, 0xE0, 0x03, 0x83, 0xFF, 0x80, 0x3C, 0x3C, 0x3E, 0x01, 0xC3,
  0xC0, 0x70, 0x1E, 0x1E, 0x03, 0xC0, 0xE0, 0xE0, 0x0E, 0x0F, 0x07, 0x00,
  0x70, 0xF0, 0x38, 0x03, 0x87, 0x81, 0xC0, 0x1C, 0x78, 0x0E, 0x00, 0xE3,
  0xC0, 0x70, 0x07, 0x3C, 0x03, 0xC0, 0x79, 0xE0, 0x1E, 0x03, 0x9E, 0x00,
  0x78, 0x7C, 0xF0, 0x01, 0xFF, 0xCF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x04, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x1F, 0xF8,
  0x0F, 0xE1, 0xF3, 0xE0, 0x7F, 0x1F, 0x1F, 0x03, 0x81, 0xF0, 0x7C, 0x1C,
  0x0F, 0x01, 0xF0, 0xE0, 0x78, 0x07, 0xCF, 0x07, 0xC0, 0x1F, 0x78, 0x3E,
  0x00, 0x7F, 0x81, 0xF0, 0x03, 0xFC, 0x0F, 0x80, 0x0F, 0xE0, 0x7C, 0x00,
  0x3F, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0xEF,
  0x81, 0xF8, 0x1E, 0x3E, 0x0F, 0xFF, 0xF0, 0xF8, 0x3F, 0xFF, 0x07, 0xC0,
  0x7F, 0xF0, 0x1F, 0x00, 0xFE, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x60, 0x0F, 0x00, 0xCF, 0x81, 0xE0, 0xFB, 0xFE, 0x3C,
  0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x7C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0x80, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x00, 0x1C,
  0x00, 0x40, 0x02, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF0, 0xF8, 0x78,
  0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xF8,
  0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3C,
  0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3E, 0x07,
  0xF8, 0x1F, 0x83, 0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0, 0xFF, 0x03, 0xF0,
  0x7F, 0x81, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0xF3, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x1F,
  0x00, 0x7E, 0x0F, 0xE0, 0x7E, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xEF, 0x00, 0x03, 0xF3,
  0xC0, 0x01, 0xF8, 0xF0, 0x00, 0xFC, 0x3C, 0x00, 0x7E, 0x0F, 0x00, 0x3F,
  0x03, 0xC0, 0x07, 0x00, 0xF0, 0x01, 0x80, 0x3C, 0x00, 0x40, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xF8, 0x1F, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81,
  0xFC, 0x0F, 0xE1, 0xF8, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x18, 0x00, 0x3E,
  0x08, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x80, 0x00, 0x7C, 0xE0, 0x00, 0x3C,
  0xF8, 0x00, 0x3E, 0xFE, 0x00, 0x3F, 0x1F, 0xC0, 0x7F, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x0F,
  0x00, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x78,
  0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x7F, 0x00, 0x78, 0xFF, 0xE0, 0x7B, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x7F, 0x01, 0xFC, 0x7C, 0x00, 0xFC, 0x78, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x20, 0x00, 0x1E, 0x70, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x7C,
  0x7F, 0x01, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0xF1,
  0xFF, 0xC0, 0xF9, 0xFF, 0xF0, 0x79, 0xFF, 0xFC, 0x3D, 0xC0, 0x7F, 0x1F,
  0x80, 0x0F, 0x8F, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xF3, 0xE0, 0x00,
  0xF8, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0xFC, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C,
  0xF0, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xE1, 0xF0, 0x01, 0xF9, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC1, 0xF0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x1F,
  0xC0, 0x7F, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0xF0, 0x00,
  0x78, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xBE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xCF,
  0x80, 0x0F, 0xC7, 0xF0, 0x1D, 0xE1, 0xFF, 0xFC, 0xF0, 0x7F, 0xFE, 0xF8,
  0x1F, 0xFC, 0x78, 0x01, 0xFC, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7D,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFB, 0xE0,
  0x3E, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0xFC, 0x7E, 0x3F, 0x3F, 0x1F, 0x8F, 0x87, 0xC3, 0xC3, 0xE1, 0xF0,
  0xF0, 0x78, 0x38, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x3F, 0x8F, 0xC0, 0x1F, 0x9F,
  0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0x60, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x07, 0x8F, 0x78, 0x1F, 0xE7, 0x78, 0x3F, 0xE7, 0x70, 0x3F, 0xF7, 0x70,
  0x7C, 0x1F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0xF0, 0x07, 0xF0,
  0xF0, 0x07, 0xF0, 0xF0, 0x07, 0xF0, 0xF0, 0x07, 0xF0, 0xF0, 0x07, 0xF0,
  0xF0, 0x07, 0xF0, 0xF0, 0x07, 0xF0, 0xF0, 0x07, 0xF0, 0x70, 0x07, 0xF0,
  0x78, 0x0F, 0xF0, 0x78, 0x0F, 0x70, 0x7F, 0x77, 0x70, 0x3F, 0xF7, 0x78,
  0x1F, 0xE7, 0x78, 0x0F, 0xC7, 0x78, 0x03, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0,
  0x7C, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x7C, 0x7C,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x00, 0x3F, 0x9E, 0x00,
  0x1F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00,
  0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F,
  0x3C, 0x00, 0x3E, 0x78, 0x01, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x00, 0x1F, 0x9E, 0x00, 0x0F, 0xBC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0x78, 0x00, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xC0, 0xFC, 0x3F, 0x00, 0x7E, 0x3E, 0x00,
  0x3E, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x0E, 0x78, 0x00, 0x08, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x08, 0x7C, 0x00, 0x0E, 0x3C, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x1F, 0xC0, 0xFC, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x00, 0x7F,
  0x1E, 0x00, 0x3F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D,
  0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x1F,
  0x3C, 0x00, 0x7E, 0x78, 0x03, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x0E, 0x78, 0x00, 0x08, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x3C,
  0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0xEF, 0x0F,
  0xFF, 0xEF, 0x07, 0xFF, 0xCF, 0x03, 0xFF, 0x8F, 0x00, 0xFE, 0x00, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xCF, 0x80, 0x3E, 0x7F, 0x07, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xCF,
  0x80, 0x03, 0xF3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x03,
  0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF9, 0xFC, 0x00,
  0x3E, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFE, 0x7C, 0x00, 0xFF, 0x1F,
  0x00, 0x3F, 0x83, 0xE0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x01, 0xEF, 0xF7, 0x81, 0xCF, 0xF7, 0x83, 0xCF, 0xF3,
  0x83, 0xCF, 0xF3, 0xC3, 0x8F, 0xF3, 0xC7, 0x8F, 0xF1, 0xE7, 0x0F, 0xF1,
  0xEF, 0x0F, 0xF0, 0xEF, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0,
  0x7C, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x38, 0x0F, 0xF0, 0x38, 0x0F, 0xF0,
  0x18, 0x0F, 0xF0, 0x10, 0x0F, 0xF0, 0x10, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFD, 0xE0,
  0x07, 0xFB, 0xC0, 0x0F, 0xF3, 0xC0, 0x1F, 0xE7, 0x80, 0x3F, 0xCF, 0x80,
  0x7F, 0x8F, 0x00, 0xFF, 0x1E, 0x01, 0xFE, 0x1E, 0x03, 0xFC, 0x3C, 0x07,
  0xF8, 0x7C, 0x0F, 0xF0, 0x78, 0x1F, 0xE0, 0xF8, 0x3F, 0xC0, 0xF0, 0x7F,
  0x81, 0xE0, 0xFF, 0x01, 0xE1, 0xFE, 0x03, 0xC3, 0xFC, 0x07, 0xC7, 0xF8,
  0x07, 0x8F, 0xF0, 0x0F, 0x1F, 0xE0, 0x0F, 0x3F, 0xC0, 0x1E, 0x7F, 0x80,
  0x3E, 0xFF, 0x00, 0x3D, 0xFE, 0x00, 0x7B, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x78,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xDE, 0x00,
  0x03, 0xEF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0xF8, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x7E, 0x0F, 0xE0, 0x7E, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF,
  0x00, 0x0F, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0xF0, 0x00,
  0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xC0,
  0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7,
  0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0xFC,
  0x1F, 0xC0, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0xFC, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xF0,
  0x3E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF0,
  0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0xF0,
  0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xC0, 0x7F,
  0x87, 0xC0, 0x03, 0xF3, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x0C, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC4, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x3E, 0x7F, 0x00, 0x1F, 0x8F, 0xF0, 0x1F, 0xC1, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x00,
  0x07, 0x9F, 0x00, 0x1F, 0x3F, 0x00, 0x3E, 0x3F, 0x01, 0xF8, 0x3F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x3C, 0x3E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F,
  0x80, 0x07, 0x80, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x07,
  0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1F,
  0x00, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0xC0, 0xF0,
  0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x3E,
  0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xEE, 0x03, 0xE0, 0x3D, 0xC0, 0x7C,
  0x07, 0xBC, 0x0F, 0xC0, 0xE7, 0x83, 0xF8, 0x1C, 0xF0, 0x7F, 0x03, 0x9E,
  0x0E, 0xE0, 0xF3, 0xC1, 0xDC, 0x1E, 0x78, 0x3B, 0xC3, 0xCF, 0x0F, 0x78,
  0x79, 0xE1, 0xE7, 0x0F, 0x3C, 0x38, 0xE1, 0xE7, 0x87, 0x1E, 0x3C, 0x70,
  0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xF1, 0xC7, 0x87, 0x1E, 0x3C, 0xE0, 0xE3,
  0x87, 0x9C, 0x1E, 0x70, 0xF7, 0x83, 0xCE, 0x1E, 0xF0, 0x39, 0xC3, 0xDC,
  0x07, 0x78, 0x7B, 0x80, 0xEF, 0x0F, 0x70, 0x1F, 0xE1, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0,
  0x1F, 0xC0, 0x7C, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0xC0,
  0x1F, 0x00, 0x3C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x1E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x3C,
  0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x00, 0xF8, 0x07, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x78,
  0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x01, 0xE0,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x3C, 0x00,
  0x07, 0x87, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xF3,
  0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0xF0, 0xF8, 0x78, 0x3C, 0x3C, 0x1E, 0x0E,
  0x0F, 0x04, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0x03, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0x80, 0x07,
  0xC0, 0x40, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x3C, 0x1F, 0x00, 0x0F,
  0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x1E, 0x00,
  0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x0E, 0xFF, 0x3F, 0xFF, 0x9F, 0xC7,
  0xFF, 0xC7, 0xF0, 0xFF, 0xE0, 0xFC, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x83, 0xF8, 0x0F, 0x1F, 0xFC, 0x1E, 0x7F,
  0xFC, 0x3D, 0xFF, 0xFC, 0x7B, 0x81, 0xFC, 0xFC, 0x00, 0xF9, 0xF0, 0x00,
  0xFB, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x7D, 0xF8, 0x01, 0xF3, 0xDC,
  0x0F, 0xE7, 0xBF, 0xFF, 0x8F, 0x3F, 0xFE, 0x1E, 0x3F, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xFC, 0x1F, 0x87, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x3E, 0x00,
  0x0C, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x87,
  0xC0, 0x01, 0xC7, 0xC0, 0x07, 0xCF, 0xC0, 0x1F, 0x0F, 0xC0, 0x7E, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0xE0, 0xF0, 0x7F, 0xF1,
  0xE1, 0xFF, 0xF3, 0xC7, 0xFF, 0xF7, 0x9F, 0xC0, 0xEF, 0x3E, 0x00, 0x7E,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xDE, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0xFC, 0xFE, 0x07, 0x78, 0xFF, 0xFE, 0xF0, 0xFF, 0xF9, 0xE0, 0xFF, 0xE3,
  0xC0, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E,
  0x00, 0x03, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xC1, 0xF0, 0x00,
  0x70, 0x7C, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0x30, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x3F,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x3F, 0x78, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x78,
  0x00, 0x07, 0xDF, 0x80, 0x07, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0xFC, 0x0F, 0x1F, 0xFC, 0x79, 0xFF, 0xF3, 0xCF, 0xFF, 0xDE, 0xE0,
  0x7E, 0xF4, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x79, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xEF, 0x80, 0x07,
  0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xF8, 0x0F,
  0xC0, 0x7C, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0x8F,
  0xC0, 0x07, 0xCF, 0x80, 0x03, 0xEF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xBE, 0x00, 0x7F, 0x9F, 0x00, 0x3F, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFC, 0xFF, 0xFC, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xE0, 0x7C,
  0x79, 0xFC, 0x7F, 0xBD, 0xFE, 0x7F, 0xDF, 0xFF, 0xBF, 0xFF, 0x87, 0xF0,
  0xFF, 0x81, 0xF0, 0x3F, 0xC0, 0xF8, 0x1F, 0xE0, 0x3C, 0x0F, 0xF0, 0x1E,
  0x03, 0xF8, 0x0F, 0x01, 0xFC, 0x07, 0x80, 0xFE, 0x03, 0xC0, 0x7F, 0x01,
  0xE0, 0x3F, 0x80, 0xF0, 0x1F, 0xC0, 0x78, 0x0F, 0xE0, 0x3C, 0x07, 0xF0,
  0x1E, 0x03, 0xF8, 0x0F, 0x01, 0xFC, 0x07, 0x80, 0xFE, 0x03, 0xC0, 0x7F,
  0x01, 0xE0, 0x3F, 0x80, 0xF0, 0x1F, 0xC0, 0x78, 0x0F, 0xE0, 0x3C, 0x07,
  0xF0, 0x1E, 0x03, 0xF8, 0x0F, 0x01, 0xFC, 0x07, 0x80, 0xE0, 0xF0, 0x7E,
  0x07, 0x8F, 0xFE, 0x3C, 0xFF, 0xF9, 0xE7, 0xFF, 0xEF, 0x70, 0x3F, 0x7A,
  0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x0F,
  0xC1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x78, 0x00,
  0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x78,
  0x00, 0x0F, 0xBC, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF0, 0xFC, 0x00, 0xF8, 0x3F, 0x01, 0xF8,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0xF0, 0x7F, 0x01, 0xE3, 0xFF, 0x83, 0xCF, 0xFF, 0x87, 0xBF, 0xFF,
  0x8F, 0x70, 0x3F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xEF, 0x00,
  0x03, 0xDF, 0x00, 0x0F, 0xBF, 0x00, 0x3E, 0x7B, 0x81, 0xFC, 0xF7, 0xFF,
  0xF1, 0xE7, 0xFF, 0xC3, 0xC7, 0xFF, 0x07, 0x83, 0xF8, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x1E, 0x0F, 0xFE, 0x3C, 0x3F, 0xFE, 0x78, 0xFF, 0xFE, 0xF3,
  0xF8, 0x1D, 0xE7, 0xC0, 0x0F, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x78,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0xC0, 0x01,
  0xEF, 0x80, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0xC0, 0xEF, 0x1F, 0xFF, 0xDE,
  0x1F, 0xFF, 0x3C, 0x1F, 0xFC, 0x78, 0x0F, 0xE0, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xF0,
  0x0F, 0x78, 0x00, 0x07, 0xB0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x1F, 0x80, 0x7F, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x0C, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x10, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xFF, 0x80, 0x7E,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x80,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x7D, 0xF0, 0x07, 0xEF, 0xC0, 0xFF, 0x3F, 0xFF, 0x78, 0xFF,
  0xF3, 0xC3, 0xFF, 0x1E, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xBC, 0x00,
  0x07, 0x9E, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x07,
  0x80, 0x1E, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x0F, 0x00,
  0x3C, 0x07, 0x80, 0x0E, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x1F, 0x00, 0xFE,
  0x01, 0xF0, 0x0E, 0xF0, 0x1F, 0x00, 0xEF, 0x01, 0xF8, 0x0E, 0xF0, 0x3B,
  0x81, 0xEF, 0x03, 0xB8, 0x1E, 0x70, 0x3B, 0x81, 0xE7, 0x03, 0xB8, 0x1E,
  0x70, 0x39, 0xC1, 0xC7, 0x87, 0x1C, 0x1C, 0x78, 0x71, 0xC1, 0xC7, 0x87,
  0x1C, 0x3C, 0x78, 0x71, 0xC3, 0xC3, 0x87, 0x0E, 0x3C, 0x38, 0xE0, 0xE3,
  0x83, 0x8E, 0x0E, 0x38, 0x38, 0xE0, 0xE3, 0x83, 0xCE, 0x0E, 0x38, 0x3C,
  0xE0, 0x73, 0x81, 0xDE, 0x07, 0x78, 0x1D, 0xC0, 0x77, 0x81, 0xDC, 0x07,
  0x70, 0x1D, 0xC0, 0x77, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0x9F, 0x00,
  0x0F, 0x8F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0x80, 0xF8, 0x07, 0x80, 0x7C,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xFB, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x1F,
  0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x3E, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0, 0x01, 0xF1,
  0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x07, 0x80, 0x3E, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x0F,
  0x00, 0x3C, 0x07, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x07, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xC0, 0x03, 0x03, 0xF8, 0x00, 0xF1, 0xFF, 0x00, 0x38, 0xFF, 0xE0,
  0x1E, 0x3C, 0x7C, 0x07, 0x9E, 0x0F, 0x81, 0xC7, 0x01, 0xE0, 0xF3, 0xC0,
  0x7E, 0x7C, 0xF0, 0x0F, 0xFE, 0x38, 0x01, 0xFF, 0x8E, 0x00, 0x3F, 0xC1,
  0x80, 0x03, 0xC0,
};

const GFXglyph IBMPlexMono_Regular52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 7, 36, 31, 12, -36 },
  { 33, 13, 14, 31, 9, -38 },
  { 56, 29, 36, 31, 1, -36 },
  { 187, 26, 48, 31, 3, -42 },
  { 343, 29, 38, 31, 1, -37 },
  { 481, 29, 38, 31, 1, -37 },
  { 619, 4, 14, 31, 14, -38 },
  { 626, 15, 47, 31, 11, -40 },
  { 715, 15, 47, 31, 6, -40 },
  { 804, 27, 26, 31, 2, -30 },
  { 892, 25, 26, 31, 3, -29 },
  { 974, 9, 14, 31, 11, -7 },
  { 990, 15, 4, 31, 8, -18 },
  { 998, 7, 7, 31, 12, -7 },
  { 1005, 22, 47, 31, 5, -40 },
  { 1135, 25, 38, 31, 3, -37 },
  { 1254, 26, 36, 31, 3, -36 },
  { 1371, 25, 37, 31, 3, -37 },
  { 1487, 25, 38, 31, 2, -37 },
  { 1606, 27, 36, 31, 2, -36 },
  { 1728, 24, 37, 31, 4, -36 },
  { 1839, 25, 37, 31, 3, -36 },
  { 1955, 25, 36, 31, 3, -36 },
  { 2068, 25, 38, 31, 3, -37 },
  { 2187, 25, 37, 31, 3, -37 },
  { 2303, 7, 28, 31, 12, -28 },
  { 2328, 9, 35, 31, 11, -28 },
  { 2368, 23, 30, 31, 4, -31 },
  { 2455, 25, 14, 31, 3, -23 },
  { 2499, 23, 30, 31, 4, -31 },
  { 2586, 23, 37, 31, 4, -37 },
  { 2693, 24, 43, 31, 3, -37 },
  { 2822, 28, 36, 31, 2, -36 },
  { 2948, 23, 36, 31, 5, -36 },
  { 3052, 24, 38, 31, 4, -37 },
  { 3166, 23, 36, 31, 5, -36 },
  { 3270, 22, 36, 31, 5, -36 },
  { 3369, 23, 36, 31, 5, -36 },
  { 3473, 24, 38, 31, 3, -37 },
  { 3587, 23, 36, 31, 4, -36 },
  { 3691, 23, 36, 31, 4, -36 },
  { 3795, 21, 37, 31, 4, -36 },
  { 3893, 26, 36, 31, 4, -36 },
  { 4010, 22, 36, 31, 6, -36 },
  { 4109, 24, 36, 31, 4, -36 },
  { 4217, 23, 36, 31, 4, -36 },
  { 4321, 25, 38, 31, 3, -37 },
  { 4440, 23, 36, 31, 5, -36 },
  { 4544, 25, 46, 31, 3, -37 },
  { 4688, 24, 36, 31, 5, -36 },
  { 4796, 26, 38, 31, 2, -37 },
  { 4920, 29, 36, 31, 1, -36 },
  { 5051, 23, 37, 31, 4, -36 },
  { 5158, 27, 36, 31, 2, -36 },
  { 5280, 27, 36, 31, 2, -36 },
  { 5402, 29, 36, 31, 1, -36 },
  { 5533, 29, 36, 31, 1, -36 },
  { 5664, 27, 36, 31, 2, -36 },
  { 5786, 14, 47, 31, 12, -40 },
  { 5869, 22, 47, 31, 5, -40 },
  { 5999, 15, 47, 31, 5, -40 },
  { 6088, 27, 21, 31, 2, -36 },
  { 6159, 25, 4, 31, 3, 5 },
  { 6172, 8, 10, 31, 10, -40 },
  { 6182, 26, 28, 31, 3, -27 },
  { 6273, 23, 39, 31, 5, -38 },
  { 6386, 23, 28, 31, 4, -27 },
  { 6467, 23, 39, 31, 3, -38 },
  { 6580, 25, 28, 31, 3, -27 },
  { 6668, 24, 38, 31, 4, -38 },
  { 6782, 26, 42, 31, 3, -31 },
  { 6919, 21, 38, 31, 5, -38 },
  { 7019, 22, 39, 31, 6, -39 },
  { 7127, 19, 49, 31, 5, -39 },
  { 7244, 25, 38, 31, 5, -38 },
  { 7363, 23, 38, 31, 4, -38 },
  { 7473, 25, 27, 31, 3, -27 },
  { 7558, 21, 27, 31, 5, -27 },
  { 7629, 25, 28, 31, 3, -27 },
  { 7717, 23, 37, 31, 5, -27 },
  { 7824, 23, 37, 31, 3, -27 },
  { 7931, 25, 27, 31, 4, -27 },
  { 8016, 24, 28, 31, 3, -27 },
  { 8100, 25, 36, 31, 2, -36 },
  { 8213, 21, 28, 31, 5, -27 },
  { 8287, 25, 27, 31, 3, -27 },
  { 8372, 28, 27, 31, 2, -27 },
  { 8467, 25, 27, 31, 3, -27 },
  { 8552, 25, 37, 31, 3, -27 },
  { 8668, 23, 27, 31, 4, -27 },
  { 8746, 21, 47, 31, 5, -40 },
  { 8870, 3, 47, 31, 14, -40 },
  { 8888, 21, 47, 31, 5, -40 },
  { 9012, 26, 12, 31, 3, -22 },
};

const GFXfont IBMPlexMono_Regular52pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular52pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular52pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _IBMPLEXMONO_REGULAR52PT7B_H_
