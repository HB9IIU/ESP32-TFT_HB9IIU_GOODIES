#ifndef _IBMPLEXMONO_REGULAR36PT7B_H_
#define _IBMPLEXMONO_REGULAR36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular36pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x8C, 0x63, 0x18, 0xC4, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x78, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xC0, 0x01, 0xC3, 0x80, 0x1C, 0x30, 0x01, 0xC3,
  0x00, 0x18, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x86, 0x07, 0xF8,
  0x7F, 0x7F, 0x8F, 0xF7, 0xF0, 0xFF, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x0C, 0x00, 0x70, 0xC0, 0x06, 0x1C, 0x0F, 0xE1, 0xFE, 0xFE, 0x1F, 0xEF,
  0xE1, 0xFE, 0x0E, 0x18, 0x00, 0xE1, 0x80, 0x0C, 0x38, 0x00, 0xC3, 0x80,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1,
  0xF3, 0x3E, 0x70, 0xC3, 0xDC, 0x30, 0x47, 0x0C, 0x01, 0xC3, 0x00, 0x70,
  0xC0, 0x1E, 0x30, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xC0, 0x0C, 0xF8, 0x03, 0x0F, 0x00, 0xC1, 0xC0, 0x30, 0x74, 0x0C, 0x1D,
  0x83, 0x07, 0xF0, 0xC3, 0x9F, 0x33, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07,
  0xF8, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0x00, 0x77, 0xF8, 0x06, 0xFF, 0xC0, 0xEE, 0x1C, 0x1C, 0xC0, 0xC1, 0xCC,
  0x0C, 0x38, 0xC0, 0xC3, 0x0C, 0x0C, 0x70, 0xE1, 0xC6, 0x0F, 0xFC, 0xE0,
  0x7F, 0x8C, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0x1F,
  0xC0, 0x63, 0xFE, 0x0E, 0x78, 0xF0, 0xC7, 0x07, 0x1C, 0x70, 0x71, 0x87,
  0x07, 0x38, 0x70, 0x77, 0x07, 0x8F, 0x70, 0x3F, 0xEE, 0x01, 0xFC, 0xE0,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xC1, 0xC0,
  0x38, 0x0E, 0x03, 0x80, 0x80, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x3E, 0x3F, 0x83, 0xE3, 0xFC,
  0x3E, 0x71, 0xE3, 0x0E, 0x0F, 0x30, 0xE0, 0x7B, 0x0E, 0x03, 0xF0, 0xE0,
  0x1F, 0x0E, 0x00, 0xE0, 0xF0, 0x0F, 0x07, 0x83, 0xF8, 0x7F, 0xF3, 0xC3,
  0xFE, 0x1C, 0x0F, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x70,
  0x1C, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x30, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xE0, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03,
  0x01, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x03, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x20, 0x70, 0x2F, 0x1C,
  0x3F, 0xFF, 0x7F, 0x7F, 0xFF, 0x03, 0xFE, 0x00, 0x1E, 0x00, 0x0F, 0xC0,
  0x07, 0x78, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x70, 0x38, 0x38, 0x0E, 0x02,
  0x01, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3E, 0x78, 0xF1, 0xC7, 0x8F,
  0x1C, 0x38, 0x61, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xF7, 0x80,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x7C, 0x78, 0x07, 0x1C,
  0x01, 0xE7, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00,
  0x3F, 0x87, 0x8F, 0xE1, 0xE3, 0xF8, 0x78, 0xFE, 0x1E, 0x3F, 0x80, 0x0E,
  0xE0, 0x03, 0xB8, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1E, 0x78, 0x07, 0x0F,
  0x07, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x7B, 0x80, 0x3C, 0xE0, 0x1E, 0x38, 0x0F, 0x0E,
  0x01, 0x83, 0x80, 0x40, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x07, 0xFF,
  0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x07, 0xF0, 0x07, 0xFE, 0x07, 0xFF,
  0x87, 0x83, 0xC7, 0x80, 0xF3, 0x80, 0x3B, 0x80, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80,
  0x07, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xE7, 0x00, 0xF1, 0x80,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xEC, 0x00, 0xEF, 0x00, 0xF3, 0xC0, 0xF8, 0xFF,
  0xF8, 0x3F, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xD8, 0x00, 0x3B, 0x00, 0x0E, 0x60, 0x01, 0x8C, 0x00, 0x71, 0x80, 0x1C,
  0x30, 0x03, 0x06, 0x00, 0xE0, 0xC0, 0x38, 0x18, 0x07, 0x03, 0x01, 0xC0,
  0x60, 0x30, 0x0C, 0x0E, 0x01, 0x83, 0x80, 0x30, 0x60, 0x06, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x63, 0xF0, 0x6F, 0xF8, 0x6F, 0xFC, 0x78, 0x3E, 0xF0, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x60, 0x07, 0xE0, 0x0E,
  0xF8, 0x3E, 0x7F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0xFC, 0x1C, 0xFF, 0x0E, 0xFF, 0xE7, 0xC1, 0xF7,
  0xC0, 0x3F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xD8, 0x00,
  0xEE, 0x00, 0x77, 0x80, 0x79, 0xE0, 0x78, 0x7F, 0xF8, 0x1F, 0xF8, 0x03,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0x77, 0x00, 0x3B, 0x80, 0x39, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xFF,
  0x83, 0xFF, 0xF1, 0xF0, 0x3C, 0x70, 0x07, 0x9C, 0x00, 0xE7, 0x00, 0x39,
  0xC0, 0x0E, 0x70, 0x07, 0x0F, 0x03, 0xC1, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F,
  0xFE, 0x0F, 0x03, 0xC7, 0x00, 0x7B, 0x80, 0x0E, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0E, 0xF0, 0x07, 0x9F, 0x03, 0xE3, 0xFF, 0xF0,
  0x7F, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87,
  0x83, 0xE7, 0x80, 0x73, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xDC, 0x00, 0xEF, 0x00, 0xF7, 0xC0, 0xF9, 0xFF, 0xDC, 0x7F,
  0xDC, 0x0F, 0x8E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x7F,
  0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xDE, 0x3C,
  0xF9, 0xF3, 0xE3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x9E, 0x3C, 0x71, 0xE3, 0xC7, 0x0E, 0x18, 0x70, 0x00, 0x01, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF3,
  0xC1, 0xFF, 0x00, 0xFC, 0x01, 0xD8, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87,
  0x83, 0xE3, 0x80, 0x73, 0x80, 0x19, 0xC0, 0x0E, 0xC0, 0xE7, 0x61, 0xFB,
  0xF0, 0xFF, 0xF8, 0xF1, 0xFC, 0x70, 0x7E, 0x38, 0x3F, 0x18, 0x1F, 0x8C,
  0x0F, 0xC6, 0x07, 0xE3, 0x03, 0xF1, 0xC1, 0xF8, 0xE0, 0xEC, 0x7F, 0xF6,
  0x1F, 0xFB, 0x87, 0xDD, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0x00,
  0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xB8, 0x00, 0x39, 0xC0, 0x03, 0x9C,
  0x00, 0x71, 0xC0, 0x07, 0x0C, 0x00, 0x70, 0xE0, 0x06, 0x0E, 0x00, 0xE0,
  0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0x83, 0xFF, 0xF8, 0x38, 0x03, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xE0, 0x00, 0xF0, 0xFF, 0xF0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x1C, 0x03, 0xCE, 0x00, 0xE7, 0x00, 0x7B, 0x80,
  0x3D, 0xC0, 0x1E, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x1F, 0xFF, 0x0F,
  0xFF, 0x07, 0xFF, 0xE3, 0x80, 0x3D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x7B, 0xFF, 0xF9, 0xFF,
  0xF8, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x1E,
  0x78, 0x0F, 0x70, 0x07, 0xE0, 0x02, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x02, 0x70, 0x07, 0x78, 0x0F, 0x3C, 0x1E,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1C, 0x07, 0xCE, 0x01, 0xE7, 0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0,
  0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xDC, 0x01,
  0xEE, 0x01, 0xE7, 0x01, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3,
  0xE7, 0x80, 0x73, 0x80, 0x3D, 0xC0, 0x09, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF,
  0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0xF7, 0x80,
  0x79, 0xE0, 0xFC, 0xFF, 0xEE, 0x3F, 0xE7, 0x07, 0xE3, 0x80, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x72, 0x01, 0xF8,
  0x07, 0xE0, 0x3D, 0xE1, 0xF7, 0xFF, 0x8F, 0xFC, 0x0F, 0xC0, 0xE0, 0x07,
  0xF8, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x3C, 0x38, 0x1E, 0x0E,
  0x0F, 0x03, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0xF0, 0x0E, 0x78, 0x03, 0xBE,
  0x00, 0xEF, 0xC0, 0x3F, 0x78, 0x0F, 0x8E, 0x03, 0xC3, 0xC0, 0xE0, 0x70,
  0x38, 0x0E, 0x0E, 0x03, 0xC3, 0x80, 0x70, 0xE0, 0x1E, 0x38, 0x03, 0xCE,
  0x00, 0x73, 0x80, 0x1E, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0x70, 0xFF, 0xB8, 0x6F, 0xCC, 0x77, 0xE7,
  0x33, 0xF1, 0xB9, 0xF8, 0xFC, 0xFC, 0x7C, 0x7E, 0x1E, 0x3F, 0x0E, 0x1F,
  0x83, 0x0F, 0xC1, 0x07, 0xE0, 0x83, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0x80,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xEE, 0x07, 0xEE, 0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE3, 0x07, 0xE3, 0x87,
  0xE3, 0x87, 0xE1, 0xC7, 0xE1, 0xC7, 0xE0, 0xC7, 0xE0, 0xE7, 0xE0, 0xE7,
  0xE0, 0x77, 0xE0, 0x77, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xE0, 0x1F, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x7C, 0x78,
  0x07, 0x1C, 0x01, 0xE7, 0x00, 0x3B, 0xC0, 0x0E, 0xE0, 0x03, 0xB8, 0x00,
  0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0E, 0xE0, 0x03, 0xBC, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1E, 0x78,
  0x07, 0x0F, 0x07, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0xFF,
  0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9C, 0x01, 0xEE, 0x00, 0x77, 0x00, 0x3B,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x01,
  0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xF0, 0x7C, 0x78, 0x07, 0x1C, 0x01, 0xE7, 0x00, 0x3B, 0xC0, 0x0E, 0xE0,
  0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0E, 0xE0, 0x03, 0xBC, 0x00, 0xE7, 0x00, 0x39,
  0xC0, 0x1E, 0x78, 0x07, 0x0F, 0x07, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07,
  0xF0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9C, 0x01, 0xEE,
  0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xB8, 0x01, 0xDC, 0x01, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xC1, 0xC1,
  0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1E, 0x1C, 0x07, 0x0E, 0x01, 0xC7,
  0x00, 0xF3, 0x80, 0x39, 0xC0, 0x1E, 0xE0, 0x07, 0x80, 0x07, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0xF1, 0xF0, 0x3E, 0x70, 0x03, 0x9C, 0x00, 0x4F, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xF4, 0x00, 0x3B, 0x80, 0x0E, 0xF0, 0x07, 0x9F, 0x03, 0xE3, 0xFF,
  0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0,
  0x0E, 0xF0, 0x0E, 0x78, 0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0xF0,
  0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07, 0xBC, 0x00, 0xE3, 0x80, 0x1C, 0x70,
  0x03, 0x8E, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0xE0, 0x78,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x1C, 0x01, 0xC3, 0x80, 0x38,
  0x70, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x3B,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xB0, 0x00, 0x76, 0x00, 0x0E, 0xC0,
  0x01, 0xD8, 0x00, 0x3B, 0x07, 0x87, 0x70, 0xF0, 0xEE, 0x1E, 0x1D, 0xC7,
  0xC3, 0xB8, 0xDC, 0x67, 0x1B, 0x8C, 0xE3, 0x31, 0x9C, 0xE6, 0x33, 0x9C,
  0xC6, 0x33, 0x1C, 0xC6, 0x63, 0xB8, 0xCC, 0x37, 0x1B, 0x86, 0xE3, 0x70,
  0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xF1, 0xF0, 0x3C, 0x3E, 0x07, 0x80, 0xF0,
  0x00, 0xE7, 0x80, 0x1E, 0x38, 0x01, 0xC1, 0xC0, 0x38, 0x1E, 0x07, 0x80,
  0xE0, 0x70, 0x07, 0x0E, 0x00, 0x71, 0xE0, 0x03, 0x9C, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x39, 0xC0, 0x07, 0x9C, 0x00, 0x70, 0xE0, 0x0E, 0x0F, 0x01, 0xE0,
  0x70, 0x1C, 0x03, 0x83, 0x80, 0x38, 0x38, 0x01, 0xC7, 0x00, 0x1E, 0xF0,
  0x00, 0xF0, 0xE0, 0x00, 0xFF, 0x00, 0x0E, 0x70, 0x01, 0xE3, 0x80, 0x1C,
  0x3C, 0x03, 0x81, 0xC0, 0x38, 0x1E, 0x07, 0x00, 0xE0, 0xF0, 0x07, 0x0E,
  0x00, 0x71, 0xC0, 0x03, 0x9C, 0x00, 0x3B, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1D, 0xC0, 0x07,
  0x38, 0x03, 0x8E, 0x00, 0xC1, 0xC0, 0x70, 0x38, 0x38, 0x0E, 0x0E, 0x01,
  0xC7, 0x00, 0x71, 0xC0, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x74, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x67, 0x1C, 0xE3, 0x8C, 0x60,
  0x07, 0xE0, 0x07, 0xFE, 0x03, 0xFF, 0xC1, 0xE0, 0x78, 0x70, 0x0E, 0x08,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF,
  0xE1, 0xE0, 0x38, 0xF0, 0x0E, 0x38, 0x03, 0x8F, 0x00, 0xE1, 0xE0, 0xD8,
  0x7F, 0xF7, 0xCF, 0xF9, 0xF0, 0xF8, 0x3C, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE1,
  0xF0, 0xE7, 0xFC, 0xEF, 0xFE, 0xE8, 0x1E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE8, 0x1E, 0xEF, 0xFE, 0xE7, 0xFC, 0xE1,
  0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x1E, 0x70, 0x0E, 0x70,
  0x04, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x06, 0x70, 0x0F, 0x3C, 0x1E, 0x3F, 0xFC, 0x1F,
  0xF8, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x07, 0xC7, 0x1F, 0xF7, 0x3F,
  0xF7, 0x7C, 0x1F, 0x78, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x78,
  0x07, 0x7C, 0x1F, 0x3F, 0xF7, 0x1F, 0xF7, 0x07, 0xC7, 0x03, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0x81, 0xE7, 0x80, 0x73, 0x80, 0x1D, 0x80, 0x0E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x11, 0xE0, 0x1E, 0x7C, 0x1E, 0x1F, 0xFE, 0x07, 0xFE, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFF, 0x83, 0xC1, 0xE0, 0xE0, 0x3C, 0x38, 0x07, 0x1E, 0x01, 0xC3, 0x80,
  0x70, 0xE0, 0x3C, 0x3C, 0x1E, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xC0,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x8F,
  0xFF, 0xF7, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xDC, 0x00, 0xF7, 0xFF,
  0xF8, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC7, 0xE3, 0x3F, 0xCD,
  0xFF, 0xB6, 0x1F, 0xE0, 0x3F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xEF, 0xFE, 0x7F, 0xF3, 0xFF, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x0F, 0x70, 0x0E, 0x38, 0x0E, 0x1C, 0x1E, 0x0E, 0x1E, 0x07,
  0x1E, 0x03, 0x9E, 0x01, 0xDE, 0x00, 0xFF, 0x80, 0x7D, 0xE0, 0x3C, 0x70,
  0x1C, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0xC3, 0x80, 0xE1, 0xC0, 0x38, 0xE0,
  0x1E, 0x70, 0x07, 0xB8, 0x01, 0xE0, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0x0F, 0x3B, 0xE7, 0xEF, 0xFB, 0xFB, 0xC7, 0x8E, 0xE1, 0xC1, 0xF8,
  0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C,
  0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07,
  0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1C, 0xC7, 0xE3, 0x3F, 0xCD, 0xFF,
  0xB6, 0x1F, 0xE0, 0x3F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87,
  0x83, 0xE7, 0x80, 0x73, 0x80, 0x1D, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xEC, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xE0,
  0x1C, 0x78, 0x3E, 0x1F, 0xFE, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0xE1, 0xF0,
  0xE7, 0xFC, 0xEF, 0xFE, 0xE8, 0x1E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0xE8, 0x1E, 0xEF, 0xFE, 0xE7, 0xFC, 0xE1, 0xF0,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x07, 0xC7, 0x1F, 0xF7, 0x3F, 0xF7, 0x7C, 0x1F, 0x78, 0x07,
  0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x78, 0x07, 0x7C, 0x1F, 0x3F, 0xF7,
  0x1F, 0xF7, 0x07, 0xC7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xFF, 0x0F, 0xFF, 0x9F, 0xFF, 0xDF,
  0xE0, 0xEC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x07,
  0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xC7, 0x81, 0xF3, 0x80, 0x23, 0x80, 0x00,
  0xE0, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x01,
  0xF0, 0x00, 0x38, 0x00, 0x1D, 0xC0, 0x0F, 0xF8, 0x1E, 0x3F, 0xFF, 0x0F,
  0xFF, 0x01, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0xC0, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xDC, 0x07, 0xBC, 0x1F, 0x3F, 0xEE, 0x7F, 0xDC, 0x3E,
  0x38, 0xE0, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xC6, 0x00, 0xE3, 0x80, 0x71,
  0xC0, 0x30, 0x60, 0x38, 0x38, 0x1C, 0x1C, 0x0C, 0x06, 0x0E, 0x03, 0x87,
  0x01, 0xC3, 0x00, 0x63, 0x80, 0x39, 0xC0, 0x1C, 0xC0, 0x06, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0xE0, 0xF0, 0x7E, 0x0F, 0x06, 0xE0,
  0xF0, 0x66, 0x0F, 0x06, 0x61, 0xB0, 0xE6, 0x1B, 0x8E, 0x71, 0x98, 0xE7,
  0x19, 0x8C, 0x71, 0x98, 0xC7, 0x31, 0x8C, 0x33, 0x18, 0xC3, 0x30, 0xDC,
  0x33, 0x0D, 0xC3, 0x30, 0xDC, 0x3F, 0x0D, 0x83, 0xE0, 0xD8, 0x1E, 0x0F,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x03, 0xBC, 0x03, 0x8F, 0x03,
  0x83, 0x81, 0xC0, 0xE1, 0xC0, 0x79, 0xC0, 0x1D, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x77, 0x80, 0x71, 0xC0,
  0x78, 0x70, 0x38, 0x1C, 0x38, 0x0F, 0x3C, 0x03, 0xBC, 0x00, 0xE0, 0xE0,
  0x01, 0xD8, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1C, 0x38, 0x07, 0x0E, 0x01,
  0x81, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0xE1, 0x80,
  0x18, 0xE0, 0x07, 0x38, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x0F,
  0x0F, 0xF8, 0x3F, 0x00, 0xFF, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x7F, 0x07, 0xFC, 0x3C, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xC0,
  0x1E, 0x01, 0xCF, 0xC0, 0x77, 0xF8, 0x19, 0xCF, 0x0E, 0x61, 0xE3, 0xB8,
  0x3F, 0xCC, 0x07, 0xF3, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_Regular36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 5, 25, 22, 8, -25 },
  { 17, 9, 10, 22, 6, -27 },
  { 29, 20, 25, 22, 1, -25 },
  { 92, 18, 33, 22, 2, -29 },
  { 167, 20, 25, 22, 1, -25 },
  { 230, 20, 25, 22, 1, -25 },
  { 293, 3, 10, 22, 9, -27 },
  { 297, 11, 32, 22, 7, -27 },
  { 341, 10, 32, 22, 4, -27 },
  { 381, 18, 18, 22, 2, -20 },
  { 422, 17, 19, 22, 2, -20 },
  { 463, 7, 10, 22, 7, -5 },
  { 472, 10, 3, 22, 6, -12 },
  { 476, 5, 5, 22, 8, -5 },
  { 480, 15, 32, 22, 3, -27 },
  { 540, 18, 25, 22, 2, -25 },
  { 597, 18, 25, 22, 2, -25 },
  { 654, 17, 25, 22, 2, -25 },
  { 708, 17, 25, 22, 2, -25 },
  { 762, 19, 25, 22, 1, -25 },
  { 822, 16, 25, 22, 3, -25 },
  { 872, 17, 25, 22, 2, -25 },
  { 926, 17, 25, 22, 2, -25 },
  { 980, 18, 25, 22, 2, -25 },
  { 1037, 17, 25, 22, 2, -25 },
  { 1091, 5, 19, 22, 8, -19 },
  { 1103, 7, 24, 22, 7, -19 },
  { 1124, 16, 21, 22, 3, -21 },
  { 1166, 17, 10, 22, 2, -16 },
  { 1188, 16, 21, 22, 3, -21 },
  { 1230, 15, 25, 22, 3, -25 },
  { 1277, 17, 29, 22, 2, -25 },
  { 1339, 20, 25, 22, 1, -25 },
  { 1402, 17, 25, 22, 3, -25 },
  { 1456, 16, 25, 22, 3, -25 },
  { 1506, 17, 25, 22, 3, -25 },
  { 1560, 16, 25, 22, 3, -25 },
  { 1610, 16, 25, 22, 3, -25 },
  { 1660, 17, 25, 22, 2, -25 },
  { 1714, 16, 25, 22, 3, -25 },
  { 1764, 16, 25, 22, 3, -25 },
  { 1814, 14, 25, 22, 3, -25 },
  { 1858, 18, 25, 22, 3, -25 },
  { 1915, 15, 25, 22, 4, -25 },
  { 1962, 17, 25, 22, 2, -25 },
  { 2016, 16, 25, 22, 3, -25 },
  { 2066, 18, 25, 22, 2, -25 },
  { 2123, 17, 25, 22, 3, -25 },
  { 2177, 18, 31, 22, 2, -25 },
  { 2247, 17, 25, 22, 3, -25 },
  { 2301, 18, 25, 22, 2, -25 },
  { 2358, 20, 25, 22, 1, -25 },
  { 2421, 16, 25, 22, 3, -25 },
  { 2471, 19, 25, 22, 1, -25 },
  { 2531, 19, 25, 22, 1, -25 },
  { 2591, 20, 25, 22, 1, -25 },
  { 2654, 20, 25, 22, 1, -25 },
  { 2717, 18, 25, 22, 2, -25 },
  { 2774, 10, 32, 22, 8, -27 },
  { 2814, 15, 32, 22, 3, -27 },
  { 2874, 11, 32, 22, 3, -27 },
  { 2918, 18, 15, 22, 2, -25 },
  { 2952, 17, 3, 22, 2, 3 },
  { 2959, 5, 7, 22, 7, -28 },
  { 2964, 18, 19, 22, 2, -19 },
  { 3007, 16, 27, 22, 3, -27 },
  { 3061, 16, 19, 22, 3, -19 },
  { 3099, 16, 27, 22, 2, -27 },
  { 3153, 17, 19, 22, 2, -19 },
  { 3194, 17, 27, 22, 3, -27 },
  { 3252, 18, 29, 22, 2, -22 },
  { 3318, 14, 27, 22, 4, -27 },
  { 3366, 16, 27, 22, 4, -27 },
  { 3420, 13, 34, 22, 3, -27 },
  { 3476, 17, 27, 22, 4, -27 },
  { 3534, 16, 27, 22, 3, -27 },
  { 3588, 18, 19, 22, 2, -19 },
  { 3631, 14, 19, 22, 4, -19 },
  { 3665, 17, 19, 22, 2, -19 },
  { 3706, 16, 26, 22, 3, -19 },
  { 3758, 16, 26, 22, 2, -19 },
  { 3810, 17, 19, 22, 3, -19 },
  { 3851, 17, 19, 22, 2, -19 },
  { 3892, 18, 25, 22, 1, -25 },
  { 3949, 15, 19, 22, 3, -19 },
  { 3985, 17, 19, 22, 2, -19 },
  { 4026, 20, 19, 22, 1, -19 },
  { 4074, 17, 19, 22, 2, -19 },
  { 4115, 18, 26, 22, 2, -19 },
  { 4174, 16, 19, 22, 3, -19 },
  { 4212, 14, 32, 22, 4, -27 },
  { 4268, 2, 32, 22, 10, -27 },
  { 4276, 14, 32, 22, 4, -27 },
  { 4332, 18, 8, 22, 2, -15 },
};

const GFXfont IBMPlexMono_Regular36pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular36pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular36pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _IBMPLEXMONO_REGULAR36PT7B_H_
