#ifndef _IBMPLEXMONO_REGULAR14PT7B_H_
#define _IBMPLEXMONO_REGULAR14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular14pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x58, 0xF0, 0xDD, 0xDD, 0x12, 0x12, 0x14, 0x77, 0x34, 0x24,
  0xE7, 0x24, 0x28, 0x28, 0x10, 0xFB, 0x5C, 0x89, 0x0E, 0x07, 0x0B, 0x13,
  0x29, 0xF0, 0x80, 0x71, 0x92, 0x92, 0x94, 0x70, 0x06, 0x39, 0x29, 0x49,
  0xC6, 0x38, 0x64, 0x40, 0x20, 0x23, 0x52, 0xCA, 0xC4, 0x4A, 0x7B, 0xF0,
  0x34, 0x48, 0x88, 0x88, 0x88, 0x44, 0x30, 0xC1, 0x04, 0x21, 0x08, 0x62,
  0x10, 0x84, 0x4C, 0x00, 0x10, 0x22, 0x5B, 0xC3, 0x09, 0x11, 0x00, 0x10,
  0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x7A, 0xF0, 0xF0, 0x04, 0x10, 0x82,
  0x10, 0x41, 0x08, 0x20, 0x84, 0x10, 0x80, 0x79, 0x8A, 0x14, 0x3B, 0x76,
  0xE1, 0xC2, 0xC4, 0xF0, 0x30, 0xA2, 0x44, 0x81, 0x02, 0x04, 0x08, 0x11,
  0xFC, 0x79, 0x9A, 0x10, 0x20, 0xC1, 0x04, 0x30, 0xC1, 0xFC, 0x7B, 0x30,
  0x43, 0x30, 0x30, 0x41, 0x8D, 0xE0, 0x0C, 0x0C, 0x14, 0x14, 0x24, 0x44,
  0x44, 0xFF, 0x04, 0x04, 0x7D, 0x04, 0x20, 0xBB, 0x10, 0x41, 0xC5, 0xE0,
  0x18, 0x41, 0x06, 0x0B, 0x98, 0xA1, 0x43, 0xC4, 0xF0, 0xFE, 0x18, 0x42,
  0x08, 0x61, 0x0C, 0x21, 0x80, 0x79, 0x8A, 0x16, 0x23, 0x98, 0xA1, 0xC3,
  0xC4, 0xF0, 0x79, 0x8A, 0x14, 0x2C, 0x6F, 0x81, 0x04, 0x18, 0xE0, 0xF0,
  0x0F, 0xF0, 0x07, 0xA0, 0x04, 0x33, 0x30, 0xC0, 0xC0, 0xC1, 0xFE, 0x00,
  0x07, 0xF0, 0x81, 0x81, 0x83, 0x0C, 0x66, 0x20, 0x7B, 0x18, 0x41, 0x08,
  0xC2, 0x00, 0x30, 0xC0, 0x79, 0x18, 0x67, 0xA6, 0x9A, 0x69, 0x9E, 0x04,
  0x0E, 0x18, 0x18, 0x14, 0x24, 0x24, 0x26, 0x7E, 0x42, 0x43, 0xC1, 0xF9,
  0x0A, 0x14, 0x2F, 0x90, 0xA1, 0xC3, 0x85, 0xF0, 0x38, 0x8A, 0x1C, 0x08,
  0x10, 0x20, 0x42, 0x46, 0x70, 0xF9, 0x9B, 0x16, 0x3C, 0x78, 0xF1, 0xE2,
  0xCD, 0xF0, 0xFE, 0x08, 0x20, 0xFE, 0x08, 0x20, 0x83, 0xF0, 0xFE, 0x08,
  0x20, 0xFE, 0x08, 0x20, 0x82, 0x00, 0x79, 0x18, 0xA0, 0x82, 0x78, 0x61,
  0xC5, 0xF0, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x86, 0x10, 0xFC, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x13, 0xF0, 0x7C, 0x10, 0x41, 0x04, 0x10, 0x41,
  0xC9, 0xE0, 0x87, 0x1A, 0x24, 0x8B, 0x1A, 0x32, 0x46, 0x85, 0x0C, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x87, 0xC0, 0xC7, 0x3C, 0xEB, 0xB6, 0x5A, 0x61,
  0x86, 0x10, 0xC7, 0x1A, 0x69, 0xB6, 0x59, 0x63, 0x8E, 0x30, 0x79, 0x8A,
  0x14, 0x38, 0x70, 0xE1, 0xC2, 0xC4, 0xF0, 0xFD, 0x0A, 0x1C, 0x38, 0x5F,
  0xA0, 0x40, 0x81, 0x00, 0x79, 0x8A, 0x14, 0x38, 0x70, 0xE1, 0xC2, 0xC4,
  0xF0, 0x40, 0xE0, 0xFD, 0x0A, 0x1C, 0x38, 0x5F, 0x26, 0x44, 0x8D, 0x0C,
  0x79, 0x8E, 0x04, 0x07, 0x01, 0x81, 0x83, 0x84, 0xF0, 0xFF, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0xC5, 0xE0, 0xC1, 0x42, 0x42, 0x22, 0x26, 0x24, 0x34, 0x14, 0x18,
  0x18, 0xC1, 0x41, 0x41, 0x59, 0x59, 0x5A, 0x56, 0x66, 0x66, 0x66, 0x43,
  0x62, 0x24, 0x14, 0x18, 0x18, 0x14, 0x26, 0x62, 0xC3, 0xC1, 0x42, 0x22,
  0x24, 0x1C, 0x18, 0x08, 0x08, 0x08, 0x08, 0xFC, 0x08, 0x20, 0xC1, 0x04,
  0x18, 0x20, 0x81, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x81,
  0x04, 0x08, 0x20, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0xF1, 0x11, 0x11,
  0x11, 0x11, 0x11, 0xF0, 0x30, 0x51, 0x22, 0x28, 0x50, 0xC0, 0xFE, 0xA4,
  0x79, 0x18, 0x13, 0xE8, 0x53, 0x9D, 0x80, 0x81, 0x02, 0x05, 0xCC, 0x50,
  0xA1, 0xC2, 0xC5, 0x70, 0x39, 0x18, 0x20, 0x81, 0x13, 0x80, 0x04, 0x10,
  0x5D, 0xCE, 0x18, 0x61, 0xC5, 0xF0, 0x7B, 0x18, 0x7F, 0x83, 0x17, 0x80,
  0x1E, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x08, 0x11, 0xF8, 0x06, 0xF1, 0x16,
  0x24, 0x47, 0x30, 0x3E, 0x83, 0x05, 0xF0, 0x82, 0x08, 0x2E, 0xC6, 0x18,
  0x61, 0x86, 0x10, 0x10, 0x30, 0x07, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC,
  0x08, 0x41, 0xF0, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x80, 0xC1, 0x83, 0x06,
  0x3C, 0x9A, 0x3C, 0x64, 0xCD, 0x8C, 0xF0, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x13, 0xF0, 0xED, 0x6E, 0x4C, 0x99, 0x32, 0x64, 0x80, 0xBB, 0x18, 0x61,
  0x86, 0x18, 0x40, 0x7B, 0x18, 0x61, 0x87, 0x17, 0x80, 0xB9, 0x8A, 0x14,
  0x38, 0x58, 0xAE, 0x40, 0x81, 0x00, 0x77, 0x38, 0x61, 0x87, 0x17, 0xC1,
  0x04, 0x10, 0xEE, 0x60, 0x81, 0x02, 0x04, 0x3F, 0x00, 0x7B, 0x1C, 0x1F,
  0x06, 0x17, 0x80, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0xF0, 0x86,
  0x18, 0x61, 0x87, 0x17, 0xC0, 0x87, 0x89, 0x12, 0x42, 0x86, 0x0C, 0x00,
  0x99, 0x59, 0x59, 0x56, 0x66, 0x66, 0x66, 0xC4, 0x90, 0xE1, 0x83, 0x89,
  0x21, 0x80, 0x87, 0x09, 0x12, 0x42, 0x86, 0x0C, 0x18, 0x21, 0xC0, 0xFC,
  0x31, 0x8C, 0x21, 0x0F, 0xC0, 0x3C, 0x82, 0x04, 0x10, 0x4E, 0x04, 0x10,
  0x42, 0x08, 0x3C, 0xFF, 0xF8, 0xF0, 0x41, 0x04, 0x20, 0x81, 0xC8, 0x20,
  0x41, 0x04, 0xF0, 0x63, 0x2A, 0x70,
};

const GFXglyph IBMPlexMono_Regular14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 4, 4, 8, 2, -10 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 7, 12, 8, 1, -11 },
  { 27, 8, 10, 8, 0, -10 },
  { 37, 8, 10, 8, 0, -10 },
  { 47, 1, 4, 8, 4, -10 },
  { 48, 4, 13, 8, 3, -11 },
  { 55, 5, 13, 8, 1, -11 },
  { 64, 7, 7, 8, 1, -8 },
  { 71, 7, 7, 8, 1, -8 },
  { 78, 2, 4, 8, 3, -2 },
  { 79, 4, 1, 8, 2, -5 },
  { 80, 2, 2, 8, 3, -2 },
  { 81, 6, 13, 8, 1, -11 },
  { 91, 7, 10, 8, 1, -10 },
  { 100, 7, 10, 8, 1, -10 },
  { 109, 7, 10, 8, 1, -10 },
  { 118, 6, 10, 8, 1, -10 },
  { 126, 8, 10, 8, 0, -10 },
  { 136, 6, 10, 8, 1, -10 },
  { 144, 7, 10, 8, 1, -10 },
  { 153, 6, 10, 8, 1, -10 },
  { 161, 7, 10, 8, 1, -10 },
  { 170, 7, 10, 8, 1, -10 },
  { 179, 2, 8, 8, 3, -8 },
  { 181, 2, 10, 8, 3, -8 },
  { 184, 6, 8, 8, 1, -8 },
  { 190, 7, 4, 8, 1, -6 },
  { 194, 6, 8, 8, 1, -8 },
  { 200, 6, 10, 8, 1, -10 },
  { 208, 6, 12, 8, 1, -10 },
  { 217, 8, 10, 8, 0, -10 },
  { 227, 7, 10, 8, 1, -10 },
  { 236, 7, 10, 8, 1, -10 },
  { 245, 7, 10, 8, 1, -10 },
  { 254, 6, 10, 8, 1, -10 },
  { 262, 6, 10, 8, 1, -10 },
  { 270, 6, 10, 8, 1, -10 },
  { 278, 6, 10, 8, 1, -10 },
  { 286, 6, 10, 8, 1, -10 },
  { 294, 6, 10, 8, 1, -10 },
  { 302, 7, 10, 8, 1, -10 },
  { 311, 5, 10, 8, 2, -10 },
  { 318, 6, 10, 8, 1, -10 },
  { 326, 6, 10, 8, 1, -10 },
  { 334, 7, 10, 8, 1, -10 },
  { 343, 7, 10, 8, 1, -10 },
  { 352, 7, 12, 8, 1, -10 },
  { 363, 7, 10, 8, 1, -10 },
  { 372, 7, 10, 8, 1, -10 },
  { 381, 8, 10, 8, 0, -10 },
  { 391, 6, 10, 8, 1, -10 },
  { 399, 8, 10, 8, 0, -10 },
  { 409, 8, 10, 8, 0, -10 },
  { 419, 8, 10, 8, 0, -10 },
  { 429, 8, 10, 8, 0, -10 },
  { 439, 7, 10, 8, 1, -10 },
  { 448, 4, 13, 8, 3, -11 },
  { 455, 6, 13, 8, 1, -11 },
  { 465, 4, 13, 8, 1, -11 },
  { 472, 7, 6, 8, 1, -10 },
  { 478, 7, 1, 8, 1, 1 },
  { 479, 2, 3, 8, 3, -11 },
  { 480, 7, 7, 8, 1, -7 },
  { 487, 7, 10, 8, 1, -10 },
  { 496, 6, 7, 8, 1, -7 },
  { 502, 6, 10, 8, 1, -10 },
  { 510, 6, 7, 8, 1, -7 },
  { 516, 7, 10, 8, 1, -10 },
  { 525, 7, 11, 8, 1, -8 },
  { 535, 6, 10, 8, 1, -10 },
  { 543, 7, 10, 8, 1, -10 },
  { 552, 5, 13, 8, 1, -10 },
  { 561, 7, 10, 8, 1, -10 },
  { 570, 6, 10, 8, 1, -10 },
  { 578, 7, 7, 8, 1, -7 },
  { 585, 6, 7, 8, 1, -7 },
  { 591, 6, 7, 8, 1, -7 },
  { 597, 7, 10, 8, 1, -7 },
  { 606, 6, 10, 8, 1, -7 },
  { 614, 7, 7, 8, 1, -7 },
  { 621, 6, 7, 8, 1, -7 },
  { 627, 6, 10, 8, 1, -10 },
  { 635, 6, 7, 8, 1, -7 },
  { 641, 7, 7, 8, 1, -7 },
  { 648, 8, 7, 8, 0, -7 },
  { 655, 7, 7, 8, 1, -7 },
  { 662, 7, 10, 8, 1, -7 },
  { 671, 6, 7, 8, 1, -7 },
  { 677, 6, 13, 8, 1, -11 },
  { 687, 1, 13, 8, 4, -11 },
  { 689, 6, 13, 8, 1, -11 },
  { 699, 7, 3, 8, 1, -6 },
};

const GFXfont IBMPlexMono_Regular14pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular14pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _IBMPLEXMONO_REGULAR14PT7B_H_
