#ifndef _IBMPLEXMONO_REGULAR31PT7B_H_
#define _IBMPLEXMONO_REGULAR31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular31pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x63, 0x18, 0xC2, 0x10, 0x80, 0x00,
  0x1D, 0xFF, 0xB8, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE3,
  0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0xE0, 0x06, 0x38, 0x03, 0x8C, 0x00,
  0xE3, 0x00, 0x30, 0xC0, 0xFC, 0x3F, 0x3F, 0x1F, 0xC0, 0xC7, 0x00, 0x71,
  0x80, 0x18, 0x60, 0x06, 0x18, 0x3F, 0x87, 0xEF, 0xE3, 0xF8, 0x38, 0xC0,
  0x0E, 0x30, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x70, 0x07,
  0x18, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x7F, 0x03, 0xFF, 0x8F,
  0x37, 0x9C, 0x63, 0xF0, 0xC4, 0xE1, 0x81, 0xC3, 0x01, 0x86, 0x03, 0x8C,
  0x03, 0xF8, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0xDE, 0x01, 0x8E, 0x03, 0x1C,
  0x06, 0x18, 0x0C, 0x34, 0x18, 0xFC, 0x31, 0xFE, 0x6F, 0x1F, 0xFC, 0x0F,
  0xE0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x3C, 0x01, 0xBF, 0x81, 0xB8,
  0xC1, 0xD8, 0x30, 0xCC, 0x18, 0xE6, 0x0C, 0x63, 0x06, 0x71, 0x83, 0x30,
  0xE3, 0x38, 0x3F, 0x80, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x77,
  0x18, 0x33, 0x06, 0x31, 0x83, 0x38, 0xC1, 0x98, 0x60, 0xDC, 0x30, 0x6C,
  0x1C, 0x6E, 0x07, 0xF6, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xF0, 0x0E, 0x1C,
  0x07, 0x07, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x83, 0xC7, 0xE1, 0xE7, 0x38, 0xC7, 0x0E, 0x63,
  0x83, 0x31, 0x81, 0xD0, 0xC0, 0x78, 0x60, 0x1C, 0x38, 0x0F, 0x0E, 0x0D,
  0xC3, 0xFC, 0x70, 0xF8, 0x3C, 0xFF, 0xFF, 0xC0, 0x03, 0x83, 0x83, 0x81,
  0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0xE0, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x60, 0x30, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0x1C, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x61, 0x87,
  0xFF, 0xBF, 0x3F, 0xFC, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x60, 0x06, 0x70,
  0x0E, 0x38, 0x1C, 0x1C, 0x18, 0x08, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x3C, 0xE7, 0x9C,
  0x71, 0xC6, 0x38, 0xFF, 0xFF, 0xC0, 0x77, 0xFE, 0xE0, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xE1,
  0xE3, 0x80, 0xC6, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0x70, 0x07, 0xC0, 0x0F,
  0x87, 0x1F, 0x1E, 0x3E, 0x3C, 0x7C, 0x38, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x06, 0xE0, 0x0C, 0xC0, 0x39, 0xC0, 0x61, 0xC3, 0xC1, 0xFF, 0x01, 0xF8,
  0x00, 0x07, 0x80, 0x1F, 0x00, 0x76, 0x01, 0xCC, 0x07, 0x18, 0x1C, 0x30,
  0x30, 0x60, 0x40, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x07, 0xFF, 0xEF, 0xFF, 0xC0, 0x0F, 0xC0, 0x7F, 0xE1, 0xE1,
  0xE3, 0x01, 0xCE, 0x01, 0xC8, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xE0, 0x3F, 0xF0, 0xF0, 0xF3, 0x80, 0xE1, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x1F, 0x80, 0x3F, 0x80,
  0x03, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x40, 0x1D, 0xC0,
  0x3F, 0xC1, 0xE3, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xD8, 0x01, 0xD8, 0x01, 0x98, 0x03, 0x98, 0x03, 0x18, 0x06, 0x18, 0x0E,
  0x18, 0x0C, 0x18, 0x1C, 0x18, 0x18, 0x18, 0x30, 0x18, 0x70, 0x18, 0x60,
  0x18, 0xE0, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x3F, 0xFC, 0x7F, 0xF8, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x67, 0xE0, 0xDF, 0xE1, 0xE1, 0xE3,
  0x80, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x40,
  0x3B, 0x80, 0x73, 0xC1, 0xC3, 0xFF, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x63, 0xE0, 0xDF, 0xE3, 0xE0, 0xE7, 0x80, 0xEE, 0x00, 0xDC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0C, 0xC0, 0x19, 0xC0, 0x71, 0xC1, 0xC1, 0xFF,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xE0, 0xE3,
  0x80, 0xEE, 0x00, 0xDC, 0x01, 0x98, 0x03, 0x30, 0x0E, 0x38, 0x38, 0x3F,
  0xC0, 0x7F, 0xC3, 0xC1, 0xC6, 0x01, 0xDC, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x73, 0xC1, 0xE3, 0xFF, 0x81, 0xFC, 0x00,
  0x0F, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xEE, 0x00, 0xDC, 0x01, 0xB8,
  0x03, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x1D, 0xC0, 0x73, 0xC1, 0x63, 0xFE,
  0xC1, 0xF3, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x77, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x7F, 0xEE, 0x39, 0xF7, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0xE7, 0x9C, 0x71, 0xC6, 0x38, 0x00, 0x08, 0x01, 0xC0, 0x1E,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x38, 0x00,
  0x40, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x80, 0x06, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x38, 0x01, 0xC0, 0x3E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x00, 0xC0, 0x04, 0x00, 0x00,
  0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x9C, 0x06, 0xE0, 0x1C, 0x80, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x7E, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x1E, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x9C, 0x06, 0x60, 0x0D,
  0x80, 0x3E, 0x1E, 0xF0, 0xFF, 0xC7, 0x1F, 0x18, 0x3C, 0x60, 0xF1, 0x83,
  0xC6, 0x0F, 0x18, 0x3C, 0x60, 0xF1, 0x83, 0xC7, 0x0F, 0x0F, 0xFE, 0x3E,
  0xD8, 0x00, 0x60, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xFC, 0x07, 0xF0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x76, 0x00, 0x33, 0x80,
  0x18, 0xC0, 0x1C, 0x60, 0x0C, 0x38, 0x06, 0x1C, 0x07, 0x06, 0x03, 0x83,
  0x81, 0x81, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0x60, 0x1C, 0x30, 0x0E, 0x38,
  0x03, 0x1C, 0x01, 0xCC, 0x00, 0xEE, 0x00, 0x37, 0x00, 0x1C, 0xFF, 0xC3,
  0xFF, 0x8C, 0x07, 0x30, 0x0E, 0xC0, 0x3B, 0x00, 0xEC, 0x03, 0xB0, 0x0E,
  0xC0, 0x33, 0x01, 0xCF, 0xFC, 0x3F, 0xF8, 0xC0, 0x3B, 0x00, 0x6C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xB0, 0x0E, 0xFF, 0xF3, 0xFF,
  0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xF0, 0xF1, 0xC0, 0xE7, 0x00, 0xEC, 0x02,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x10, 0xE0, 0x1C, 0xE0,
  0x71, 0xE1, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0xFF, 0x83, 0xFF, 0x8E, 0x0F,
  0x38, 0x1C, 0xE0, 0x3B, 0x80, 0x6E, 0x01, 0xB8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x06, 0xE0,
  0x1B, 0x80, 0xEE, 0x07, 0x38, 0x3C, 0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x07, 0xC0,
  0x7F, 0xC3, 0x83, 0x9C, 0x07, 0x60, 0x1F, 0x80, 0x4E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x7F, 0xE1, 0xFF, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0D, 0x80, 0x77, 0x01, 0xCE, 0x1B, 0x3F, 0xEC, 0x3E,
  0x30, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x30, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xF9, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0x01, 0xD8, 0x0C, 0xF0,
  0xE3, 0xFE, 0x07, 0xC0, 0xC0, 0x1F, 0x80, 0x73, 0x00, 0xE6, 0x03, 0x8C,
  0x0E, 0x18, 0x38, 0x30, 0xE0, 0x63, 0xC0, 0xC7, 0x01, 0x9C, 0x03, 0x7C,
  0x07, 0xD8, 0x0F, 0x38, 0x1C, 0x38, 0x38, 0x70, 0x60, 0x70, 0xC0, 0x71,
  0x80, 0xE3, 0x00, 0xE6, 0x01, 0xCC, 0x01, 0xD8, 0x01, 0xC0, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xFE, 0x0F, 0xF8, 0x7F, 0xF1, 0xBE, 0xC6, 0xFB, 0x33,
  0xE6, 0xCF, 0x9F, 0x3E, 0x78, 0xF8, 0xE3, 0xE3, 0x0F, 0x84, 0x3E, 0x10,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x30, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xB0, 0x3E,
  0xE0, 0xF9, 0x83, 0xE7, 0x0F, 0x9C, 0x3E, 0x30, 0xF8, 0xE3, 0xE1, 0x8F,
  0x87, 0x3E, 0x1C, 0xF8, 0x33, 0xE0, 0xEF, 0x81, 0xBE, 0x07, 0xF8, 0x1F,
  0xE0, 0x3F, 0x80, 0xF0, 0x0F, 0xC0, 0x3F, 0xE0, 0xE1, 0xE3, 0x80, 0xC6,
  0x01, 0xDC, 0x01, 0xB8, 0x03, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x06, 0xE0, 0x0C,
  0xC0, 0x39, 0xC0, 0x61, 0xC3, 0xC1, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xE3,
  0xFF, 0xCC, 0x03, 0xB0, 0x06, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1B, 0x00, 0xEF, 0xFF, 0x3F, 0xF8, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xE1, 0xE3, 0x80, 0xC6, 0x01, 0xDC, 0x01,
  0xB8, 0x03, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x06, 0xE0, 0x0C, 0xC0, 0x39, 0xC0,
  0x61, 0xC3, 0xC1, 0xFF, 0x01, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0xF0, 0x03, 0xE0, 0xFF, 0xE3, 0xFF, 0xCC, 0x03, 0xB0, 0x06, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1B, 0x00, 0xEF, 0xFF, 0x3F,
  0xF0, 0xC3, 0x83, 0x06, 0x0C, 0x1C, 0x30, 0x30, 0xC0, 0xE3, 0x01, 0xCC,
  0x07, 0x30, 0x0E, 0xC0, 0x3B, 0x00, 0x70, 0x07, 0xF0, 0x1F, 0xFC, 0x3C,
  0x1E, 0x30, 0x07, 0x70, 0x04, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x20, 0x07, 0xF0, 0x0E, 0x7C, 0x1E, 0x1F,
  0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x76, 0x01, 0xD8, 0x07, 0x60, 0x1D, 0x80, 0x77, 0x01, 0x8E,
  0x0E, 0x3F, 0xF0, 0x3F, 0x80, 0xE0, 0x03, 0x60, 0x07, 0x70, 0x07, 0x70,
  0x06, 0x70, 0x06, 0x30, 0x0E, 0x38, 0x0E, 0x38, 0x0C, 0x18, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x1C, 0x18, 0x0C, 0x38, 0x0E, 0x38, 0x0E, 0x30, 0x06,
  0x70, 0x06, 0x70, 0x07, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0xC0, 0x03, 0xF0, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0x6E, 0x00, 0x37,
  0x00, 0x19, 0x87, 0x0C, 0xC3, 0x86, 0x63, 0xC3, 0x31, 0xB1, 0x98, 0xD8,
  0xCC, 0x6C, 0xE6, 0x66, 0x73, 0x33, 0x31, 0x98, 0xD8, 0xEC, 0x6C, 0x76,
  0x36, 0x3E, 0x1B, 0x0F, 0x0D, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0,
  0xE0, 0x07, 0xB8, 0x03, 0x8E, 0x03, 0x87, 0x01, 0x81, 0xC1, 0xC0, 0x61,
  0xC0, 0x38, 0xE0, 0x0E, 0xE0, 0x07, 0x60, 0x01, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x3B, 0x80, 0x19, 0xC0, 0x1C, 0x70, 0x1C, 0x18,
  0x0C, 0x0E, 0x0E, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0x77, 0x00, 0x1C, 0xE0,
  0x03, 0xF0, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC3, 0x80, 0xE0, 0xC0, 0xE0,
  0x70, 0x70, 0x18, 0x70, 0x0E, 0x30, 0x03, 0x38, 0x01, 0xD8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F,
  0xFF, 0xF0, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x70,
  0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x03, 0xE0,
  0x03, 0xE0, 0x06, 0x70, 0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x18, 0x18, 0x1C,
  0x38, 0x0C, 0x30, 0x0E, 0x70, 0x07, 0x60, 0x07, 0xC0, 0x02, 0xFF, 0xFF,
  0xFF, 0xFC, 0x47, 0x18, 0xE3, 0x0C, 0x0F, 0xC0, 0x7F, 0xC1, 0xC1, 0xC3,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x0F, 0xFC, 0x7F, 0xF9, 0xE0,
  0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9E, 0x0B, 0x1F, 0xE7, 0x8F, 0x87,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x31, 0xF0, 0xDF, 0xF3, 0x41, 0xCE, 0x03, 0xB8, 0x06, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xB8, 0x0E, 0xD0,
  0x73, 0x7F, 0xCC, 0x7C, 0x00, 0x0F, 0xC1, 0xFF, 0x1E, 0x1C, 0xC0, 0x7E,
  0x02, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0,
  0x26, 0x03, 0xBC, 0x38, 0xFF, 0x81, 0xF8, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC3, 0xE7, 0x3F, 0xDD, 0xE1,
  0xF7, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xDC, 0x07, 0x78, 0x7C, 0xFF, 0x70, 0xF9, 0xC0,
  0x07, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xC6, 0x01, 0xDC, 0x01, 0xB8,
  0x03, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x87, 0x07, 0x87, 0xFE, 0x03, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x0F, 0xFF, 0x9F,
  0xFF, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x3F, 0xC0, 0xFF, 0x83, 0x87, 0x8E,
  0x07, 0x1C, 0x06, 0x38, 0x0C, 0x70, 0x18, 0xE0, 0x70, 0xE1, 0xE0, 0xFF,
  0x81, 0xFC, 0x06, 0x00, 0x18, 0x00, 0x38, 0x00, 0x3F, 0xF8, 0x7F, 0xFD,
  0x80, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xDF, 0xFF, 0x0F, 0xF8, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0xF8,
  0xEF, 0xE7, 0x83, 0xB8, 0x0D, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x70,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x7F, 0xEF, 0xF8, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x1E, 0xE0, 0x71, 0xC1, 0xC3, 0x87, 0x07, 0x1C, 0x0E, 0x70, 0x1D, 0xE0,
  0x3F, 0xC0, 0x7D, 0xC0, 0xF1, 0xC1, 0xC1, 0xC3, 0x83, 0x87, 0x03, 0x8E,
  0x03, 0x9C, 0x03, 0xB8, 0x07, 0x80, 0xFF, 0x83, 0xFE, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0xCE,
  0x3D, 0xBE, 0xFB, 0x8E, 0x3E, 0x1C, 0x7C, 0x30, 0x78, 0x60, 0xF0, 0xC1,
  0xE1, 0x83, 0xC3, 0x07, 0x86, 0x0F, 0x0C, 0x1E, 0x18, 0x3C, 0x30, 0x78,
  0x60, 0xF0, 0xC1, 0xE1, 0x83, 0xE7, 0xC7, 0x7F, 0x3C, 0x1D, 0xC0, 0x6E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0x0F, 0xC0, 0x3F, 0xE0, 0xE0,
  0xE3, 0x80, 0xE6, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0x70, 0x07, 0xE0, 0x0F,
  0xC0, 0x1B, 0x80, 0x33, 0x00, 0xE7, 0x01, 0xC7, 0x07, 0x07, 0xFC, 0x07,
  0xE0, 0xC7, 0xC3, 0x7F, 0xCD, 0x07, 0x38, 0x0E, 0xE0, 0x1B, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x06, 0xE0, 0x3B,
  0x41, 0xCD, 0xFF, 0x31, 0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x0F, 0x9C, 0xFF, 0x77, 0x87, 0xDC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0x70, 0x1D, 0xE1, 0xF3, 0xFD, 0xC3, 0xE7, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xFF, 0x1F, 0xFE, 0xFC, 0x1F,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x3F, 0xFF, 0x7F,
  0xFE, 0x0F, 0xE0, 0xFF, 0xE7, 0x83, 0xDC, 0x02, 0x60, 0x01, 0xC0, 0x07,
  0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0xF0, 0x00, 0xC0, 0x03, 0x60, 0x0F,
  0xE0, 0xF3, 0xFF, 0x83, 0xF8, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xB8, 0x7D, 0xFE, 0xE3,
  0xE7, 0xE0, 0x0E, 0xC0, 0x19, 0x80, 0x73, 0x80, 0xC3, 0x01, 0x86, 0x07,
  0x0E, 0x0C, 0x0C, 0x18, 0x18, 0x70, 0x38, 0xC0, 0x31, 0x80, 0x67, 0x00,
  0xEC, 0x00, 0xD8, 0x01, 0xE0, 0x01, 0xC0, 0xC1, 0xC3, 0xE0, 0xE1, 0xB0,
  0xF0, 0xDC, 0x68, 0x66, 0x36, 0x33, 0x1B, 0x19, 0x89, 0x8C, 0xCC, 0xC6,
  0x66, 0x26, 0x33, 0x1B, 0x09, 0x8D, 0x86, 0x86, 0xC3, 0x43, 0x61, 0xE0,
  0xB0, 0xF0, 0x70, 0x78, 0x38, 0xE0, 0x1E, 0xE0, 0x30, 0xE0, 0xE0, 0xE3,
  0x81, 0xC6, 0x01, 0xD8, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x3B, 0x80, 0xE3, 0x03, 0x87, 0x06, 0x07, 0x1C, 0x07, 0x70, 0x0F, 0xC0,
  0x0F, 0xC0, 0x19, 0x80, 0x73, 0x80, 0xE3, 0x01, 0x86, 0x07, 0x0E, 0x0C,
  0x0C, 0x38, 0x1C, 0x60, 0x18, 0xC0, 0x33, 0x80, 0x76, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x07, 0xC0, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0xFF, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x8F, 0xE0, 0xFE, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xF0, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C,
  0x00, 0xC0, 0x0E, 0x00, 0x7F, 0x07, 0xF0, 0xE0, 0x0C, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xFF,
  0x0F, 0xE0, 0x3C, 0x06, 0xFC, 0x0D, 0x9C, 0x3E, 0x1C, 0x6C, 0x18, 0xD8,
  0x1F, 0x30, 0x1C, 0x00,
};

const GFXglyph IBMPlexMono_Regular31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 22, 19, 7, -22 },
  { 15, 8, 9, 19, 5, -23 },
  { 24, 18, 22, 19, 0, -22 },
  { 74, 15, 28, 19, 2, -25 },
  { 127, 17, 22, 19, 1, -22 },
  { 174, 17, 22, 19, 1, -22 },
  { 221, 2, 9, 19, 8, -23 },
  { 224, 9, 28, 19, 6, -24 },
  { 256, 9, 28, 19, 3, -24 },
  { 288, 16, 15, 19, 1, -18 },
  { 318, 15, 14, 19, 2, -16 },
  { 345, 6, 8, 19, 6, -4 },
  { 351, 9, 2, 19, 5, -10 },
  { 354, 5, 4, 19, 7, -4 },
  { 357, 13, 28, 19, 3, -24 },
  { 403, 15, 22, 19, 2, -22 },
  { 445, 15, 22, 19, 2, -22 },
  { 487, 15, 22, 19, 2, -22 },
  { 529, 15, 22, 19, 1, -22 },
  { 571, 16, 22, 19, 1, -22 },
  { 615, 15, 22, 19, 2, -22 },
  { 657, 15, 22, 19, 2, -22 },
  { 699, 14, 22, 19, 2, -22 },
  { 738, 15, 22, 19, 2, -22 },
  { 780, 15, 22, 19, 2, -22 },
  { 822, 5, 16, 19, 7, -16 },
  { 832, 6, 20, 19, 6, -16 },
  { 847, 13, 18, 19, 3, -18 },
  { 877, 15, 9, 19, 2, -14 },
  { 894, 13, 18, 19, 3, -18 },
  { 924, 14, 22, 19, 2, -22 },
  { 963, 14, 25, 19, 2, -22 },
  { 1007, 17, 22, 19, 1, -22 },
  { 1054, 14, 22, 19, 3, -22 },
  { 1093, 15, 22, 19, 2, -22 },
  { 1135, 14, 22, 19, 3, -22 },
  { 1174, 13, 22, 19, 3, -22 },
  { 1210, 13, 22, 19, 3, -22 },
  { 1246, 14, 22, 19, 2, -22 },
  { 1285, 14, 22, 19, 2, -22 },
  { 1324, 13, 22, 19, 3, -22 },
  { 1360, 13, 22, 19, 2, -22 },
  { 1396, 15, 22, 19, 3, -22 },
  { 1438, 13, 22, 19, 4, -22 },
  { 1474, 14, 22, 19, 2, -22 },
  { 1513, 14, 22, 19, 2, -22 },
  { 1552, 15, 22, 19, 2, -22 },
  { 1594, 14, 22, 19, 3, -22 },
  { 1633, 15, 27, 19, 2, -22 },
  { 1684, 14, 22, 19, 3, -22 },
  { 1723, 16, 22, 19, 1, -22 },
  { 1767, 17, 22, 19, 1, -22 },
  { 1814, 14, 22, 19, 2, -22 },
  { 1853, 16, 22, 19, 1, -22 },
  { 1897, 17, 22, 19, 1, -22 },
  { 1944, 17, 22, 19, 1, -22 },
  { 1991, 17, 22, 19, 1, -22 },
  { 2038, 16, 22, 19, 1, -22 },
  { 2082, 9, 28, 19, 7, -24 },
  { 2114, 13, 28, 19, 3, -24 },
  { 2160, 9, 28, 19, 3, -24 },
  { 2192, 16, 13, 19, 1, -22 },
  { 2218, 15, 2, 19, 2, 3 },
  { 2222, 5, 6, 19, 6, -24 },
  { 2226, 15, 16, 19, 2, -16 },
  { 2256, 14, 23, 19, 3, -23 },
  { 2297, 13, 16, 19, 3, -16 },
  { 2323, 14, 23, 19, 2, -23 },
  { 2364, 15, 16, 19, 2, -16 },
  { 2394, 15, 23, 19, 2, -23 },
  { 2438, 15, 24, 19, 2, -18 },
  { 2483, 13, 23, 19, 3, -23 },
  { 2521, 14, 23, 19, 3, -23 },
  { 2562, 11, 29, 19, 3, -23 },
  { 2602, 15, 23, 19, 3, -23 },
  { 2646, 14, 23, 19, 2, -23 },
  { 2687, 15, 16, 19, 2, -16 },
  { 2717, 13, 16, 19, 3, -16 },
  { 2743, 15, 16, 19, 2, -16 },
  { 2773, 14, 22, 19, 3, -16 },
  { 2812, 14, 22, 19, 2, -16 },
  { 2851, 15, 16, 19, 2, -16 },
  { 2881, 14, 16, 19, 2, -16 },
  { 2909, 15, 22, 19, 1, -22 },
  { 2951, 13, 16, 19, 3, -16 },
  { 2977, 15, 16, 19, 2, -16 },
  { 3007, 17, 16, 19, 1, -16 },
  { 3041, 15, 16, 19, 2, -16 },
  { 3071, 15, 22, 19, 2, -16 },
  { 3113, 13, 16, 19, 3, -16 },
  { 3139, 12, 28, 19, 3, -24 },
  { 3181, 2, 28, 19, 8, -24 },
  { 3188, 12, 28, 19, 3, -24 },
  { 3230, 15, 7, 19, 2, -13 },
};

const GFXfont IBMPlexMono_Regular31pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular31pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular31pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _IBMPLEXMONO_REGULAR31PT7B_H_
