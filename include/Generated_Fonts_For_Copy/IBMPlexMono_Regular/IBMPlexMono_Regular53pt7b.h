#ifndef _IBMPLEXMONO_REGULAR53PT7B_H_
#define _IBMPLEXMONO_REGULAR53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular53pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7C, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x0F, 0xFE,
  0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0x81,
  0xFF, 0xC0, 0x1C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x03, 0x81, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x3F, 0xF8, 0x1F, 0xFC, 0xFF,
  0xE0, 0x7F, 0xF3, 0xFF, 0x81, 0xFF, 0xC0, 0x1E, 0x0F, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xE3, 0x9F, 0xE3, 0xE0, 0xE0, 0xFC,
  0xF0, 0x38, 0x1F, 0x7C, 0x0E, 0x03, 0x1E, 0x03, 0x80, 0x87, 0x80, 0xE0,
  0x01, 0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x1F, 0x03, 0x80, 0x07, 0xC0,
  0xE0, 0x00, 0xF8, 0x38, 0x00, 0x3F, 0x0E, 0x00, 0x07, 0xFB, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x38, 0xFE, 0x00, 0x0E, 0x0F, 0x80, 0x03,
  0x81, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x0E, 0x03, 0xC0,
  0x03, 0x80, 0xF0, 0x00, 0xE0, 0x3C, 0xC0, 0x38, 0x0F, 0x78, 0x0E, 0x07,
  0xFF, 0x03, 0x83, 0xE7, 0xE0, 0xE1, 0xF9, 0xFE, 0x39, 0xFC, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xF3,
  0xFF, 0xC0, 0x07, 0x9F, 0x0F, 0x00, 0x1E, 0x78, 0x1E, 0x00, 0xF1, 0xC0,
  0x38, 0x03, 0x8F, 0x00, 0xF0, 0x1E, 0x3C, 0x03, 0xC0, 0x70, 0xF0, 0x0F,
  0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x3C, 0x03, 0xC3,
  0xC0, 0xF0, 0x0F, 0x0F, 0x01, 0xC0, 0x38, 0x78, 0x07, 0x81, 0xE1, 0xE0,
  0x1F, 0x0F, 0x0F, 0x00, 0x3F, 0xFC, 0x3C, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x0F, 0x0F, 0xFF, 0x00, 0x3C, 0x7C, 0x3C, 0x01, 0xE1,
  0xE0, 0x78, 0x07, 0x0F, 0x00, 0xE0, 0x3C, 0x3C, 0x03, 0x80, 0xE0, 0xF0,
  0x0F, 0x07, 0x83, 0xC0, 0x3C, 0x3C, 0x0F, 0x00, 0xF0, 0xF0, 0x3C, 0x03,
  0xC7, 0x80, 0xF0, 0x0F, 0x1E, 0x03, 0xC0, 0x38, 0xF0, 0x0F, 0x00, 0xE3,
  0xC0, 0x1E, 0x07, 0x9E, 0x00, 0x7C, 0x3C, 0x78, 0x00, 0xFF, 0xF3, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7E, 0x0F,
  0x80, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xE0, 0x01, 0xE0, 0x04, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x3F,
  0xC0, 0xFE, 0x01, 0xFE, 0x1F, 0xF8, 0x0F, 0xF1, 0xFF, 0xE0, 0x7F, 0x9F,
  0x9F, 0x03, 0xC0, 0xF8, 0x7C, 0x1E, 0x0F, 0x81, 0xF0, 0xE0, 0x78, 0x07,
  0xC7, 0x03, 0xC0, 0x3F, 0x38, 0x3E, 0x00, 0xF9, 0xC1, 0xF0, 0x03, 0xEE,
  0x0F, 0x80, 0x0F, 0xF0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x0F,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0x7C, 0x0F, 0xE0,
  0x79, 0xF0, 0x3F, 0xFF, 0x87, 0xC0, 0xFF, 0xF8, 0x1F, 0x03, 0xFF, 0x80,
  0x7C, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x60, 0x0F, 0x00, 0x67, 0xC0, 0xF0, 0x3E, 0x7F, 0x8F,
  0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x9F, 0xCF, 0xC7, 0xE3,
  0xF3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x79,
  0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0x81, 0xFF, 0x83,
  0xF0, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC1, 0xFF,
  0x81, 0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9F, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x07,
  0xC0, 0x0F, 0x81, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xEF, 0x80, 0x03,
  0xF3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0x80,
  0x3F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xC0, 0x3E, 0x00, 0x20, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x1F, 0xC1,
  0xF0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x1F,
  0x5C, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3E, 0x00,
  0x7E, 0x7C, 0x00, 0x3E, 0x18, 0x00, 0x1E, 0x08, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x20, 0x00, 0x1F, 0x70, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x7F, 0x01, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xFB,
  0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x3C,
  0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x3F, 0x80, 0x78,
  0xFF, 0xE0, 0x79, 0xFF, 0xF0, 0x7B, 0xFF, 0xF8, 0x7F, 0x01, 0xFC, 0x7E,
  0x00, 0x7E, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x10, 0x00, 0x1F, 0x70, 0x00, 0x1E, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7F, 0x01, 0xFC, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0x78, 0xFF, 0xE0, 0x7C, 0xFF,
  0xFC, 0x3E, 0xFF, 0xFF, 0x1E, 0xF0, 0x3F, 0x8F, 0xE0, 0x07, 0xE7, 0xE0,
  0x01, 0xF7, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x7B, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x1F, 0x00, 0x3F, 0x0F, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0x80, 0x0F, 0xC7, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0xC1, 0xE0, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0x80, 0x7E, 0x0F,
  0x80, 0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0x9F, 0x80, 0x07, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFC,
  0x0F, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x78,
  0x00, 0x0F, 0xBC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x1F,
  0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x0D, 0xE7, 0xF8, 0x1F,
  0xF1, 0xFF, 0xFE, 0xF8, 0x7F, 0xFE, 0x78, 0x1F, 0xFE, 0x7C, 0x01, 0xFC,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7C, 0x3E, 0x3F, 0x9F, 0xEF, 0xF7, 0xFB, 0xF8, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0xFE, 0x7E, 0x3F, 0x1F, 0x9F, 0x8F, 0xC7, 0xC3, 0xE1, 0xE1,
  0xF0, 0xF0, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0xCF, 0xC0, 0x0F, 0x9F,
  0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x60, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xE0,
  0xF8, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x1C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xEF, 0x00, 0xF8, 0xF7, 0x81, 0xFE,
  0x7B, 0xC0, 0xFF, 0xBD, 0xC0, 0xFF, 0xDE, 0xE0, 0xFC, 0x3F, 0xF0, 0x78,
  0x0F, 0xF8, 0x3C, 0x03, 0xFC, 0x1E, 0x01, 0xFE, 0x0E, 0x00, 0xFF, 0x0F,
  0x00, 0x7F, 0x87, 0x80, 0x3F, 0xC3, 0xC0, 0x1F, 0xE1, 0xE0, 0x0F, 0xF0,
  0x70, 0x07, 0xF8, 0x38, 0x03, 0xFC, 0x1E, 0x01, 0xFE, 0x0F, 0x00, 0xF7,
  0x07, 0xC0, 0xFB, 0x81, 0xF9, 0xFD, 0xE0, 0xFF, 0xDE, 0xF0, 0x3F, 0xEF,
  0x78, 0x0F, 0xE7, 0xBC, 0x01, 0x80, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x0F, 0x1F,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0,
  0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x03, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x81, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3C,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8,
  0xF0, 0x01, 0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x06, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x61, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x1F, 0x07, 0xF0, 0x3F, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xF0, 0x07, 0xF0, 0xF0, 0x01, 0xF8, 0xF0,
  0x00, 0xFC, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0xFC, 0xF0, 0x01, 0xF8, 0xF0, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFC, 0x0F, 0xE0, 0xF8, 0x01,
  0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0xBE, 0x00,
  0x02, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x3E, 0x00,
  0x1F, 0x8F, 0x80, 0x1B, 0xC7, 0xF0, 0x3D, 0xE1, 0xFF, 0xFC, 0xF0, 0x7F,
  0xFC, 0x78, 0x1F, 0xFC, 0x3C, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x7C, 0x01,
  0xF3, 0xF8, 0x3F, 0x8F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xF8, 0x00,
  0xFE, 0x00, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x3E, 0x00,
  0x7E, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xFC, 0x00, 0x1F,
  0x3F, 0x80, 0x03, 0xEF, 0xF8, 0x00, 0x7F, 0xEF, 0x80, 0x0F, 0xF9, 0xF0,
  0x01, 0xFE, 0x1F, 0x00, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x7C,
  0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x87, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E,
  0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xEF, 0xF7, 0x81, 0xEF, 0xF7, 0x81, 0xEF, 0xF3, 0x81, 0xCF, 0xF3, 0xC3,
  0xCF, 0xF3, 0xC3, 0x8F, 0xF1, 0xE7, 0x8F, 0xF1, 0xE7, 0x8F, 0xF0, 0xE7,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x38, 0x0F, 0xF0, 0x18,
  0x0F, 0xF0, 0x18, 0x0F, 0xF0, 0x10, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xF7, 0x80,
  0x0F, 0xF7, 0xC0, 0x0F, 0xF3, 0xC0, 0x0F, 0xF3, 0xC0, 0x0F, 0xF1, 0xE0,
  0x0F, 0xF1, 0xE0, 0x0F, 0xF1, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0,
  0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x3C,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1F,
  0x0F, 0xF0, 0x0F, 0x0F, 0xF0, 0x0F, 0x0F, 0xF0, 0x07, 0x8F, 0xF0, 0x07,
  0x8F, 0xF0, 0x07, 0xCF, 0xF0, 0x03, 0xCF, 0xF0, 0x03, 0xCF, 0xF0, 0x01,
  0xEF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFC, 0x07,
  0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0x1F, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x1E, 0xF8, 0x00,
  0x07, 0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x79, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF0,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x81, 0xFC, 0x0F,
  0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1F, 0x00,
  0x03, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E,
  0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFC, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0xC0, 0xF0,
  0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0,
  0x00, 0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFC, 0x03, 0xF8, 0x3E, 0x00,
  0x1F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x02, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC4, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xCF, 0xE0, 0x01, 0xF0,
  0xFF, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F,
  0x81, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x78, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x00,
  0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xC0, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78,
  0x1F, 0x81, 0xE7, 0x81, 0xF8, 0x1E, 0x78, 0x1F, 0x81, 0xE7, 0x81, 0xF8,
  0x1E, 0x78, 0x3F, 0x81, 0xE7, 0x83, 0xFC, 0x1E, 0x78, 0x3B, 0xC1, 0xE7,
  0x83, 0x9C, 0x1E, 0x78, 0x39, 0xC1, 0xC7, 0x87, 0x9E, 0x1C, 0x78, 0x79,
  0xE1, 0xC3, 0x87, 0x1E, 0x3C, 0x38, 0x70, 0xE3, 0xC3, 0xC7, 0x0E, 0x3C,
  0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0xF3, 0xC3, 0xCE,
  0x07, 0x3C, 0x3D, 0xE0, 0x73, 0xC3, 0xDE, 0x07, 0xBC, 0x3D, 0xE0, 0x7B,
  0xC3, 0xDC, 0x07, 0xB8, 0x3F, 0xC0, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x1F,
  0xC0, 0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x80, 0x7C, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x01, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x1E, 0x7C,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1E,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x01, 0xF0,
  0x3E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1E, 0x3E,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x78, 0x0F, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01,
  0xE0, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1E, 0x20, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x30, 0xF8, 0x78,
  0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x06, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x3F, 0x07, 0x80, 0x07, 0xC0, 0x20, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x1F, 0xC0, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0,
  0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x07, 0xC1, 0xF0, 0x03,
  0xF0, 0x7E, 0x03, 0x9F, 0xCF, 0xFF, 0xE7, 0xF1, 0xFF, 0xF0, 0xFC, 0x3F,
  0xF8, 0x1F, 0x03, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x3F, 0x00, 0xF0, 0xFF, 0xC0, 0xF3, 0xFF, 0xF0,
  0xF3, 0xFF, 0xF8, 0xF7, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C,
  0xFC, 0x00, 0xFC, 0xF7, 0x03, 0xF8, 0xF3, 0xFF, 0xF8, 0xF3, 0xFF, 0xF0,
  0xF0, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x0F, 0xC3, 0xE0, 0x0F, 0x8F,
  0x80, 0x0F, 0x9E, 0x00, 0x0C, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x87, 0x80, 0x01, 0x8F, 0x80, 0x07,
  0x8F, 0x80, 0x1F, 0x1F, 0xC0, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0xFC, 0x0F, 0x07, 0xFF, 0x0F, 0x0F, 0xFF, 0x8F,
  0x1F, 0xFF, 0xCF, 0x1F, 0x80, 0xEF, 0x3F, 0x00, 0x7F, 0x7E, 0x00, 0x3F,
  0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x1F, 0x80, 0xEF, 0x1F, 0xFF, 0xCF, 0x0F, 0xFF, 0x8F,
  0x07, 0xFF, 0x0F, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0x81, 0xF8, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x08,
  0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0xFC, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xFD, 0xFE,
  0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFE, 0x07,
  0xE0, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC1, 0xF0,
  0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC0,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x7E, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF9, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xBF,
  0x00, 0x0F, 0xEF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x1F,
  0xC0, 0xF0, 0xFF, 0xC3, 0xC7, 0xFF, 0x8F, 0x3F, 0xFF, 0x3D, 0xC0, 0xFE,
  0xF4, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xBF, 0xFF,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x7E, 0xF0,
  0x00, 0xFC, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0,
  0x0F, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x7C, 0x00, 0xF1,
  0xF8, 0x00, 0xF3, 0xF0, 0x00, 0xF7, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0x7C, 0x00, 0xFE, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF0,
  0x0F, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xE0, 0xF0, 0x03, 0xE0, 0xF0,
  0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xF0, 0x3E, 0x3C, 0xFE, 0x3F, 0xCF, 0x7F, 0x8F, 0xFB,
  0xDF, 0xF7, 0xFE, 0xFC, 0x7D, 0x8F, 0xBC, 0x0F, 0xC1, 0xFF, 0x01, 0xE0,
  0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01,
  0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF,
  0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80,
  0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07,
  0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC,
  0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0x00, 0x7F, 0x03,
  0xC3, 0xFF, 0x0F, 0x1F, 0xFE, 0x3C, 0xFF, 0xFC, 0xF7, 0x03, 0xFB, 0xD0,
  0x03, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x78, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xDE, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1F, 0xC0, 0xFC, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0xF0, 0xFF, 0xC0, 0xF3, 0xFF, 0xF0, 0xF3, 0xFF, 0xF8, 0xF7, 0x03, 0xF8,
  0xFC, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0xF7, 0x03, 0xF8,
  0xF3, 0xFF, 0xF8, 0xF3, 0xFF, 0xF0, 0xF0, 0xFF, 0xC0, 0xF0, 0x3F, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x0F,
  0x0F, 0xFF, 0x8F, 0x1F, 0xFF, 0xCF, 0x1F, 0x80, 0xEF, 0x3F, 0x00, 0x7F,
  0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0xEF, 0x1F, 0xFF, 0xCF,
  0x0F, 0xFF, 0x8F, 0x07, 0xFF, 0x0F, 0x01, 0xFC, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xCF, 0xFF, 0x00, 0xF3, 0x80, 0x00, 0x3D, 0x80, 0x00, 0x0F,
  0x40, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0x00, 0xFE, 0x3C, 0x00,
  0x3C, 0x7C, 0x00, 0x08, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x20, 0x00,
  0x1F, 0x70, 0x00, 0x1E, 0xFC, 0x00, 0x3E, 0xFF, 0x00, 0xFE, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7,
  0xC0, 0x0F, 0xDF, 0xC0, 0xFF, 0x3F, 0xFF, 0x7C, 0x7F, 0xFD, 0xF0, 0xFF,
  0xE7, 0xC0, 0xFE, 0x00, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDF, 0x00,
  0x03, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03,
  0xC0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0xFF, 0x01, 0xF8, 0x0F,
  0xF0, 0x1F, 0x80, 0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0xFF, 0x01,
  0xF8, 0x0E, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x78, 0x39, 0xC1,
  0xE7, 0x83, 0x9C, 0x1E, 0x78, 0x79, 0xC1, 0xE7, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x0E,
  0x3C, 0x3C, 0xE0, 0xF3, 0xC3, 0xCE, 0x07, 0x3C, 0x3C, 0xE0, 0x73, 0x81,
  0xCE, 0x07, 0x38, 0x1D, 0xE0, 0x73, 0x81, 0xDC, 0x07, 0xB8, 0x1D, 0xC0,
  0x3F, 0x81, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1E, 0x00,
  0x7C, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x3C, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x7C, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x3E, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1F, 0x00,
  0x3E, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x07,
  0x80, 0x78, 0x01, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x01, 0x83, 0xF8, 0x00, 0xF1, 0xFF, 0x00, 0x3C,
  0xFF, 0xE0, 0x0E, 0x3C, 0x7C, 0x03, 0x9E, 0x0F, 0x81, 0xE7, 0x81, 0xF0,
  0x79, 0xC0, 0x3E, 0x3C, 0xF0, 0x0F, 0xFF, 0x3C, 0x01, 0xFF, 0x8E, 0x00,
  0x3F, 0xC1, 0x80, 0x03, 0xE0,
};

const GFXglyph IBMPlexMono_Regular53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 8, 37, 32, 12, -37 },
  { 38, 14, 15, 32, 9, -39 },
  { 65, 30, 37, 32, 1, -37 },
  { 204, 26, 49, 32, 3, -43 },
  { 364, 30, 39, 32, 1, -38 },
  { 511, 29, 39, 32, 1, -38 },
  { 653, 4, 15, 32, 14, -39 },
  { 661, 15, 47, 32, 11, -40 },
  { 750, 15, 47, 32, 6, -40 },
  { 839, 28, 26, 32, 2, -30 },
  { 930, 26, 26, 32, 3, -29 },
  { 1015, 9, 14, 32, 11, -7 },
  { 1031, 16, 4, 32, 8, -18 },
  { 1039, 8, 7, 32, 12, -7 },
  { 1046, 22, 47, 32, 5, -40 },
  { 1176, 26, 39, 32, 3, -38 },
  { 1303, 26, 37, 32, 3, -37 },
  { 1424, 25, 38, 32, 3, -38 },
  { 1543, 24, 39, 32, 3, -38 },
  { 1660, 28, 37, 32, 2, -37 },
  { 1790, 24, 38, 32, 4, -37 },
  { 1904, 25, 38, 32, 3, -37 },
  { 2023, 25, 37, 32, 3, -37 },
  { 2139, 26, 39, 32, 3, -38 },
  { 2266, 25, 38, 32, 3, -38 },
  { 2385, 8, 28, 32, 12, -28 },
  { 2413, 9, 35, 32, 11, -28 },
  { 2453, 23, 31, 32, 4, -32 },
  { 2543, 26, 15, 32, 3, -24 },
  { 2592, 23, 31, 32, 4, -32 },
  { 2682, 23, 38, 32, 4, -38 },
  { 2792, 25, 44, 32, 3, -38 },
  { 2930, 28, 37, 32, 2, -37 },
  { 3060, 24, 37, 32, 5, -37 },
  { 3171, 25, 39, 32, 4, -38 },
  { 3293, 24, 37, 32, 5, -37 },
  { 3404, 23, 37, 32, 5, -37 },
  { 3511, 23, 37, 32, 5, -37 },
  { 3618, 25, 39, 32, 3, -38 },
  { 3740, 24, 37, 32, 4, -37 },
  { 3851, 23, 37, 32, 4, -37 },
  { 3958, 21, 38, 32, 4, -37 },
  { 4058, 27, 37, 32, 4, -37 },
  { 4183, 22, 37, 32, 6, -37 },
  { 4285, 24, 37, 32, 4, -37 },
  { 4396, 24, 37, 32, 4, -37 },
  { 4507, 26, 39, 32, 3, -38 },
  { 4634, 24, 37, 32, 5, -37 },
  { 4745, 26, 47, 32, 3, -38 },
  { 4898, 24, 37, 32, 5, -37 },
  { 5009, 27, 39, 32, 2, -38 },
  { 5141, 29, 37, 32, 1, -37 },
  { 5276, 24, 38, 32, 4, -37 },
  { 5390, 28, 37, 32, 2, -37 },
  { 5520, 28, 37, 32, 2, -37 },
  { 5650, 29, 37, 32, 1, -37 },
  { 5785, 30, 37, 32, 1, -37 },
  { 5924, 26, 37, 32, 3, -37 },
  { 6045, 15, 47, 32, 12, -40 },
  { 6134, 22, 47, 32, 5, -40 },
  { 6264, 15, 47, 32, 5, -40 },
  { 6353, 27, 22, 32, 2, -37 },
  { 6428, 26, 4, 32, 3, 5 },
  { 6441, 8, 10, 32, 10, -41 },
  { 6451, 26, 29, 32, 3, -28 },
  { 6546, 24, 40, 32, 5, -39 },
  { 6666, 23, 29, 32, 4, -28 },
  { 6750, 24, 40, 32, 3, -39 },
  { 6870, 24, 29, 32, 4, -28 },
  { 6957, 25, 39, 32, 4, -39 },
  { 7079, 26, 42, 32, 4, -31 },
  { 7216, 22, 39, 32, 5, -39 },
  { 7324, 23, 39, 32, 6, -39 },
  { 7437, 19, 50, 32, 5, -39 },
  { 7556, 24, 39, 32, 6, -39 },
  { 7673, 24, 39, 32, 4, -39 },
  { 7790, 26, 28, 32, 3, -28 },
  { 7881, 22, 28, 32, 5, -28 },
  { 7958, 25, 29, 32, 3, -28 },
  { 8049, 24, 39, 32, 5, -28 },
  { 8166, 24, 39, 32, 3, -28 },
  { 8283, 26, 27, 32, 4, -27 },
  { 8371, 24, 29, 32, 4, -28 },
  { 8458, 26, 37, 32, 2, -37 },
  { 8579, 22, 28, 32, 5, -27 },
  { 8656, 25, 27, 32, 3, -27 },
  { 8741, 28, 27, 32, 2, -27 },
  { 8836, 26, 27, 32, 3, -27 },
  { 8924, 26, 38, 32, 3, -27 },
  { 9048, 23, 27, 32, 4, -27 },
  { 9126, 20, 47, 32, 6, -40 },
  { 9244, 4, 47, 32, 14, -40 },
  { 9268, 20, 47, 32, 6, -40 },
  { 9386, 26, 12, 32, 3, -22 },
};

const GFXfont IBMPlexMono_Regular53pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular53pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular53pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _IBMPLEXMONO_REGULAR53PT7B_H_
