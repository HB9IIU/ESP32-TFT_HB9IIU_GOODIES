#ifndef _IBMPLEXMONO_REGULAR16PT7B_H_
#define _IBMPLEXMONO_REGULAR16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xA8, 0x3C, 0x99, 0x99, 0x09, 0x0D, 0x84, 0x8E, 0x71, 0x20,
  0x90, 0x49, 0xEF, 0x24, 0x12, 0x09, 0x00, 0x10, 0x10, 0x3C, 0x53, 0xD0,
  0xD0, 0x70, 0x3C, 0x13, 0x13, 0x93, 0xD2, 0x7C, 0x10, 0x10, 0x70, 0xE4,
  0xE2, 0x59, 0x47, 0x20, 0x00, 0x5C, 0x49, 0x24, 0xA2, 0x71, 0xC0, 0x1C,
  0x13, 0x18, 0x04, 0x03, 0x01, 0x8D, 0x25, 0x8A, 0xC2, 0x23, 0x8E, 0x60,
  0xF0, 0x19, 0x18, 0x84, 0x62, 0x10, 0xC2, 0x10, 0xC2, 0x0C, 0xC4, 0x21,
  0x11, 0x11, 0x11, 0x12, 0x4C, 0x10, 0x10, 0x91, 0xFF, 0x18, 0x38, 0x64,
  0x46, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x69, 0x60, 0xF8, 0xF0,
  0x02, 0x0C, 0x10, 0x20, 0x81, 0x06, 0x08, 0x10, 0x40, 0x83, 0x04, 0x18,
  0x00, 0x3C, 0x46, 0xC2, 0x83, 0x9B, 0x9B, 0x83, 0x83, 0xC2, 0x46, 0x3C,
  0x38, 0x68, 0xC8, 0x88, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x3C,
  0xC6, 0x82, 0x02, 0x06, 0x04, 0x08, 0x10, 0x20, 0xC0, 0xFF, 0x7D, 0x8C,
  0x08, 0x10, 0x47, 0x01, 0x81, 0x83, 0x8D, 0xF0, 0x0C, 0x1C, 0x14, 0x24,
  0x24, 0x44, 0xC4, 0x84, 0xFF, 0x04, 0x04, 0x7E, 0x40, 0x40, 0x40, 0x5C,
  0x66, 0x02, 0x03, 0x82, 0xC6, 0x7C, 0x1C, 0x30, 0x60, 0x40, 0xFC, 0xC6,
  0xC2, 0x83, 0xC2, 0x46, 0x3C, 0xFF, 0x82, 0x86, 0x04, 0x04, 0x0C, 0x08,
  0x18, 0x10, 0x30, 0x20, 0x3C, 0x46, 0xC2, 0xC2, 0x46, 0x38, 0xC6, 0x83,
  0x83, 0xC2, 0x7C, 0x3C, 0x46, 0xC2, 0x83, 0xC3, 0xC6, 0x7A, 0x06, 0x04,
  0x08, 0x30, 0xF0, 0x0F, 0x6C, 0x00, 0x1A, 0x58, 0x02, 0x0C, 0x63, 0x0C,
  0x0C, 0x06, 0x03, 0x02, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0xE0, 0x70,
  0x21, 0xC6, 0x30, 0x80, 0x3C, 0x8F, 0x08, 0x10, 0xC2, 0x04, 0x00, 0x00,
  0x70, 0xE0, 0x3C, 0x8F, 0x0C, 0xF9, 0x32, 0x6C, 0xD9, 0x93, 0x3D, 0x03,
  0x03, 0xC0, 0x0C, 0x0E, 0x05, 0x02, 0xC1, 0x21, 0x90, 0x8C, 0x7E, 0x61,
  0x20, 0xF0, 0x20, 0xFC, 0xC6, 0xC2, 0xC2, 0xC6, 0xFC, 0xC2, 0xC3, 0xC3,
  0xC2, 0xFC, 0x3C, 0x62, 0x43, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x42, 0x63,
  0x3C, 0xF9, 0x1A, 0x14, 0x38, 0x70, 0xE1, 0xC3, 0x85, 0x1B, 0xE0, 0xFF,
  0x83, 0x06, 0x0C, 0x1F, 0xF0, 0x60, 0xC1, 0x83, 0xF8, 0xFF, 0x83, 0x06,
  0x0C, 0x1F, 0xF0, 0x60, 0xC1, 0x83, 0x00, 0x3C, 0x8F, 0x0C, 0x08, 0x10,
  0x23, 0xC1, 0xC2, 0x8C, 0xE8, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xF0, 0xE1,
  0xC3, 0x87, 0x08, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x23,
  0xF8, 0x7E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x87, 0x89, 0xE0, 0xC3,
  0xC6, 0xCC, 0xC8, 0xD0, 0xF8, 0xE8, 0xCC, 0xC6, 0xC2, 0xC3, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xF8, 0xC3, 0xC7, 0xA7, 0xA7,
  0xBB, 0x9B, 0x93, 0x93, 0x83, 0x83, 0x83, 0xC3, 0xC7, 0x8F, 0x9D, 0x3A,
  0x72, 0xE5, 0xCF, 0x8F, 0x18, 0x3C, 0x46, 0xC2, 0x83, 0x83, 0x83, 0x83,
  0x83, 0xC2, 0x46, 0x3C, 0xFE, 0xC2, 0xC3, 0xC3, 0xC2, 0xFE, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x3C, 0x46, 0xC2, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC2,
  0x46, 0x3C, 0x10, 0x0E, 0xFE, 0xC2, 0xC3, 0xC3, 0xC2, 0xFC, 0xC8, 0xCC,
  0xC4, 0xC6, 0xC3, 0x3C, 0xC3, 0xC0, 0xC0, 0x60, 0x3C, 0x02, 0x03, 0x83,
  0xC2, 0x7C, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x00, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC2, 0x8C,
  0xF0, 0x83, 0x83, 0xC2, 0x42, 0x46, 0x64, 0x24, 0x2C, 0x28, 0x38, 0x18,
  0x81, 0x81, 0x81, 0x99, 0x99, 0x9B, 0xAB, 0xAE, 0xA6, 0xA6, 0xC6, 0x41,
  0x90, 0x8C, 0x82, 0xC1, 0xC0, 0x60, 0x70, 0x24, 0x23, 0x30, 0xB0, 0x60,
  0xC0, 0xB0, 0x88, 0xC6, 0x41, 0x60, 0x60, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x00, 0xFF, 0x02, 0x06, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x40, 0xC0, 0xFF,
  0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC0, 0x81, 0x81, 0x02, 0x02,
  0x04, 0x0C, 0x08, 0x10, 0x10, 0x20, 0x60, 0x40, 0xF1, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x1F, 0x18, 0x38, 0x24, 0x44, 0x42, 0x83, 0x82, 0xFF, 0x89,
  0x80, 0x7C, 0xC4, 0x06, 0x7E, 0xC6, 0x86, 0xCA, 0x73, 0x81, 0x02, 0x04,
  0x0B, 0x99, 0xA1, 0x43, 0x87, 0x0A, 0x37, 0xC0, 0x3C, 0x85, 0x06, 0x0C,
  0x08, 0x10, 0x9E, 0x02, 0x04, 0x08, 0x17, 0xA8, 0xE0, 0xC1, 0x83, 0x05,
  0x1B, 0xD0, 0x3C, 0x46, 0x82, 0xFF, 0x80, 0xC2, 0x46, 0x3C, 0x0F, 0x10,
  0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFE, 0x03, 0x3C,
  0x46, 0x42, 0x42, 0x46, 0x7C, 0x40, 0x7E, 0x81, 0xC1, 0x7E, 0x82, 0x08,
  0x20, 0xBB, 0x38, 0x61, 0x86, 0x18, 0x61, 0x30, 0x60, 0x00, 0x0F, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x47, 0xF0, 0x0C, 0x30, 0x00, 0xFC, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x17, 0x80, 0x81, 0x02, 0x04, 0x08, 0x71, 0x2C,
  0x78, 0xD1, 0x12, 0x34, 0x30, 0xF0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x47, 0xF0, 0xB6, 0xDB, 0x91, 0x91, 0x91, 0x91, 0x91, 0x91,
  0xBB, 0x38, 0x61, 0x86, 0x18, 0x61, 0x3C, 0x46, 0xC2, 0x83, 0x83, 0xC2,
  0x46, 0x3C, 0xB9, 0x9A, 0x14, 0x38, 0x70, 0xA3, 0x7C, 0x81, 0x02, 0x00,
  0x7A, 0x8E, 0x0C, 0x18, 0x30, 0x51, 0xBD, 0x02, 0x04, 0x08, 0xF7, 0x18,
  0x10, 0x10, 0x10, 0x10, 0x10, 0xFE, 0x3C, 0x85, 0x03, 0xC0, 0xE0, 0x70,
  0xBE, 0x30, 0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x78, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x51, 0x9D, 0x83, 0x42, 0x46, 0x64, 0x24, 0x2C,
  0x38, 0x18, 0xCC, 0xA6, 0x53, 0x2A, 0x95, 0x52, 0x99, 0x4C, 0x66, 0xC3,
  0x64, 0x2C, 0x18, 0x18, 0x2C, 0x64, 0xC3, 0x83, 0xC2, 0x46, 0x64, 0x24,
  0x28, 0x18, 0x18, 0x10, 0x30, 0xE0, 0x7E, 0x0C, 0x30, 0xC1, 0x04, 0x10,
  0x7F, 0x3C, 0x82, 0x08, 0x10, 0x4E, 0x04, 0x10, 0x42, 0x08, 0x20, 0xF0,
  0xFF, 0xFC, 0xF0, 0x41, 0x08, 0x61, 0x81, 0xC8, 0x40, 0x83, 0x04, 0x13,
  0xC0, 0x61, 0x9A, 0x8E,
};

const GFXglyph IBMPlexMono_Regular16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 11, 10, 4, -11 },
  { 4, 4, 4, 10, 3, -12 },
  { 6, 9, 11, 10, 0, -11 },
  { 19, 8, 15, 10, 1, -13 },
  { 34, 9, 11, 10, 0, -11 },
  { 47, 9, 11, 10, 0, -11 },
  { 60, 1, 4, 10, 4, -12 },
  { 61, 5, 14, 10, 3, -12 },
  { 70, 4, 14, 10, 2, -12 },
  { 77, 8, 8, 10, 1, -9 },
  { 85, 8, 7, 10, 1, -8 },
  { 92, 3, 4, 10, 3, -2 },
  { 94, 5, 1, 10, 2, -5 },
  { 95, 2, 2, 10, 4, -2 },
  { 96, 7, 14, 10, 1, -12 },
  { 109, 8, 11, 10, 1, -11 },
  { 120, 8, 11, 10, 1, -11 },
  { 131, 8, 11, 10, 1, -11 },
  { 142, 7, 11, 10, 1, -11 },
  { 152, 8, 11, 10, 1, -11 },
  { 163, 8, 11, 10, 1, -11 },
  { 174, 8, 11, 10, 1, -11 },
  { 185, 8, 11, 10, 1, -11 },
  { 196, 8, 11, 10, 1, -11 },
  { 207, 8, 11, 10, 1, -11 },
  { 218, 2, 8, 10, 4, -8 },
  { 220, 3, 10, 10, 3, -8 },
  { 224, 7, 9, 10, 1, -9 },
  { 232, 8, 4, 10, 1, -7 },
  { 236, 7, 9, 10, 1, -9 },
  { 244, 7, 11, 10, 1, -11 },
  { 254, 7, 13, 10, 1, -11 },
  { 266, 9, 11, 10, 0, -11 },
  { 279, 8, 11, 10, 1, -11 },
  { 290, 8, 11, 10, 1, -11 },
  { 301, 7, 11, 10, 2, -11 },
  { 311, 7, 11, 10, 1, -11 },
  { 321, 7, 11, 10, 1, -11 },
  { 331, 7, 11, 10, 1, -11 },
  { 341, 7, 11, 10, 1, -11 },
  { 351, 7, 11, 10, 1, -11 },
  { 361, 7, 11, 10, 1, -11 },
  { 371, 8, 11, 10, 1, -11 },
  { 382, 7, 11, 10, 2, -11 },
  { 392, 8, 11, 10, 1, -11 },
  { 403, 7, 11, 10, 1, -11 },
  { 413, 8, 11, 10, 1, -11 },
  { 424, 8, 11, 10, 1, -11 },
  { 435, 8, 13, 10, 1, -11 },
  { 448, 8, 11, 10, 1, -11 },
  { 459, 8, 11, 10, 1, -11 },
  { 470, 9, 11, 10, 0, -11 },
  { 483, 7, 11, 10, 1, -11 },
  { 493, 8, 11, 10, 1, -11 },
  { 504, 8, 11, 10, 1, -11 },
  { 515, 9, 11, 10, 0, -11 },
  { 528, 9, 11, 10, 0, -11 },
  { 541, 8, 11, 10, 1, -11 },
  { 552, 4, 14, 10, 4, -12 },
  { 559, 7, 14, 10, 1, -12 },
  { 572, 4, 14, 10, 2, -12 },
  { 579, 8, 7, 10, 1, -11 },
  { 586, 8, 1, 10, 1, 2 },
  { 587, 3, 3, 10, 3, -12 },
  { 589, 8, 8, 10, 1, -8 },
  { 597, 7, 12, 10, 2, -12 },
  { 608, 7, 8, 10, 1, -8 },
  { 615, 7, 12, 10, 1, -12 },
  { 626, 8, 8, 10, 1, -8 },
  { 634, 8, 12, 10, 1, -12 },
  { 646, 8, 12, 10, 1, -9 },
  { 658, 6, 12, 10, 2, -12 },
  { 667, 7, 12, 10, 2, -12 },
  { 678, 6, 15, 10, 1, -12 },
  { 690, 7, 12, 10, 2, -12 },
  { 701, 7, 12, 10, 1, -12 },
  { 712, 8, 8, 10, 1, -8 },
  { 720, 6, 8, 10, 2, -8 },
  { 726, 8, 8, 10, 1, -8 },
  { 734, 7, 11, 10, 2, -8 },
  { 744, 7, 11, 10, 1, -8 },
  { 754, 8, 8, 10, 1, -8 },
  { 762, 7, 8, 10, 1, -8 },
  { 769, 7, 11, 10, 1, -11 },
  { 779, 7, 8, 10, 1, -8 },
  { 786, 8, 8, 10, 1, -8 },
  { 794, 9, 8, 10, 0, -8 },
  { 803, 8, 8, 10, 1, -8 },
  { 811, 8, 11, 10, 1, -8 },
  { 822, 7, 8, 10, 1, -8 },
  { 829, 6, 14, 10, 2, -12 },
  { 840, 1, 14, 10, 4, -12 },
  { 842, 6, 14, 10, 2, -12 },
  { 853, 8, 3, 10, 1, -7 },
};

const GFXfont IBMPlexMono_Regular16pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular16pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _IBMPLEXMONO_REGULAR16PT7B_H_
