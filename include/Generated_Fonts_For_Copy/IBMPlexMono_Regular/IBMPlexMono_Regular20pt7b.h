#ifndef _IBMPLEXMONO_REGULAR20PT7B_H_
#define _IBMPLEXMONO_REGULAR20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0x83, 0xF0, 0xCF, 0x3C, 0xF3, 0xCF, 0x30, 0x04, 0xC0,
  0xCC, 0x0C, 0x80, 0xC8, 0x08, 0x87, 0x9F, 0x09, 0x81, 0x90, 0xF9, 0xE1,
  0x10, 0x13, 0x01, 0x30, 0x33, 0x03, 0x20, 0x04, 0x01, 0x03, 0xF1, 0x97,
  0x44, 0x91, 0x0C, 0x41, 0x90, 0x3E, 0x01, 0xE0, 0x4C, 0x13, 0x04, 0xD1,
  0x3E, 0x58, 0xFC, 0x04, 0x01, 0x00, 0x38, 0x34, 0x46, 0xC4, 0x4C, 0x4C,
  0xC4, 0x84, 0x58, 0x38, 0x00, 0x1C, 0x1A, 0x21, 0x23, 0x32, 0x32, 0x23,
  0x62, 0x2C, 0x1C, 0x1F, 0x06, 0x30, 0x80, 0x10, 0x03, 0x00, 0x60, 0x06,
  0x01, 0x67, 0x66, 0xC8, 0x53, 0x06, 0x20, 0xC6, 0x2C, 0x78, 0xC0, 0xFF,
  0xF0, 0x0C, 0x42, 0x18, 0x41, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x41, 0x06,
  0x08, 0x10, 0x30, 0xC0, 0x81, 0x06, 0x08, 0x20, 0xC3, 0x0C, 0x30, 0xC3,
  0x08, 0x21, 0x84, 0x23, 0x00, 0x0C, 0x03, 0x00, 0xC3, 0x33, 0xFF, 0xC7,
  0x81, 0xE0, 0x48, 0x33, 0x18, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF,
  0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x76, 0x64, 0xCC, 0xFC, 0xFC, 0x01,
  0x03, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x30, 0x20,
  0x20, 0x60, 0x40, 0xC0, 0x80, 0x1E, 0x08, 0x44, 0x09, 0x02, 0xC0, 0xF0,
  0x3C, 0xCF, 0x33, 0xC0, 0xF0, 0x34, 0x09, 0x02, 0x21, 0x07, 0x80, 0x1C,
  0x0D, 0x06, 0x43, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x1F, 0xF0, 0x3E, 0x18, 0xCC, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x10, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x3F, 0xF0, 0x3E,
  0x31, 0x90, 0x60, 0x30, 0x18, 0x18, 0x70, 0x06, 0x01, 0x80, 0x40, 0x30,
  0x3E, 0x31, 0xF0, 0x07, 0x01, 0x40, 0xD0, 0x24, 0x19, 0x0C, 0x42, 0x11,
  0x84, 0xC1, 0x20, 0x4F, 0xFC, 0x04, 0x01, 0x00, 0x40, 0x7F, 0x98, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x04, 0xF1, 0xC6, 0x00, 0x80, 0x30, 0x0D, 0x02,
  0xE1, 0x8F, 0x80, 0x07, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x04, 0xF3,
  0xC6, 0xC0, 0xB0, 0x3C, 0x0D, 0x02, 0x61, 0x87, 0x80, 0xFF, 0xF0, 0x3C,
  0x1B, 0x06, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x0C, 0x00, 0x3F, 0x18, 0x64, 0x09, 0x02, 0x40, 0x98, 0x61, 0xE1,
  0x86, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x61, 0x8F, 0xC0, 0x1E, 0x18, 0x64,
  0x0B, 0x03, 0xC0, 0xF0, 0x36, 0x1C, 0xFA, 0x01, 0x80, 0x60, 0x30, 0x18,
  0x0E, 0x0E, 0x00, 0xFC, 0x00, 0xFC, 0x66, 0x60, 0x00, 0x00, 0x76, 0x64,
  0xCC, 0x01, 0x03, 0x0E, 0x38, 0x70, 0xC0, 0xC0, 0x70, 0x38, 0x0E, 0x03,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x80, 0xC0, 0x70, 0x1C,
  0x0E, 0x03, 0x03, 0x0E, 0x1C, 0x70, 0xC0, 0x80, 0x7C, 0xC3, 0x83, 0x03,
  0x03, 0x06, 0x1C, 0x10, 0x10, 0x00, 0x00, 0x38, 0x38, 0x38, 0x1E, 0x08,
  0x64, 0x09, 0x02, 0xC6, 0xB2, 0x7D, 0x8F, 0x63, 0xD8, 0xF6, 0x3C, 0x8D,
  0x3F, 0x40, 0x18, 0x03, 0x00, 0x7C, 0x0C, 0x07, 0x81, 0xE0, 0x48, 0x13,
  0x0C, 0xC3, 0x30, 0x84, 0x61, 0x9F, 0xE4, 0x0B, 0x03, 0xC0, 0xF0, 0x30,
  0xFE, 0x41, 0xA0, 0x50, 0x28, 0x14, 0x1B, 0xF1, 0x06, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x37, 0xF0, 0x1F, 0x0C, 0x66, 0x0D, 0x00, 0x40, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x83, 0x31, 0x87, 0xC0, 0xFC, 0x61,
  0x30, 0xD8, 0x2C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x58, 0x6C,
  0x27, 0xE0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0xFF, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x03, 0xFD,
  0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00, 0x1F, 0x10, 0xD8, 0x28,
  0x0C, 0x06, 0x03, 0x01, 0x8F, 0xC0, 0xE0, 0x50, 0x2C, 0x36, 0x18, 0xF4,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0x3F, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x78, 0x26, 0x31, 0xF0, 0x81, 0xA0, 0xC8, 0x62,
  0x18, 0x8C, 0x26, 0x0B, 0x83, 0xB0, 0xCC, 0x21, 0x88, 0x62, 0x0C, 0x81,
  0xA0, 0x70, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x07, 0xFC, 0xE1, 0xF8, 0x7E, 0x1F, 0xCF, 0xD2,
  0xF7, 0xBC, 0xCF, 0x33, 0xCC, 0xF2, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30,
  0xC1, 0xE1, 0xE1, 0xA1, 0xB1, 0x91, 0x99, 0x99, 0x89, 0x8D, 0x85, 0x87,
  0x87, 0x83, 0x1E, 0x08, 0x46, 0x19, 0x02, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x34, 0x09, 0x86, 0x21, 0x07, 0x80, 0xFE, 0x41, 0xA0, 0x70,
  0x38, 0x1C, 0x0E, 0x0D, 0xFC, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x00,
  0x1E, 0x08, 0x46, 0x19, 0x02, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x34, 0x09, 0x86, 0x61, 0x87, 0x80, 0xC0, 0x30, 0x07, 0x80, 0xFE, 0x41,
  0xA0, 0x70, 0x38, 0x1C, 0x0E, 0x0D, 0xFC, 0x8C, 0x42, 0x21, 0x90, 0x68,
  0x34, 0x0C, 0x3F, 0x18, 0x74, 0x0B, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0x0E,
  0x00, 0xC0, 0x30, 0x0F, 0x03, 0xE1, 0x8F, 0xC0, 0xFF, 0xF0, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0xC3, 0xC3, 0x7E, 0xC0, 0xF0, 0x3C, 0x0D, 0x02,
  0x61, 0x98, 0x62, 0x10, 0xCC, 0x33, 0x04, 0x81, 0x20, 0x78, 0x1E, 0x03,
  0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0xCC, 0x73, 0x3C, 0xEF, 0x7B, 0xD2,
  0xF4, 0xB5, 0x29, 0xCE, 0x73, 0x98, 0x60, 0xC0, 0xCC, 0x11, 0x86, 0x19,
  0x81, 0x30, 0x3C, 0x03, 0x00, 0x60, 0x1E, 0x06, 0x60, 0xC4, 0x30, 0xCC,
  0x0D, 0x81, 0xC0, 0xE0, 0x36, 0x06, 0x30, 0xC3, 0x0C, 0x19, 0x81, 0x98,
  0x0F, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0xFF, 0xC0, 0x20, 0x18, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C,
  0x02, 0x01, 0x80, 0xC0, 0x3F, 0xF0, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xF0, 0x80, 0xC0, 0x40, 0x60,
  0x20, 0x20, 0x30, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02,
  0x03, 0x01, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0F, 0xF0, 0x0C, 0x07, 0x81, 0x20, 0xCC, 0x21, 0x18, 0x64,
  0x0B, 0x03, 0xFF, 0xC0, 0x99, 0x10, 0x3E, 0x18, 0xC4, 0x10, 0x06, 0x3F,
  0x98, 0x6C, 0x1B, 0x06, 0x63, 0x8F, 0x30, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0xF3, 0x8D, 0x82, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x16, 0x1B, 0xF8,
  0x3E, 0x63, 0xC2, 0x80, 0x80, 0x80, 0x80, 0xC1, 0x63, 0x3E, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x19, 0xED, 0x8E, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x34,
  0x1B, 0x0C, 0xFE, 0x1E, 0x08, 0x64, 0x09, 0x03, 0xFF, 0xF0, 0x04, 0x01,
  0x02, 0x21, 0x87, 0xC0, 0x07, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xF0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x07, 0xF8, 0x01,
  0xC7, 0xC2, 0x11, 0x86, 0x61, 0x98, 0x62, 0x10, 0x78, 0x60, 0x18, 0x03,
  0xF9, 0x03, 0xC0, 0x50, 0x33, 0xF8, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xDE,
  0xE3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x1C, 0x0E, 0x00,
  0x00, 0x0F, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87,
  0xFC, 0x06, 0x0C, 0x00, 0x0F, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x07, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x1F,
  0x19, 0x98, 0xD8, 0x7C, 0x3B, 0x18, 0xCC, 0x36, 0x1B, 0x06, 0xF8, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0xFF, 0xFB, 0xB3, 0x3C, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x33, 0xCC,
  0xF3, 0x30, 0xDE, 0xE3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0x1E, 0x18, 0x64, 0x0B, 0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0x02, 0x61, 0x87,
  0x80, 0xDE, 0x71, 0xB0, 0x58, 0x3C, 0x1E, 0x0F, 0x07, 0x82, 0xC3, 0x7F,
  0x30, 0x18, 0x0C, 0x06, 0x00, 0x3D, 0xB1, 0xD0, 0x78, 0x3C, 0x1E, 0x0F,
  0x06, 0x83, 0x61, 0x9F, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0xF3, 0x8E, 0x06,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x7F, 0x80, 0x3F, 0x30, 0xD8,
  0x0C, 0x03, 0xC0, 0x3C, 0x02, 0x81, 0xE1, 0x9F, 0x80, 0x18, 0x06, 0x01,
  0x80, 0x60, 0xFF, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x03, 0xF0, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xC3,
  0x7F, 0xC0, 0xD0, 0x26, 0x18, 0x84, 0x21, 0x0C, 0xC1, 0x20, 0x78, 0x1E,
  0x03, 0x00, 0x8C, 0x63, 0x18, 0xC6, 0x79, 0xD2, 0xF4, 0xB5, 0x29, 0x4A,
  0x73, 0x98, 0x60, 0xE1, 0xD8, 0x63, 0x30, 0x78, 0x0C, 0x03, 0x01, 0xE0,
  0xCC, 0x61, 0xB0, 0x30, 0xC0, 0xD0, 0x26, 0x18, 0x84, 0x33, 0x0C, 0xC1,
  0x20, 0x78, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x18, 0x1C, 0x00, 0xFF, 0x03,
  0x06, 0x0C, 0x18, 0x10, 0x30, 0x60, 0xC0, 0xFF, 0x1F, 0x10, 0x10, 0x10,
  0x18, 0x0C, 0x0C, 0x0C, 0xF0, 0x08, 0x0C, 0x0C, 0x18, 0x18, 0x10, 0x10,
  0x10, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x08, 0x08, 0x08, 0x18,
  0x30, 0x30, 0x30, 0x0F, 0x10, 0x30, 0x30, 0x18, 0x18, 0x08, 0x08, 0x08,
  0xF8, 0x30, 0x52, 0x3C, 0x4A, 0x0C,
};

const GFXglyph IBMPlexMono_Regular20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 2, 14, 12, 5, -14 },
  { 5, 6, 6, 12, 3, -15 },
  { 10, 12, 14, 12, 0, -14 },
  { 31, 10, 18, 12, 1, -16 },
  { 54, 12, 14, 12, 0, -14 },
  { 75, 11, 14, 12, 0, -14 },
  { 95, 2, 6, 12, 5, -15 },
  { 97, 6, 18, 12, 4, -15 },
  { 111, 6, 18, 12, 2, -15 },
  { 125, 10, 10, 12, 1, -11 },
  { 138, 10, 9, 12, 1, -11 },
  { 150, 4, 6, 12, 4, -3 },
  { 153, 6, 1, 12, 3, -7 },
  { 154, 2, 3, 12, 5, -3 },
  { 155, 8, 18, 12, 2, -15 },
  { 173, 10, 14, 12, 1, -14 },
  { 191, 10, 14, 12, 1, -14 },
  { 209, 10, 14, 12, 1, -14 },
  { 227, 9, 14, 12, 1, -14 },
  { 243, 10, 14, 12, 1, -14 },
  { 261, 10, 14, 12, 1, -14 },
  { 279, 10, 14, 12, 1, -14 },
  { 297, 10, 14, 12, 1, -14 },
  { 315, 10, 14, 12, 1, -14 },
  { 333, 10, 14, 12, 1, -14 },
  { 351, 2, 11, 12, 5, -11 },
  { 354, 4, 14, 12, 4, -11 },
  { 361, 8, 12, 12, 2, -12 },
  { 373, 10, 5, 12, 1, -9 },
  { 380, 8, 12, 12, 2, -12 },
  { 392, 8, 14, 12, 2, -14 },
  { 406, 10, 16, 12, 1, -14 },
  { 426, 10, 14, 12, 1, -14 },
  { 444, 9, 14, 12, 2, -14 },
  { 460, 10, 14, 12, 1, -14 },
  { 478, 9, 14, 12, 2, -14 },
  { 494, 8, 14, 12, 2, -14 },
  { 508, 9, 14, 12, 2, -14 },
  { 524, 9, 14, 12, 1, -14 },
  { 540, 8, 14, 12, 2, -14 },
  { 554, 8, 14, 12, 2, -14 },
  { 568, 9, 14, 12, 1, -14 },
  { 584, 10, 14, 12, 2, -14 },
  { 602, 9, 14, 12, 2, -14 },
  { 618, 10, 14, 12, 1, -14 },
  { 636, 8, 14, 12, 2, -14 },
  { 650, 10, 14, 12, 1, -14 },
  { 668, 9, 14, 12, 2, -14 },
  { 684, 10, 17, 12, 1, -14 },
  { 706, 9, 14, 12, 2, -14 },
  { 722, 10, 14, 12, 1, -14 },
  { 740, 12, 14, 12, 0, -14 },
  { 761, 8, 14, 12, 2, -14 },
  { 775, 10, 14, 12, 1, -14 },
  { 793, 10, 14, 12, 1, -14 },
  { 811, 11, 14, 12, 1, -14 },
  { 831, 12, 14, 12, 0, -14 },
  { 852, 10, 14, 12, 1, -14 },
  { 870, 6, 18, 12, 4, -15 },
  { 884, 8, 18, 12, 2, -15 },
  { 902, 6, 18, 12, 2, -15 },
  { 916, 10, 8, 12, 1, -14 },
  { 926, 10, 1, 12, 1, 2 },
  { 928, 3, 4, 12, 4, -16 },
  { 930, 10, 10, 12, 1, -10 },
  { 943, 9, 15, 12, 2, -15 },
  { 960, 8, 10, 12, 2, -10 },
  { 970, 9, 15, 12, 1, -15 },
  { 987, 10, 10, 12, 1, -10 },
  { 1000, 10, 15, 12, 1, -15 },
  { 1019, 10, 15, 12, 1, -11 },
  { 1038, 8, 15, 12, 2, -15 },
  { 1053, 9, 14, 12, 2, -14 },
  { 1069, 7, 18, 12, 2, -14 },
  { 1085, 9, 15, 12, 2, -15 },
  { 1102, 8, 15, 12, 2, -15 },
  { 1117, 10, 10, 12, 1, -10 },
  { 1130, 8, 10, 12, 2, -10 },
  { 1140, 10, 10, 12, 1, -10 },
  { 1153, 9, 14, 12, 2, -10 },
  { 1169, 9, 14, 12, 1, -10 },
  { 1185, 9, 10, 12, 2, -10 },
  { 1197, 9, 10, 12, 1, -10 },
  { 1209, 10, 14, 12, 1, -14 },
  { 1227, 8, 10, 12, 2, -10 },
  { 1237, 10, 10, 12, 1, -10 },
  { 1250, 10, 10, 12, 1, -10 },
  { 1263, 10, 10, 12, 1, -10 },
  { 1276, 10, 14, 12, 1, -10 },
  { 1294, 8, 10, 12, 2, -10 },
  { 1304, 8, 18, 12, 2, -15 },
  { 1322, 2, 18, 12, 5, -15 },
  { 1327, 8, 18, 12, 2, -15 },
  { 1345, 10, 4, 12, 1, -8 },
};

const GFXfont IBMPlexMono_Regular20pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular20pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular20pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _IBMPLEXMONO_REGULAR20PT7B_H_
