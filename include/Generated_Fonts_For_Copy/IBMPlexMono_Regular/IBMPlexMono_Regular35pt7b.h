#ifndef _IBMPLEXMONO_REGULAR35PT7B_H_
#define _IBMPLEXMONO_REGULAR35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular35pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x42, 0x10, 0x80, 0x00,
  0x00, 0xEF, 0xFF, 0xEE, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC7, 0xE3, 0xF1, 0xC0, 0x01, 0xC7, 0x00, 0x30, 0xE0, 0x06, 0x1C, 0x00,
  0xC3, 0x80, 0x38, 0x60, 0x07, 0x0C, 0x00, 0xE3, 0x80, 0x18, 0x70, 0x7F,
  0x0F, 0xEF, 0xE1, 0xFC, 0x1C, 0x30, 0x03, 0x86, 0x00, 0x61, 0xC0, 0x0C,
  0x38, 0x3F, 0x87, 0xF7, 0xF0, 0xFE, 0x0E, 0x18, 0x01, 0xC7, 0x00, 0x30,
  0xE0, 0x06, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0x60, 0x07, 0x0C, 0x00, 0xE3,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x7F, 0x80,
  0xFF, 0xF0, 0xF3, 0x3C, 0xE1, 0x87, 0x70, 0xC1, 0x38, 0x60, 0x18, 0x30,
  0x0E, 0x18, 0x07, 0x0C, 0x03, 0xC6, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x67, 0x80, 0x31, 0xE0, 0x18, 0x70, 0x0C, 0x38, 0x06, 0x1D,
  0x03, 0x0E, 0xC1, 0x87, 0xF0, 0xC7, 0xBE, 0x67, 0x8F, 0xFF, 0x81, 0xFF,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x1E, 0x00, 0x6F,
  0xF0, 0x1F, 0x86, 0x07, 0x60, 0xE0, 0xEC, 0x0C, 0x39, 0x81, 0x86, 0x30,
  0x31, 0xC6, 0x06, 0x30, 0xC1, 0xCE, 0x1C, 0x31, 0x81, 0xFE, 0x70, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x0E, 0x7F, 0x81, 0x8C, 0x38, 0x73, 0x83, 0x0C,
  0x60, 0x63, 0x8C, 0x0C, 0x61, 0x81, 0x9C, 0x30, 0x37, 0x07, 0x06, 0xE0,
  0x61, 0xF8, 0x0F, 0xF6, 0x00, 0x78, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x70,
  0xF0, 0x0C, 0x0E, 0x03, 0x81, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x81, 0xF3, 0xB8,
  0x3E, 0xE3, 0x86, 0x18, 0x38, 0xC7, 0x07, 0x38, 0xE0, 0x76, 0x1C, 0x07,
  0xC3, 0x80, 0x78, 0x70, 0x07, 0x0F, 0x01, 0x70, 0xF0, 0x67, 0x0F, 0xF8,
  0xF0, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x18, 0x07, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0,
  0x18, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x81, 0xC0, 0x9E, 0x38, 0xF3, 0xFF, 0xFE, 0x9F, 0xFF,
  0x20, 0x7F, 0x00, 0x07, 0xC0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x0E, 0x38,
  0x03, 0x83, 0x80, 0xE0, 0x38, 0x0C, 0x06, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x3E, 0x78, 0xF3, 0xC7, 0x8E, 0x1C,
  0x38, 0xE1, 0xC0, 0xFF, 0xFF, 0xFC, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0x07, 0xF0,
  0x07, 0xFC, 0x0F, 0x07, 0x87, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x39, 0x80,
  0x0D, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x70, 0xFC, 0x7C, 0x7E,
  0x3E, 0x3F, 0x0E, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xB0, 0x01,
  0x9C, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0xE1, 0xE0, 0xF0, 0x7F, 0xE0, 0x0F,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xB8, 0x03, 0x9C, 0x07, 0x8E, 0x07,
  0x87, 0x03, 0x83, 0x80, 0x81, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01,
  0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0x07, 0x0E, 0x01,
  0xC7, 0x00, 0xE7, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x1F, 0xF8, 0x7C,
  0x3C, 0x70, 0x0E, 0x20, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x3C, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x40, 0x07, 0xE0,
  0x0E, 0x78, 0x1E, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x37, 0x00, 0x0E, 0xE0, 0x03, 0x9C, 0x00, 0x63, 0x80,
  0x1C, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x38, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x70, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0xE0, 0x0E, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x7F, 0xFE, 0x7F, 0xFE, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x63, 0xE0,
  0xEF, 0xF8, 0xF8, 0x3C, 0xE0, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x40, 0x0E, 0xE0, 0x1E, 0xF8, 0x3C,
  0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x39,
  0xF8, 0x1D, 0xFF, 0x0D, 0x83, 0xCF, 0x80, 0xF7, 0x80, 0x3B, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xDC, 0x00, 0xCE, 0x00, 0xE3, 0x80,
  0xF1, 0xE0, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x73, 0x80, 0x38, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0x07, 0x8F, 0x01, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0,
  0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x18, 0x07, 0x07, 0x07, 0x01, 0xFF, 0x00,
  0xFF, 0x81, 0xE0, 0xF1, 0xC0, 0x1D, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x77, 0x00, 0x73, 0xE0, 0xF8, 0x7F, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x0F, 0xFE, 0x0F, 0x07, 0x8F, 0x01, 0xC7, 0x00, 0x77,
  0x80, 0x1B, 0x80, 0x0D, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xDC, 0x01,
  0xEF, 0x01, 0xF3, 0xC1, 0xB0, 0xFF, 0xB8, 0x1F, 0x9C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xDF, 0xFF, 0xDC, 0x38, 0xF9, 0xF3, 0xE3, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x9E, 0x3C, 0xF1, 0xE3, 0x87, 0x0E, 0x38,
  0x70, 0x00, 0x02, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x03, 0x80, 0x04, 0x00,
  0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xE0, 0xF7, 0x80, 0xEE, 0x00, 0xEC, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x1F, 0xC0, 0x3E, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xF0,
  0x0F, 0xFC, 0x1C, 0x1E, 0x38, 0x0E, 0x30, 0x07, 0x70, 0x07, 0x60, 0x03,
  0x60, 0xF3, 0xE1, 0xFB, 0xE3, 0x87, 0xE3, 0x83, 0xE3, 0x03, 0xE3, 0x03,
  0xE3, 0x03, 0xE3, 0x03, 0xE3, 0x03, 0xE3, 0x03, 0xE3, 0x03, 0xE3, 0x87,
  0x61, 0xFF, 0x60, 0xFB, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xC6, 0x00, 0x38,
  0xE0, 0x07, 0x1C, 0x00, 0xC3, 0x80, 0x38, 0x38, 0x07, 0x07, 0x00, 0xE0,
  0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0x00,
  0x70, 0xE0, 0x0E, 0x38, 0x01, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00,
  0x77, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0,
  0x3C, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x1E, 0xFF,
  0xFC, 0xFF, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0x07, 0x83, 0xC7, 0x80, 0xE3,
  0x80, 0x3B, 0x80, 0x11, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x87, 0x00, 0x73, 0xC0, 0x70,
  0xF0, 0x78, 0x3F, 0xF8, 0x07, 0xF0, 0xFF, 0xC0, 0xFF, 0xF0, 0xE0, 0x78,
  0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C,
  0xE0, 0x38, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1C, 0x1E, 0x38, 0x0F, 0x70,
  0x07, 0x70, 0x02, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x38, 0x0F, 0x3C, 0x1B, 0x1F,
  0xF3, 0x07, 0xE3, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0xFF,
  0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x74, 0x01, 0xF8, 0x07, 0xE0, 0x39, 0xC1, 0xC7,
  0xFE, 0x07, 0xF0, 0xE0, 0x07, 0xF0, 0x07, 0xB8, 0x07, 0x9C, 0x07, 0x8E,
  0x03, 0x87, 0x03, 0x83, 0x83, 0x81, 0xC3, 0xC0, 0xE3, 0xC0, 0x73, 0xC0,
  0x39, 0xE0, 0x1D, 0xF0, 0x0F, 0xDC, 0x07, 0xCF, 0x03, 0xE3, 0x81, 0xE1,
  0xE0, 0xE0, 0x70, 0x70, 0x1C, 0x38, 0x0F, 0x1C, 0x03, 0x8E, 0x00, 0xE7,
  0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF,
  0xC1, 0xFF, 0x60, 0xDF, 0xB8, 0xEF, 0xCC, 0x67, 0xE7, 0x33, 0xF3, 0xB9,
  0xF8, 0xD8, 0xFC, 0x7C, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC1,
  0x07, 0xE0, 0x83, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3D, 0xC0, 0x7B, 0x80, 0xF3, 0x81, 0xE7, 0x03, 0xC6, 0x07, 0x8E,
  0x0F, 0x1C, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x38, 0xF0, 0x71, 0xE0, 0x63,
  0xC0, 0xE7, 0x81, 0xCF, 0x01, 0xDE, 0x03, 0xBC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x0F, 0x07, 0xF0, 0x07, 0xFC, 0x0F, 0x07, 0x87, 0x01, 0xC7,
  0x00, 0x73, 0x80, 0x39, 0x80, 0x0D, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xB0, 0x01, 0x9C, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0xE1,
  0xE0, 0xF0, 0x7F, 0xE0, 0x0F, 0xE0, 0xFF, 0xF0, 0xFF, 0xFC, 0xE0, 0x1E,
  0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0E, 0xE0, 0x1E, 0xFF, 0xFC, 0xFF, 0xF0, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x0F, 0x07,
  0x07, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x39, 0x80, 0x0D, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xB0, 0x01, 0x9C, 0x01, 0xCE, 0x00,
  0xE3, 0x80, 0xE1, 0xE0, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0xFF, 0xF0, 0xFF, 0xFC,
  0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x1E, 0xFF, 0xFC, 0xFF, 0xF0, 0xE1, 0xC0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x78, 0xE0, 0x38, 0xE0, 0x3C,
  0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0x07, 0xF8, 0x0F, 0xFF,
  0x0F, 0x07, 0xCE, 0x00, 0xF7, 0x00, 0x27, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0xF8, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xD0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x73, 0xE0, 0xF8, 0xFF, 0xF0, 0x1F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x77, 0x01, 0xCF,
  0x07, 0x8F, 0xFE, 0x07, 0xF0, 0xF0, 0x00, 0xEE, 0x00, 0x39, 0xC0, 0x07,
  0x38, 0x00, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x18,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x07, 0x00, 0xE0, 0xE0,
  0x1C, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0x63, 0x00,
  0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x76,
  0x00, 0x0C, 0xC0, 0x01, 0x98, 0x38, 0x33, 0x07, 0x86, 0x61, 0xF0, 0xCE,
  0x36, 0x39, 0xC6, 0xC7, 0x38, 0xD8, 0xE7, 0x3B, 0x9C, 0xE7, 0x73, 0x9C,
  0xC6, 0x73, 0x98, 0xCE, 0x33, 0x19, 0x86, 0xE3, 0xB0, 0xDC, 0x76, 0x1B,
  0x06, 0xC3, 0x60, 0xD8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0xF0,
  0x01, 0xEF, 0x00, 0x38, 0xE0, 0x0E, 0x0E, 0x03, 0xC1, 0xC0, 0x70, 0x1C,
  0x1C, 0x01, 0xC3, 0x80, 0x38, 0xE0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x07,
  0xC0, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xEE, 0x00, 0x3C,
  0xE0, 0x07, 0x1C, 0x01, 0xC1, 0xC0, 0x78, 0x3C, 0x0E, 0x03, 0x83, 0x80,
  0x38, 0x70, 0x07, 0x9C, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x3D, 0xC0, 0x07, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x38, 0x0E, 0x07, 0x81,
  0xC0, 0x70, 0x70, 0x0F, 0x1E, 0x00, 0xE3, 0x80, 0x0E, 0xE0, 0x01, 0xDC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0xEE,
  0x00, 0xE3, 0x80, 0x71, 0xC0, 0x70, 0x70, 0x38, 0x38, 0x38, 0x0E, 0x18,
  0x07, 0x1C, 0x01, 0xCC, 0x00, 0x6E, 0x00, 0x3E, 0x00, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x47, 0x38, 0xE3, 0x1C, 0x40, 0x0F, 0xE0, 0x1F, 0xFC,
  0x1E, 0x0F, 0x0E, 0x03, 0x82, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x0F, 0xFE, 0x1F, 0xFF, 0x1E, 0x03, 0x9E, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0x71, 0xC0, 0x78, 0xF0, 0x7C, 0x3F, 0xE7, 0x87, 0xC3, 0xC0, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE3, 0xE0, 0xEF, 0xF8, 0xF8, 0x3C, 0xF0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xF0, 0x0E, 0xF8, 0x3C, 0xEF,
  0xF8, 0xE3, 0xE0, 0x07, 0xE0, 0x3F, 0xF0, 0xF0, 0xF3, 0x80, 0x77, 0x00,
  0x9C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x9C, 0x03, 0x9E, 0x0E, 0x1F, 0xF8, 0x0F,
  0xE0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x0F, 0xC7, 0x1F, 0xF7, 0x3C, 0x17, 0x70,
  0x0F, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x3C,
  0x17, 0x1F, 0xF7, 0x0F, 0xC7, 0x03, 0xF0, 0x07, 0xFC, 0x07, 0x07, 0x87,
  0x01, 0xC7, 0x00, 0x73, 0x80, 0x39, 0x80, 0x0D, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x10, 0xE0,
  0x1C, 0x38, 0x3C, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x01, 0xFF,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFE, 0xFF, 0xFE,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x7E, 0x80, 0x3F, 0xF0, 0x1C, 0x1E, 0x0E,
  0x03, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x0C, 0x03, 0x83, 0x80,
  0xE0, 0xF0, 0x70, 0x1F, 0xF8, 0x01, 0xF8, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x40, 0x0E, 0x60, 0x01, 0xB8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0E, 0x78, 0x07, 0x8F, 0xFF, 0xC0, 0xFF,
  0x80, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE3, 0xE1, 0xDF, 0xF3, 0xA0, 0xF7, 0x80, 0xEE,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1C, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xCF, 0xFC, 0x7F, 0xC0, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x1E, 0xC0, 0x3C, 0xC0, 0x78, 0xC0, 0xF0, 0xC1, 0xC0, 0xC3,
  0x80, 0xC7, 0x00, 0xCF, 0x00, 0xFF, 0x80, 0xFB, 0xC0, 0xF1, 0xC0, 0xC0,
  0xE0, 0xC0, 0xF0, 0xC0, 0x78, 0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x1E, 0xC0,
  0x0F, 0xFF, 0x81, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFC, 0xCF, 0x1E, 0x6F, 0xDF, 0xB8, 0xE8, 0xFC, 0x38, 0x7E, 0x1C,
  0x3E, 0x0E, 0x1F, 0x07, 0x07, 0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0,
  0x70, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x83, 0x83,
  0xC1, 0xC1, 0xE0, 0xE0, 0xC0, 0xE3, 0xE1, 0xDF, 0xF3, 0xA0, 0xF7, 0x80,
  0xEE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1C, 0x07, 0xF0, 0x07, 0xFC, 0x0F, 0x07, 0x87, 0x01, 0xC7,
  0x00, 0x73, 0x80, 0x39, 0x80, 0x0D, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xEC, 0x00, 0x67, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x38, 0x78,
  0x3C, 0x0F, 0xF8, 0x01, 0xF0, 0x00, 0xE3, 0xE0, 0xEF, 0xF8, 0xF8, 0x3C,
  0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xF0, 0x0E,
  0xF8, 0x3C, 0xEF, 0xF8, 0xE3, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0xC7, 0x1F, 0xF7,
  0x3C, 0x17, 0x70, 0x0F, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07,
  0x70, 0x0F, 0x3C, 0x17, 0x1F, 0xF7, 0x0F, 0xC7, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xFF, 0x1F,
  0xFF, 0x9F, 0xC1, 0xD8, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xFF, 0xFE, 0x7F, 0xFF,
  0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3C, 0x0F, 0x38, 0x06, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3E, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x20, 0x07, 0x70, 0x07, 0xFC, 0x0E, 0x1F, 0xFC, 0x07,
  0xF0, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xDC, 0x07, 0xBC, 0x17, 0x3F, 0xEE,
  0x1F, 0x1C, 0xE0, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE3, 0x80,
  0xE1, 0xC0, 0x70, 0x60, 0x30, 0x38, 0x38, 0x1C, 0x1C, 0x06, 0x0C, 0x03,
  0x8E, 0x01, 0xC7, 0x00, 0x63, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x06, 0xC0,
  0x03, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0xC3,
  0xB0, 0xD8, 0x66, 0x1B, 0x0C, 0xC3, 0x61, 0x98, 0x6C, 0x33, 0x0C, 0xC6,
  0x73, 0x19, 0xC6, 0x63, 0x38, 0xCC, 0x66, 0x19, 0x8C, 0xC3, 0x31, 0x98,
  0x6C, 0x1B, 0x0D, 0x83, 0x61, 0xF0, 0x6C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0,
  0xF0, 0x07, 0xBC, 0x07, 0x8E, 0x03, 0x83, 0x83, 0x80, 0xE3, 0x80, 0x79,
  0xC0, 0x1D, 0xC0, 0x07, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xEE, 0x00, 0xE3, 0x80, 0xF1, 0xE0, 0x70, 0x70, 0x70, 0x1C, 0x70, 0x0F,
  0x78, 0x03, 0xC0, 0xE0, 0x03, 0xF0, 0x01, 0xDC, 0x01, 0xCE, 0x00, 0xE3,
  0x80, 0x61, 0xC0, 0x70, 0x60, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x07, 0x0C,
  0x03, 0x8E, 0x00, 0xC6, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0xC3, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x1F, 0xC0, 0xFE, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xF8, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0x7F, 0x03, 0xF8, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC3,
  0xFC, 0x1F, 0xE0, 0x1E, 0x01, 0x9F, 0x80, 0xDC, 0xE0, 0xEC, 0x38, 0x6E,
  0x0E, 0x76, 0x03, 0xF3, 0x00, 0xF0,
};

const GFXglyph IBMPlexMono_Regular35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 24, 21, 8, -24 },
  { 16, 9, 10, 21, 6, -26 },
  { 28, 19, 24, 21, 1, -24 },
  { 85, 17, 32, 21, 2, -28 },
  { 153, 19, 24, 21, 1, -24 },
  { 210, 19, 24, 21, 1, -24 },
  { 267, 3, 10, 21, 9, -26 },
  { 271, 10, 32, 21, 7, -27 },
  { 311, 10, 32, 21, 4, -27 },
  { 351, 19, 17, 21, 1, -20 },
  { 392, 17, 16, 21, 2, -19 },
  { 426, 7, 10, 21, 7, -5 },
  { 435, 11, 2, 21, 5, -12 },
  { 438, 5, 5, 21, 8, -5 },
  { 442, 15, 32, 21, 3, -27 },
  { 502, 17, 24, 21, 2, -24 },
  { 553, 17, 24, 21, 2, -24 },
  { 604, 17, 24, 21, 2, -24 },
  { 655, 16, 24, 21, 2, -24 },
  { 703, 19, 24, 21, 1, -24 },
  { 760, 16, 24, 21, 3, -24 },
  { 808, 17, 24, 21, 2, -24 },
  { 859, 17, 24, 21, 2, -24 },
  { 910, 17, 24, 21, 2, -24 },
  { 961, 17, 24, 21, 2, -24 },
  { 1012, 5, 19, 21, 8, -19 },
  { 1024, 7, 24, 21, 7, -19 },
  { 1045, 15, 20, 21, 3, -21 },
  { 1083, 17, 9, 21, 2, -15 },
  { 1103, 15, 20, 21, 3, -21 },
  { 1141, 15, 24, 21, 3, -24 },
  { 1186, 16, 28, 21, 2, -24 },
  { 1242, 19, 24, 21, 1, -24 },
  { 1299, 16, 24, 21, 3, -24 },
  { 1347, 17, 24, 21, 2, -24 },
  { 1398, 16, 24, 21, 3, -24 },
  { 1446, 15, 24, 21, 3, -24 },
  { 1491, 16, 24, 21, 3, -24 },
  { 1539, 16, 24, 21, 2, -24 },
  { 1587, 15, 24, 21, 3, -24 },
  { 1632, 15, 24, 21, 3, -24 },
  { 1677, 14, 24, 21, 3, -24 },
  { 1719, 17, 24, 21, 3, -24 },
  { 1770, 15, 24, 21, 4, -24 },
  { 1815, 17, 24, 21, 2, -24 },
  { 1866, 15, 24, 21, 3, -24 },
  { 1911, 17, 24, 21, 2, -24 },
  { 1962, 16, 24, 21, 3, -24 },
  { 2010, 17, 29, 21, 2, -24 },
  { 2072, 16, 24, 21, 3, -24 },
  { 2120, 17, 24, 21, 2, -24 },
  { 2171, 19, 24, 21, 1, -24 },
  { 2228, 15, 24, 21, 3, -24 },
  { 2273, 19, 24, 21, 1, -24 },
  { 2330, 19, 24, 21, 1, -24 },
  { 2387, 19, 24, 21, 1, -24 },
  { 2444, 19, 24, 21, 1, -24 },
  { 2501, 17, 24, 21, 2, -24 },
  { 2552, 10, 32, 21, 8, -27 },
  { 2592, 15, 32, 21, 3, -27 },
  { 2652, 10, 32, 21, 3, -27 },
  { 2692, 17, 14, 21, 2, -24 },
  { 2722, 17, 2, 21, 2, 4 },
  { 2727, 5, 7, 21, 7, -27 },
  { 2732, 17, 18, 21, 2, -18 },
  { 2771, 16, 26, 21, 3, -26 },
  { 2823, 15, 18, 21, 3, -18 },
  { 2857, 16, 26, 21, 2, -26 },
  { 2909, 17, 18, 21, 2, -18 },
  { 2948, 16, 26, 21, 3, -26 },
  { 3000, 18, 27, 21, 2, -20 },
  { 3061, 15, 26, 21, 3, -26 },
  { 3110, 15, 26, 21, 4, -26 },
  { 3159, 13, 33, 21, 3, -26 },
  { 3213, 16, 26, 21, 4, -26 },
  { 3265, 15, 26, 21, 3, -26 },
  { 3314, 17, 18, 21, 2, -18 },
  { 3353, 15, 18, 21, 3, -18 },
  { 3387, 17, 18, 21, 2, -18 },
  { 3426, 16, 25, 21, 3, -18 },
  { 3476, 16, 25, 21, 2, -18 },
  { 3526, 17, 18, 21, 3, -18 },
  { 3565, 16, 18, 21, 2, -18 },
  { 3601, 17, 24, 21, 1, -24 },
  { 3652, 15, 18, 21, 3, -18 },
  { 3686, 17, 18, 21, 2, -18 },
  { 3725, 19, 18, 21, 1, -18 },
  { 3768, 17, 18, 21, 2, -18 },
  { 3807, 17, 25, 21, 2, -18 },
  { 3861, 15, 18, 21, 3, -18 },
  { 3895, 13, 32, 21, 4, -27 },
  { 3947, 3, 32, 21, 9, -27 },
  { 3959, 13, 32, 21, 4, -27 },
  { 4011, 17, 7, 21, 2, -14 },
};

const GFXfont IBMPlexMono_Regular35pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular35pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _IBMPLEXMONO_REGULAR35PT7B_H_
