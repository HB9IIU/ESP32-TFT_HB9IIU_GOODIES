#ifndef _IBMPLEXMONO_REGULAR27PT7B_H_
#define _IBMPLEXMONO_REGULAR27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular27pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x62, 0x00, 0x07, 0xFF, 0x70, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0x80, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x18, 0x02, 0x30, 0x06, 0x30, 0x7E, 0x3F, 0x7E, 0x3F, 0x06, 0x30,
  0x06, 0x30, 0x0C, 0x60, 0xFC, 0x7E, 0xFC, 0x7E, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x01, 0x00, 0x04, 0x00,
  0x10, 0x03, 0xF8, 0x3F, 0xF0, 0xE4, 0xE7, 0x11, 0xD8, 0x40, 0x61, 0x01,
  0xC4, 0x03, 0x90, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x11, 0xC0, 0x43,
  0x01, 0x0D, 0x04, 0x36, 0x11, 0xFE, 0x4E, 0x3F, 0xF0, 0x3F, 0x80, 0x10,
  0x00, 0x40, 0x01, 0x00, 0x1E, 0x07, 0x7F, 0x06, 0x63, 0x0C, 0x41, 0x8C,
  0x41, 0x98, 0x41, 0x98, 0x63, 0x30, 0x7F, 0x30, 0x3E, 0x40, 0x00, 0x00,
  0x00, 0x3C, 0x0E, 0xFE, 0x0C, 0xC6, 0x18, 0xC3, 0x18, 0x83, 0x30, 0x83,
  0x30, 0xC6, 0x60, 0xFE, 0xE0, 0x3C, 0x0F, 0x00, 0x7F, 0x03, 0x8E, 0x1C,
  0x10, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x3C, 0xF8, 0xF6,
  0x63, 0x30, 0xCC, 0xC3, 0xB3, 0x07, 0xCC, 0x0E, 0x30, 0x1C, 0xE0, 0xB1,
  0xFE, 0x63, 0xE1, 0xC0, 0xFF, 0xFC, 0x06, 0x18, 0x61, 0x86, 0x0C, 0x10,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81, 0x03, 0x06,
  0x06, 0x06, 0x06, 0x06, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x06,
  0x06, 0x02, 0x03, 0x03, 0x03, 0x03, 0x03, 0x06, 0x06, 0x06, 0x06, 0x0C,
  0x0C, 0x18, 0x30, 0x70, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x43, 0x0F, 0xED, 0xF3, 0xFF, 0x01, 0xE0, 0x07, 0x80, 0x3B, 0x01, 0xCE,
  0x06, 0x18, 0x30, 0x30, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x03, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x77, 0xEE, 0xEC, 0xCC, 0xFF, 0xFF, 0x7F, 0xF7, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0xE0,
  0x00, 0x1F, 0x81, 0xFE, 0x1C, 0x38, 0xC0, 0xEC, 0x03, 0x60, 0x1B, 0x00,
  0xD8, 0x07, 0xC7, 0x3E, 0x79, 0xF1, 0xCF, 0x80, 0x7C, 0x03, 0x60, 0x1B,
  0x00, 0xCC, 0x0E, 0x70, 0xE1, 0xFE, 0x03, 0xE0, 0x07, 0x80, 0x3E, 0x01,
  0xD8, 0x0E, 0x60, 0x71, 0x83, 0x86, 0x04, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x81, 0xFF, 0xF7, 0xFF, 0xC0, 0x1F, 0x81, 0xFE, 0x1C, 0x39, 0xC0,
  0xCC, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x0F, 0xC1, 0xFF, 0x0E, 0x1C, 0xC0, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x0C, 0x0F, 0xC0, 0x7E, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0D,
  0x00, 0xEC, 0x07, 0xF0, 0x71, 0xFF, 0x03, 0xE0, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xD8, 0x06, 0x60, 0x19, 0x80, 0xC6, 0x06, 0x18, 0x18, 0x60,
  0xC1, 0x87, 0x06, 0x18, 0x18, 0xC0, 0x63, 0xFF, 0xFF, 0xFF, 0xC0, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x7F, 0xF7, 0xFF, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0xF8, 0x7F, 0xE7, 0x0F, 0x20, 0x70, 0x03,
  0x00, 0x30, 0x03, 0x40, 0x3C, 0x07, 0x70, 0xE3, 0xFC, 0x1F, 0x80, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x06, 0x78, 0xDF,
  0xEF, 0x0F, 0xE0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x07, 0x70,
  0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x07, 0xC0, 0x6C,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x00, 0x0F, 0xC0, 0xFF,
  0xC3, 0x87, 0x9C, 0x06, 0x60, 0x19, 0x80, 0x67, 0x01, 0x8E, 0x1C, 0x1F,
  0xE0, 0x7F, 0x83, 0x83, 0x18, 0x06, 0x60, 0x1F, 0x80, 0x76, 0x01, 0xD8,
  0x06, 0x78, 0x38, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xFC, 0x70, 0xEE,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x77, 0x0F, 0x7F, 0xB1,
  0xF7, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x1C, 0x00,
  0x7F, 0xF7, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x70, 0x7F, 0xF7, 0x00, 0x00,
  0x00, 0x07, 0x7E, 0xEE, 0xCC, 0xC0, 0x00, 0x10, 0x07, 0x00, 0xF0, 0x3C,
  0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x80, 0x0E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x70, 0x0E, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0x80, 0xE0, 0x08, 0x00, 0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x07,
  0xC0, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x0F, 0xC0, 0xE0, 0x0E, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x1F,
  0x83, 0xFC, 0x70, 0xE6, 0x07, 0xC0, 0x3C, 0x03, 0xC3, 0xBC, 0x7F, 0xCE,
  0x3C, 0xC3, 0xCC, 0x3C, 0xC3, 0xCC, 0x3C, 0xC3, 0xCC, 0x3C, 0x7F, 0xC7,
  0xBC, 0x00, 0x60, 0x07, 0x00, 0x3F, 0xC0, 0xFC, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xB0, 0x0C, 0xC0, 0x33, 0x00, 0xCE, 0x07, 0x18, 0x18, 0x60,
  0x61, 0xC3, 0x87, 0x0C, 0x0C, 0x3F, 0xF0, 0xFF, 0xE7, 0x01, 0x98, 0x06,
  0x60, 0x1F, 0x80, 0x3C, 0x00, 0xC0, 0xFF, 0x87, 0xFF, 0x38, 0x19, 0xC0,
  0xEE, 0x03, 0x70, 0x1B, 0x81, 0xDC, 0x0C, 0xFF, 0xC7, 0xFF, 0x38, 0x1D,
  0xC0, 0x6E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x06, 0xE0, 0x77, 0xFF, 0x3F,
  0xF0, 0x0F, 0x81, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x03, 0xF0, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0xCC, 0x07, 0x38, 0x71, 0xFF, 0x03, 0xE0, 0xFF, 0x0F, 0xF8, 0xC1,
  0xCC, 0x0E, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0xC1, 0xCF, 0xF8, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F,
  0x83, 0xFC, 0x70, 0xE6, 0x07, 0xE0, 0x2C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x3F, 0xC3, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x07, 0x70,
  0xF3, 0xFB, 0x1F, 0x30, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0xFF, 0xFF, 0xFF,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xE7, 0xFC, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xD0, 0x1F, 0x07,
  0x71, 0xCF, 0xF8, 0x7C, 0x00, 0xE0, 0x3B, 0x81, 0xCE, 0x06, 0x38, 0x38,
  0xE1, 0xC3, 0x8E, 0x0E, 0x70, 0x39, 0x80, 0xEE, 0x03, 0xFC, 0x0F, 0xB0,
  0x3C, 0xE0, 0xE1, 0xC3, 0x83, 0x0E, 0x0E, 0x38, 0x18, 0xE0, 0x73, 0x80,
  0xEE, 0x01, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x0F,
  0xD8, 0xFD, 0x9B, 0xD9, 0xBC, 0xD3, 0xCF, 0x3C, 0x73, 0xC6, 0x3C, 0x63,
  0xC4, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0xF0,
  0x3F, 0x03, 0xF0, 0x3D, 0x83, 0xD8, 0x3D, 0xC3, 0xCC, 0x3C, 0xC3, 0xC6,
  0x3C, 0x63, 0xC7, 0x3C, 0x33, 0xC3, 0x3C, 0x1B, 0xC1, 0xBC, 0x1F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x70, 0x1F, 0x81, 0xFE, 0x1C, 0x38, 0xC0, 0xEC, 0x03,
  0x60, 0x1B, 0x00, 0xD8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0x60, 0x1B, 0x00, 0xCC, 0x0E, 0x70, 0xE1, 0xFE, 0x03, 0xE0, 0xFF,
  0xC7, 0xFF, 0x38, 0x1D, 0xC0, 0x6E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x06,
  0xE0, 0x77, 0xFF, 0x3F, 0xF1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x1F, 0x81, 0xFE, 0x1C, 0x38, 0xC0,
  0xEC, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0x60, 0x1B, 0x00, 0xDC, 0x0E, 0x70, 0xE1, 0xFE, 0x07,
  0xE0, 0x0C, 0x00, 0x60, 0x03, 0xF0, 0x0F, 0x80, 0xFF, 0xC7, 0xFF, 0x38,
  0x1D, 0xC0, 0x6E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x06, 0xE0, 0x77, 0xFF,
  0x3F, 0xF1, 0xC6, 0x0E, 0x18, 0x70, 0xE3, 0x83, 0x1C, 0x1C, 0xE0, 0x67,
  0x03, 0xB8, 0x0E, 0x0F, 0xC0, 0xFF, 0xC7, 0x83, 0x9C, 0x06, 0x60, 0x01,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x0F, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x74, 0x01, 0xF8, 0x06, 0x78, 0x38, 0xFF, 0xC0, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x36,
  0x07, 0x70, 0xE3, 0xFE, 0x1F, 0x80, 0xE0, 0x0F, 0x80, 0x76, 0x01, 0xD8,
  0x06, 0x70, 0x18, 0xC0, 0xE3, 0x03, 0x0C, 0x0C, 0x38, 0x70, 0x61, 0x81,
  0x86, 0x07, 0x18, 0x0C, 0xE0, 0x33, 0x00, 0xCC, 0x01, 0xB0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x0E, 0x3C, 0x38, 0xD9, 0xE3, 0x67, 0x8D, 0x9A, 0x36, 0x4C, 0x9B,
  0x36, 0x6C, 0xD9, 0xB3, 0x66, 0xC5, 0x9A, 0x1E, 0x78, 0x79, 0xE1, 0xE7,
  0x87, 0x80, 0xE0, 0x0C, 0xE0, 0x30, 0xC0, 0xE1, 0xC1, 0x81, 0x87, 0x03,
  0x9C, 0x03, 0xB0, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x7E,
  0x00, 0xCE, 0x03, 0x8C, 0x06, 0x1C, 0x18, 0x18, 0x70, 0x38, 0xC0, 0x3B,
  0x80, 0x38, 0xE0, 0x07, 0x70, 0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x1C, 0x18,
  0x0C, 0x38, 0x0E, 0x30, 0x06, 0x60, 0x07, 0xE0, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x7F, 0xF9, 0xFF, 0xE0, 0x01, 0x80, 0x0C, 0x00,
  0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x06, 0x00, 0x30, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0xFF, 0xFE, 0x03, 0x80, 0x1E, 0x00, 0xFC, 0x03, 0x30, 0x1C, 0x60,
  0x61, 0x83, 0x03, 0x0C, 0x0C, 0x60, 0x19, 0x80, 0x7C, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC6, 0x63, 0x10, 0x1F, 0x03, 0xFE, 0x38, 0x30, 0x81,
  0xC0, 0x06, 0x00, 0x30, 0xFF, 0x8F, 0xFC, 0xE0, 0x66, 0x03, 0x30, 0x19,
  0xC3, 0xC7, 0xF7, 0x9F, 0x1C, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xCF, 0x0D, 0xFC, 0xE1, 0xEC, 0x06, 0xC0, 0x6C, 0x06, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x06, 0xC0, 0x6E, 0x1E, 0xDF, 0xCC, 0xF0, 0x0F,
  0x83, 0xFC, 0x70, 0x66, 0x03, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x37, 0x06, 0x3F, 0xE0, 0xF8, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x1E, 0x77, 0xFF, 0x70, 0xFE, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x77, 0x0F, 0x7F,
  0xF1, 0xE7, 0x0F, 0x83, 0xFC, 0x70, 0xE6, 0x07, 0xC0, 0x3C, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x60, 0x27, 0x07, 0x3F, 0xE0, 0xF8, 0x03,
  0xF8, 0x3F, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x03, 0xFF, 0xFF, 0xFF,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x3F, 0xFD, 0xFF, 0xE0, 0x00, 0x78, 0x03, 0xC7,
  0xF0, 0x7F, 0x87, 0x0E, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0x70, 0xE1, 0xFE,
  0x07, 0xE0, 0x40, 0x06, 0x00, 0x3F, 0xF0, 0xFF, 0xC8, 0x07, 0xC0, 0x1E,
  0x00, 0xF8, 0x0F, 0xFF, 0xE3, 0xFC, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x33, 0xC6, 0xFE, 0xE1, 0xD8, 0x1F, 0x03, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x30, 0x06,
  0x00, 0xF0, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFE, 0xFE, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x01, 0xD8, 0x18, 0xC3,
  0x86, 0x38, 0x33, 0x81, 0xB8, 0x0F, 0xE0, 0x7B, 0x83, 0x0C, 0x18, 0x70,
  0xC1, 0xC6, 0x07, 0x30, 0x19, 0x80, 0xF0, 0xFE, 0x0F, 0xE0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xCE, 0x7B, 0x7B, 0xEE, 0x39, 0xF8, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C,
  0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F,
  0x0C, 0x30, 0xCF, 0x1B, 0xFB, 0x87, 0x60, 0x7C, 0x0F, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xC0, 0x1F, 0x83,
  0xFC, 0x70, 0xEE, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xE0, 0x77, 0x0E, 0x3F, 0xC1, 0xF8, 0xCF, 0x0D, 0xFC, 0xE1, 0xEC,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x06, 0xC0, 0x6E,
  0x1E, 0xDF, 0xCC, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00,
  0x1E, 0x77, 0xFF, 0x70, 0xFE, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xE0, 0x77, 0x0F, 0x7F, 0xF1, 0xE7, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0xFC, 0x7F, 0xE7, 0xC3, 0x40, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x0F, 0xFF, 0x7F, 0xF8, 0x1F, 0x83, 0xFE, 0x70, 0x76, 0x02, 0x60, 0x07,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x70, 0x03, 0x40, 0x3E, 0x07, 0x7F, 0xE1,
  0xF8, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x7F, 0xFF, 0xFF,
  0xE0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0xC0, 0xFE, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x07, 0x60,
  0x77, 0x0F, 0x3F, 0x71, 0xE7, 0xC0, 0x3C, 0x03, 0x60, 0x76, 0x06, 0x60,
  0x63, 0x0E, 0x30, 0xC3, 0x0C, 0x19, 0x81, 0x98, 0x1D, 0x80, 0xF0, 0x0F,
  0x00, 0x70, 0xC3, 0x0F, 0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0x8D, 0x12,
  0x36, 0x4C, 0x9B, 0x32, 0x6C, 0xD9, 0xB1, 0x66, 0x85, 0x8A, 0x1E, 0x38,
  0x70, 0xE1, 0xC0, 0xE0, 0x33, 0x03, 0x0C, 0x38, 0x73, 0x81, 0xD8, 0x07,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x80, 0xCC, 0x0E, 0x70, 0xE1, 0xC6, 0x06,
  0x60, 0x1C, 0xE0, 0x1D, 0x80, 0x67, 0x01, 0x8C, 0x0C, 0x30, 0x30, 0x61,
  0xC1, 0x86, 0x03, 0x18, 0x0C, 0xC0, 0x3B, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xC7, 0xF1,
  0x80, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x63, 0xF0,
  0xFC, 0x01, 0x80, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x7F, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFC, 0x3F, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x3F, 0x0F, 0xC6, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x01, 0x80, 0x63, 0xF8, 0xFC, 0x00, 0x1C, 0x0C, 0xF8, 0x36,
  0x71, 0x98, 0xE6, 0x41, 0xF3, 0x03, 0x80,
};

const GFXglyph IBMPlexMono_Regular27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 19, 16, 6, -19 },
  { 11, 7, 7, 16, 5, -20 },
  { 18, 16, 19, 16, 0, -19 },
  { 56, 14, 25, 16, 1, -22 },
  { 100, 16, 19, 16, 0, -19 },
  { 138, 14, 19, 16, 1, -19 },
  { 172, 2, 7, 16, 7, -20 },
  { 174, 7, 25, 16, 6, -21 },
  { 196, 8, 25, 16, 3, -21 },
  { 221, 14, 13, 16, 1, -15 },
  { 244, 13, 14, 16, 2, -15 },
  { 267, 4, 8, 16, 6, -4 },
  { 271, 8, 2, 16, 4, -9 },
  { 273, 4, 4, 16, 6, -4 },
  { 275, 12, 25, 16, 2, -21 },
  { 313, 13, 19, 16, 2, -19 },
  { 344, 14, 19, 16, 1, -19 },
  { 378, 13, 19, 16, 2, -19 },
  { 409, 13, 19, 16, 1, -19 },
  { 440, 14, 19, 16, 1, -19 },
  { 474, 12, 19, 16, 2, -19 },
  { 503, 12, 19, 16, 2, -19 },
  { 532, 12, 19, 16, 2, -19 },
  { 561, 14, 19, 16, 1, -19 },
  { 595, 12, 19, 16, 2, -19 },
  { 624, 4, 15, 16, 6, -15 },
  { 632, 4, 19, 16, 6, -15 },
  { 642, 12, 16, 16, 2, -16 },
  { 666, 13, 7, 16, 2, -12 },
  { 678, 12, 16, 16, 2, -16 },
  { 702, 12, 19, 16, 2, -19 },
  { 731, 12, 22, 16, 2, -19 },
  { 764, 14, 19, 16, 1, -19 },
  { 798, 13, 19, 16, 2, -19 },
  { 829, 13, 19, 16, 2, -19 },
  { 860, 12, 19, 16, 3, -19 },
  { 889, 12, 19, 16, 2, -19 },
  { 918, 12, 19, 16, 2, -19 },
  { 947, 12, 19, 16, 2, -19 },
  { 976, 12, 19, 16, 2, -19 },
  { 1005, 12, 19, 16, 2, -19 },
  { 1034, 11, 19, 16, 2, -19 },
  { 1061, 14, 19, 16, 2, -19 },
  { 1095, 11, 19, 16, 3, -19 },
  { 1122, 12, 19, 16, 2, -19 },
  { 1151, 12, 19, 16, 2, -19 },
  { 1180, 13, 19, 16, 2, -19 },
  { 1211, 13, 19, 16, 2, -19 },
  { 1242, 13, 23, 16, 2, -19 },
  { 1280, 13, 19, 16, 2, -19 },
  { 1311, 14, 19, 16, 1, -19 },
  { 1345, 15, 19, 16, 1, -19 },
  { 1381, 12, 19, 16, 2, -19 },
  { 1410, 14, 19, 16, 1, -19 },
  { 1444, 14, 19, 16, 1, -19 },
  { 1478, 15, 19, 16, 1, -19 },
  { 1514, 16, 19, 16, 0, -19 },
  { 1552, 14, 19, 16, 1, -19 },
  { 1586, 8, 25, 16, 6, -21 },
  { 1611, 12, 25, 16, 2, -21 },
  { 1649, 7, 25, 16, 3, -21 },
  { 1671, 14, 11, 16, 1, -19 },
  { 1691, 13, 2, 16, 2, 3 },
  { 1695, 4, 5, 16, 5, -21 },
  { 1698, 13, 14, 16, 2, -14 },
  { 1721, 12, 20, 16, 3, -20 },
  { 1751, 12, 14, 16, 2, -14 },
  { 1772, 12, 20, 16, 2, -20 },
  { 1802, 12, 14, 16, 2, -14 },
  { 1823, 13, 20, 16, 2, -20 },
  { 1856, 13, 21, 16, 2, -16 },
  { 1891, 11, 20, 16, 3, -20 },
  { 1919, 12, 20, 16, 3, -20 },
  { 1949, 9, 25, 16, 3, -20 },
  { 1978, 13, 20, 16, 3, -20 },
  { 2011, 12, 20, 16, 2, -20 },
  { 2041, 14, 14, 16, 1, -14 },
  { 2066, 11, 14, 16, 3, -14 },
  { 2086, 12, 14, 16, 2, -14 },
  { 2107, 12, 19, 16, 3, -14 },
  { 2136, 12, 19, 16, 2, -14 },
  { 2165, 13, 14, 16, 2, -14 },
  { 2188, 12, 14, 16, 2, -14 },
  { 2209, 13, 19, 16, 1, -19 },
  { 2240, 12, 14, 16, 2, -14 },
  { 2261, 12, 14, 16, 2, -14 },
  { 2282, 14, 14, 16, 1, -14 },
  { 2307, 13, 14, 16, 2, -14 },
  { 2330, 14, 19, 16, 1, -14 },
  { 2364, 12, 14, 16, 2, -14 },
  { 2385, 10, 25, 16, 3, -21 },
  { 2417, 2, 25, 16, 7, -21 },
  { 2424, 10, 25, 16, 3, -21 },
  { 2456, 14, 6, 16, 1, -11 },
};

const GFXfont IBMPlexMono_Regular27pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular27pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular27pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _IBMPLEXMONO_REGULAR27PT7B_H_
