#ifndef _IBMPLEXMONO_REGULAR55PT7B_H_
#define _IBMPLEXMONO_REGULAR55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular55pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x7F, 0x3F, 0xBF, 0xFF, 0xF7, 0xF3, 0xF8, 0xF8, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xF0, 0x3C, 0x01, 0xFF, 0xE0, 0x7F, 0xF3, 0xFF, 0xC0, 0xFF,
  0xE7, 0xFF, 0x01, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0x80, 0x3C, 0x0F, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0xFF, 0xE0, 0x3F, 0xF9, 0xFF,
  0xC0, 0xFF, 0xF3, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x7F, 0x3C, 0xFF, 0x1F, 0x87, 0x87, 0xF3, 0xE0, 0xF0, 0x3E, 0xF8, 0x1E,
  0x03, 0x1F, 0x03, 0xC0, 0x43, 0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x00, 0x0F,
  0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xE0, 0xF0,
  0x00, 0x7E, 0x1E, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xF3, 0xFC, 0x00, 0x1E, 0x1F, 0x80, 0x03, 0xC1, 0xF8, 0x00,
  0x78, 0x1F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0x80, 0xF2, 0x00, 0xF0, 0x1E, 0x60, 0x1E, 0x07, 0xDE, 0x03,
  0xC0, 0xFF, 0xE0, 0x78, 0x3E, 0x7F, 0x0F, 0x0F, 0xC7, 0xF9, 0xE7, 0xF0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3C, 0xFF, 0xF0, 0x00, 0xF1, 0xFF, 0xF0,
  0x01, 0xE7, 0xC1, 0xF0, 0x07, 0x8F, 0x01, 0xE0, 0x0F, 0x3C, 0x03, 0xC0,
  0x3C, 0x78, 0x03, 0x80, 0x78, 0xF0, 0x07, 0x01, 0xE1, 0xE0, 0x0E, 0x07,
  0x83, 0xC0, 0x1C, 0x0F, 0x07, 0x80, 0x38, 0x3C, 0x0F, 0x00, 0xF0, 0x78,
  0x0F, 0x01, 0xE1, 0xE0, 0x1F, 0x07, 0xC3, 0xC0, 0x3F, 0xFF, 0x0F, 0x00,
  0x3F, 0xFC, 0x1E, 0x00, 0x3F, 0xF0, 0x78, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1E, 0x0F, 0xFC, 0x00, 0x78, 0x3F, 0xFC, 0x00, 0xF0, 0xFF, 0xF8, 0x03,
  0xC3, 0xE0, 0xF8, 0x07, 0x87, 0x80, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x3C,
  0x1C, 0x01, 0xE0, 0xF0, 0x38, 0x03, 0xC1, 0xE0, 0x70, 0x07, 0x87, 0x80,
  0xE0, 0x0F, 0x1E, 0x01, 0xC0, 0x1E, 0x3C, 0x03, 0xC0, 0x3C, 0xF0, 0x07,
  0x80, 0xF1, 0xE0, 0x0F, 0x83, 0xE7, 0x80, 0x0F, 0xFF, 0x8F, 0x00, 0x0F,
  0xFF, 0x3C, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xC0, 0x03,
  0xC0, 0x04, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0xFF,
  0x0F, 0xFE, 0x03, 0xFC, 0x7E, 0xF8, 0x0F, 0xF3, 0xE1, 0xF0, 0x3C, 0x0F,
  0x83, 0xE0, 0xF0, 0x7C, 0x07, 0xC3, 0x81, 0xF0, 0x1F, 0x8E, 0x07, 0x80,
  0x3E, 0x38, 0x3E, 0x00, 0x7C, 0xE0, 0xF8, 0x00, 0xFF, 0x83, 0xE0, 0x01,
  0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x1E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0xFF, 0x03, 0xE0, 0x07, 0x7E, 0x0F, 0xE0, 0x78, 0xF8,
  0x1F, 0xFF, 0xE1, 0xF0, 0x3F, 0xFF, 0x03, 0xE0, 0x7F, 0xF8, 0x07, 0xC0,
  0x7F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x40, 0x0F, 0x80, 0x13, 0xC0, 0x7C, 0x07, 0x9F, 0xC3, 0xE1,
  0xFC, 0xFF, 0xDF, 0x7F, 0xEB, 0xFF, 0xFF, 0xFE, 0x83, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x78, 0x03, 0xC0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x40, 0x01, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC7,
  0xF1, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC1,
  0xE0, 0x78, 0x3E, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3E, 0x3F, 0x9F, 0xDF, 0xFF, 0xFB, 0xF9, 0xFC, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x00,
  0x7C, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3C,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x03, 0xE0, 0x7F, 0xE0,
  0xFE, 0x0F, 0xFC, 0x1F, 0xC1, 0xFF, 0x83, 0xF8, 0x3F, 0xF0, 0x7F, 0x07,
  0xFE, 0x07, 0xC0, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C,
  0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3C, 0x3E, 0x00,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0x78, 0x00, 0x1F, 0xCF, 0x00, 0x07, 0xF1, 0xE0,
  0x01, 0xFC, 0x3C, 0x00, 0x7E, 0x07, 0x80, 0x1F, 0x80, 0xF0, 0x03, 0xE0,
  0x1E, 0x00, 0x38, 0x03, 0xC0, 0x02, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F,
  0x81, 0xFC, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x1F, 0x1C, 0x00, 0x07, 0xC1, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE1, 0xF8, 0x01, 0xF9,
  0xF0, 0x00, 0x7C, 0x38, 0x00, 0x3E, 0x08, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x60, 0x00, 0x1F, 0x70, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xBF, 0x80, 0x0F, 0xCF, 0xF0, 0x1F, 0xC3, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x3E, 0x78, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00,
  0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x03,
  0xC0, 0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0xFE, 0x00, 0x79, 0xFF, 0xE0, 0x39, 0xFF, 0xF8, 0x3D, 0xFF, 0xFE,
  0x1F, 0xE0, 0x3F, 0x8F, 0xC0, 0x07, 0xE7, 0xC0, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x40, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x3F,
  0x00, 0x1F, 0x0F, 0xE0, 0x3F, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x7F, 0x00, 0xF9, 0xFF, 0xE0, 0x79, 0xFF, 0xF8, 0x7D,
  0xFF, 0xFE, 0x3F, 0xE0, 0x3F, 0x9E, 0xC0, 0x07, 0xEF, 0xC0, 0x01, 0xF7,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0x7C, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x3F, 0x83, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1E,
  0x78, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF0,
  0x7E, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x7C, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE3,
  0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x07,
  0xE3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xF9, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x83, 0xF8,
  0x0F, 0xC1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x1E, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x06,
  0xF3, 0xF8, 0x0E, 0xF9, 0xFF, 0xFF, 0x7C, 0x3F, 0xFF, 0x3C, 0x0F, 0xFF,
  0x3E, 0x01, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x3F, 0x9F, 0xDF, 0xFF, 0xFB, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0xFE, 0x7F, 0x7F, 0xFF, 0xEF, 0xE7, 0xF1, 0xF0, 0x1F, 0x0F,
  0xE3, 0xF9, 0xFF, 0x7F, 0xCF, 0xE3, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x7F, 0x1F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3E, 0x0F, 0x87,
  0xE1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x38, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x07, 0xC1,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x3D, 0xE0, 0x0F, 0x8F, 0x78, 0x0F, 0xF3, 0xDE, 0x07,
  0xFE, 0xF7, 0x83, 0xFF, 0xBD, 0xE0, 0xF8, 0x3F, 0x78, 0x3C, 0x07, 0xDE,
  0x1F, 0x00, 0xFF, 0x87, 0x80, 0x3F, 0xE1, 0xE0, 0x0F, 0xF8, 0x78, 0x03,
  0xFE, 0x1E, 0x00, 0xFF, 0x87, 0x80, 0x3F, 0xE1, 0xE0, 0x0F, 0xF8, 0x78,
  0x03, 0xFE, 0x1E, 0x00, 0xFF, 0x87, 0x80, 0x3D, 0xE1, 0xE0, 0x0F, 0x78,
  0x7C, 0x03, 0xDE, 0x0F, 0x01, 0xF7, 0x83, 0xF9, 0xFD, 0xE0, 0x7F, 0xEF,
  0x78, 0x1F, 0xF3, 0xDE, 0x03, 0xFC, 0xF3, 0xC0, 0x18, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x3E, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87,
  0x80, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7C, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x0F, 0x00, 0x1F, 0xC7, 0x80, 0x03, 0xF3, 0xC0, 0x00, 0xF9, 0xE0,
  0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E,
  0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x01, 0xF1,
  0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x0F, 0x00, 0x0F, 0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x00,
  0x7D, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3D, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0x78, 0x00, 0x7F, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0x3E, 0x3C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0x87, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x60, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0xCF,
  0xC0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x80,
  0x3F, 0x87, 0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0x7C, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDF, 0x00,
  0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF9, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7C, 0x01, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xE0,
  0x7F, 0x07, 0xE0, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0x87, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7D, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF1,
  0xF8, 0x03, 0xFC, 0x7F, 0x81, 0xDF, 0x0F, 0xFF, 0xF7, 0xC1, 0xFF, 0xF9,
  0xF0, 0x1F, 0xFC, 0x7C, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x40, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0x7C, 0x00, 0x7D, 0xF8, 0x03, 0xE3, 0xF0, 0x3F, 0x8F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0xDE,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x0F, 0x00, 0x07,
  0xE1, 0xE0, 0x01, 0xF8, 0x3C, 0x00, 0x7E, 0x07, 0x80, 0x0F, 0x80, 0xF0,
  0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x3F, 0x00, 0x78, 0x0F, 0xC0,
  0x0F, 0x03, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0xF1, 0xF8, 0x00, 0x1E, 0x7F, 0x80, 0x03, 0xDF, 0xF8, 0x00,
  0x7B, 0xFF, 0x00, 0x0F, 0xFB, 0xF0, 0x01, 0xFE, 0x3E, 0x00, 0x3F, 0x83,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xC0, 0x0F, 0xC0, 0x78, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x81, 0xE0, 0x01,
  0xF0, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xF0, 0xF0, 0x00, 0x3E, 0x1E,
  0x00, 0x03, 0xE3, 0xC0, 0x00, 0x7E, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x00,
  0xFD, 0xE0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xEF, 0x01, 0xEF, 0xF7, 0x80, 0xF7, 0xFB, 0xE0, 0x7B, 0xFC, 0xF0, 0x79,
  0xFE, 0x78, 0x3C, 0xFF, 0x1E, 0x3C, 0x7F, 0x8F, 0x1E, 0x3F, 0xC3, 0xDE,
  0x1F, 0xE1, 0xEF, 0x0F, 0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0x83, 0xFC, 0x1F,
  0xC1, 0xFE, 0x07, 0xC0, 0xFF, 0x03, 0xE0, 0x7F, 0x80, 0xE0, 0x3F, 0xC0,
  0x70, 0x1F, 0xE0, 0x38, 0x0F, 0xF0, 0x08, 0x07, 0xF8, 0x04, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3C, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xF7,
  0x80, 0x1F, 0xFB, 0xC0, 0x0F, 0xFD, 0xF0, 0x07, 0xFE, 0x78, 0x03, 0xFF,
  0x3E, 0x01, 0xFF, 0x8F, 0x00, 0xFF, 0xC7, 0x80, 0x7F, 0xE3, 0xE0, 0x3F,
  0xF0, 0xF0, 0x1F, 0xF8, 0x7C, 0x0F, 0xFC, 0x1E, 0x07, 0xFE, 0x0F, 0x83,
  0xFF, 0x07, 0xC1, 0xFF, 0x81, 0xE0, 0xFF, 0xC0, 0xF8, 0x7F, 0xE0, 0x3C,
  0x3F, 0xF0, 0x1F, 0x1F, 0xF8, 0x07, 0x8F, 0xFC, 0x03, 0xC7, 0xFE, 0x01,
  0xF3, 0xFF, 0x00, 0x79, 0xFF, 0x80, 0x3E, 0xFF, 0xC0, 0x0F, 0x7F, 0xE0,
  0x07, 0xBF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC1,
  0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF9, 0xF0, 0x00,
  0x1F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3C,
  0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x01, 0xFB, 0xE0, 0x00,
  0x7D, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3D, 0xF0, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x1E, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3D, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x03, 0xE0, 0x7C, 0x01,
  0xF0, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x1C, 0x3E, 0x00, 0x00, 0x83, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x10, 0x00, 0x01, 0xF1,
  0x80, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0xE0, 0x00, 0x7E, 0x7F, 0x00,
  0x0F, 0xC3, 0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0xE0, 0x3F,
  0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3C,
  0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x78,
  0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80,
  0x3C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x3E, 0x07, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x03, 0xE0, 0x3C, 0xF0,
  0x1F, 0x01, 0xE7, 0x81, 0xFC, 0x0F, 0x3C, 0x0F, 0xE0, 0x79, 0xE0, 0x7F,
  0x03, 0xCF, 0x03, 0xB8, 0x1E, 0x78, 0x1D, 0xE0, 0xF3, 0xC1, 0xEF, 0x07,
  0x9E, 0x0F, 0x78, 0x3C, 0xF0, 0x71, 0xC1, 0xE3, 0xC3, 0x8E, 0x0E, 0x1E,
  0x3C, 0x78, 0xF0, 0xF1, 0xE3, 0xC7, 0x87, 0x8F, 0x1E, 0x3C, 0x3C, 0x70,
  0x71, 0xE1, 0xE3, 0x83, 0xCF, 0x0F, 0x3C, 0x1E, 0x78, 0x79, 0xE0, 0xF3,
  0xC3, 0xCF, 0x07, 0x9E, 0x1E, 0x70, 0x1C, 0xF0, 0xF7, 0x80, 0xF7, 0x87,
  0xBC, 0x07, 0xBC, 0x1D, 0xE0, 0x3D, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF0,
  0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80,
  0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0xF9, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3C, 0xF8, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8,
  0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x78, 0xF8,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x0F, 0x5C, 0x00, 0x00, 0x74, 0x40, 0x00,
  0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0x1C, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x78,
  0x1E, 0x0F, 0x03, 0xC0, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0x00, 0x3F,
  0x07, 0x80, 0x07, 0xC0, 0x40, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x3F, 0x80, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0xFC, 0x1F, 0x80, 0xEF, 0xF7, 0xFF, 0xF9, 0xFC, 0xFF, 0xFC, 0x7F,
  0x1F, 0xFE, 0x07, 0xC0, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x83, 0xF8, 0x07,
  0xC7, 0xFF, 0x03, 0xE7, 0xFF, 0xC1, 0xF7, 0xFF, 0xF0, 0xFF, 0x81, 0xFC,
  0x7F, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1E, 0xF8,
  0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x80, 0x07, 0xCF,
  0xE0, 0x07, 0xE7, 0xFC, 0x0F, 0xE3, 0xEF, 0xFF, 0xE1, 0xF3, 0xFF, 0xE0,
  0xF8, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x1F, 0xC7, 0xC0, 0x0F,
  0x9F, 0x00, 0x0F, 0xBE, 0x00, 0x0E, 0x78, 0x00, 0x11, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x01, 0x1F, 0x00,
  0x07, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x7E, 0x3F, 0x01, 0xF8, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x0F, 0xE0, 0xF8, 0x1F, 0xFC, 0x7C, 0x1F, 0xFF, 0x3E, 0x1F, 0xFF, 0xDF,
  0x1F, 0xC0, 0xFF, 0x9F, 0x80, 0x1F, 0xCF, 0x80, 0x07, 0xEF, 0x80, 0x01,
  0xF7, 0xC0, 0x00, 0xFB, 0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0xF0,
  0x00, 0x1F, 0x78, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xE7,
  0xC0, 0x03, 0xF3, 0xF0, 0x03, 0xF8, 0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0xBE,
  0x1F, 0xFF, 0x9F, 0x03, 0xFF, 0x8F, 0x80, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC,
  0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x78,
  0x00, 0x0F, 0x7C, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x21, 0xF0, 0x00, 0x38, 0x7C, 0x00,
  0x3E, 0x3F, 0x00, 0x3F, 0x0F, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0x9F, 0xF0,
  0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFC, 0x07,
  0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x3E,
  0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x07,
  0x81, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x7E,
  0x03, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x3C, 0x00,
  0x0F, 0xCF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7, 0xF0, 0x00,
  0xFE, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x83, 0xF0, 0x1F, 0x1F, 0xFC, 0x3E, 0x7F, 0xFC, 0x7D, 0xFF,
  0xFC, 0xFB, 0x81, 0xF9, 0xFC, 0x01, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE7, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xCF, 0x00, 0x07, 0xE3, 0xC0, 0x03,
  0xF0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x03, 0xC0,
  0x3E, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x1F, 0x80, 0x0F, 0x0F, 0xC0, 0x03,
  0xC7, 0xE0, 0x00, 0xF3, 0xF8, 0x00, 0x3D, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFC, 0xF8, 0x00, 0xFE, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x0F, 0x80,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xFC, 0x0F,
  0x00, 0x1F, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x1F,
  0x8F, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0xC0, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x1F, 0x1E,
  0x7F, 0x0F, 0xF3, 0xDF, 0xF3, 0xFF, 0x7B, 0xFF, 0x7F, 0xEF, 0xC3, 0xF8,
  0x7F, 0xF0, 0x3E, 0x07, 0xFC, 0x07, 0xC0, 0x7F, 0x80, 0xF8, 0x0F, 0xF0,
  0x1F, 0x01, 0xFE, 0x03, 0xE0, 0x3F, 0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0x80,
  0xFF, 0x01, 0xF0, 0x1F, 0xE0, 0x3E, 0x03, 0xFC, 0x07, 0xC0, 0x7F, 0x80,
  0xF8, 0x0F, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xE0, 0x3F, 0xC0, 0x7C, 0x07,
  0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x1F, 0xE0, 0x3E, 0x03, 0xFC, 0x07,
  0xC0, 0x7F, 0x80, 0xF8, 0x0F, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xE0, 0x3F,
  0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x1E, 0x00, 0x3F,
  0x01, 0xF1, 0xFF, 0xC3, 0xE7, 0xFF, 0xC7, 0xDF, 0xFF, 0xCF, 0xB8, 0x1F,
  0x9F, 0xC0, 0x1F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF8,
  0x0F, 0xC1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x78,
  0x00, 0x0F, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7C,
  0x7F, 0xF0, 0x3E, 0x7F, 0xFC, 0x1F, 0x7F, 0xFF, 0x0F, 0xF8, 0x1F, 0xC7,
  0xF0, 0x03, 0xF3, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x7C, 0xFE,
  0x00, 0x7E, 0x7F, 0xC0, 0xFE, 0x3E, 0xFF, 0xFE, 0x1F, 0x3F, 0xFE, 0x0F,
  0x8F, 0xFE, 0x07, 0xC1, 0xFC, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xC7, 0xC1, 0xFF, 0xF3, 0xE1, 0xFF,
  0xFD, 0xF1, 0xFC, 0x0F, 0xF9, 0xF8, 0x01, 0xFC, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x3E, 0x7C, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x7F, 0xC3, 0xFF,
  0xFB, 0xE1, 0xFF, 0xF9, 0xF0, 0x3F, 0xF8, 0xF8, 0x07, 0xF0, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0xFF, 0xF0, 0x07, 0xBC, 0x00, 0x00,
  0xF6, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xF8, 0x0F, 0xF1, 0xF0, 0x00, 0xF1,
  0xF0, 0x00, 0x30, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xFC, 0x00, 0x1F, 0x3F,
  0xC0, 0x3F, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x7F, 0x7F, 0x03, 0xFE,
  0x7F, 0xFF, 0x7C, 0x7F, 0xFC, 0xF8, 0x7F, 0xF1, 0xF0, 0x3F, 0x80, 0x00,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xEF, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x7C, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x1F, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x1E, 0x03, 0xC0, 0x0F,
  0x01, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x7F, 0x80, 0x7C, 0x03, 0xFC,
  0x03, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xB8, 0x0E,
  0xE0, 0x3D, 0xC0, 0x77, 0x01, 0xCF, 0x03, 0xB8, 0x0E, 0x78, 0x3C, 0xE0,
  0xF3, 0xC1, 0xC7, 0x07, 0x9E, 0x0E, 0x38, 0x3C, 0xF0, 0x71, 0xC1, 0xE3,
  0x83, 0x8E, 0x0E, 0x1C, 0x3C, 0x78, 0x70, 0xF1, 0xC1, 0xC3, 0x87, 0x8E,
  0x0E, 0x3C, 0x3C, 0x70, 0x71, 0xE1, 0xE3, 0x83, 0x8F, 0x07, 0x3C, 0x1E,
  0x70, 0x39, 0xC0, 0x73, 0x81, 0xCE, 0x03, 0x9C, 0x0E, 0x70, 0x1C, 0xE0,
  0x7B, 0x80, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x07,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x78, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78,
  0x1F, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x1E, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0xC1, 0xFE, 0x00, 0x3C, 0x7F, 0xE0, 0x07, 0x9F,
  0xFE, 0x00, 0xF3, 0xC7, 0xE0, 0x1C, 0xF0, 0x7E, 0x07, 0x9E, 0x07, 0xE0,
  0xF3, 0x80, 0x7E, 0x3C, 0xF0, 0x07, 0xFF, 0x9E, 0x00, 0x7F, 0xE3, 0xC0,
  0x07, 0xF8, 0x30, 0x00, 0x3C, 0x00,
};

const GFXglyph IBMPlexMono_Regular55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 9, 39, 33, 12, -38 },
  { 45, 13, 15, 33, 10, -41 },
  { 70, 31, 38, 33, 1, -38 },
  { 218, 27, 52, 33, 3, -45 },
  { 394, 31, 40, 33, 1, -39 },
  { 549, 30, 40, 33, 1, -39 },
  { 699, 5, 15, 33, 14, -41 },
  { 709, 16, 50, 33, 11, -42 },
  { 809, 16, 50, 33, 6, -42 },
  { 909, 29, 27, 33, 2, -31 },
  { 1007, 27, 28, 33, 3, -31 },
  { 1102, 10, 15, 33, 11, -7 },
  { 1121, 15, 4, 33, 9, -19 },
  { 1129, 9, 8, 33, 12, -7 },
  { 1138, 23, 50, 33, 5, -42 },
  { 1282, 27, 40, 33, 3, -39 },
  { 1417, 27, 38, 33, 3, -38 },
  { 1546, 26, 39, 33, 4, -39 },
  { 1673, 25, 40, 33, 3, -39 },
  { 1798, 29, 38, 33, 2, -38 },
  { 1936, 25, 39, 33, 4, -38 },
  { 2058, 25, 39, 33, 4, -38 },
  { 2180, 25, 38, 33, 4, -38 },
  { 2299, 27, 40, 33, 3, -39 },
  { 2434, 25, 39, 33, 4, -39 },
  { 2556, 9, 30, 33, 12, -29 },
  { 2590, 10, 37, 33, 11, -29 },
  { 2637, 23, 32, 33, 5, -33 },
  { 2729, 27, 15, 33, 3, -24 },
  { 2780, 23, 32, 33, 5, -33 },
  { 2872, 24, 40, 33, 4, -39 },
  { 2992, 26, 45, 33, 3, -39 },
  { 3139, 29, 38, 33, 2, -38 },
  { 3277, 25, 38, 33, 5, -38 },
  { 3396, 26, 40, 33, 4, -39 },
  { 3526, 25, 38, 33, 5, -38 },
  { 3645, 24, 38, 33, 5, -38 },
  { 3759, 24, 38, 33, 5, -38 },
  { 3873, 26, 40, 33, 3, -39 },
  { 4003, 25, 38, 33, 4, -38 },
  { 4122, 23, 38, 33, 5, -38 },
  { 4232, 22, 39, 33, 4, -38 },
  { 4340, 27, 38, 33, 5, -38 },
  { 4469, 22, 38, 33, 7, -38 },
  { 4574, 25, 38, 33, 4, -38 },
  { 4693, 25, 38, 33, 4, -38 },
  { 4812, 27, 40, 33, 3, -39 },
  { 4947, 25, 38, 33, 5, -38 },
  { 5066, 27, 49, 33, 3, -39 },
  { 5232, 25, 38, 33, 5, -38 },
  { 5351, 28, 40, 33, 2, -39 },
  { 5491, 31, 38, 33, 1, -38 },
  { 5639, 25, 39, 33, 4, -38 },
  { 5761, 29, 38, 33, 2, -38 },
  { 5899, 29, 38, 33, 2, -38 },
  { 6037, 31, 38, 33, 1, -38 },
  { 6185, 31, 38, 33, 1, -38 },
  { 6333, 27, 38, 33, 3, -38 },
  { 6462, 16, 50, 33, 12, -42 },
  { 6562, 23, 50, 33, 5, -42 },
  { 6706, 16, 50, 33, 5, -42 },
  { 6806, 29, 23, 33, 2, -38 },
  { 6890, 27, 4, 33, 3, 5 },
  { 6904, 9, 11, 33, 10, -43 },
  { 6917, 26, 30, 33, 4, -29 },
  { 7015, 25, 42, 33, 5, -41 },
  { 7147, 23, 30, 33, 5, -29 },
  { 7234, 25, 42, 33, 3, -41 },
  { 7366, 25, 30, 33, 4, -29 },
  { 7460, 26, 41, 33, 4, -41 },
  { 7594, 27, 44, 33, 4, -32 },
  { 7743, 23, 41, 33, 5, -41 },
  { 7861, 24, 40, 33, 6, -40 },
  { 7981, 20, 51, 33, 5, -40 },
  { 8109, 26, 41, 33, 6, -41 },
  { 8243, 25, 41, 33, 4, -41 },
  { 8372, 27, 29, 33, 3, -29 },
  { 8470, 23, 29, 33, 5, -29 },
  { 8554, 25, 30, 33, 4, -29 },
  { 8648, 25, 40, 33, 5, -29 },
  { 8773, 25, 40, 33, 3, -29 },
  { 8898, 27, 28, 33, 4, -28 },
  { 8993, 25, 30, 33, 4, -29 },
  { 9087, 27, 38, 33, 2, -38 },
  { 9216, 23, 29, 33, 5, -28 },
  { 9300, 25, 28, 33, 4, -28 },
  { 9388, 29, 28, 33, 2, -28 },
  { 9490, 27, 28, 33, 3, -28 },
  { 9585, 27, 39, 33, 3, -28 },
  { 9717, 23, 28, 33, 5, -28 },
  { 9798, 21, 50, 33, 6, -42 },
  { 9930, 3, 50, 33, 15, -42 },
  { 9949, 21, 50, 33, 6, -42 },
  { 10081, 27, 12, 33, 3, -23 },
};

const GFXfont IBMPlexMono_Regular55pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular55pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular55pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _IBMPLEXMONO_REGULAR55PT7B_H_
