#ifndef _IBMPLEXMONO_REGULAR51PT7B_H_
#define _IBMPLEXMONO_REGULAR51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular51pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7,
  0x8F, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x06, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFB, 0xE0, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3C, 0x00, 0x1E, 0x0F, 0x00,
  0x00, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03,
  0xC0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x0F, 0x00,
  0x7F, 0xF0, 0x7F, 0xF3, 0xFF, 0x03, 0xFF, 0x9F, 0xF8, 0x1F, 0xFC, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x00,
  0x7F, 0xF0, 0x3F, 0xF3, 0xFF, 0x83, 0xFF, 0x9F, 0xFC, 0x1F, 0xFC, 0xFF,
  0xC0, 0xFF, 0xE0, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x1F,
  0xCE, 0x3F, 0x8F, 0x87, 0x07, 0xEF, 0x83, 0x81, 0xE7, 0x81, 0xC0, 0x63,
  0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xF0, 0x38, 0x00, 0x78, 0x1C, 0x00,
  0x3E, 0x0E, 0x00, 0x1F, 0x07, 0x00, 0x07, 0xE3, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0x0F, 0xC0, 0x03, 0x83, 0xE0, 0x01,
  0xC0, 0xF8, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x0F, 0x00,
  0x1C, 0x07, 0x90, 0x0E, 0x03, 0xDC, 0x07, 0x03, 0xFF, 0x03, 0x81, 0xFF,
  0xE1, 0xC1, 0xF3, 0xFC, 0xE7, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0xFF, 0x80, 0x07, 0x8F, 0xFE, 0x00, 0x38, 0xF8, 0x78, 0x03,
  0xC7, 0x01, 0xC0, 0x1C, 0x78, 0x0F, 0x01, 0xE3, 0xC0, 0x38, 0x0E, 0x1C,
  0x01, 0xC0, 0xF0, 0xE0, 0x0E, 0x0F, 0x07, 0x00, 0x70, 0x78, 0x38, 0x03,
  0x87, 0x81, 0xE0, 0x1C, 0x3C, 0x0F, 0x01, 0xE3, 0xC0, 0x38, 0x0E, 0x1C,
  0x01, 0xF0, 0xF1, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x78, 0xFF, 0xF0, 0x07, 0x87, 0x87, 0x80, 0x38, 0x78,
  0x1E, 0x03, 0xC3, 0x80, 0x70, 0x1C, 0x1C, 0x03, 0x81, 0xE1, 0xE0, 0x1C,
  0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x78, 0x07, 0x8F, 0x03, 0xC0, 0x3C, 0x78,
  0x0E, 0x01, 0xC7, 0x80, 0x70, 0x0E, 0x38, 0x03, 0xC0, 0xF3, 0xC0, 0x0F,
  0x0F, 0x1C, 0x00, 0x7F, 0xF9, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x00,
  0x70, 0x00, 0xF0, 0x04, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x0F,
  0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xF1, 0xFF, 0xC0, 0xFF, 0x3E,
  0x3E, 0x0F, 0x03, 0xC1, 0xF0, 0xF0, 0x7C, 0x1F, 0x8E, 0x07, 0x80, 0xF8,
  0xE0, 0x78, 0x07, 0xCE, 0x0F, 0x80, 0x3E, 0xE0, 0xF8, 0x01, 0xFE, 0x0F,
  0x80, 0x0F, 0xC0, 0xF8, 0x00, 0xFC, 0x07, 0x80, 0x07, 0xC0, 0x78, 0x00,
  0x7E, 0x07, 0xC0, 0x0F, 0xF0, 0x3F, 0x03, 0xCF, 0x83, 0xFF, 0xFC, 0x7C,
  0x1F, 0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x1F, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x70, 0x1E, 0x01, 0xDF, 0x87, 0x83, 0xFF, 0xFD, 0xE7, 0xFD,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x1F,
  0x1E, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xC0, 0xF8, 0x01, 0xF0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x3C, 0x00, 0xF8, 0x03, 0x00, 0x18, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC, 0x3F, 0x0F, 0x83,
  0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xF8, 0x1F, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x03,
  0xDF, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x3C, 0x0F, 0xF8, 0x3F, 0x07, 0xFC, 0x1F,
  0x83, 0xFE, 0x0F, 0xC1, 0xFF, 0x07, 0xE0, 0xFF, 0x81, 0xF0, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0x9E,
  0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF0,
  0xF8, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x1F, 0x81, 0xFC, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7E,
  0xF0, 0x00, 0x7E, 0x78, 0x00, 0x7E, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x7C,
  0x0F, 0x00, 0x7C, 0x07, 0x80, 0x1C, 0x03, 0xC0, 0x0C, 0x01, 0xE0, 0x04,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x78, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x10, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E,
  0x0C, 0x00, 0x1F, 0x08, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x10, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0xFE, 0x00, 0x3E, 0x3F, 0x80, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x1E, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0,
  0x07, 0x80, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x01, 0xC0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03,
  0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x0F, 0xE0,
  0x1E, 0x7F, 0xF0, 0x3D, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFE, 0x07, 0xF1,
  0xF0, 0x03, 0xF3, 0xC0, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF2, 0x00, 0x03, 0xEE, 0x00, 0x07, 0xBE, 0x00,
  0x1F, 0x7E, 0x00, 0x7E, 0x7F, 0x03, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x3F,
  0x80, 0x3C, 0x7F, 0xE0, 0x7D, 0xFF, 0xF8, 0x7B, 0xFF, 0xFC, 0x7B, 0x81,
  0xFC, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0xFC, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xF8,
  0x0F, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0x78,
  0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xC3,
  0xC0, 0x01, 0xE1, 0xF0, 0x01, 0xE0, 0x7E, 0x03, 0xE0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x1F,
  0x83, 0xE0, 0x03, 0xE3, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x3D, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0xFC,
  0x00, 0x7E, 0x3F, 0x80, 0xFE, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x3E, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x6F,
  0x3F, 0x80, 0xEF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x9E, 0x07, 0xFF, 0x1E,
  0x01, 0xFC, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF0, 0x1F, 0x0F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0xFC,
  0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x70, 0x3C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x03,
  0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7C,
  0xC0, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3C,
  0x00, 0x1E, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x78, 0x0F, 0x8F, 0x78,
  0x1F, 0xCF, 0x70, 0x3F, 0xEF, 0x70, 0x7F, 0xFF, 0xF0, 0x7C, 0x3F, 0xF0,
  0x78, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0,
  0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0,
  0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0x78, 0x1F, 0xF0,
  0x7E, 0x7F, 0x70, 0x3F, 0xEF, 0x70, 0x3F, 0xEF, 0x78, 0x1F, 0xCF, 0x78,
  0x06, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF8,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x1E,
  0x03, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x7C, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x78, 0x00,
  0x0F, 0x1F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF0, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x01,
  0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3C, 0xF8, 0x00,
  0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00,
  0x3C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x01, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xF8, 0x00,
  0xFC, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xF8, 0x1F,
  0x87, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x23, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x87, 0x80, 0x01, 0xEF, 0x80, 0x03,
  0xCF, 0x80, 0x0F, 0x9F, 0x80, 0x3E, 0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x00, 0x7F, 0x1E,
  0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xFB, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B,
  0xC0, 0x01, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x1F, 0x3C,
  0x00, 0x7C, 0x78, 0x03, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xC1, 0xFC, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x7C,
  0x00, 0x1F, 0x78, 0x00, 0x08, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x6F, 0x1F,
  0x81, 0xEF, 0x0F, 0xFF, 0xCF, 0x0F, 0xFF, 0xCF, 0x03, 0xFF, 0x0F, 0x00,
  0xFC, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x70,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xF7, 0xC0, 0x3F, 0x7E, 0x07, 0xE3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0x8F, 0x80,
  0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xF8,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F,
  0x83, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xF0, 0x00,
  0xF9, 0xF8, 0x00, 0x7D, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xF7, 0xC0,
  0x0F, 0xF1, 0xF0, 0x07, 0xF0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xF7, 0x80, 0xFF, 0xF7,
  0x80, 0xEF, 0xF3, 0x81, 0xEF, 0xF3, 0xC1, 0xEF, 0xF3, 0xC1, 0xCF, 0xF1,
  0xE3, 0xCF, 0xF1, 0xE3, 0x8F, 0xF0, 0xE3, 0x8F, 0xF0, 0xF7, 0x8F, 0xF0,
  0xF7, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0,
  0x3E, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x1C, 0x0F, 0xF0, 0x18, 0x0F, 0xF0,
  0x08, 0x0F, 0xF0, 0x08, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFD, 0xE0, 0x07, 0xFB, 0xC0,
  0x0F, 0xF7, 0xC0, 0x1F, 0xE7, 0x80, 0x3F, 0xCF, 0x00, 0x7F, 0x8F, 0x00,
  0xFF, 0x1E, 0x01, 0xFE, 0x3E, 0x03, 0xFC, 0x3C, 0x07, 0xF8, 0x78, 0x0F,
  0xF0, 0x78, 0x1F, 0xE0, 0xF0, 0x3F, 0xC1, 0xF0, 0x7F, 0x81, 0xE0, 0xFF,
  0x03, 0xC1, 0xFE, 0x03, 0xC3, 0xFC, 0x07, 0x87, 0xF8, 0x0F, 0x8F, 0xF0,
  0x0F, 0x1F, 0xE0, 0x1E, 0x3F, 0xC0, 0x1E, 0x7F, 0x80, 0x3C, 0xFF, 0x00,
  0x7D, 0xFE, 0x00, 0x7B, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF8,
  0x1F, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x7C,
  0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1E, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00,
  0x03, 0xE7, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x7E,
  0x00, 0xF8, 0x1F, 0x81, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0x00, 0x1F, 0x9E, 0x00, 0x0F, 0xBC,
  0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0x78, 0x00, 0x3E, 0xF0, 0x01, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xF8, 0x1F, 0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x9E, 0x00, 0x03,
  0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E,
  0x00, 0x07, 0xCF, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xE1, 0xF0, 0x01, 0xF0,
  0xFC, 0x01, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0x00, 0x1F, 0x9E, 0x00,
  0x0F, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xBC, 0x00, 0x0F, 0x78, 0x00, 0x3E, 0xF0, 0x01, 0xF9, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1E, 0x07, 0x80, 0x3C,
  0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1F, 0x03, 0xC0,
  0x1E, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x3C, 0x00,
  0x7C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF9, 0xE0, 0x00, 0xFB, 0xC0, 0x01,
  0xF7, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0x7F, 0x0F, 0xC0, 0x07, 0xE3,
  0xE0, 0x00, 0x78, 0xF0, 0x00, 0x08, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x10,
  0x00, 0x07, 0x9E, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x7C,
  0x3F, 0xC0, 0x7F, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00,
  0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x3F, 0x01, 0xF8, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x78, 0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x0F,
  0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x0F,
  0x80, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x0F, 0x80, 0x1F,
  0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3E,
  0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xCE, 0x03, 0xE0, 0x79, 0xC0, 0x7C,
  0x0F, 0x38, 0x1F, 0x81, 0xE7, 0x83, 0xF0, 0x3C, 0xF0, 0x7F, 0x07, 0x9E,
  0x0E, 0xE0, 0xF3, 0xC1, 0xDC, 0x1E, 0x78, 0x7B, 0x83, 0xCF, 0x0E, 0x78,
  0x71, 0xE1, 0xCF, 0x0E, 0x3C, 0x38, 0xE1, 0xC7, 0x87, 0x1C, 0x38, 0xF1,
  0xE3, 0x87, 0x0E, 0x38, 0x79, 0xE1, 0xC7, 0x0F, 0x3C, 0x38, 0xE0, 0xE7,
  0x87, 0x1C, 0x1C, 0xF0, 0xF7, 0x83, 0x9E, 0x1E, 0xE0, 0x7B, 0xC3, 0xDC,
  0x0F, 0x78, 0x7B, 0x80, 0xEF, 0x0F, 0xF0, 0x1D, 0xC1, 0xFE, 0x03, 0xB8,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x80, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x03,
  0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x78, 0xF0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x3C,
  0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0xF0, 0x0F,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x01,
  0xF0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x80,
  0x07, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF8, 0x3C, 0x00, 0x03,
  0xC3, 0xE0, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3C, 0xF8,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x3E, 0x03,
  0xC0, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x10, 0x00,
  0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x20, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x0E,
  0x05, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x07, 0xC0, 0xE0, 0x01, 0xE0, 0x20,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x7E, 0x00, 0x78, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x1E,
  0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC1, 0xE0, 0x02,
  0xE0, 0xFC, 0x0F, 0x7F, 0x3F, 0xFF, 0x3F, 0x9F, 0xFF, 0x0F, 0xC3, 0xFF,
  0x03, 0xE0, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x83, 0xF8, 0x0F, 0x1F, 0xFC, 0x1E, 0x7F, 0xFC, 0x3D, 0xFF, 0xFC,
  0x7F, 0x81, 0xF8, 0xFC, 0x01, 0xF9, 0xF0, 0x01, 0xF3, 0xC0, 0x01, 0xF7,
  0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00,
  0x3E, 0xF8, 0x00, 0xF9, 0xF8, 0x03, 0xF3, 0xFC, 0x0F, 0xC7, 0xBF, 0xFF,
  0x8F, 0x3F, 0xFE, 0x1E, 0x3F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0x81, 0xF8,
  0xF8, 0x01, 0xE3, 0xC0, 0x03, 0xDF, 0x00, 0x0C, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x04, 0x7C, 0x00, 0x18, 0xF0, 0x00, 0xF3, 0xE0,
  0x07, 0xC7, 0xE0, 0x7E, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x0F,
  0xC0, 0xF0, 0x7F, 0xE1, 0xE1, 0xFF, 0xF3, 0xC7, 0xFF, 0xE7, 0x9F, 0xC0,
  0xEF, 0x3E, 0x00, 0x7E, 0xF8, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0xFC, 0xFE, 0x07, 0x78, 0xFF, 0xFC, 0xF0, 0xFF,
  0xF9, 0xE0, 0xFF, 0xC3, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x80, 0xFC, 0x1F,
  0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x08, 0x3E,
  0x00, 0x1E, 0x1F, 0x00, 0x3E, 0x1F, 0xC0, 0xFC, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x01, 0xFD, 0xFE, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x7E, 0x07, 0xE0, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x03, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03,
  0xE0, 0x03, 0xC0, 0x78, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x1E, 0x70, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0x7E,
  0x00, 0x3F, 0x9F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0xFC, 0x0F,
  0x1F, 0xF8, 0x79, 0xFF, 0xE3, 0xDF, 0xFF, 0x9E, 0xE0, 0xFE, 0xFC, 0x01,
  0xF7, 0xC0, 0x07, 0xBC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x7E, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07,
  0xC0, 0xF0, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x7C,
  0x00, 0xF0, 0xF8, 0x00, 0xF1, 0xF0, 0x00, 0xF7, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0x3E, 0x00, 0xFE, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x01,
  0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x7C, 0x7B, 0xF8, 0x7F,
  0x3D, 0xFE, 0x7F, 0xDF, 0xFF, 0x7F, 0xEF, 0x87, 0xB0, 0xF7, 0x81, 0xF0,
  0x7F, 0xC0, 0xF0, 0x1F, 0xE0, 0x78, 0x0F, 0xF0, 0x3C, 0x07, 0xF8, 0x1E,
  0x03, 0xFC, 0x0F, 0x01, 0xFE, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x7F, 0x81,
  0xE0, 0x3F, 0xC0, 0xF0, 0x1F, 0xE0, 0x78, 0x0F, 0xF0, 0x3C, 0x07, 0xF8,
  0x1E, 0x03, 0xFC, 0x0F, 0x01, 0xFE, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x7F,
  0x81, 0xE0, 0x3F, 0xC0, 0xF0, 0x1F, 0xE0, 0x78, 0x0F, 0xF0, 0x3C, 0x07,
  0xF8, 0x1E, 0x03, 0xFC, 0x0F, 0x01, 0xE0, 0x00, 0x7E, 0x07, 0x8F, 0xFC,
  0x3C, 0xFF, 0xF1, 0xEF, 0xFF, 0xCF, 0x70, 0x7F, 0x7E, 0x00, 0xFB, 0xE0,
  0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0x81, 0xFC, 0x3E, 0x00, 0x7C,
  0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x1F, 0x81, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x01, 0xE3, 0xFF, 0x83,
  0xCF, 0xFF, 0x87, 0xBF, 0xFF, 0x8F, 0xF0, 0x3F, 0x1F, 0x80, 0x3F, 0x3E,
  0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0,
  0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0xF7, 0x80, 0x01, 0xEF, 0x00, 0x07, 0xDF, 0x00, 0x1F, 0x3F, 0x00, 0x7E,
  0x7F, 0x81, 0xF8, 0xF7, 0xFF, 0xF1, 0xE7, 0xFF, 0xC3, 0xC7, 0xFF, 0x07,
  0x83, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x3C, 0x3F,
  0xFE, 0x78, 0xFF, 0xFC, 0xF3, 0xF8, 0x1D, 0xE7, 0xC0, 0x0F, 0xDF, 0x00,
  0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xCF, 0x80, 0x1F, 0x9F,
  0xC0, 0xEF, 0x1F, 0xFF, 0x9E, 0x1F, 0xFF, 0x3C, 0x1F, 0xF8, 0x78, 0x0F,
  0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0xFF, 0xF0, 0x0F, 0x70, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x1F, 0x80, 0xFE, 0x3E, 0x00, 0x1C, 0x3C, 0x00, 0x08, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x10, 0x00, 0x0F, 0x38, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xFF,
  0x80, 0xFE, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0xFD, 0xF8, 0x1D, 0xEF, 0xFF, 0xEF, 0x3F, 0xFE,
  0x78, 0xFF, 0xE3, 0xC1, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x78,
  0x0F, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xE0,
  0x03, 0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xC0, 0x01, 0xC3, 0xC0,
  0x01, 0xE3, 0xC0, 0x01, 0xE3, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xF7, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0xE0, 0x1F, 0x01, 0xFC, 0x03, 0xE0, 0x3F, 0x80, 0x7C, 0x07, 0xF8, 0x1F,
  0x80, 0xFF, 0x03, 0xB8, 0x1D, 0xE0, 0x77, 0x03, 0x9C, 0x0E, 0xE0, 0x73,
  0x81, 0xDC, 0x0E, 0x70, 0x73, 0x83, 0xCE, 0x0E, 0x38, 0x79, 0xE1, 0xC7,
  0x0E, 0x3C, 0x38, 0xE1, 0xC7, 0x87, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E,
  0x38, 0x38, 0xE1, 0xC7, 0x07, 0x3C, 0x38, 0xE0, 0xE7, 0x87, 0x9C, 0x1C,
  0xE0, 0xF7, 0x03, 0x9C, 0x0E, 0xE0, 0x7B, 0x81, 0xDC, 0x07, 0x70, 0x3B,
  0x80, 0xEE, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x0F, 0x80,
  0x0F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x1F,
  0x07, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xFB, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0xF0, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x78, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x7C, 0x00,
  0x0F, 0xC0, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF,
  0x00, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF0,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x79,
  0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x3F,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x07, 0x80, 0x03, 0x0F, 0xF0, 0x01, 0xC7, 0xFC, 0x01,
  0xE7, 0xFF, 0x00, 0xE7, 0xCF, 0x80, 0x73, 0xC3, 0xE0, 0x79, 0xC0, 0xF8,
  0x39, 0xE0, 0x3E, 0x3C, 0xF0, 0x0F, 0xFE, 0x70, 0x03, 0xFE, 0x38, 0x00,
  0xFE, 0x0C, 0x00, 0x3E, 0x00,
};

const GFXglyph IBMPlexMono_Regular51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 7, 36, 31, 12, -36 },
  { 33, 13, 14, 31, 9, -38 },
  { 56, 29, 36, 31, 1, -36 },
  { 187, 25, 47, 31, 3, -41 },
  { 334, 29, 37, 31, 1, -36 },
  { 469, 28, 37, 31, 1, -36 },
  { 599, 4, 14, 31, 13, -38 },
  { 606, 15, 46, 31, 10, -39 },
  { 693, 15, 46, 31, 5, -39 },
  { 780, 26, 25, 31, 2, -29 },
  { 862, 24, 26, 31, 3, -29 },
  { 940, 10, 14, 31, 10, -7 },
  { 958, 15, 4, 31, 8, -17 },
  { 966, 7, 7, 31, 12, -7 },
  { 973, 21, 46, 31, 5, -39 },
  { 1094, 25, 37, 31, 3, -36 },
  { 1210, 25, 36, 31, 3, -36 },
  { 1323, 24, 36, 31, 3, -36 },
  { 1431, 24, 37, 31, 2, -36 },
  { 1542, 27, 36, 31, 2, -36 },
  { 1664, 23, 37, 31, 4, -36 },
  { 1771, 24, 37, 31, 3, -36 },
  { 1882, 24, 36, 31, 3, -36 },
  { 1990, 25, 37, 31, 3, -36 },
  { 2106, 24, 36, 31, 3, -36 },
  { 2214, 7, 27, 31, 12, -27 },
  { 2238, 10, 34, 31, 10, -27 },
  { 2281, 22, 29, 31, 4, -30 },
  { 2361, 24, 14, 31, 3, -23 },
  { 2403, 22, 29, 31, 4, -30 },
  { 2483, 22, 36, 31, 4, -36 },
  { 2582, 24, 42, 31, 3, -36 },
  { 2708, 27, 36, 31, 2, -36 },
  { 2830, 24, 36, 31, 4, -36 },
  { 2938, 23, 37, 31, 4, -36 },
  { 3045, 23, 36, 31, 5, -36 },
  { 3149, 22, 36, 31, 5, -36 },
  { 3248, 22, 36, 31, 5, -36 },
  { 3347, 24, 37, 31, 3, -36 },
  { 3458, 23, 36, 31, 4, -36 },
  { 3562, 22, 36, 31, 4, -36 },
  { 3661, 20, 37, 31, 4, -36 },
  { 3754, 25, 36, 31, 4, -36 },
  { 3867, 21, 36, 31, 6, -36 },
  { 3962, 24, 36, 31, 3, -36 },
  { 4070, 23, 36, 31, 4, -36 },
  { 4174, 25, 37, 31, 3, -36 },
  { 4290, 23, 36, 31, 5, -36 },
  { 4394, 25, 44, 31, 3, -36 },
  { 4532, 23, 36, 31, 5, -36 },
  { 4636, 26, 37, 31, 2, -36 },
  { 4757, 28, 36, 31, 1, -36 },
  { 4883, 23, 37, 31, 4, -36 },
  { 4990, 27, 36, 31, 2, -36 },
  { 5112, 27, 36, 31, 2, -36 },
  { 5234, 28, 36, 31, 1, -36 },
  { 5360, 29, 36, 31, 1, -36 },
  { 5491, 26, 36, 31, 2, -36 },
  { 5608, 15, 46, 31, 11, -39 },
  { 5695, 21, 46, 31, 5, -39 },
  { 5816, 14, 46, 31, 5, -39 },
  { 5897, 26, 21, 31, 2, -36 },
  { 5966, 25, 4, 31, 3, 5 },
  { 5979, 8, 10, 31, 10, -40 },
  { 5989, 25, 28, 31, 3, -27 },
  { 6077, 23, 39, 31, 5, -38 },
  { 6190, 22, 28, 31, 4, -27 },
  { 6267, 23, 39, 31, 3, -38 },
  { 6380, 24, 28, 31, 3, -27 },
  { 6464, 24, 38, 31, 4, -38 },
  { 6578, 26, 41, 31, 3, -30 },
  { 6712, 21, 38, 31, 5, -38 },
  { 6812, 23, 38, 31, 5, -38 },
  { 6922, 18, 48, 31, 5, -38 },
  { 7030, 24, 38, 31, 5, -38 },
  { 7144, 23, 38, 31, 4, -38 },
  { 7254, 25, 27, 31, 3, -27 },
  { 7339, 21, 27, 31, 5, -27 },
  { 7410, 24, 28, 31, 3, -27 },
  { 7494, 23, 37, 31, 5, -27 },
  { 7601, 23, 37, 31, 3, -27 },
  { 7708, 25, 26, 31, 4, -26 },
  { 7790, 24, 28, 31, 3, -27 },
  { 7874, 25, 36, 31, 2, -36 },
  { 7987, 21, 27, 31, 5, -26 },
  { 8058, 24, 26, 31, 3, -26 },
  { 8136, 27, 26, 31, 2, -26 },
  { 8224, 25, 26, 31, 3, -26 },
  { 8306, 25, 36, 31, 3, -26 },
  { 8419, 22, 26, 31, 4, -26 },
  { 8491, 20, 46, 31, 5, -39 },
  { 8606, 3, 46, 31, 14, -39 },
  { 8624, 20, 46, 31, 5, -39 },
  { 8739, 25, 12, 31, 3, -21 },
};

const GFXfont IBMPlexMono_Regular51pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular51pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular51pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _IBMPLEXMONO_REGULAR51PT7B_H_
