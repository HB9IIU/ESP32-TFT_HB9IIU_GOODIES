#ifndef _IBMPLEXMONO_REGULAR26PT7B_H_
#define _IBMPLEXMONO_REGULAR26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular26pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x64, 0x40, 0x00, 0xEF, 0xFE, 0xCF, 0x3C,
  0xF3, 0xCF, 0x3C, 0xC0, 0x03, 0x18, 0x06, 0x20, 0x0C, 0xC0, 0x31, 0x80,
  0x63, 0x0F, 0xC7, 0xDF, 0x8F, 0x83, 0x30, 0x04, 0x60, 0x18, 0xC0, 0x31,
  0x87, 0xE3, 0xEF, 0xC7, 0xC1, 0x98, 0x02, 0x30, 0x0C, 0x60, 0x18, 0xC0,
  0x31, 0x80, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x1F, 0x83, 0xFF, 0x39, 0x9D,
  0x8C, 0x6C, 0x60, 0x63, 0x03, 0x98, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F, 0x01,
  0x9C, 0x0C, 0x60, 0x63, 0x43, 0x1B, 0x18, 0xFC, 0xCE, 0x7F, 0xE0, 0xFC,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x3C, 0x06, 0xFC, 0x19, 0x8C, 0x32, 0x18,
  0xC4, 0x31, 0x88, 0x66, 0x18, 0xCC, 0x3F, 0x30, 0x3C, 0x00, 0x00, 0xF0,
  0x3B, 0xF0, 0x66, 0x31, 0x98, 0x63, 0x30, 0xCC, 0x61, 0x98, 0x63, 0x60,
  0xFD, 0xC0, 0xF0, 0x0F, 0x00, 0xFE, 0x03, 0x0C, 0x1C, 0x20, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x3C, 0x3D, 0xF8, 0xFE, 0x73, 0x30, 0xC8,
  0xC1, 0xA3, 0x03, 0x8C, 0x0E, 0x38, 0x7C, 0x7F, 0x38, 0xF8, 0x70, 0xFF,
  0xFC, 0x07, 0x0C, 0x18, 0x18, 0x30, 0x20, 0x60, 0x60, 0x60, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60, 0x20, 0x30, 0x18, 0x18, 0x0C,
  0x07, 0xC0, 0xC0, 0xC0, 0xC0, 0x81, 0x81, 0x03, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x08, 0x30, 0x41, 0x86, 0x18, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x0C, 0x31, 0xFF, 0xFC, 0x7F, 0x80, 0xE0, 0x0F,
  0x80, 0x66, 0x06, 0x38, 0x70, 0xC1, 0x03, 0x00, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x3B, 0x9C, 0xE6, 0x31, 0x98, 0xFF, 0xFF, 0xEF, 0xFE, 0x00,
  0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0x0F, 0x80, 0xFF, 0x0E,
  0x1C, 0xE0, 0x66, 0x03, 0xB0, 0x0D, 0x80, 0x7C, 0x03, 0xE7, 0x1F, 0x38,
  0xF9, 0xC6, 0xC0, 0x36, 0x01, 0xB0, 0x1D, 0xC0, 0xC7, 0x0E, 0x1F, 0xE0,
  0x7C, 0x00, 0x07, 0x80, 0x7C, 0x07, 0xE0, 0x77, 0x07, 0x38, 0x71, 0xC1,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFB, 0xFF, 0xC0, 0x1F, 0x07, 0xFC, 0x60,
  0xEC, 0x06, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0x0F,
  0x83, 0xFE, 0x70, 0x72, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0xFC, 0x0F,
  0xC0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x60, 0x3F, 0x07, 0x3F,
  0xE1, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x36, 0x01, 0xD8, 0x06, 0x60, 0x31,
  0x80, 0xC6, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x06, 0x30, 0x18, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x7F, 0xE7,
  0xFE, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x6F, 0x85, 0xFC, 0x70, 0xEC,
  0x06, 0x00, 0x70, 0x03, 0x00, 0x30, 0x07, 0xC0, 0x6E, 0x0E, 0x7F, 0xC1,
  0xF0, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0x6F, 0x8D,
  0xFC, 0xF0, 0xEE, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x67,
  0x0E, 0x3F, 0xC1, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x06, 0xC0, 0xE0,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x0F, 0xC1, 0xFF, 0x9C, 0x1C,
  0xC0, 0x76, 0x03, 0xB0, 0x18, 0xC1, 0xC3, 0xFC, 0x1F, 0xE1, 0x83, 0x98,
  0x0E, 0xC0, 0x3E, 0x01, 0xF0, 0x0D, 0x80, 0xEE, 0x0E, 0x3F, 0xF0, 0x7E,
  0x00, 0x1F, 0x03, 0xFC, 0x70, 0xEE, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xE0, 0x7F, 0x0B, 0x7F, 0xE1, 0xE6, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x01, 0xC0, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0xEF, 0xFE, 0x73,
  0xDE, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0xE7, 0x39, 0x8C, 0x66, 0x00, 0x00,
  0x20, 0x0C, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x3C, 0x06, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xC0, 0x08, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0x00, 0xE0, 0x78, 0x3C, 0x0E,
  0x07, 0x81, 0xC0, 0x20, 0x00, 0x1F, 0x87, 0xF9, 0xC3, 0xF0, 0x3C, 0x06,
  0x00, 0xC0, 0x38, 0x1E, 0x0E, 0x01, 0x80, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x06,
  0xC0, 0x6C, 0x7B, 0xCF, 0xBC, 0xC7, 0xCC, 0x3C, 0xC3, 0xCC, 0x3C, 0xC3,
  0xCC, 0x3C, 0xC3, 0xCF, 0xFC, 0x7B, 0xC0, 0x06, 0x00, 0x70, 0x03, 0xFC,
  0x0F, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x03, 0x60, 0x0C, 0xC0, 0x33,
  0x01, 0x8C, 0x06, 0x38, 0x18, 0x60, 0xE1, 0x83, 0x06, 0x0F, 0xFC, 0x7F,
  0xF1, 0x80, 0xC6, 0x03, 0x98, 0x06, 0xE0, 0x1B, 0x00, 0x70, 0xFF, 0x8F,
  0xFC, 0xC0, 0xEC, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0xFF, 0x8F,
  0xFC, 0xC0, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xFF, 0xEF,
  0xF8, 0x0F, 0x83, 0xFC, 0x70, 0xE6, 0x07, 0xE0, 0x2C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x02, 0x60, 0x77,
  0x0E, 0x3F, 0xC0, 0xF8, 0xFF, 0x0F, 0xFC, 0xE0, 0xEE, 0x06, 0xE0, 0x7E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x6E, 0x0E, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF,
  0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x0F, 0x80, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x01, 0xB0, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x0F, 0xF8, 0x7E, 0xC0, 0x36, 0x01, 0xB0, 0x1D,
  0xC0, 0xE7, 0x0B, 0x3F, 0xD8, 0x7C, 0xC0, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xFF, 0xFF,
  0xFC, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xFF, 0xFF, 0xFC, 0x3F,
  0xCF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xD0, 0x3C, 0x0D, 0x87, 0x7F, 0x87, 0xC0, 0xC0, 0x3E,
  0x03, 0xB0, 0x39, 0x83, 0x8C, 0x38, 0x61, 0x83, 0x18, 0x19, 0xC0, 0xDE,
  0x07, 0xF8, 0x3C, 0xC1, 0xC7, 0x0C, 0x1C, 0x60, 0x63, 0x03, 0x98, 0x0C,
  0xC0, 0x36, 0x01, 0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xFF, 0xFF, 0xFC, 0xE0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xD9,
  0xBD, 0x9B, 0xDB, 0x3C, 0xF3, 0xCE, 0x3C, 0x63, 0xC4, 0x3C, 0x43, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3F, 0x03, 0xF0,
  0x3F, 0x83, 0xD8, 0x3D, 0x83, 0xCC, 0x3C, 0xC3, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x33, 0xC3, 0x3C, 0x1B, 0xC1, 0xBC, 0x1F, 0xC0, 0xFC, 0x0F, 0x0F,
  0x80, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x03, 0xB0, 0x0D, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x1D, 0xC0, 0xC7,
  0x0E, 0x1F, 0xE0, 0x7C, 0x00, 0xFF, 0xCF, 0xFE, 0xE0, 0x7E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xFF, 0xEF, 0xFC, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x80, 0xFF, 0x0E,
  0x1C, 0xE0, 0x66, 0x03, 0xB0, 0x0D, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x1D, 0xC0, 0xC7, 0x0E, 0x1F, 0xE0,
  0x7E, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0x00, 0xF8, 0xFF, 0xCF, 0xFE, 0xE0,
  0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xFF, 0xEF, 0xF8, 0xE3,
  0x0E, 0x38, 0xE1, 0x8E, 0x1C, 0xE0, 0xCE, 0x0E, 0xE0, 0x6E, 0x03, 0x0F,
  0xC1, 0xFF, 0x9C, 0x1E, 0xC0, 0x26, 0x00, 0x30, 0x01, 0xC0, 0x0F, 0x80,
  0x3F, 0xC0, 0x7F, 0x80, 0x1E, 0x00, 0x30, 0x01, 0xA0, 0x0F, 0x80, 0xEE,
  0x0E, 0x3F, 0xF0, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x06, 0xC0, 0x6C, 0x06, 0xE0, 0x67,
  0x0E, 0x7F, 0xC1, 0xF8, 0xC0, 0x1F, 0x80, 0x66, 0x01, 0x98, 0x0E, 0x70,
  0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x18, 0x38, 0x60, 0x61, 0x81, 0x8E, 0x07,
  0x30, 0x0C, 0xC0, 0x33, 0x00, 0xD8, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xB0, 0x02, 0xC0, 0x1B, 0x1C, 0x6C, 0x71,
  0xB1, 0xE6, 0x47, 0x99, 0x96, 0x66, 0xC9, 0x9B, 0x26, 0x6C, 0xD9, 0xA3,
  0x67, 0x8D, 0x9E, 0x14, 0x78, 0x71, 0xE1, 0xC0, 0xE0, 0x1D, 0x80, 0xE3,
  0x03, 0x0E, 0x1C, 0x18, 0x60, 0x73, 0x00, 0xDC, 0x01, 0xE0, 0x07, 0x00,
  0x1E, 0x00, 0x78, 0x03, 0x30, 0x1C, 0xC0, 0x61, 0x83, 0x07, 0x1C, 0x0C,
  0x60, 0x1B, 0x00, 0x70, 0xE0, 0x0E, 0xE0, 0x18, 0xC0, 0x71, 0xC0, 0xC1,
  0x83, 0x81, 0x86, 0x03, 0x1C, 0x03, 0x30, 0x06, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x18, 0x03, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0xFF, 0xFF, 0x07, 0x00, 0x3C, 0x03, 0x60, 0x19, 0x81, 0x8C, 0x0C, 0x30,
  0xC1, 0xCE, 0x06, 0x60, 0x1E, 0x00, 0xD0, 0x04, 0xFF, 0xFF, 0xFF, 0x4E,
  0x63, 0x30, 0x1F, 0x07, 0xF8, 0xE1, 0xC4, 0x0C, 0x00, 0xC0, 0x0C, 0x3F,
  0xCF, 0xFC, 0xE0, 0xCC, 0x0C, 0xC1, 0x4F, 0xF7, 0x3E, 0x70, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0x8F, 0xFC, 0xF0, 0xEE,
  0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xF0, 0xEF,
  0xFC, 0xE7, 0x80, 0x0F, 0x87, 0xF9, 0xC3, 0xB0, 0x3E, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xE0, 0x0C, 0x0D, 0xC3, 0x9F, 0xE0, 0xF8, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xCF, 0x9B, 0xFB, 0xE0, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0xEF, 0xEC, 0xF9, 0x80,
  0x1F, 0x03, 0xFC, 0x70, 0xEC, 0x06, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00,
  0xC0, 0x0E, 0x02, 0x70, 0xE3, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x70, 0x07, 0x87, 0xE0, 0x7F, 0x87, 0x0E, 0x30, 0x31, 0x81,
  0x8C, 0x0C, 0x70, 0xC1, 0xFE, 0x0F, 0xC0, 0xC0, 0x06, 0x00, 0x3F, 0xF0,
  0xFF, 0xD8, 0x06, 0xC0, 0x1E, 0x01, 0xBF, 0xFC, 0x7F, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0xF3, 0xFE, 0xE1, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0x0E, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x1F, 0xFF, 0xFF,
  0x80, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x67, 0xF9, 0xFC, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xEC, 0x1C, 0xC3, 0x8C, 0x60, 0xCC, 0x0D,
  0xC0, 0xFE, 0x0E, 0x70, 0xC3, 0x0C, 0x18, 0xC1, 0xCC, 0x0E, 0xC0, 0x70,
  0xFE, 0x0F, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0xCC, 0x76, 0xF7, 0xF9, 0xC7, 0x86, 0x3C,
  0x31, 0xE1, 0x8F, 0x0C, 0x78, 0x63, 0xC3, 0x1E, 0x18, 0xF0, 0xC7, 0x86,
  0x3C, 0x31, 0x80, 0xCF, 0x3F, 0xEE, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x1F, 0x03, 0xFC, 0x70,
  0xEC, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x06, 0x70,
  0xE3, 0xFC, 0x1F, 0x00, 0xE7, 0x8F, 0xFC, 0xF0, 0xEE, 0x07, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xF0, 0xEF, 0xFC, 0xE7, 0x8E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x3E, 0x6F, 0xEF, 0x83, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x83, 0xBF, 0xB3,
  0xE6, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0xFC, 0x7F, 0xEF, 0xC3,
  0x40, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x01, 0xFF, 0xCF, 0xFE, 0x00, 0x1F, 0x87, 0xFE, 0x60, 0x6E, 0x00,
  0x60, 0x07, 0xE0, 0x3F, 0xC0, 0x3E, 0x00, 0x78, 0x07, 0xE0, 0x67, 0xFE,
  0x1F, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x7F, 0xFF,
  0xFF, 0xE1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0xF8, 0x1F, 0xC0, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0D, 0xC3, 0xBF,
  0xB1, 0xE6, 0xC0, 0x3C, 0x06, 0x60, 0x66, 0x06, 0x60, 0xC3, 0x0C, 0x30,
  0xC3, 0x18, 0x19, 0x81, 0xB0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xC3, 0x0F,
  0x1C, 0x3C, 0x70, 0xB1, 0x62, 0xC5, 0x99, 0x12, 0x66, 0xC9, 0x9B, 0x36,
  0x68, 0xD1, 0xA3, 0x47, 0x85, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x76, 0x0E,
  0x30, 0xC3, 0x98, 0x1F, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x1B, 0x83, 0x18,
  0x70, 0xC6, 0x0E, 0xC0, 0x70, 0xE0, 0x1B, 0x00, 0xDC, 0x0C, 0x60, 0x63,
  0x06, 0x0C, 0x30, 0x63, 0x81, 0x98, 0x0C, 0xC0, 0x6C, 0x01, 0xE0, 0x0E,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x7C, 0x03, 0xC0, 0x00, 0xFF,
  0xFF, 0xFC, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0x7F, 0xFF, 0xFE, 0x0F, 0xC7, 0xF1, 0x80, 0x60, 0x18, 0x06,
  0x00, 0xC0, 0x18, 0x06, 0x01, 0x80, 0xE3, 0xF0, 0xFC, 0x03, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x40, 0x10, 0x04, 0x03,
  0x00, 0xC0, 0x60, 0x10, 0x0C, 0x01, 0x80, 0x3F, 0x0F, 0xC6, 0x03, 0x00,
  0x40, 0x18, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x0F, 0xC3, 0xF0, 0x1C,
  0x09, 0xF0, 0xD9, 0xC6, 0xC6, 0x64, 0x1F, 0x60, 0x70,
};

const GFXglyph IBMPlexMono_Regular26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 18, 16, 6, -18 },
  { 10, 6, 7, 16, 5, -19 },
  { 16, 15, 18, 16, 0, -18 },
  { 50, 13, 24, 16, 1, -21 },
  { 89, 15, 18, 16, 0, -18 },
  { 123, 14, 18, 16, 1, -18 },
  { 155, 2, 7, 16, 7, -19 },
  { 157, 8, 24, 16, 5, -20 },
  { 181, 7, 24, 16, 3, -20 },
  { 202, 13, 13, 16, 1, -15 },
  { 224, 12, 12, 16, 2, -14 },
  { 242, 5, 8, 16, 5, -4 },
  { 247, 8, 2, 16, 4, -9 },
  { 249, 4, 4, 16, 6, -4 },
  { 251, 11, 24, 16, 2, -20 },
  { 284, 13, 18, 16, 1, -18 },
  { 314, 13, 18, 16, 1, -18 },
  { 344, 12, 18, 16, 2, -18 },
  { 371, 12, 18, 16, 1, -18 },
  { 398, 14, 18, 16, 1, -18 },
  { 430, 12, 18, 16, 2, -18 },
  { 457, 12, 18, 16, 2, -18 },
  { 484, 12, 18, 16, 2, -18 },
  { 511, 13, 18, 16, 1, -18 },
  { 541, 12, 18, 16, 2, -18 },
  { 568, 4, 14, 16, 6, -14 },
  { 575, 5, 18, 16, 5, -14 },
  { 587, 11, 15, 16, 2, -15 },
  { 608, 12, 8, 16, 2, -12 },
  { 620, 11, 15, 16, 2, -15 },
  { 641, 11, 18, 16, 2, -18 },
  { 666, 12, 21, 16, 2, -18 },
  { 698, 14, 18, 16, 1, -18 },
  { 730, 12, 18, 16, 2, -18 },
  { 757, 12, 18, 16, 2, -18 },
  { 784, 12, 18, 16, 2, -18 },
  { 811, 12, 18, 16, 2, -18 },
  { 838, 12, 18, 16, 2, -18 },
  { 865, 13, 18, 16, 1, -18 },
  { 895, 12, 18, 16, 2, -18 },
  { 922, 11, 18, 16, 2, -18 },
  { 947, 10, 18, 16, 2, -18 },
  { 970, 13, 18, 16, 2, -18 },
  { 1000, 11, 18, 16, 3, -18 },
  { 1025, 12, 18, 16, 2, -18 },
  { 1052, 12, 18, 16, 2, -18 },
  { 1079, 13, 18, 16, 1, -18 },
  { 1109, 12, 18, 16, 2, -18 },
  { 1136, 13, 22, 16, 1, -18 },
  { 1172, 12, 18, 16, 2, -18 },
  { 1199, 13, 18, 16, 1, -18 },
  { 1229, 14, 18, 16, 1, -18 },
  { 1261, 12, 18, 16, 2, -18 },
  { 1288, 14, 18, 16, 1, -18 },
  { 1320, 14, 18, 16, 1, -18 },
  { 1352, 14, 18, 16, 1, -18 },
  { 1384, 15, 18, 16, 0, -18 },
  { 1418, 13, 18, 16, 1, -18 },
  { 1448, 7, 24, 16, 6, -20 },
  { 1469, 11, 24, 16, 2, -20 },
  { 1502, 8, 24, 16, 2, -20 },
  { 1526, 13, 11, 16, 1, -18 },
  { 1544, 12, 2, 16, 2, 2 },
  { 1547, 4, 5, 16, 5, -20 },
  { 1550, 12, 13, 16, 2, -13 },
  { 1570, 12, 19, 16, 2, -19 },
  { 1599, 11, 13, 16, 2, -13 },
  { 1617, 11, 19, 16, 2, -19 },
  { 1644, 12, 13, 16, 2, -13 },
  { 1664, 12, 19, 16, 2, -19 },
  { 1693, 13, 20, 16, 2, -15 },
  { 1726, 10, 19, 16, 3, -19 },
  { 1750, 11, 19, 16, 3, -19 },
  { 1777, 10, 24, 16, 2, -19 },
  { 1807, 12, 19, 16, 3, -19 },
  { 1836, 12, 19, 16, 2, -19 },
  { 1865, 13, 13, 16, 1, -13 },
  { 1887, 10, 13, 16, 3, -13 },
  { 1904, 12, 13, 16, 2, -13 },
  { 1924, 12, 18, 16, 2, -13 },
  { 1951, 11, 18, 16, 2, -13 },
  { 1976, 13, 13, 16, 2, -13 },
  { 1998, 12, 13, 16, 2, -13 },
  { 2018, 13, 18, 16, 1, -18 },
  { 2048, 11, 13, 16, 2, -13 },
  { 2066, 12, 13, 16, 2, -13 },
  { 2086, 14, 13, 16, 1, -13 },
  { 2109, 12, 13, 16, 2, -13 },
  { 2129, 13, 18, 16, 1, -13 },
  { 2159, 11, 13, 16, 2, -13 },
  { 2177, 10, 24, 16, 3, -20 },
  { 2207, 2, 24, 16, 7, -20 },
  { 2213, 10, 24, 16, 3, -20 },
  { 2243, 13, 6, 16, 1, -11 },
};

const GFXfont IBMPlexMono_Regular26pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular26pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _IBMPLEXMONO_REGULAR26PT7B_H_
