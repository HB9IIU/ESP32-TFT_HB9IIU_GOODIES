#ifndef _IBMPLEXMONO_REGULAR25PT7B_H_
#define _IBMPLEXMONO_REGULAR25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xD2, 0x49, 0x00, 0x3F, 0xE0, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0x80, 0x03, 0x30, 0x04, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x62,
  0x0F, 0xCF, 0xDF, 0x1F, 0x86, 0x30, 0x0C, 0x60, 0x18, 0xC3, 0xF1, 0xF7,
  0xE7, 0xE0, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x0C, 0x40, 0x19, 0x80, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x1F, 0x83, 0xFE, 0x39, 0xB9, 0x8C, 0x6C, 0x60,
  0x63, 0x03, 0x98, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x01, 0x9C, 0x0C, 0x68,
  0x63, 0x63, 0x3F, 0x9B, 0x8F, 0xF8, 0x1F, 0x80, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x3C, 0x0E, 0xFC, 0x19, 0x8C, 0x62, 0x18, 0xCC, 0x33, 0x0C, 0x66,
  0x1F, 0x98, 0x1E, 0x30, 0x00, 0x00, 0x18, 0xF0, 0x33, 0xF0, 0xCC, 0x61,
  0x98, 0x46, 0x30, 0xCC, 0x63, 0x30, 0x7E, 0xE0, 0x78, 0x1F, 0x01, 0xFC,
  0x1C, 0x70, 0xC1, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x0F, 0x7C, 0x7F,
  0x73, 0x31, 0xD9, 0x87, 0xCC, 0x1E, 0x60, 0x63, 0x87, 0x8F, 0xE6, 0x3E,
  0x18, 0xFE, 0x06, 0x18, 0x61, 0x82, 0x0C, 0x18, 0x20, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x10, 0x30, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x81, 0x83, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x06,
  0x0C, 0x10, 0x61, 0x86, 0x18, 0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x0E, 0x23, 0xFF, 0xFC, 0x7F, 0x00, 0xE0, 0x0D, 0x80, 0xE6, 0x06, 0x30,
  0x60, 0xC0, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x41, 0xFF, 0xFF, 0xF8,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x7B, 0x9C, 0xC6, 0x63, 0x00,
  0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x01, 0x80, 0x00, 0x0F,
  0x81, 0xFF, 0x0E, 0x38, 0xC0, 0x66, 0x03, 0x30, 0x1B, 0x80, 0xDC, 0xE7,
  0xE7, 0x3F, 0x39, 0xF8, 0x0E, 0xC0, 0x66, 0x03, 0x30, 0x18, 0xE3, 0x87,
  0xFC, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x0E, 0xC0, 0xF6, 0x0F, 0x30, 0x31,
  0x81, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x0F, 0xFF, 0x7F, 0xF8, 0x1F, 0x0F, 0xF3, 0x87, 0x60,
  0x7C, 0x0E, 0x00, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x38, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0x83, 0xFE, 0x70, 0xE2,
  0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0xF8, 0x0F, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x34, 0x07, 0xF0, 0xE3, 0xFC, 0x1F, 0x80, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x0D, 0x80, 0x6C, 0x06, 0x60, 0x63, 0x03, 0x18, 0x30, 0xC3,
  0x06, 0x18, 0x31, 0x81, 0x8F, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x7F, 0xEF, 0xFD, 0x80, 0x30, 0x06, 0x00, 0x80, 0x13, 0xC2, 0xFE,
  0xE0, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x80, 0xF8, 0x33, 0xFE, 0x1F,
  0x00, 0x07, 0x81, 0xC0, 0x60, 0x1C, 0x07, 0x00, 0xC0, 0x3B, 0xE6, 0xFE,
  0xE0, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xD8, 0x3B, 0xFE, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x7C, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38,
  0x00, 0x0F, 0xC1, 0xFF, 0x1C, 0x1C, 0xC0, 0x66, 0x03, 0x30, 0x18, 0xC1,
  0x83, 0xF8, 0x1F, 0xC3, 0x83, 0x98, 0x0D, 0xC0, 0x7E, 0x03, 0xB0, 0x19,
  0xC1, 0xC7, 0xFC, 0x0F, 0x80, 0x1F, 0x0F, 0xFB, 0x83, 0x60, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0xEF, 0xEC, 0xFB, 0x80, 0x60, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x3C, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x73, 0x9C,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0xE7, 0x31, 0x98, 0xC0, 0x00, 0x20, 0x1C,
  0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x40, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x01, 0x00, 0x00, 0x1F,
  0x07, 0xF9, 0xC3, 0x60, 0x74, 0x06, 0x01, 0xC0, 0x30, 0x3C, 0x0E, 0x01,
  0x80, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x0E, 0x00, 0x1F,
  0x07, 0xF9, 0xC3, 0x60, 0x3C, 0x07, 0x8E, 0xF3, 0xFC, 0x63, 0x98, 0x73,
  0x0E, 0x61, 0xCC, 0x38, 0xC7, 0x9F, 0xF1, 0xDE, 0x00, 0xE0, 0x0E, 0x00,
  0xFE, 0x0F, 0xC0, 0x07, 0x00, 0x38, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x0C,
  0x60, 0x63, 0x03, 0x18, 0x30, 0x61, 0x83, 0x0F, 0xF8, 0xFF, 0xE6, 0x03,
  0x30, 0x19, 0x80, 0xD8, 0x03, 0xC0, 0x18, 0xFF, 0x8F, 0xFC, 0xC0, 0xEC,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xCF, 0xF8, 0xFF, 0xCC, 0x0E, 0xC0, 0x6C,
  0x07, 0xC0, 0x7C, 0x06, 0xC0, 0xEF, 0xFC, 0xFF, 0x80, 0x1F, 0x07, 0xF9,
  0xC3, 0xB0, 0x3C, 0x05, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x04, 0xC0, 0xDC, 0x39, 0xFE, 0x1F, 0x00, 0xFF, 0x0F, 0xF8,
  0xC1, 0xCC, 0x0E, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0xC1, 0xCF, 0xF8, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x0F,
  0x83, 0xFC, 0x38, 0x67, 0x03, 0x60, 0x26, 0x00, 0xE0, 0x0E, 0x00, 0xE3,
  0xFE, 0x3F, 0xE0, 0x36, 0x03, 0x60, 0x36, 0x03, 0x38, 0x73, 0xFB, 0x0F,
  0x30, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x60, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87, 0xFF, 0xFF,
  0xE0, 0x3F, 0xCF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x40, 0xF0, 0x3E, 0x1D, 0xFE, 0x3E, 0x00, 0xC0,
  0x7C, 0x0E, 0xC0, 0xCC, 0x18, 0xC3, 0x0C, 0x70, 0xCE, 0x0D, 0xC0, 0xDE,
  0x0F, 0x70, 0xE3, 0x0C, 0x18, 0xC1, 0xCC, 0x0C, 0xC0, 0xEC, 0x07, 0xC0,
  0x30, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0xE0,
  0xFC, 0x1F, 0x83, 0xF8, 0xFF, 0x1F, 0xB6, 0xF6, 0xDE, 0x53, 0xCE, 0x79,
  0xCF, 0x11, 0xE2, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x60, 0xE0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3D, 0x87, 0xB0, 0xF3, 0x1E, 0x63, 0xCE, 0x78,
  0xCF, 0x19, 0xE1, 0xBC, 0x37, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xE0, 0x0F,
  0x81, 0xFF, 0x0E, 0x38, 0xC0, 0x66, 0x03, 0x30, 0x1B, 0x80, 0xDC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x66, 0x03, 0x30, 0x18, 0xE3, 0x87,
  0xFC, 0x0F, 0x80, 0xFF, 0x8F, 0xFC, 0xC0, 0xEC, 0x06, 0xC0, 0x7C, 0x07,
  0xC0, 0x6C, 0x0E, 0xFF, 0xCF, 0xF8, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x0F, 0x81, 0xFF, 0x0E, 0x38, 0xC0, 0x66,
  0x03, 0x30, 0x1B, 0x80, 0xDC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0C, 0xC0,
  0x66, 0x03, 0x30, 0x18, 0xE3, 0x87, 0xFC, 0x0F, 0x80, 0x38, 0x00, 0xC0,
  0x07, 0xC0, 0x1E, 0x00, 0xFF, 0x8F, 0xFC, 0xC0, 0xEC, 0x06, 0xC0, 0x7C,
  0x07, 0xC0, 0x6C, 0x0E, 0xFF, 0xCF, 0xF8, 0xC7, 0x0C, 0x30, 0xC1, 0x8C,
  0x1C, 0xC0, 0xCC, 0x0E, 0xC0, 0x70, 0x0F, 0x81, 0xFF, 0x1C, 0x1C, 0xC0,
  0x66, 0x00, 0x30, 0x01, 0xC0, 0x07, 0xE0, 0x1F, 0xE0, 0x0F, 0x80, 0x0C,
  0x00, 0x74, 0x03, 0xF0, 0x19, 0xC1, 0xC7, 0xFC, 0x1F, 0x80, 0xFF, 0xFF,
  0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xC1, 0xD8, 0x33, 0xFE,
  0x1F, 0x00, 0xC0, 0x1F, 0x01, 0xD8, 0x0C, 0xC0, 0x66, 0x03, 0x18, 0x30,
  0xC1, 0x86, 0x0C, 0x38, 0xE0, 0xC6, 0x06, 0x30, 0x31, 0x80, 0xD8, 0x06,
  0xC0, 0x36, 0x00, 0xE0, 0x07, 0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x71, 0xE3, 0x8F, 0x14, 0x78, 0xA3, 0x4D, 0x92, 0x6C, 0x9B, 0x64,
  0xD1, 0x66, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x70, 0x70, 0xE0, 0x1B,
  0x01, 0x8C, 0x1C, 0x70, 0xC1, 0x8C, 0x06, 0xE0, 0x36, 0x00, 0xE0, 0x07,
  0x00, 0x3C, 0x03, 0x60, 0x39, 0x81, 0x8E, 0x18, 0x31, 0xC1, 0xCC, 0x06,
  0xC0, 0x18, 0xE0, 0x0E, 0xE0, 0x38, 0xC0, 0x60, 0xC1, 0xC1, 0x83, 0x01,
  0x8C, 0x03, 0xB8, 0x03, 0x60, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x7F, 0xF3,
  0xFF, 0x80, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFE, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xFF, 0xC0, 0xC0, 0x0C,
  0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x02,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0xFF, 0xFC, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1F, 0xFF,
  0xC0, 0x07, 0x00, 0x38, 0x03, 0x60, 0x33, 0x81, 0x8C, 0x18, 0x30, 0xC1,
  0x8C, 0x06, 0x60, 0x36, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x4C, 0x66,
  0x30, 0x1F, 0x07, 0xF8, 0xE1, 0xC4, 0x0C, 0x00, 0xC0, 0x0C, 0x3F, 0xCF,
  0xFC, 0xC0, 0xCC, 0x0C, 0xC1, 0xCF, 0xEF, 0x3C, 0x70, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xCF, 0x8D, 0xFC, 0xF0, 0xEE, 0x06,
  0xC0, 0x6C, 0x06, 0xC0, 0x7C, 0x06, 0xC0, 0x6E, 0x06, 0xF0, 0xED, 0xFC,
  0xCF, 0x80, 0x1F, 0x07, 0xF9, 0xC3, 0x30, 0x3C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x0C, 0x0D, 0xC3, 0x1F, 0xE1, 0xF0, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x1F, 0x33, 0xFB, 0x70, 0xF6, 0x07, 0x60,
  0x36, 0x03, 0xE0, 0x36, 0x03, 0x60, 0x36, 0x07, 0x70, 0xF3, 0xFB, 0x1F,
  0x30, 0x1F, 0x07, 0xF9, 0x83, 0x60, 0x3C, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0xC0, 0x18, 0x09, 0xC3, 0x9F, 0xE1, 0xF0, 0x03, 0xF0, 0x7F, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0F, 0xFE, 0xFF, 0xE0,
  0x00, 0xF0, 0x0F, 0x1F, 0x87, 0xFC, 0x61, 0xCE, 0x0C, 0xE0, 0xC6, 0x0C,
  0x61, 0xC3, 0xF8, 0x3F, 0x06, 0x00, 0x40, 0x07, 0xFC, 0x3F, 0xEC, 0x03,
  0xC0, 0x3C, 0x07, 0xFF, 0xE3, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x33, 0xC6, 0xFE, 0xD0, 0xDC, 0x1F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0x80, 0x0E, 0x01, 0xC0,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x1F, 0xFF, 0xFF, 0x80,
  0x03, 0x81, 0xC0, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0D, 0xFE, 0xFE, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x3E, 0x0C, 0xC3, 0x19, 0xC3, 0x70, 0x7E, 0x0F, 0xC1, 0xCC, 0x30, 0xC6,
  0x1C, 0xC1, 0x98, 0x1B, 0x03, 0x80, 0xFE, 0x1F, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x1F, 0xFF, 0xFF, 0x80, 0xDC, 0x76, 0xF7,
  0xB9, 0xCF, 0x8C, 0x3C, 0x21, 0xE1, 0x0F, 0x08, 0x78, 0x43, 0xC2, 0x1E,
  0x10, 0xF0, 0x87, 0x84, 0x3C, 0x21, 0x80, 0xCF, 0x1B, 0xFB, 0x43, 0x70,
  0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x06, 0x1F, 0x0F, 0xF9, 0x83, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0D, 0x83, 0x3F, 0xE1, 0xF0, 0xCF, 0x8D, 0xFC, 0xF0, 0xEE,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x7C, 0x06, 0xC0, 0x6E, 0x06, 0xF0, 0xED,
  0xFC, 0xCF, 0x8C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x1F, 0x33,
  0xFB, 0x70, 0xF6, 0x07, 0x60, 0x36, 0x03, 0xE0, 0x36, 0x03, 0x60, 0x36,
  0x07, 0x70, 0xF3, 0xFB, 0x1F, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0xFC, 0xFF, 0xDF, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x0F, 0xFE, 0xFF, 0xE0, 0x1F, 0x0F, 0xF9,
  0x83, 0xE0, 0x0E, 0x00, 0xFC, 0x0F, 0xF0, 0x1F, 0x00, 0x70, 0x0F, 0x83,
  0xBF, 0xE1, 0xF8, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x7F, 0x07, 0xF0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x1D, 0x85, 0xBF, 0xB1, 0xE6, 0xC0,
  0x78, 0x0F, 0x01, 0xB0, 0x66, 0x0C, 0x41, 0x0C, 0x61, 0x8C, 0x19, 0x03,
  0x60, 0x6C, 0x07, 0x00, 0xE0, 0xC7, 0x1E, 0x38, 0xF1, 0x47, 0x8A, 0x3C,
  0xD9, 0xA6, 0xC9, 0x36, 0x4D, 0x16, 0x68, 0xB3, 0xC7, 0x9E, 0x3C, 0xF1,
  0xE3, 0x06, 0x00, 0xC0, 0x66, 0x0C, 0x71, 0xC3, 0x98, 0x1B, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1B, 0x03, 0x18, 0x71, 0xC6, 0x0C, 0xC0, 0x70, 0xE0,
  0x3B, 0x01, 0x98, 0x0C, 0x60, 0xC3, 0x06, 0x0C, 0x60, 0x63, 0x03, 0x18,
  0x0D, 0x80, 0x6C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01,
  0x80, 0x7C, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x7F, 0xFF, 0xFE, 0x1F,
  0x8F, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x07, 0x3E, 0x1F,
  0x80, 0xE0, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xF8, 0xFC,
  0xFF, 0xFF, 0xFC, 0xF8, 0x7E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x60,
  0x30, 0x1C, 0x07, 0xE3, 0xF3, 0x81, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x03,
  0x01, 0x8F, 0xC7, 0xE0, 0x38, 0x19, 0xE0, 0x99, 0x84, 0x86, 0x6C, 0x1E,
  0x60, 0x70,
};

const GFXglyph IBMPlexMono_Regular25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 3, 17, 15, 6, -17 },
  { 8, 7, 7, 15, 4, -19 },
  { 15, 15, 17, 15, 0, -17 },
  { 47, 13, 23, 15, 1, -20 },
  { 85, 15, 17, 15, 0, -17 },
  { 117, 13, 17, 15, 1, -17 },
  { 145, 1, 7, 15, 7, -19 },
  { 146, 7, 22, 15, 5, -19 },
  { 166, 7, 22, 15, 3, -19 },
  { 186, 13, 12, 15, 1, -14 },
  { 206, 11, 12, 15, 2, -14 },
  { 223, 5, 7, 15, 5, -3 },
  { 228, 7, 2, 15, 4, -9 },
  { 230, 3, 3, 15, 6, -3 },
  { 232, 11, 22, 15, 2, -19 },
  { 263, 13, 17, 15, 1, -17 },
  { 291, 13, 17, 15, 1, -17 },
  { 319, 11, 17, 15, 2, -17 },
  { 343, 12, 17, 15, 1, -17 },
  { 369, 13, 17, 15, 1, -17 },
  { 397, 11, 17, 15, 2, -17 },
  { 421, 11, 17, 15, 2, -17 },
  { 445, 11, 17, 15, 2, -17 },
  { 469, 13, 17, 15, 1, -17 },
  { 497, 11, 17, 15, 2, -17 },
  { 521, 3, 13, 15, 6, -13 },
  { 526, 5, 17, 15, 5, -13 },
  { 537, 11, 14, 15, 2, -15 },
  { 557, 11, 7, 15, 2, -11 },
  { 567, 11, 14, 15, 2, -15 },
  { 587, 11, 17, 15, 2, -17 },
  { 611, 11, 20, 15, 2, -17 },
  { 639, 13, 17, 15, 1, -17 },
  { 667, 12, 17, 15, 2, -17 },
  { 693, 11, 17, 15, 2, -17 },
  { 717, 12, 17, 15, 2, -17 },
  { 743, 11, 17, 15, 2, -17 },
  { 767, 11, 17, 15, 2, -17 },
  { 791, 12, 17, 15, 1, -17 },
  { 817, 11, 17, 15, 2, -17 },
  { 841, 11, 17, 15, 2, -17 },
  { 865, 10, 17, 15, 2, -17 },
  { 887, 12, 17, 15, 2, -17 },
  { 913, 10, 17, 15, 3, -17 },
  { 935, 11, 17, 15, 2, -17 },
  { 959, 11, 17, 15, 2, -17 },
  { 983, 13, 17, 15, 1, -17 },
  { 1011, 12, 17, 15, 2, -17 },
  { 1037, 13, 21, 15, 1, -17 },
  { 1072, 12, 17, 15, 2, -17 },
  { 1098, 13, 17, 15, 1, -17 },
  { 1126, 13, 17, 15, 1, -17 },
  { 1154, 11, 17, 15, 2, -17 },
  { 1178, 13, 17, 15, 1, -17 },
  { 1206, 13, 17, 15, 1, -17 },
  { 1234, 13, 17, 15, 1, -17 },
  { 1262, 15, 17, 15, 0, -17 },
  { 1294, 13, 17, 15, 1, -17 },
  { 1322, 7, 22, 15, 6, -19 },
  { 1342, 11, 22, 15, 2, -19 },
  { 1373, 7, 22, 15, 2, -19 },
  { 1393, 13, 10, 15, 1, -17 },
  { 1410, 13, 2, 15, 1, 2 },
  { 1414, 4, 5, 15, 5, -20 },
  { 1417, 12, 13, 15, 2, -13 },
  { 1437, 12, 19, 15, 2, -19 },
  { 1466, 11, 13, 15, 2, -13 },
  { 1484, 12, 19, 15, 1, -19 },
  { 1513, 11, 13, 15, 2, -13 },
  { 1531, 12, 19, 15, 2, -19 },
  { 1560, 12, 20, 15, 2, -15 },
  { 1590, 11, 19, 15, 2, -19 },
  { 1617, 11, 19, 15, 3, -19 },
  { 1644, 9, 24, 15, 2, -19 },
  { 1671, 11, 19, 15, 3, -19 },
  { 1698, 11, 19, 15, 2, -19 },
  { 1725, 13, 13, 15, 1, -13 },
  { 1747, 11, 13, 15, 2, -13 },
  { 1765, 11, 13, 15, 2, -13 },
  { 1783, 12, 18, 15, 2, -13 },
  { 1810, 12, 18, 15, 1, -13 },
  { 1837, 12, 13, 15, 2, -13 },
  { 1857, 11, 13, 15, 2, -13 },
  { 1875, 12, 17, 15, 1, -17 },
  { 1901, 11, 13, 15, 2, -13 },
  { 1919, 11, 13, 15, 2, -13 },
  { 1937, 13, 13, 15, 1, -13 },
  { 1959, 12, 13, 15, 2, -13 },
  { 1979, 13, 18, 15, 1, -13 },
  { 2009, 11, 13, 15, 2, -13 },
  { 2027, 9, 22, 15, 3, -19 },
  { 2052, 1, 22, 15, 7, -19 },
  { 2055, 9, 22, 15, 3, -19 },
  { 2080, 13, 6, 15, 1, -10 },
};

const GFXfont IBMPlexMono_Regular25pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular25pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _IBMPLEXMONO_REGULAR25PT7B_H_
