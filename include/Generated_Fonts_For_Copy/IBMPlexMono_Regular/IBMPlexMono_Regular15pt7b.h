#ifndef _IBMPLEXMONO_REGULAR15PT7B_H_
#define _IBMPLEXMONO_REGULAR15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: IBMPlexMono-Regular.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t IBMPlexMono_Regular15pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x90, 0xFC, 0xB6, 0xD0, 0x1A, 0x09, 0x04, 0x8E, 0x71,
  0x61, 0xA3, 0x9C, 0x48, 0x24, 0x16, 0x00, 0x10, 0x21, 0xF6, 0xB9, 0x1A,
  0x1E, 0x0F, 0x13, 0x27, 0x5B, 0xE1, 0x02, 0x00, 0x71, 0xC4, 0xA2, 0x91,
  0x47, 0x40, 0xB8, 0xA2, 0x51, 0x48, 0xE3, 0x80, 0x3C, 0x33, 0x18, 0x04,
  0x03, 0x32, 0xD3, 0x29, 0x8C, 0x46, 0x3C, 0xC0, 0xF0, 0x12, 0x44, 0x88,
  0x88, 0x84, 0x42, 0x10, 0x84, 0x22, 0x11, 0x11, 0x12, 0x24, 0x80, 0x10,
  0x22, 0x4F, 0xF3, 0x85, 0x11, 0x00, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04,
  0x00, 0x6B, 0x40, 0xF8, 0xFC, 0x06, 0x08, 0x10, 0x40, 0x82, 0x04, 0x08,
  0x20, 0x41, 0x02, 0x0C, 0x00, 0x38, 0x8A, 0x0C, 0x19, 0x32, 0x60, 0xC1,
  0x44, 0x70, 0x38, 0xF3, 0x64, 0xC1, 0x83, 0x06, 0x0C, 0x19, 0xFC, 0x79,
  0x8A, 0x18, 0x30, 0x41, 0x04, 0x10, 0xC1, 0xFC, 0x79, 0x88, 0x18, 0x23,
  0x80, 0x81, 0x83, 0x84, 0xF0, 0x0C, 0x28, 0xD1, 0x24, 0x58, 0xA1, 0x7F,
  0x04, 0x08, 0x7E, 0x81, 0x02, 0x07, 0xD8, 0xC0, 0x81, 0xC6, 0xF8, 0x18,
  0x41, 0x02, 0x0B, 0xD8, 0xE0, 0xC1, 0x46, 0x78, 0xFF, 0x0E, 0x10, 0x20,
  0x81, 0x06, 0x08, 0x30, 0x40, 0x7D, 0x8E, 0x0A, 0x23, 0x98, 0xE0, 0xC1,
  0xC6, 0xF8, 0x79, 0x8A, 0x0C, 0x1C, 0x6F, 0x41, 0x02, 0x08, 0x60, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1A, 0xD0, 0x02, 0x18, 0x63, 0x08, 0x0C, 0x06,
  0x06, 0x02, 0xFE, 0x00, 0x07, 0xF0, 0x80, 0xC0, 0xC0, 0x60, 0x21, 0x8C,
  0x30, 0x80, 0x38, 0x8A, 0x18, 0x30, 0xC2, 0x04, 0x00, 0x30, 0x60, 0x38,
  0x8A, 0x0C, 0xDB, 0x74, 0x68, 0xD1, 0x9F, 0x01, 0x01, 0xE0, 0x0C, 0x0A,
  0x05, 0x02, 0x82, 0x21, 0x10, 0xF8, 0xC6, 0x41, 0x60, 0xC0, 0xFD, 0x8F,
  0x1E, 0x2F, 0x98, 0xF0, 0xE1, 0xC7, 0xF8, 0x3C, 0x8F, 0x14, 0x08, 0x10,
  0x20, 0x62, 0x46, 0x78, 0xF9, 0x8B, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC5,
  0xF0, 0xFF, 0x83, 0x06, 0x0F, 0xF8, 0x30, 0x60, 0xC1, 0xFC, 0xFF, 0x83,
  0x06, 0x0F, 0xF8, 0x30, 0x60, 0xC1, 0x80, 0x3C, 0x8A, 0x1C, 0x08, 0x13,
  0xE0, 0xC1, 0x46, 0xF4, 0x83, 0x06, 0x0C, 0x1F, 0xF0, 0x60, 0xC1, 0x83,
  0x04, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC, 0x7C, 0x10,
  0x41, 0x04, 0x10, 0x61, 0xC5, 0xE0, 0xC3, 0xC4, 0xC8, 0xD8, 0xF0, 0xF8,
  0xC8, 0xC4, 0xC6, 0xC3, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0xF0,
  0xC7, 0x8E, 0xAD, 0x5B, 0xB2, 0x64, 0xC1, 0x83, 0x04, 0xC3, 0xC6, 0x8D,
  0x19, 0x32, 0x62, 0xC5, 0x8F, 0x0C, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x44, 0x70, 0xFD, 0x8F, 0x0E, 0x1C, 0x7F, 0xB0, 0x60, 0xC1, 0x80,
  0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x44, 0xF8, 0x40, 0xE0, 0xFD,
  0x8F, 0x0E, 0x1C, 0x7F, 0xB2, 0x66, 0xC5, 0x84, 0x7D, 0x8E, 0x06, 0x07,
  0x01, 0xC0, 0xC1, 0xC6, 0xF8, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x00, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xE3,
  0x44, 0xF8, 0x83, 0x07, 0x1A, 0x24, 0x4C, 0x8A, 0x14, 0x28, 0x70, 0x83,
  0x06, 0x0C, 0x9A, 0xB5, 0x6A, 0xD5, 0xEF, 0x8C, 0x41, 0x91, 0x8C, 0x82,
  0x80, 0xC0, 0xE0, 0x50, 0x44, 0x63, 0x60, 0xC0, 0xC1, 0xB1, 0x88, 0x86,
  0xC1, 0x40, 0xE0, 0x20, 0x10, 0x08, 0x04, 0x00, 0xFE, 0x0C, 0x10, 0x41,
  0x06, 0x08, 0x20, 0x81, 0xFC, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x0F, 0x80, 0xC0, 0x81, 0x01, 0x02, 0x02, 0x04, 0x08, 0x08, 0x10, 0x10,
  0x20, 0x60, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x80, 0x10,
  0x51, 0xB2, 0x2C, 0x70, 0x40, 0xFE, 0xB4, 0x79, 0x88, 0x13, 0xEC, 0x50,
  0xB3, 0x3B, 0xC1, 0x83, 0x07, 0xEC, 0x78, 0x70, 0xE1, 0xC3, 0x8F, 0xF0,
  0x3C, 0x8F, 0x06, 0x0C, 0x18, 0x11, 0x9E, 0x06, 0x0C, 0x1B, 0xFC, 0x70,
  0xE1, 0xC3, 0x87, 0x8D, 0xF8, 0x38, 0x8A, 0x0F, 0xF8, 0x10, 0x91, 0x9C,
  0x1E, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x08, 0x10, 0x23, 0xF8, 0x06, 0x79,
  0x16, 0x24, 0x48, 0x9E, 0x20, 0x7F, 0x06, 0x0B, 0xE0, 0xC1, 0x83, 0x06,
  0xEE, 0x58, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0x30, 0xC0, 0x3C, 0x30, 0xC3,
  0x0C, 0x30, 0xCF, 0xC0, 0x0C, 0x30, 0x3E, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x09, 0xE0, 0x81, 0x02, 0x04, 0x69, 0x96, 0x38, 0x48, 0x99, 0x1A,
  0x18, 0xF0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x23, 0xF8, 0xA7,
  0xB6, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0xDD, 0xCB, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x51, 0x1C, 0xFD, 0x8F, 0x0E, 0x1C,
  0x38, 0x71, 0xFE, 0xC1, 0x83, 0x00, 0x7F, 0x8E, 0x1C, 0x38, 0x70, 0xF1,
  0xBF, 0x06, 0x0C, 0x18, 0xF6, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x7F, 0x7C,
  0x8F, 0x03, 0x80, 0xE0, 0x71, 0xBE, 0x20, 0x43, 0xF9, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x3C, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xD1, 0xBF, 0x83, 0x8D,
  0x12, 0x22, 0x85, 0x0A, 0x08, 0xC9, 0xAC, 0x95, 0x4A, 0xA5, 0x52, 0xA9,
  0x94, 0x44, 0xC6, 0x88, 0xA1, 0x83, 0x85, 0x11, 0x63, 0x83, 0x8D, 0x12,
  0x22, 0x85, 0x0E, 0x08, 0x10, 0x43, 0x80, 0xFE, 0x08, 0x20, 0xC3, 0x0C,
  0x10, 0x7F, 0x39, 0x08, 0x41, 0x0B, 0x86, 0x11, 0x08, 0x43, 0x80, 0xFF,
  0xF8, 0xE1, 0x08, 0x44, 0x20, 0xEC, 0x41, 0x08, 0x4E, 0x00, 0x63, 0x26,
  0x30,
};

const GFXglyph IBMPlexMono_Regular15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 10, 9, 3, -10 },
  { 5, 3, 4, 9, 3, -11 },
  { 7, 9, 10, 9, 0, -10 },
  { 19, 7, 14, 9, 1, -12 },
  { 32, 9, 10, 9, 0, -10 },
  { 44, 9, 10, 9, 0, -10 },
  { 56, 1, 4, 9, 4, -11 },
  { 57, 4, 13, 9, 3, -11 },
  { 64, 4, 13, 9, 2, -11 },
  { 71, 7, 7, 9, 1, -9 },
  { 78, 7, 7, 9, 1, -8 },
  { 85, 3, 4, 9, 3, -2 },
  { 87, 5, 1, 9, 2, -5 },
  { 88, 3, 2, 9, 3, -2 },
  { 89, 7, 13, 9, 1, -11 },
  { 101, 7, 10, 9, 1, -10 },
  { 110, 7, 10, 9, 1, -10 },
  { 119, 7, 10, 9, 1, -10 },
  { 128, 7, 10, 9, 1, -10 },
  { 137, 7, 10, 9, 1, -10 },
  { 146, 7, 10, 9, 1, -10 },
  { 155, 7, 10, 9, 1, -10 },
  { 164, 7, 10, 9, 1, -10 },
  { 173, 7, 10, 9, 1, -10 },
  { 182, 7, 10, 9, 1, -10 },
  { 191, 3, 8, 9, 3, -8 },
  { 194, 3, 10, 9, 3, -8 },
  { 198, 7, 9, 9, 1, -9 },
  { 206, 7, 4, 9, 1, -7 },
  { 210, 7, 9, 9, 1, -9 },
  { 218, 7, 10, 9, 1, -10 },
  { 227, 7, 12, 9, 1, -10 },
  { 238, 9, 10, 9, 0, -10 },
  { 250, 7, 10, 9, 1, -10 },
  { 259, 7, 10, 9, 1, -10 },
  { 268, 7, 10, 9, 1, -10 },
  { 277, 7, 10, 9, 1, -10 },
  { 286, 7, 10, 9, 1, -10 },
  { 295, 7, 10, 9, 1, -10 },
  { 304, 7, 10, 9, 1, -10 },
  { 313, 7, 10, 9, 1, -10 },
  { 322, 6, 10, 9, 1, -10 },
  { 330, 8, 10, 9, 1, -10 },
  { 340, 6, 10, 9, 2, -10 },
  { 348, 7, 10, 9, 1, -10 },
  { 357, 7, 10, 9, 1, -10 },
  { 366, 7, 10, 9, 1, -10 },
  { 375, 7, 10, 9, 1, -10 },
  { 384, 7, 12, 9, 1, -10 },
  { 395, 7, 10, 9, 1, -10 },
  { 404, 7, 10, 9, 1, -10 },
  { 413, 9, 10, 9, 0, -10 },
  { 425, 7, 10, 9, 1, -10 },
  { 434, 7, 10, 9, 1, -10 },
  { 443, 7, 10, 9, 1, -10 },
  { 452, 9, 10, 9, 0, -10 },
  { 464, 9, 10, 9, 0, -10 },
  { 476, 7, 10, 9, 1, -10 },
  { 485, 5, 13, 9, 3, -11 },
  { 494, 7, 13, 9, 1, -11 },
  { 506, 5, 13, 9, 1, -11 },
  { 515, 7, 6, 9, 1, -10 },
  { 521, 7, 1, 9, 1, 1 },
  { 522, 2, 3, 9, 3, -12 },
  { 523, 7, 8, 9, 1, -8 },
  { 530, 7, 11, 9, 1, -11 },
  { 540, 7, 8, 9, 1, -8 },
  { 547, 7, 11, 9, 1, -11 },
  { 557, 7, 8, 9, 1, -8 },
  { 564, 7, 11, 9, 1, -11 },
  { 574, 7, 12, 9, 1, -9 },
  { 585, 7, 11, 9, 1, -11 },
  { 595, 6, 11, 9, 2, -11 },
  { 604, 6, 14, 9, 1, -11 },
  { 615, 7, 11, 9, 2, -11 },
  { 625, 7, 11, 9, 1, -11 },
  { 635, 7, 8, 9, 1, -8 },
  { 642, 7, 8, 9, 1, -8 },
  { 649, 7, 8, 9, 1, -8 },
  { 656, 7, 11, 9, 1, -8 },
  { 666, 7, 11, 9, 1, -8 },
  { 676, 7, 8, 9, 1, -8 },
  { 683, 7, 8, 9, 1, -8 },
  { 690, 7, 10, 9, 1, -10 },
  { 699, 7, 8, 9, 1, -8 },
  { 706, 7, 8, 9, 1, -8 },
  { 713, 9, 8, 9, 0, -8 },
  { 722, 7, 8, 9, 1, -8 },
  { 729, 7, 11, 9, 1, -8 },
  { 739, 7, 8, 9, 1, -8 },
  { 746, 5, 13, 9, 2, -11 },
  { 755, 1, 13, 9, 4, -11 },
  { 757, 5, 13, 9, 2, -11 },
  { 766, 7, 3, 9, 1, -6 },
};

const GFXfont IBMPlexMono_Regular15pt7b PROGMEM = {
  (uint8_t  *)IBMPlexMono_Regular15pt7bBitmaps,
  (GFXglyph *)IBMPlexMono_Regular15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _IBMPLEXMONO_REGULAR15PT7B_H_
