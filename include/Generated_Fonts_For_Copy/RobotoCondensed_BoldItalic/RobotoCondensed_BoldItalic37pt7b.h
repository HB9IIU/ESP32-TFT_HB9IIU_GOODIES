#ifndef _ROBOTOCONDENSED_BOLDITALIC37PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x1F,
  0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x38, 0x00, 0x39, 0xE7, 0x3D, 0xE7, 0xBC,
  0xE7, 0x1C, 0xE3, 0x9C, 0xF3, 0x9C, 0xE3, 0x9C, 0x70, 0x00, 0x73, 0x80,
  0x3C, 0xE0, 0x0E, 0x78, 0x03, 0x9C, 0x01, 0xE7, 0x00, 0x71, 0xC0, 0x1C,
  0xE0, 0x0F, 0x38, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0x1C, 0x70,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0xFF, 0xFF, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE0, 0x73, 0x80, 0x38, 0xE0, 0x0E, 0x78, 0x03, 0x9C,
  0x01, 0xE7, 0x00, 0x73, 0xC0, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x1F, 0xF8, 0x1F,
  0xFE, 0x1F, 0x9F, 0x0F, 0x87, 0x87, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0x80, 0x03, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8,
  0x7E, 0x3E, 0x7E, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x00, 0x0F,
  0xE0, 0x07, 0xFC, 0x01, 0xE7, 0x0C, 0x71, 0xC7, 0xBC, 0x71, 0xCF, 0x1C,
  0xE3, 0xCF, 0x78, 0xF3, 0x9C, 0x1F, 0xEE, 0x07, 0xF7, 0x00, 0x7B, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x3D, 0xE0, 0x1E, 0xFC, 0x07, 0x7F, 0x83,
  0xBC, 0xE1, 0xEE, 0x3C, 0x73, 0x8F, 0x38, 0xE3, 0x9E, 0x38, 0xE7, 0x0E,
  0x78, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x0F, 0x9E, 0x03, 0xC7, 0x81, 0xF1, 0xE0,
  0x7C, 0x78, 0x1F, 0x3E, 0x03, 0xDF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xC0, 0x07, 0xF8, 0xF3, 0xFE, 0x3D, 0xFF, 0xDF, 0xF9, 0xF7, 0xBE, 0x7F,
  0xEF, 0x8F, 0xFB, 0xE1, 0xFC, 0xF8, 0x7E, 0x3F, 0x1F, 0x8F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xE3, 0xE0, 0x39, 0xE7, 0x9E, 0x79, 0xC7,
  0x1C, 0xF3, 0xC0, 0x00, 0x40, 0x1C, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0x80, 0x02, 0x00, 0x30, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x07, 0x00,
  0x40, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x04, 0x1C, 0x2E,
  0x3B, 0xFF, 0xFF, 0xBF, 0xFF, 0x0F, 0xF0, 0x1F, 0x80, 0x7F, 0x00, 0xFF,
  0x03, 0xCE, 0x0F, 0x1E, 0x0C, 0x1C, 0x00, 0x20, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x7F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x1E,
  0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0xF0, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x23, 0xEF, 0xBF, 0xF9, 0xC0, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF3, 0xF3,
  0xE7, 0xC7, 0xDF, 0x07, 0xBE, 0x0F, 0x7C, 0x1E, 0xF8, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1E, 0xF8, 0x7D, 0xE0,
  0xFB, 0xC1, 0xF7, 0x83, 0xCF, 0x0F, 0x9F, 0x3F, 0x3F, 0xFC, 0x3F, 0xF0,
  0x3F, 0xC0, 0x3F, 0x00, 0x00, 0x60, 0x3C, 0x3F, 0xBF, 0xF7, 0xFD, 0xFF,
  0xBF, 0xF6, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F,
  0xFE, 0x0F, 0x8F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFF, 0x80, 0x01, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3,
  0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x3C, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC7,
  0xE7, 0xE3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xE0, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8,
  0x03, 0xFC, 0x03, 0xFE, 0x03, 0xDF, 0x01, 0xEF, 0x81, 0xE7, 0xC1, 0xF7,
  0xC0, 0xF3, 0xE0, 0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0x7C, 0x7F, 0xFF, 0xBF,
  0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF0, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x78, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xE1,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x3E, 0x0F, 0x9F,
  0x07, 0xCF, 0x87, 0xE3, 0xE7, 0xE1, 0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x7E, 0x7E, 0x7C, 0x3E, 0x7C, 0x1F, 0x7C,
  0x1F, 0x78, 0x1F, 0x78, 0x3E, 0x78, 0x3E, 0x7C, 0x3E, 0x7C, 0xFC, 0x3F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xE1,
  0xF9, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F,
  0x87, 0xCF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xF0, 0xFC,
  0xF8, 0x7C, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC7,
  0xE7, 0xE1, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x0F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE3, 0xF7, 0xE7, 0xC7, 0xDF, 0x0F,
  0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xE0, 0xFB, 0xE1, 0xF7, 0xC3, 0xEF,
  0x8F, 0xDF, 0xFF, 0x1F, 0xFE, 0x3F, 0xFC, 0x1E, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xF0, 0x00,
  0x04, 0x1F, 0x3F, 0x3F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0xF8, 0xF8, 0xFC, 0xF8, 0x70, 0x01, 0x80, 0x78,
  0x1F, 0x83, 0xF0, 0x7C, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0x10, 0x00,
  0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0xFF, 0xE7, 0xFC,
  0x3F, 0xC0, 0xF8, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F,
  0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x20, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x10, 0x00, 0x70, 0x00, 0xF8, 0x01,
  0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x01,
  0xF8, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0x7C, 0x00,
  0xE0, 0x01, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFF, 0x7E,
  0x7D, 0xF1, 0xF7, 0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x3C, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x3E, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x1C,
  0x1C, 0x00, 0x07, 0x1E, 0x0F, 0x83, 0x8E, 0x0F, 0xF1, 0xCF, 0x0F, 0xF8,
  0xE7, 0x0F, 0x1C, 0x77, 0x8F, 0x1E, 0x3B, 0x87, 0x8F, 0x1D, 0xC7, 0x87,
  0x0F, 0xE3, 0xC3, 0x87, 0xF1, 0xC3, 0xC3, 0xF1, 0xE1, 0xE1, 0xF8, 0xF0,
  0xE1, 0xDC, 0x78, 0x70, 0xEE, 0x3C, 0x78, 0x77, 0x1E, 0x3C, 0x73, 0x8F,
  0x3E, 0x79, 0xC3, 0xFF, 0xF8, 0xE1, 0xFB, 0xF8, 0x70, 0x78, 0xF8, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x38, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x01,
  0xF0, 0xF0, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xC1, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0x80, 0xFC, 0xFC,
  0x03, 0xE7, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xC0, 0x07, 0xFE,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0x8F, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F,
  0x07, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x83,
  0xE0, 0xFC, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0xFC,
  0x7C, 0x0F, 0xC7, 0xC3, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF,
  0xFC, 0x0F, 0xCF, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xE0, 0x3F, 0x3E,
  0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7C,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x87, 0xE3, 0xF0, 0x3F, 0xFF,
  0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0x8F, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1,
  0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x7E,
  0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F,
  0x87, 0xC7, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF,
  0x81, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x81, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xC7, 0xE1, 0xF8, 0x3E, 0x1F, 0x03, 0xE3, 0xE0,
  0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x3F, 0xE7, 0xC3, 0xFE, 0x7C, 0x3F, 0xE7, 0xC3, 0xFC, 0x7C, 0x07, 0xC7,
  0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0xC7, 0xF3, 0xF8,
  0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xC0,
  0x7E, 0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xF8,
  0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C,
  0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F,
  0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xFC, 0x7C, 0x1F, 0xBF, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xFC,
  0x1F, 0x83, 0xF0, 0x3E, 0x0F, 0xE0, 0x7C, 0x1F, 0x80, 0xF8, 0x7E, 0x01,
  0xF1, 0xF8, 0x03, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0x3E,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7E, 0x7C,
  0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xF0,
  0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF0, 0x1F, 0x80,
  0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0,
  0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0,
  0x3F, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0xFF, 0xC1, 0xFF, 0x0F, 0x7C, 0x1E, 0x70, 0xF7, 0xC3, 0xE7,
  0x1E, 0x78, 0x3E, 0x79, 0xEF, 0x83, 0xE7, 0xBC, 0xF8, 0x3E, 0x7B, 0xCF,
  0x83, 0xE7, 0xF8, 0xF8, 0x7E, 0x7F, 0x9F, 0x87, 0xC7, 0xF9, 0xF0, 0x7C,
  0x7F, 0x1F, 0x07, 0xC3, 0xF1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE1,
  0xF0, 0xFC, 0x3C, 0x3F, 0x0F, 0x83, 0xC3, 0xE0, 0x07, 0xC0, 0x7E, 0x1F,
  0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7F, 0x03, 0xE0, 0xFE, 0x07, 0xC1, 0xFC,
  0x1F, 0x83, 0xFC, 0x3E, 0x0F, 0xF8, 0x7C, 0x1F, 0xF0, 0xF8, 0x3E, 0xE1,
  0xF0, 0x7D, 0xE3, 0xE0, 0xFB, 0xCF, 0xC1, 0xF7, 0x9F, 0x07, 0xE7, 0x3E,
  0x0F, 0x8F, 0x7C, 0x1F, 0x1E, 0xF8, 0x3E, 0x3D, 0xF0, 0x7C, 0x3F, 0xE1,
  0xF8, 0x7F, 0x83, 0xF0, 0xFF, 0x07, 0xC0, 0xFE, 0x0F, 0x81, 0xFC, 0x1F,
  0x03, 0xF8, 0x3E, 0x07, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xEF, 0xE1,
  0xF8, 0x3E, 0x1F, 0x03, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F,
  0x7E, 0x01, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E, 0x7C, 0x03,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x7C, 0x07, 0xC7, 0xC0,
  0x7C, 0x7C, 0x0F, 0x87, 0xF3, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0x87, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1, 0xF8, 0x1F,
  0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xF1, 0xF0, 0x3F, 0x1F, 0x0F,
  0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xCF, 0xE1, 0xF8, 0x3E,
  0x1F, 0x03, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7E, 0x01,
  0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C,
  0x0F, 0x87, 0xF3, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xE0,
  0x00, 0x04, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F,
  0x03, 0xF1, 0xF0, 0x3E, 0x1F, 0x07, 0xE1, 0xF0, 0xFC, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x3E, 0x3F, 0x07, 0xE3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x87, 0xC1, 0xF8, 0xFC, 0x0F, 0x8F, 0x80, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFC, 0xFC, 0x3E, 0x0F, 0x8F, 0xC1,
  0xF1, 0xF0, 0x3E, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0xC1, 0xF0, 0xFC, 0xFE,
  0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF1,
  0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xF1, 0xF0, 0x3E,
  0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07,
  0xE3, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0,
  0x7C, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0x7C,
  0x1F, 0x87, 0xE7, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7C,
  0xFC, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC3, 0xF0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7C, 0x03, 0xC7,
  0xC0, 0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x3E, 0xF8, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x1E, 0x0F, 0xBE, 0x0F,
  0x83, 0xEF, 0x83, 0xE0, 0xFB, 0xE1, 0xF8, 0x7C, 0xF8, 0x7E, 0x1F, 0x3E,
  0x1F, 0x87, 0xCF, 0x8F, 0xE3, 0xE3, 0xE3, 0xF8, 0xF8, 0xF8, 0xFE, 0x3E,
  0x3E, 0x7F, 0x8F, 0x0F, 0x9F, 0xE7, 0xC3, 0xE7, 0xF9, 0xF0, 0xFB, 0xFE,
  0x78, 0x3E, 0xF7, 0xBE, 0x07, 0xBD, 0xEF, 0x81, 0xFF, 0x7B, 0xC0, 0x7F,
  0x9F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x0F,
  0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x3E, 0x3F, 0x00, 0x7C,
  0x7C, 0x00, 0xF9, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0x7C, 0x00, 0x7E, 0xFC, 0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x0F,
  0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xFF, 0x81, 0xF9, 0xF0, 0x3F, 0x3E, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8,
  0x7E, 0x0F, 0x0F, 0x81, 0xF3, 0xF0, 0x3E, 0x7C, 0x07, 0xDF, 0x00, 0x7B,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x00, 0xF8,
  0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07,
  0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x07, 0x83, 0xE1, 0xF0, 0x03, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x00, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3B, 0x83, 0xDE, 0x3C, 0xF1, 0xE7,
  0x9E, 0x1C, 0xF0, 0xEF, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7C, 0x7C, 0x3E, 0x1E, 0x1E, 0x01, 0xF0, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1F, 0x3E, 0x3E, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x07,
  0xFE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x3E, 0xFC, 0x7C, 0xF8,
  0x7C, 0xFC, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1E, 0x7C, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x7C, 0x0F, 0xFF, 0x07, 0xFF, 0xC3, 0xFF,
  0xE1, 0xF9, 0xF1, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F,
  0x07, 0x8F, 0x87, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0xFC,
  0xFC, 0xFC, 0x7F, 0xFE, 0x7F, 0xFE, 0x3E, 0xFE, 0x1F, 0x3E, 0x00, 0x03,
  0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE7, 0xCF, 0x87, 0xDF, 0x0F,
  0xFC, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x0F, 0xBE, 0x1E, 0x7C, 0x7C, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x07, 0x9F, 0x07, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x7F, 0x1F, 0x0F, 0xC7, 0xC3, 0xE3, 0xE0,
  0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C,
  0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xF3, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x07,
  0xFF, 0x80, 0xF9, 0xE0, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF, 0xE3,
  0xE3, 0xEF, 0x87, 0xDF, 0x0F, 0xBC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x04, 0x7E, 0x3C, 0x7F, 0xF8,
  0xFF, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F,
  0xF0, 0xFE, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x7F, 0xE3, 0xFF, 0x1F, 0xF8,
  0xFF, 0xC1, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE7, 0xC3, 0xFD, 0xF0, 0xFF, 0xF8, 0x7F,
  0xFE, 0x3F, 0x1F, 0x8F, 0x83, 0xE3, 0xE0, 0xF9, 0xF0, 0x3E, 0x7C, 0x1F,
  0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7,
  0xC3, 0xE1, 0xF9, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3E,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC1, 0xC3, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x7C, 0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0x3F, 0x3E, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0x07, 0x83, 0xE0, 0xFC, 0x3E, 0x07, 0x00, 0x00, 0x00,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x80, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x0F, 0xC7,
  0xC7, 0xE1, 0xF3, 0xF0, 0x7C, 0xF8, 0x1F, 0x7E, 0x0F, 0xBF, 0x03, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0,
  0x7E, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x78, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xE3, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0x1F, 0x7C, 0x3E, 0x0F, 0xFF, 0x3F, 0x87,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xF3, 0xF9, 0xF9, 0xF0, 0xF8, 0x7C,
  0xF8, 0x7C, 0x3E, 0x7C, 0x3E, 0x1F, 0x3E, 0x1F, 0x0F, 0x9F, 0x0F, 0x87,
  0xCF, 0x87, 0x87, 0xEF, 0x87, 0xC3, 0xE7, 0xC3, 0xE1, 0xF3, 0xE1, 0xF0,
  0xF9, 0xF0, 0xF8, 0x7C, 0xF8, 0x7C, 0x3E, 0x78, 0x3C, 0x3F, 0x7C, 0x3E,
  0x1F, 0x3E, 0x1F, 0x0F, 0x9F, 0x0F, 0x87, 0xC0, 0x1F, 0x7C, 0x1F, 0xFE,
  0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0x3F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F,
  0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C,
  0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3E, 0x3E, 0x7C, 0x3E,
  0x7C, 0x1E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E,
  0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xFC, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xC0, 0x0F, 0xBE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0F, 0x8F, 0x87, 0xC3, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07,
  0xC7, 0xC3, 0xE1, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3,
  0xE1, 0xF0, 0xFC, 0xFC, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xDF, 0xC1, 0xF3,
  0xE0, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x07, 0x8F, 0x1F, 0xEF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x7E, 0x7F, 0x7C, 0x3F, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xFC, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x1E, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0x78, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x1F,
  0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3E, 0x3E, 0x3E, 0x1F,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0x7F, 0xF8, 0x7F, 0xF8,
  0x3F, 0xF0, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x87, 0xFE, 0xFF,
  0xBF, 0xF7, 0xFE, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xF0, 0xFE, 0x0F, 0xC0,
  0xF8, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFC, 0xFC, 0xFF, 0xFC, 0x7F,
  0xFC, 0x7F, 0x78, 0x3E, 0xF8, 0xF8, 0x3F, 0xF0, 0xFB, 0xE1, 0xF7, 0xC3,
  0xEF, 0x8F, 0x9F, 0x1F, 0x1E, 0x3C, 0x3C, 0xF8, 0x79, 0xF0, 0xF7, 0xC1,
  0xEF, 0x83, 0xDE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x78, 0x7B, 0xE3, 0xE3,
  0xEF, 0x8F, 0x8F, 0xBE, 0x3E, 0x3C, 0xF9, 0xF9, 0xF3, 0xE7, 0xE7, 0xCF,
  0xBF, 0x9E, 0x3E, 0xFE, 0xF8, 0xFB, 0xBB, 0xE3, 0xFE, 0xEF, 0x0F, 0xFB,
  0xFC, 0x3F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0, 0x1E,
  0x0F, 0x80, 0x1F, 0x0F, 0xC3, 0xE3, 0xE0, 0xF9, 0xF8, 0x3E, 0x7C, 0x07,
  0xBE, 0x01, 0xEF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF7, 0x80,
  0xFD, 0xF0, 0x3E, 0x7C, 0x1F, 0x9F, 0x07, 0xC3, 0xE3, 0xF0, 0xF8, 0x1F,
  0x07, 0xC7, 0xC3, 0xF1, 0xF0, 0xF8, 0x7C, 0x7E, 0x1F, 0x1F, 0x07, 0xC7,
  0xC0, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0x3E, 0x03, 0xDF, 0x00, 0xF7, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFE, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xFC,
  0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x60, 0x1C, 0x0F, 0x81, 0xE0,
  0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0x81, 0xF0, 0xFC, 0x1F, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x06, 0x00, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x04, 0x00, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3C, 0x0F, 0x83, 0xF0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0xF8,
  0x1E, 0x03, 0x80, 0x60, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0xF3, 0xFC, 0x39,
  0xFF, 0x9E, 0x79, 0xFF, 0x9C, 0x3F, 0xCF, 0x07, 0xF0, 0x00, 0xF0,
};

const GFXglyph RobotoCondensed_BoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 26, 9, 1, -26 },
  { 31, 11, 10, 12, 2, -28 },
  { 45, 18, 26, 19, 1, -26 },
  { 104, 17, 34, 18, 1, -30 },
  { 177, 18, 26, 23, 3, -26 },
  { 236, 18, 26, 21, 1, -26 },
  { 295, 6, 10, 6, 2, -28 },
  { 303, 11, 37, 12, 2, -29 },
  { 354, 12, 37, 12, -2, -29 },
  { 410, 15, 16, 16, 2, -26 },
  { 440, 16, 19, 17, 1, -22 },
  { 478, 8, 11, 9, -2, -4 },
  { 489, 9, 4, 13, 2, -13 },
  { 494, 6, 6, 10, 1, -6 },
  { 499, 16, 28, 12, -2, -26 },
  { 555, 15, 26, 18, 2, -26 },
  { 604, 11, 26, 18, 4, -26 },
  { 640, 18, 26, 18, 0, -26 },
  { 699, 17, 26, 18, 1, -26 },
  { 755, 17, 26, 18, 0, -26 },
  { 811, 17, 26, 18, 1, -26 },
  { 867, 16, 26, 18, 1, -26 },
  { 919, 17, 26, 18, 2, -26 },
  { 975, 17, 26, 18, 1, -26 },
  { 1031, 15, 26, 18, 2, -26 },
  { 1080, 8, 21, 10, 1, -21 },
  { 1101, 11, 28, 9, -2, -21 },
  { 1140, 14, 17, 16, 1, -20 },
  { 1170, 16, 12, 18, 1, -18 },
  { 1194, 15, 18, 16, 1, -20 },
  { 1228, 14, 26, 16, 2, -26 },
  { 1274, 25, 34, 28, 1, -26 },
  { 1381, 21, 26, 21, -2, -26 },
  { 1450, 20, 26, 20, 0, -26 },
  { 1515, 20, 26, 20, 1, -26 },
  { 1580, 20, 26, 20, 0, -26 },
  { 1645, 19, 26, 18, 0, -26 },
  { 1707, 19, 26, 17, 0, -26 },
  { 1769, 20, 26, 21, 1, -26 },
  { 1834, 23, 26, 22, 0, -26 },
  { 1909, 10, 26, 10, 0, -26 },
  { 1942, 18, 26, 18, 0, -26 },
  { 2001, 23, 26, 20, 0, -26 },
  { 2076, 15, 26, 17, 0, -26 },
  { 2125, 28, 26, 27, 0, -26 },
  { 2216, 23, 26, 22, 0, -26 },
  { 2291, 20, 26, 22, 1, -26 },
  { 2356, 20, 26, 20, 0, -26 },
  { 2421, 20, 31, 22, 1, -26 },
  { 2499, 20, 26, 20, 0, -26 },
  { 2564, 19, 26, 19, 1, -26 },
  { 2626, 18, 26, 20, 3, -26 },
  { 2685, 20, 26, 21, 1, -26 },
  { 2750, 20, 26, 21, 3, -26 },
  { 2815, 26, 26, 27, 3, -26 },
  { 2900, 23, 26, 20, -1, -26 },
  { 2975, 19, 26, 20, 3, -26 },
  { 3037, 21, 26, 19, -1, -26 },
  { 3106, 13, 37, 9, -1, -31 },
  { 3167, 9, 28, 14, 3, -26 },
  { 3199, 13, 37, 9, -2, -31 },
  { 3260, 13, 13, 14, 1, -26 },
  { 3282, 14, 4, 14, -2, 0 },
  { 3289, 8, 6, 12, 4, -28 },
  { 3295, 16, 20, 17, 0, -20 },
  { 3335, 17, 28, 18, 0, -28 },
  { 3395, 15, 20, 17, 1, -20 },
  { 3433, 18, 28, 18, 1, -28 },
  { 3496, 15, 20, 17, 1, -20 },
  { 3534, 13, 28, 12, 1, -28 },
  { 3580, 18, 28, 18, 0, -20 },
  { 3643, 16, 28, 18, 0, -28 },
  { 3699, 10, 27, 9, 0, -27 },
  { 3733, 14, 35, 9, -4, -27 },
  { 3795, 18, 28, 17, 0, -28 },
  { 3858, 10, 28, 9, 0, -28 },
  { 3893, 25, 20, 27, 0, -20 },
  { 3956, 16, 20, 18, 0, -20 },
  { 3996, 16, 20, 18, 1, -20 },
  { 4036, 18, 28, 18, -1, -20 },
  { 4099, 16, 28, 18, 1, -20 },
  { 4155, 13, 20, 12, 0, -20 },
  { 4188, 16, 20, 16, 0, -20 },
  { 4228, 11, 24, 11, 1, -24 },
  { 4261, 16, 20, 18, 1, -20 },
  { 4301, 15, 20, 16, 2, -20 },
  { 4339, 22, 20, 23, 2, -20 },
  { 4394, 18, 20, 16, -1, -20 },
  { 4439, 18, 28, 16, -1, -20 },
  { 4502, 16, 20, 16, 0, -20 },
  { 4542, 11, 36, 11, 1, -29 },
  { 4592, 8, 31, 9, 1, -26 },
  { 4623, 11, 36, 11, -1, -29 },
  { 4673, 18, 8, 20, 1, -15 },
};

const GFXfont RobotoCondensed_BoldItalic37pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic37pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic37pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _ROBOTOCONDENSED_BOLDITALIC37PT7B_H_
