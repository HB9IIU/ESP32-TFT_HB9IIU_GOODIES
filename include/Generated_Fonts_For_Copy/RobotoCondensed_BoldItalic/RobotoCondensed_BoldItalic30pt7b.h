#ifndef _ROBOTOCONDENSED_BOLDITALIC30PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x79, 0xF3, 0xC7, 0x8F, 0x1E, 0x3C, 0x71, 0xE3, 0xC7,
  0x8E, 0x1C, 0x00, 0x01, 0xC3, 0xC7, 0x8F, 0x1C, 0x00, 0x73, 0x3B, 0x9D,
  0xDC, 0xEE, 0x77, 0x33, 0x99, 0x8C, 0x01, 0x9C, 0x03, 0x38, 0x0E, 0x60,
  0x1D, 0xC0, 0x33, 0x80, 0xE6, 0x0F, 0xFF, 0x9F, 0xFE, 0x3F, 0xFC, 0x1D,
  0xC0, 0x33, 0x80, 0xE6, 0x01, 0xCC, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF8,
  0x3B, 0x80, 0x67, 0x01, 0xCC, 0x03, 0xB8, 0x06, 0x70, 0x1C, 0xC0, 0x00,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x07, 0x80, 0xFF, 0x0F, 0xFC, 0x7F, 0xE7,
  0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xBC, 0x3D, 0xE1, 0xEF, 0x1F, 0x7D, 0xF1,
  0xFF, 0x87, 0xF8, 0x1F, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x3C, 0x01,
  0xF8, 0x0F, 0xE1, 0x39, 0xCE, 0xC7, 0x3B, 0x19, 0xCC, 0x6E, 0x3B, 0xB0,
  0xFD, 0xC1, 0xEE, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0xF0, 0x37, 0xE1, 0xFF,
  0x8E, 0xE7, 0x33, 0x9D, 0xCC, 0x7E, 0x31, 0x90, 0xEE, 0x03, 0xF0, 0x03,
  0x80, 0x01, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7B, 0xC0, 0xE3, 0x81, 0xC7,
  0x03, 0x9E, 0x07, 0x78, 0x0F, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0xFC, 0x73,
  0xFC, 0xEF, 0xFB, 0xDE, 0x7F, 0xBC, 0xFE, 0x78, 0xFC, 0xF1, 0xF1, 0xF7,
  0xE3, 0xFF, 0xE3, 0xFF, 0xC3, 0xE7, 0xC0, 0x77, 0x7E, 0xEE, 0xEE, 0x00,
  0x80, 0x60, 0x3C, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x03,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x06,
  0x00, 0x80, 0x08, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC1,
  0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0F, 0x07, 0x02,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x17, 0x33, 0xBF, 0xFC, 0x7F,
  0xC1, 0xE0, 0x1F, 0x80, 0xEC, 0x0E, 0x70, 0xE1, 0xC0, 0x08, 0x00, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x38, 0x71, 0xE3, 0xC7, 0x1E, 0x78, 0x60, 0x7F, 0x7F, 0x7F, 0x0F, 0xFF,
  0xE0, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x3D, 0xF3, 0xC7,
  0x9E, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xFF,
  0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x8F, 0x1E, 0xF8, 0xFF,
  0x83, 0xF8, 0x0F, 0x80, 0x00, 0x83, 0xC7, 0xEF, 0xF7, 0xFF, 0xFA, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x03, 0xE0, 0x1F, 0xE0, 0xFF, 0x87, 0xDF,
  0x1E, 0x3C, 0xF0, 0xF3, 0xC3, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF8,
  0x07, 0xC0, 0x3F, 0xFE, 0xFF, 0xF3, 0xFF, 0xC0, 0x03, 0xE0, 0x3F, 0xE0,
  0xFF, 0x87, 0xDF, 0x1E, 0x3C, 0xF0, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x1F, 0xC0, 0x7C, 0x01, 0xFC, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0xF0, 0x79, 0xE3, 0xC7, 0xDF, 0x1F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0x00,
  0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x81,
  0xDE, 0x0F, 0x78, 0x39, 0xE1, 0xEF, 0x0F, 0x3C, 0x38, 0xF1, 0xE3, 0xC7,
  0xFF, 0xBF, 0xFE, 0xFF, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0x87, 0xFE, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0xF0, 0x3F, 0xE1, 0xFF, 0x87, 0x9F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0xF0, 0xF3, 0xC7, 0x8F, 0xBE, 0x1F,
  0xF0, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x81, 0xFC, 0x1F, 0xE1,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0xF8, 0x7F, 0xE3, 0xFF, 0x9F, 0x7C, 0xF1,
  0xEF, 0x8F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF3, 0x8F, 0x9E, 0xF8,
  0xFF, 0x83, 0xFC, 0x0F, 0x80, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x7F, 0x87,
  0xFE, 0x3D, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3E, 0xF0, 0xFF,
  0x07, 0xF0, 0x7F, 0xC7, 0x9E, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7,
  0x8F, 0x3E, 0xF8, 0xFF, 0x87, 0xF8, 0x0F, 0x80, 0x07, 0x81, 0xFC, 0x3F,
  0xE7, 0xDE, 0x78, 0xF7, 0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1,
  0xFF, 0x9E, 0x7F, 0xE7, 0xFE, 0x3D, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x7F,
  0x07, 0xE0, 0x7C, 0x07, 0x00, 0x00, 0xF3, 0xCF, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x23, 0xCF, 0x3C, 0xE0, 0x04, 0x0F, 0x1F, 0x0F, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x3C, 0x38, 0x78,
  0x78, 0xF0, 0xE0, 0x40, 0x00, 0x20, 0x0E, 0x03, 0xE0, 0xFE, 0x3F, 0xCF,
  0xF0, 0xF8, 0x0F, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0x7C, 0x03, 0x80,
  0x08, 0x3F, 0xF9, 0xFF, 0x9F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xDF, 0xFC, 0xFF, 0xE0, 0x20, 0x03, 0x80, 0x3E, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xE0, 0x3E, 0x1F, 0xE7, 0xF8, 0xFE, 0x0F, 0x80, 0xE0, 0x08,
  0x00, 0x0F, 0x87, 0xF9, 0xFF, 0xBF, 0xFF, 0x1F, 0xE3, 0xC0, 0x78, 0x1F,
  0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x03, 0xE7, 0xC0, 0x78, 0x0E, 0x0E, 0x00, 0x61, 0xC0, 0x07, 0x1C,
  0x7C, 0x73, 0x8F, 0xE3, 0x31, 0xFE, 0x37, 0x1C, 0xE3, 0x73, 0x8E, 0x3E,
  0x38, 0xE3, 0xE7, 0x0C, 0x3E, 0x71, 0xC7, 0xE7, 0x1C, 0x7C, 0x71, 0xC6,
  0xC7, 0x18, 0x6C, 0x73, 0x8E, 0xC7, 0xFD, 0xCC, 0x7F, 0xF8, 0xC3, 0x8F,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xBC, 0x03,
  0xDE, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0xF1, 0xE0, 0x7F, 0xF0,
  0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x1E, 0x07, 0x9F, 0x03, 0xCF, 0x01,
  0xEF, 0x80, 0xF7, 0x80, 0x78, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F,
  0xFF, 0x1E, 0x1F, 0x1E, 0x0F, 0x1E, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3F,
  0xFC, 0x3F, 0xF0, 0x3F, 0xFC, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF,
  0xC0, 0x03, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xFE, 0x3E, 0x1E, 0x3C,
  0x1E, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x3C, 0xF0, 0x3C, 0x78,
  0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1E, 0x1E, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x3E, 0x0F, 0x3C, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x7C, 0x1E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F,
  0xFE, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF,
  0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3,
  0xFF, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFE, 0x3E, 0x1E, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0xFE, 0xF8, 0xFE, 0xF8, 0xFE, 0xF0,
  0x3E, 0xF0, 0x3C, 0xF8, 0x3C, 0x78, 0x3C, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F,
  0xF0, 0x0F, 0xC0, 0x0F, 0x03, 0xC3, 0xC0, 0xF1, 0xF0, 0x3C, 0x78, 0x0F,
  0x1E, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x3E, 0x07, 0x8F,
  0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0x03, 0xC7, 0xC0,
  0xF1, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78,
  0xF8, 0x1E, 0x3C, 0x07, 0x80, 0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78,
  0x78, 0x78, 0xF8, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xF3,
  0xE1, 0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x07, 0xC3,
  0xC3, 0xE1, 0xF1, 0xF0, 0x78, 0x7C, 0x1E, 0x3E, 0x07, 0x9F, 0x01, 0xE7,
  0x80, 0x7B, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xF0, 0x0F, 0xFC, 0x07, 0xEF, 0x01, 0xF3, 0xE0, 0x78, 0xF8, 0x1E,
  0x1E, 0x07, 0x87, 0x81, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x0F, 0x00, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x7F, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x7C, 0x1F,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFE, 0x07, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0x87, 0xF0, 0xFE, 0x0E, 0xE1, 0xFC, 0x3D, 0xC3, 0xF8, 0x7B, 0x8F,
  0xF0, 0xF7, 0x1D, 0xE1, 0xEE, 0x7B, 0xC3, 0xDC, 0xEF, 0x07, 0xBB, 0xDE,
  0x1F, 0x77, 0x3C, 0x3C, 0xEE, 0x78, 0x78, 0xF8, 0xF0, 0xF1, 0xF3, 0xE1,
  0xE3, 0xE7, 0x83, 0xC7, 0x8F, 0x0F, 0x8F, 0x1E, 0x1E, 0x1C, 0x3C, 0x00,
  0x0F, 0x03, 0xC3, 0xC0, 0xF1, 0xF8, 0x3C, 0x7E, 0x0F, 0x1F, 0x87, 0xC7,
  0xE1, 0xE1, 0xFC, 0x78, 0x7F, 0x1E, 0x3F, 0xC7, 0x8F, 0x71, 0xE3, 0xCE,
  0xF8, 0xF3, 0xBC, 0x3C, 0xEF, 0x0F, 0x3B, 0xC7, 0xC7, 0xF1, 0xE1, 0xFC,
  0x78, 0x7F, 0x1E, 0x1F, 0x87, 0x83, 0xE1, 0xE0, 0xF8, 0xF8, 0x3E, 0x3C,
  0x0F, 0x80, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1F,
  0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F,
  0x78, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x3C,
  0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x0F, 0xF8,
  0x07, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78,
  0x3C, 0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xC1, 0xFF, 0x81, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x07,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1E, 0x3C, 0x0F, 0x3C, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x78, 0x1E, 0xF8, 0x1E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF8, 0x3C, 0x78, 0x7C, 0x7F, 0xF8, 0x3F,
  0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x70, 0x00,
  0x20, 0x0F, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x1E, 0x1F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3F, 0xFE, 0x3F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x7C, 0xF0, 0x78, 0xF8, 0x78, 0xF8, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x7C, 0xF8, 0x7C, 0xF0, 0x3C, 0x03, 0xE0, 0x1F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x1F, 0x00,
  0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE1, 0xF3, 0xFF, 0xC3, 0xFF, 0x83, 0xFE,
  0x03, 0xF0, 0x00, 0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x3E,
  0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0xF8,
  0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF8, 0x78, 0x7F, 0xF8, 0x7F,
  0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0xF8, 0x0F, 0x7C, 0x0F, 0x9E, 0x07, 0xCF,
  0x07, 0xC7, 0x83, 0xE3, 0xC1, 0xE1, 0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0x78,
  0x3C, 0x7C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F, 0xF1, 0xF1, 0xEF,
  0x1F, 0x1E, 0xF1, 0xF1, 0xEF, 0x3F, 0x3C, 0xF3, 0xF3, 0xCF, 0x3F, 0x3C,
  0xF7, 0xF3, 0xCF, 0x77, 0x78, 0xF7, 0x77, 0x8F, 0xF7, 0x78, 0xFE, 0x7F,
  0x0F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7,
  0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0x80, 0x0F,
  0x03, 0xC1, 0xF0, 0xF8, 0x3E, 0x1E, 0x03, 0xC7, 0xC0, 0x79, 0xF0, 0x0F,
  0x3C, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7B,
  0xC0, 0x1F, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x1E, 0x1F, 0x07, 0xC3,
  0xE1, 0xF0, 0x3C, 0x00, 0x78, 0x1F, 0x78, 0x3E, 0x78, 0x3C, 0x78, 0x7C,
  0x7C, 0x78, 0x3C, 0xF8, 0x3C, 0xF0, 0x3D, 0xF0, 0x3D, 0xE0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xC0, 0x07,
  0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3E, 0x07, 0xC1, 0xF8, 0x00, 0xF0, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x0F, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C,
  0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x00, 0x07,
  0x01, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xE3, 0x98, 0xE6, 0x71, 0xDC, 0x7E,
  0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xF9, 0xE3, 0x8F, 0x1C, 0x07, 0xC0,
  0x7F, 0x87, 0xFC, 0x7D, 0xF3, 0xC7, 0x80, 0x7C, 0x3F, 0xC7, 0xFE, 0x7E,
  0xF3, 0xC7, 0xBE, 0x3D, 0xE3, 0xEF, 0xBE, 0x3F, 0xF1, 0xFF, 0x87, 0xBC,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xFC, 0x3F, 0xF9, 0xFF, 0xCF, 0xBE, 0x78, 0xF3, 0xC7, 0x9E, 0x3D, 0xE1,
  0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xFB, 0xEF, 0xFF, 0x7B, 0xF3,
  0xCF, 0x00, 0x0F, 0x81, 0xFE, 0x3F, 0xE7, 0xDF, 0x78, 0xFF, 0x0F, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF1, 0xEF, 0x1E, 0xFB, 0xCF, 0xFC, 0x7F,
  0x81, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x87, 0xDE, 0x3F, 0xF9, 0xFF, 0xE7, 0xDF, 0xBE, 0x3C, 0xF0,
  0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3, 0xC7, 0x8F, 0x1E, 0x3E,
  0xF8, 0xFF, 0xE1, 0xFF, 0x83, 0xDE, 0x00, 0x0F, 0xC1, 0xFE, 0x3F, 0xE7,
  0xDF, 0x78, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F,
  0x04, 0xFD, 0xC7, 0xFE, 0x7F, 0xC1, 0xF0, 0x03, 0xC1, 0xF0, 0xFC, 0x7F,
  0x1E, 0x07, 0x81, 0xE1, 0xFE, 0xFF, 0xBF, 0xE3, 0xC0, 0xF0, 0x3C, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x00,
  0x07, 0x9C, 0x7F, 0xF1, 0xFF, 0xCF, 0xBF, 0x3C, 0x3D, 0xE1, 0xE7, 0x87,
  0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x3C, 0x7D, 0xF1, 0xFF,
  0xC3, 0xFF, 0x07, 0xBC, 0x00, 0xF1, 0x07, 0x87, 0x3E, 0x3F, 0xF0, 0xFF,
  0x80, 0xFC, 0x00, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0xBE, 0x78, 0xF3, 0xC7,
  0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0xF3, 0xC7, 0x9E, 0x3D, 0xE1, 0xEF,
  0x0F, 0x78, 0x7B, 0xC7, 0x80, 0x0E, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x1E,
  0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0xF0, 0xF0, 0x01, 0xC0, 0x7C, 0x0F, 0x80, 0xE0, 0x00, 0x00, 0x00,
  0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0xFE, 0x1F, 0x83, 0xE0, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x1E, 0x3C, 0x7C, 0x79,
  0xF0, 0xF7, 0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xE7, 0x83, 0xCF, 0x0F, 0x1E, 0x1E, 0x1E, 0x3C,
  0x3C, 0x00, 0x0F, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0,
  0xF0, 0x1D, 0xF1, 0xE3, 0xFF, 0x7F, 0x3F, 0xFF, 0xF3, 0xEF, 0xFF, 0x3C,
  0x78, 0xF3, 0xC7, 0x8F, 0x3C, 0x78, 0xF7, 0x87, 0x8F, 0x78, 0x78, 0xF7,
  0x8F, 0x0F, 0x78, 0xF1, 0xF7, 0x8F, 0x1E, 0x78, 0xF1, 0xEF, 0x0F, 0x1E,
  0xF0, 0xF1, 0xEF, 0x1E, 0x1E, 0x1D, 0xF1, 0xFF, 0x8F, 0xFE, 0x7D, 0xF3,
  0xC7, 0x9E, 0x3D, 0xF1, 0xEF, 0x0F, 0x78, 0x7B, 0xC7, 0x9E, 0x3C, 0xF1,
  0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x3C, 0x0F, 0xC0, 0xFF, 0x0F, 0xFC,
  0xFB, 0xE7, 0x8F, 0x78, 0x7B, 0xC3, 0xDE, 0x1E, 0xF0, 0xF7, 0x87, 0xBC,
  0x3D, 0xE3, 0xCF, 0xBE, 0x3F, 0xE1, 0xFE, 0x03, 0xE0, 0x0E, 0xF0, 0x7F,
  0xF1, 0xFF, 0xC7, 0xDF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x0F, 0x3C,
  0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1F, 0x3E, 0xF9, 0xFF, 0xE7, 0xBF, 0x1E,
  0x78, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x1F, 0x79, 0xFF, 0xDF, 0xFE, 0xFB, 0xFF, 0x8F, 0x78, 0x7B, 0xC3, 0xDE,
  0x1E, 0xF0, 0xF7, 0x8F, 0xBC, 0x79, 0xE3, 0xCF, 0xBE, 0x7F, 0xF1, 0xFF,
  0x87, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x1D, 0xCF, 0xF3, 0xFC, 0xFF, 0x3E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0x07, 0xC0, 0xFF, 0x0F,
  0xFC, 0x79, 0xE3, 0xC7, 0x9E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F,
  0x00, 0x79, 0xE1, 0xCF, 0x1E, 0x3F, 0xF0, 0xFF, 0x03, 0xE0, 0x1E, 0x1E,
  0x1E, 0x3C, 0xFF, 0xFF, 0xFF, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x78, 0xF0, 0xFC, 0x7C, 0x7C, 0x3C, 0x3C, 0x7B, 0xC3, 0xDE, 0x1E, 0xF1,
  0xF7, 0x8F, 0x3C, 0x7B, 0xE3, 0xDE, 0x1E, 0xF0, 0xF7, 0x8F, 0xBC, 0x79,
  0xE3, 0xCF, 0xBE, 0x7F, 0xF1, 0xFF, 0x87, 0xB8, 0xF1, 0xFF, 0x1E, 0xF1,
  0xEF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF7, 0x8F, 0x78, 0xF7, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF1, 0xC7, 0xF9, 0xE3,
  0xFC, 0xF3, 0xDC, 0x79, 0xEE, 0x7C, 0xF7, 0x3E, 0xF3, 0xBF, 0x79, 0xDF,
  0xB8, 0xEF, 0xFC, 0x7E, 0x7E, 0x3F, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87,
  0xC7, 0x83, 0xC3, 0xC1, 0xE1, 0xC0, 0x1E, 0x3E, 0x3C, 0x78, 0x39, 0xE0,
  0x7B, 0xC0, 0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x7F, 0x80, 0xFF, 0x03, 0xDE, 0x0F, 0x9E, 0x1E, 0x3C, 0x7C, 0x78,
  0x1E, 0x3E, 0x3C, 0x78, 0x78, 0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0xDF, 0x07,
  0xBC, 0x0F, 0x78, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x01,
  0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0x80, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0x01, 0x01, 0xC1, 0xE1,
  0xE0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x87, 0x87, 0xC3,
  0x81, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x3C, 0x0E, 0x02, 0x00, 0x0E, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0E, 0x1C,
  0x30, 0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x1C,
  0x30, 0x60, 0xC0, 0x0C, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x78, 0x1C, 0x3E, 0x3C, 0x1E, 0x0E, 0x07,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x78, 0x38, 0x18, 0x00, 0x1C,
  0x00, 0xF8, 0x77, 0xF1, 0xDF, 0xEF, 0xE3, 0xFB, 0x87, 0xE0, 0x0E, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 22, 8, 1, -22 },
  { 21, 9, 8, 9, 2, -23 },
  { 30, 15, 22, 15, 1, -22 },
  { 72, 13, 28, 15, 1, -25 },
  { 118, 14, 22, 19, 3, -22 },
  { 157, 15, 22, 17, 0, -22 },
  { 199, 4, 8, 5, 2, -23 },
  { 203, 10, 31, 9, 1, -24 },
  { 242, 9, 31, 9, -1, -24 },
  { 277, 13, 13, 13, 1, -22 },
  { 299, 12, 16, 14, 1, -18 },
  { 323, 7, 9, 7, -2, -4 },
  { 331, 8, 3, 10, 1, -10 },
  { 334, 4, 5, 8, 1, -5 },
  { 337, 13, 24, 10, -2, -22 },
  { 376, 13, 22, 15, 1, -22 },
  { 412, 9, 22, 15, 3, -22 },
  { 437, 14, 22, 15, 0, -22 },
  { 476, 14, 22, 15, 0, -22 },
  { 515, 14, 22, 15, 0, -22 },
  { 554, 14, 22, 15, 1, -22 },
  { 593, 13, 22, 15, 1, -22 },
  { 629, 14, 22, 15, 1, -22 },
  { 668, 13, 22, 15, 1, -22 },
  { 704, 12, 22, 15, 2, -22 },
  { 737, 6, 17, 8, 1, -17 },
  { 750, 8, 22, 8, -1, -17 },
  { 772, 12, 14, 13, 1, -16 },
  { 793, 13, 9, 15, 1, -14 },
  { 808, 12, 14, 13, 1, -16 },
  { 829, 11, 22, 13, 2, -22 },
  { 860, 20, 28, 22, 1, -21 },
  { 930, 17, 22, 17, -1, -22 },
  { 977, 16, 22, 16, 0, -22 },
  { 1021, 16, 22, 17, 1, -22 },
  { 1065, 16, 22, 16, 0, -22 },
  { 1109, 16, 22, 14, 0, -22 },
  { 1153, 15, 22, 14, 0, -22 },
  { 1195, 16, 22, 17, 1, -22 },
  { 1239, 18, 22, 18, 0, -22 },
  { 1289, 8, 22, 8, 0, -22 },
  { 1311, 15, 22, 14, 0, -22 },
  { 1353, 18, 22, 16, 0, -22 },
  { 1403, 12, 22, 14, 0, -22 },
  { 1436, 23, 22, 22, 0, -22 },
  { 1500, 18, 22, 18, 0, -22 },
  { 1550, 16, 22, 18, 1, -22 },
  { 1594, 17, 22, 17, 0, -22 },
  { 1641, 16, 26, 18, 1, -22 },
  { 1693, 16, 22, 16, 0, -22 },
  { 1737, 15, 22, 16, 1, -22 },
  { 1779, 15, 22, 16, 2, -22 },
  { 1821, 16, 22, 17, 1, -22 },
  { 1865, 17, 22, 17, 2, -22 },
  { 1912, 20, 22, 22, 3, -22 },
  { 1967, 19, 22, 16, -1, -22 },
  { 2020, 16, 22, 16, 2, -22 },
  { 2064, 17, 22, 15, 0, -22 },
  { 2111, 11, 30, 8, -1, -25 },
  { 2153, 8, 24, 11, 2, -22 },
  { 2177, 11, 30, 8, -2, -25 },
  { 2219, 10, 11, 11, 1, -22 },
  { 2233, 12, 3, 12, -2, 0 },
  { 2238, 6, 5, 10, 3, -23 },
  { 2242, 13, 16, 14, 0, -16 },
  { 2268, 13, 23, 14, 0, -23 },
  { 2306, 12, 16, 13, 1, -16 },
  { 2330, 14, 23, 14, 1, -23 },
  { 2371, 12, 16, 14, 1, -16 },
  { 2395, 10, 23, 10, 1, -23 },
  { 2424, 14, 22, 15, 0, -16 },
  { 2463, 13, 23, 14, 0, -23 },
  { 2501, 8, 22, 7, 0, -22 },
  { 2523, 11, 28, 7, -3, -22 },
  { 2562, 15, 23, 14, 0, -23 },
  { 2606, 8, 23, 7, 0, -23 },
  { 2629, 20, 16, 22, 0, -16 },
  { 2669, 13, 16, 14, 0, -16 },
  { 2695, 13, 16, 14, 1, -16 },
  { 2721, 14, 22, 14, -1, -16 },
  { 2760, 13, 22, 14, 1, -16 },
  { 2796, 10, 16, 10, 0, -16 },
  { 2816, 13, 16, 13, 0, -16 },
  { 2842, 8, 20, 9, 1, -20 },
  { 2862, 13, 16, 14, 1, -16 },
  { 2888, 12, 16, 13, 2, -16 },
  { 2912, 17, 16, 18, 2, -16 },
  { 2946, 15, 16, 13, -1, -16 },
  { 2976, 15, 22, 13, -1, -16 },
  { 3018, 13, 16, 13, 0, -16 },
  { 3044, 9, 28, 9, 1, -23 },
  { 3076, 7, 26, 7, 0, -22 },
  { 3099, 9, 28, 9, -1, -23 },
  { 3131, 14, 7, 16, 1, -12 },
};

const GFXfont RobotoCondensed_BoldItalic30pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic30pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic30pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _ROBOTOCONDENSED_BOLDITALIC30PT7B_H_
