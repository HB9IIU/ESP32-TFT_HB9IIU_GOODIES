#ifndef _ROBOTOCONDENSED_BOLDITALIC36PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x1F,
  0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0x83, 0xE1, 0xF0, 0xF8, 0x38, 0x00, 0x39, 0xEF, 0x39, 0xE7, 0x3C,
  0xE7, 0x1C, 0xE7, 0x9C, 0xE7, 0x9C, 0xE3, 0x9C, 0x70, 0x00, 0xF3, 0x80,
  0x39, 0xE0, 0x0E, 0x70, 0x03, 0x9C, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x1C,
  0xE0, 0x0E, 0x38, 0x1F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF8, 0x1C, 0xE0,
  0x07, 0x38, 0x03, 0x8E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0xFF, 0xFE, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE0, 0x73, 0x80, 0x39, 0xE0, 0x0E, 0x70, 0x03, 0x9C,
  0x01, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF,
  0x1F, 0x9F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1F, 0x1E, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3C, 0xF8, 0x3C, 0xF8, 0x3C, 0xF8, 0x7C, 0x7C, 0xFC,
  0x7F, 0xF8, 0x7F, 0xF8, 0x3F, 0xE0, 0x0F, 0xC0, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0E, 0x78, 0x4F, 0x1C,
  0x77, 0x9E, 0x7B, 0x8F, 0x39, 0xC7, 0x38, 0xF3, 0xB8, 0x3F, 0xFC, 0x1F,
  0xDC, 0x07, 0xDC, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x78, 0x0F, 0xFE,
  0x07, 0x7F, 0x87, 0x79, 0xC7, 0x38, 0xE7, 0x9C, 0x73, 0x8E, 0x3B, 0x87,
  0x1D, 0xC3, 0x9C, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x01, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFB, 0xE0, 0x78, 0xF0, 0x7C,
  0x78, 0x3C, 0x7C, 0x1F, 0x3C, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0xFE, 0x3C, 0xFF, 0x9E, 0xFF, 0xCF, 0xF9, 0xF7, 0xFC, 0xFF,
  0xFE, 0x3F, 0xDF, 0x1F, 0xEF, 0x87, 0xE7, 0xC3, 0xE3, 0xFF, 0xF8, 0xFF,
  0xFE, 0x3F, 0xFF, 0x0F, 0xCF, 0xC0, 0x3B, 0xDE, 0xF7, 0xB9, 0xDE, 0xF7,
  0x00, 0x00, 0x40, 0x18, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x60, 0x04, 0x00, 0x02, 0x00, 0x30, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xF0,
  0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x70, 0x04, 0x00, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x04, 0x18, 0x0E, 0x73, 0xFF, 0xFF, 0xBF, 0xFF,
  0x0F, 0xF0, 0x1F, 0x00, 0x7F, 0x01, 0xEE, 0x07, 0xCE, 0x0F, 0x1E, 0x1C,
  0x38, 0x00, 0x20, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xE7, 0x8F, 0x3E, 0x79, 0xE0,
  0x80, 0xFF, 0xFF, 0xFF, 0xDF, 0xE0, 0x07, 0xFF, 0xFF, 0xB8, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE,
  0x0F, 0xFE, 0x1F, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F,
  0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x7C, 0x3E,
  0x78, 0x3E, 0x78, 0x3E, 0xF8, 0x3E, 0x78, 0x3C, 0x78, 0x7C, 0x78, 0x7C,
  0x7C, 0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x60,
  0x7C, 0x3F, 0x3F, 0xE7, 0xFD, 0xFF, 0xBD, 0xF6, 0x3E, 0x07, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0x00, 0xF8,
  0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF9, 0xF8, 0xF8, 0x7C, 0x7C,
  0x3E, 0x7C, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFE, 0x3F, 0x3F, 0x3E, 0x1F, 0x3E, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0xF0, 0x7C, 0xF8, 0x7C,
  0xF8, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x03, 0xFE, 0x03, 0xDF, 0x01, 0xEF, 0x01, 0xEF, 0x81, 0xE7, 0xC0,
  0xF3, 0xE0, 0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0x78, 0x7F, 0xFF, 0x3F, 0xFF,
  0x9F, 0xFF, 0xDF, 0xFF, 0xE0, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0xE0, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xE3, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x3E, 0x0F, 0x9F, 0x07,
  0x8F, 0x87, 0xC3, 0xE7, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x07,
  0xE0, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x01,
  0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7D, 0xE0, 0xFF, 0xF3, 0xFF,
  0xE7, 0xFF, 0xEF, 0xCF, 0xDF, 0x0F, 0xBE, 0x1F, 0x78, 0x3E, 0xF0, 0x7D,
  0xE0, 0xFB, 0xC1, 0xF7, 0x87, 0xCF, 0x9F, 0x8F, 0xFE, 0x1F, 0xF8, 0x1F,
  0xE0, 0x1F, 0x80, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x9F, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x1E, 0x1F, 0x3E, 0x0F, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x7C, 0x7C, 0x7C, 0x7C, 0xF8, 0x3C, 0xF8,
  0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFC, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE3, 0xE7,
  0xCF, 0x87, 0x9F, 0x0F, 0xBE, 0x1F, 0x78, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xE7, 0x87, 0xCF, 0x8F, 0x9F, 0xFF, 0x1F, 0xFE, 0x3F, 0xF8, 0x3F,
  0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xFC, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7E, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x3F, 0x3F, 0x1F, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xF8, 0xF8, 0xF8, 0x70,
  0x00, 0x00, 0x78, 0x1F, 0x03, 0xF0, 0x7C, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03,
  0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x00,
  0xC0, 0x00, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7E, 0x0F, 0xF8, 0xFF,
  0xCF, 0xFC, 0x3F, 0xC0, 0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x20, 0x3F, 0xFE, 0x7F, 0xFC,
  0xFF, 0xF9, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x7F,
  0xFC, 0xFF, 0xFB, 0xFF, 0xF0, 0x10, 0x00, 0xE0, 0x03, 0xE0, 0x0F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0x00, 0xFC, 0x0F, 0xF0, 0xFF,
  0x9F, 0xF8, 0xFF, 0x83, 0xF8, 0x0F, 0x80, 0x38, 0x00, 0x80, 0x00, 0x07,
  0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0x7C, 0xFD, 0xF1, 0xFF, 0x87, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x3E, 0x07, 0x80, 0x3C, 0x00,
  0xE0, 0x3C, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x3C, 0x1F, 0x0E, 0x1C, 0x3F,
  0xC7, 0x1E, 0x3F, 0xF1, 0x8E, 0x1E, 0x70, 0xCF, 0x1E, 0x38, 0x67, 0x1E,
  0x1C, 0x33, 0x8F, 0x1E, 0x3B, 0xC7, 0x0F, 0x1D, 0xE7, 0x87, 0x0E, 0xE3,
  0xC3, 0x87, 0x71, 0xE3, 0xC3, 0xB8, 0xF1, 0xE1, 0x9C, 0x78, 0xE1, 0xCE,
  0x3C, 0xF0, 0xE7, 0x1E, 0x78, 0xE3, 0x8F, 0xFF, 0xE1, 0xC3, 0xF7, 0xE0,
  0xE0, 0xE1, 0xE0, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x60, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x00, 0x3C, 0xF8, 0x03, 0xE7,
  0xC0, 0x1F, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0x80, 0xF8, 0x3C, 0x07,
  0xC1, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xE0,
  0x0F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xF8, 0x7E, 0x1F, 0x07, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0xFC, 0x7C, 0x3F, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F,
  0xFF, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E,
  0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x7F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07,
  0xFF, 0xE1, 0xFC, 0x7C, 0x3E, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E,
  0x03, 0xEF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x01, 0xF3, 0xE0,
  0x3E, 0x3C, 0x07, 0xC7, 0xC1, 0xF0, 0xFC, 0x7E, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x3F,
  0xFE, 0x07, 0xFF, 0xC0, 0xF8, 0xFC, 0x1F, 0x0F, 0x87, 0xE0, 0xF8, 0xF8,
  0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xF0,
  0x3E, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0,
  0xF9, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF0, 0xF8, 0xFE, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F,
  0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC, 0x7C, 0x3E, 0x07, 0xC7,
  0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC3, 0xFC, 0xF8, 0x7F, 0x9F, 0x1F, 0xF3, 0xE3, 0xFE, 0x7C,
  0x07, 0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xFC,
  0x7F, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xFE, 0x00, 0x07,
  0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x80,
  0xF8, 0x3E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xF8,
  0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x07,
  0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x00, 0x07,
  0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x8F, 0x83, 0xE3, 0xE1, 0xF0, 0xFC, 0x7C, 0x1F, 0x3F, 0x07, 0xFF, 0x81,
  0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xFC, 0x3E, 0x07,
  0xE0, 0xF8, 0x3F, 0x03, 0xE1, 0xF8, 0x0F, 0x8F, 0xE0, 0x3E, 0x3F, 0x01,
  0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xE3, 0xE0, 0x1F,
  0x0F, 0x80, 0x7C, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x07,
  0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x07, 0xE0, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x01,
  0xFC, 0x1F, 0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0x83, 0xFE, 0x1F,
  0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7B, 0xC3, 0xDE, 0x0F, 0x78, 0x7F,
  0xC3, 0xEF, 0x1E, 0xF8, 0x7D, 0xE3, 0xDF, 0x0F, 0x9C, 0xF3, 0xE1, 0xF3,
  0x9E, 0x78, 0x3E, 0x73, 0x9F, 0x07, 0xCE, 0xF3, 0xE1, 0xF1, 0xFE, 0x7C,
  0x3E, 0x3F, 0x8F, 0x87, 0xC7, 0xF1, 0xF0, 0xF8, 0xFC, 0x7C, 0x1F, 0x1F,
  0x8F, 0x83, 0xE3, 0xE1, 0xF0, 0xF8, 0x3C, 0x3E, 0x1F, 0x07, 0x07, 0xC0,
  0x07, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x3E, 0x0F,
  0xE0, 0xF8, 0x3F, 0x83, 0xE1, 0xFE, 0x0F, 0x87, 0xF8, 0x3E, 0x1F, 0xF0,
  0xF8, 0x7F, 0xC7, 0xC1, 0xF7, 0x1F, 0x07, 0xDE, 0x7C, 0x3F, 0x79, 0xF0,
  0xF9, 0xE7, 0xC3, 0xE3, 0x9F, 0x0F, 0x8F, 0xF8, 0x3E, 0x3F, 0xE0, 0xF8,
  0xFF, 0x87, 0xC1, 0xFE, 0x1F, 0x07, 0xF8, 0x7C, 0x1F, 0xE1, 0xF0, 0x7F,
  0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x1F, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC, 0x7E,
  0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7D,
  0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB,
  0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x00, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC7,
  0xC1, 0xF8, 0xFC, 0x7E, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x00,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0x87, 0xE0, 0xF8, 0x3E, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xE1, 0xF0, 0x7E, 0x3F, 0x0F, 0xE3, 0xFF,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC, 0x7C, 0x3E, 0x07, 0xCF, 0xC0, 0xF9,
  0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7D, 0xF0, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xCF,
  0x00, 0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xFC, 0x7E, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x07, 0xFE, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xF8, 0x7E, 0x1F, 0x07, 0xC7,
  0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x0F,
  0x87, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x3E,
  0x3E, 0x07, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xF0, 0xF8,
  0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x9F, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0x8F, 0x87, 0xC1,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3F, 0x3F, 0x1F,
  0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF1,
  0xF0, 0x3F, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x3E,
  0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07,
  0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0,
  0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0xFC,
  0x1F, 0x07, 0xE7, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0xFE, 0x00, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x7C, 0x07, 0xEF,
  0x80, 0xF9, 0xF8, 0x3F, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F,
  0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF9, 0xF0, 0x0F,
  0x3E, 0x01, 0xE7, 0xC0, 0x3D, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0x80, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x0F, 0xFC, 0x1F, 0x0F, 0xBE, 0x1F,
  0x87, 0xDF, 0x0F, 0xC3, 0xEF, 0x87, 0xE3, 0xE7, 0xC7, 0xF1, 0xF3, 0xE3,
  0xF8, 0xF9, 0xF1, 0xFC, 0x78, 0xF9, 0xFE, 0x7C, 0x7C, 0xFF, 0x3E, 0x3E,
  0x7F, 0x9E, 0x1F, 0x7F, 0xDF, 0x0F, 0xBD, 0xEF, 0x87, 0xDE, 0xF7, 0x83,
  0xFF, 0x7F, 0xC1, 0xFF, 0x3F, 0xE0, 0xFF, 0x9F, 0xF0, 0x7F, 0xCF, 0xF0,
  0x3F, 0xC7, 0xF8, 0x0F, 0xE3, 0xFC, 0x07, 0xF1, 0xFC, 0x03, 0xF0, 0xFE,
  0x01, 0xF8, 0x7F, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xF0,
  0x7C, 0x03, 0xE3, 0xF0, 0x0F, 0x9F, 0x80, 0x3E, 0x7C, 0x00, 0xFB, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x9F, 0x80,
  0x7C, 0x3E, 0x03, 0xF0, 0xF8, 0x1F, 0x83, 0xE0, 0x7E, 0x0F, 0xC3, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0xFE, 0x03, 0xF7, 0xC1, 0xF9, 0xF0, 0x7C, 0x7C,
  0x1F, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0xF1, 0xF0, 0x3E, 0x7C, 0x0F, 0xBE,
  0x03, 0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x00, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1,
  0xE0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x83, 0xC1, 0xE0, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x01,
  0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x03,
  0xC0, 0x3C, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xEE, 0x1E, 0xE1, 0xEE, 0x3C,
  0xE3, 0xCF, 0x78, 0xF7, 0x8F, 0xF0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFE, 0xF8, 0xF0, 0xF1, 0xF1, 0xE0, 0x01, 0xF0, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xF3, 0xF3, 0xE7, 0xC7, 0xC0, 0x0F, 0x83, 0xFF, 0x1F, 0xFE,
  0x7F, 0xFD, 0xF8, 0xF3, 0xE3, 0xEF, 0x87, 0xDF, 0x0F, 0xBE, 0x3F, 0x3F,
  0xFE, 0x7F, 0xF8, 0x7F, 0xF0, 0x79, 0xF0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x7C, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFF, 0x3F, 0x1F, 0x3E, 0x1F, 0x3E,
  0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1E, 0x7C, 0x3E, 0x7E, 0x7E, 0x7F, 0xFC, 0xFF, 0xFC, 0xFB, 0xF8, 0xF9,
  0xF0, 0x07, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0xFF, 0x7E, 0x7D, 0xF0, 0xF7,
  0x83, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x7B,
  0xE3, 0xEF, 0x8F, 0xBF, 0xFC, 0x7F, 0xF0, 0xFF, 0x81, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x07, 0x9F, 0x0F, 0xEF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xC7, 0xE7, 0xE3, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C,
  0x1E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1,
  0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x0F, 0xBE, 0x00, 0x03, 0xE0, 0x1F,
  0xF0, 0x7F, 0xF1, 0xFF, 0xE3, 0xE3, 0xCF, 0x87, 0xDE, 0x0F, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xC0, 0x0F, 0x80, 0x1F, 0x02, 0x3F,
  0x1C, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x1F,
  0xC1, 0xFE, 0x0F, 0xE0, 0xFC, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x7F, 0xE3,
  0xFF, 0x1F, 0xF8, 0xFF, 0x81, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE7, 0x87, 0xFF, 0xC7, 0xFF, 0xE3,
  0xFF, 0xF3, 0xF1, 0xF9, 0xF0, 0xF8, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F,
  0x3E, 0x0F, 0x9F, 0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF9,
  0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xDF, 0x00, 0x0F, 0x80,
  0x07, 0xC3, 0x07, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x7C, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F,
  0xFE, 0x3F, 0x3F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0x07, 0x87, 0xC3, 0xE1, 0xF0,
  0x70, 0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xF8, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x1F, 0x87, 0xC7, 0xE1, 0xF3, 0xF0, 0x79, 0xF8, 0x3E, 0xFC,
  0x0F, 0xBE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFF, 0x01, 0xFF, 0xC0, 0x7E, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE0, 0x07, 0xC1, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x80, 0x1F, 0x7C, 0x3C, 0x1F, 0xFE, 0xFE,
  0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0x3F, 0x9F, 0x3E, 0x1F, 0x1F,
  0x3E, 0x1F, 0x0F, 0x3E, 0x1E, 0x1F, 0x3E, 0x3E, 0x1F, 0x3C, 0x3E, 0x1F,
  0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x1F, 0x7C, 0x3E, 0x1E, 0x7C, 0x3C, 0x3E,
  0x7C, 0x7C, 0x3E, 0x78, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E,
  0xF8, 0x7C, 0x3C, 0x1F, 0x7C, 0x1E, 0xFE, 0x1F, 0xFE, 0x3F, 0xFF, 0x3F,
  0x3F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x7C, 0x3E, 0x7C,
  0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xFF,
  0xE7, 0xE3, 0xEF, 0x87, 0xDE, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xDF, 0x0F, 0xBF, 0x3F, 0x3F, 0xFC, 0x7F,
  0xF0, 0x7F, 0xC0, 0x3E, 0x00, 0x0F, 0xBE, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xF1, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F,
  0x8F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xF0, 0xF8, 0xF8,
  0xFC, 0xFF, 0xFC, 0x7F, 0xFE, 0x3E, 0xFE, 0x1F, 0x3C, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x8F, 0x1F, 0xDF, 0x3F, 0xFF, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xFF, 0xF8, 0x7F, 0xF8, 0x7F,
  0xF8, 0x3E, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x71, 0xFF, 0x1F, 0xF1, 0xFF, 0x3F,
  0xF3, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xF0,
  0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xDF, 0x0F,
  0xBE, 0x1F, 0x3F, 0xFC, 0x7F, 0xF8, 0x7F, 0xE0, 0x3F, 0x00, 0x0F, 0x83,
  0xC1, 0xF0, 0x7C, 0x1F, 0x1F, 0xF7, 0xFF, 0xFF, 0xFF, 0xCF, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7F,
  0x1F, 0xC3, 0xE0, 0x78, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0xF8, 0x7C,
  0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0xF8, 0xFF, 0xF8,
  0x7F, 0xF8, 0x7F, 0xF8, 0x3E, 0xF8, 0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7,
  0xC7, 0xCF, 0x8F, 0x9F, 0x3E, 0x1E, 0x7C, 0x3C, 0xF0, 0x7B, 0xE0, 0xF7,
  0xC1, 0xEF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0xF0, 0xFF, 0xC7, 0x87, 0xBE,
  0x3C, 0x7D, 0xF3, 0xE3, 0xEF, 0x9F, 0x1E, 0x7D, 0xFD, 0xF3, 0xEF, 0xEF,
  0x9F, 0x7F, 0x78, 0xFF, 0xFB, 0xC7, 0xFF, 0xFC, 0x3F, 0xDF, 0xE1, 0xFE,
  0xFF, 0x0F, 0xE7, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xC0,
  0x7C, 0x3E, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0x1F, 0x0F, 0x83, 0xC3,
  0xE0, 0xF9, 0xF0, 0x3E, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x07, 0xFE, 0x01, 0xF7, 0x80, 0xF9, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F,
  0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0xC7, 0xC3, 0xE1, 0xF1, 0xF8, 0x7C, 0x7C,
  0x1F, 0x1F, 0x07, 0xCF, 0x80, 0xF3, 0xE0, 0x3D, 0xF0, 0x0F, 0x7C, 0x03,
  0xDE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFF, 0xF8, 0xFF, 0xF8,
  0xFF, 0xF8, 0xFF, 0xF8, 0x00, 0x40, 0x3C, 0x0F, 0x83, 0xE0, 0x78, 0x1F,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x0F,
  0x87, 0xE0, 0xF8, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x1F, 0x03,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0,
  0x1C, 0x01, 0x80, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x00, 0x04, 0x00, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3F, 0x03, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8,
  0x1E, 0x07, 0x80, 0xE0, 0x18, 0x00, 0x0F, 0x00, 0x1F, 0xC1, 0xCF, 0xF1,
  0xEF, 0xFC, 0xF7, 0x9F, 0xF7, 0x87, 0xFB, 0xC3, 0xF8, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_BoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 26, 9, 1, -26 },
  { 31, 11, 10, 11, 2, -27 },
  { 45, 18, 26, 18, 1, -26 },
  { 104, 16, 33, 18, 1, -30 },
  { 170, 17, 26, 22, 3, -26 },
  { 226, 17, 26, 20, 1, -26 },
  { 282, 5, 10, 6, 2, -27 },
  { 289, 11, 36, 11, 2, -28 },
  { 339, 12, 36, 11, -2, -28 },
  { 393, 15, 16, 16, 2, -26 },
  { 423, 15, 19, 17, 1, -22 },
  { 459, 7, 11, 9, -2, -4 },
  { 469, 9, 4, 13, 2, -13 },
  { 474, 5, 6, 10, 1, -6 },
  { 478, 16, 28, 12, -2, -26 },
  { 534, 16, 26, 18, 1, -26 },
  { 586, 11, 26, 18, 4, -26 },
  { 622, 17, 26, 18, 0, -26 },
  { 678, 16, 26, 18, 1, -26 },
  { 730, 17, 26, 18, 0, -26 },
  { 786, 17, 26, 18, 1, -26 },
  { 842, 15, 26, 18, 1, -26 },
  { 891, 17, 26, 18, 2, -26 },
  { 947, 16, 26, 18, 1, -26 },
  { 999, 15, 26, 18, 2, -26 },
  { 1048, 8, 20, 10, 1, -20 },
  { 1068, 11, 27, 9, -2, -20 },
  { 1106, 14, 17, 16, 1, -20 },
  { 1136, 15, 11, 18, 1, -17 },
  { 1157, 14, 17, 16, 1, -19 },
  { 1187, 14, 26, 16, 2, -26 },
  { 1233, 25, 33, 27, 1, -25 },
  { 1337, 21, 26, 21, -2, -26 },
  { 1406, 19, 26, 20, 0, -26 },
  { 1468, 19, 26, 20, 1, -26 },
  { 1530, 19, 26, 20, 0, -26 },
  { 1592, 19, 26, 17, 0, -26 },
  { 1654, 18, 26, 17, 0, -26 },
  { 1713, 19, 26, 20, 1, -26 },
  { 1775, 22, 26, 21, 0, -26 },
  { 1847, 10, 26, 9, 0, -26 },
  { 1880, 18, 26, 17, 0, -26 },
  { 1939, 22, 26, 19, 0, -26 },
  { 2011, 15, 26, 17, 0, -26 },
  { 2060, 27, 26, 26, 0, -26 },
  { 2148, 22, 26, 21, 0, -26 },
  { 2220, 19, 26, 21, 1, -26 },
  { 2282, 20, 26, 20, 0, -26 },
  { 2347, 19, 31, 21, 1, -26 },
  { 2421, 19, 26, 19, 0, -26 },
  { 2483, 18, 26, 19, 1, -26 },
  { 2542, 18, 26, 19, 3, -26 },
  { 2601, 20, 26, 20, 1, -26 },
  { 2666, 19, 26, 20, 3, -26 },
  { 2728, 25, 26, 26, 3, -26 },
  { 2810, 22, 26, 20, -1, -26 },
  { 2882, 18, 26, 19, 3, -26 },
  { 2941, 21, 26, 19, -1, -26 },
  { 3010, 13, 36, 9, -1, -30 },
  { 3069, 9, 28, 13, 3, -26 },
  { 3101, 12, 36, 9, -2, -30 },
  { 3155, 12, 13, 14, 1, -26 },
  { 3175, 14, 4, 14, -2, 0 },
  { 3182, 7, 5, 12, 4, -27 },
  { 3187, 15, 19, 16, 0, -19 },
  { 3223, 16, 27, 17, 0, -27 },
  { 3277, 14, 19, 16, 1, -19 },
  { 3311, 17, 27, 17, 1, -27 },
  { 3369, 15, 19, 17, 1, -19 },
  { 3405, 13, 27, 11, 1, -27 },
  { 3449, 17, 26, 18, 0, -19 },
  { 3505, 16, 27, 17, 0, -27 },
  { 3559, 9, 26, 9, 0, -26 },
  { 3589, 13, 33, 9, -4, -26 },
  { 3643, 18, 27, 17, 0, -27 },
  { 3704, 10, 27, 9, 0, -27 },
  { 3738, 24, 19, 26, 0, -19 },
  { 3795, 16, 19, 17, 0, -19 },
  { 3833, 15, 19, 17, 1, -19 },
  { 3869, 17, 26, 17, -1, -19 },
  { 3925, 16, 26, 17, 1, -19 },
  { 3977, 12, 19, 12, 0, -19 },
  { 4006, 15, 19, 16, 0, -19 },
  { 4042, 10, 24, 11, 1, -24 },
  { 4072, 16, 19, 17, 1, -19 },
  { 4110, 15, 19, 16, 2, -19 },
  { 4146, 21, 19, 22, 2, -19 },
  { 4196, 18, 19, 16, -1, -19 },
  { 4239, 18, 26, 16, -1, -19 },
  { 4298, 16, 19, 16, 0, -19 },
  { 4336, 11, 34, 10, 1, -28 },
  { 4383, 7, 31, 9, 1, -26 },
  { 4411, 11, 34, 10, -1, -28 },
  { 4458, 17, 8, 20, 1, -15 },
};

const GFXfont RobotoCondensed_BoldItalic36pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic36pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic36pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOCONDENSED_BOLDITALIC36PT7B_H_
