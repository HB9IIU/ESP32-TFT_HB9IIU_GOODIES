#ifndef _ROBOTOCONDENSED_BOLDITALIC16PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x36, 0x66, 0x60, 0xCC, 0x5E, 0xB5, 0x20, 0x0B, 0x0B,
  0x0A, 0x1A, 0x7F, 0x14, 0x34, 0xFE, 0x28, 0x68, 0x58, 0x58, 0x04, 0x04,
  0x1C, 0x3E, 0x37, 0x33, 0x30, 0x38, 0x1C, 0x06, 0x66, 0x66, 0x7C, 0x38,
  0x10, 0x10, 0x70, 0x5A, 0xDA, 0xD6, 0x7C, 0x08, 0x18, 0x36, 0x2B, 0x6B,
  0x4B, 0x0E, 0x1C, 0x3E, 0x36, 0x36, 0x3C, 0x38, 0x7B, 0x7F, 0xEF, 0xEE,
  0x7E, 0x7F, 0x7E, 0x10, 0x8C, 0xC6, 0x23, 0x18, 0xC6, 0x21, 0x08, 0x63,
  0x08, 0x40, 0x10, 0x86, 0x30, 0x84, 0x63, 0x18, 0xC6, 0x33, 0x19, 0x88,
  0x80, 0x10, 0x23, 0x53, 0xE7, 0x0B, 0x12, 0x00, 0x18, 0x30, 0x63, 0xF7,
  0xE3, 0x0C, 0x18, 0x6D, 0xBC, 0xFF, 0xEC, 0x06, 0x08, 0x30, 0x60, 0x83,
  0x04, 0x18, 0x30, 0xC1, 0x82, 0x0C, 0x00, 0x38, 0xF9, 0xB6, 0x7C, 0xF9,
  0xB3, 0x66, 0xCD, 0xBB, 0xE3, 0x80, 0x13, 0xBC, 0x63, 0x19, 0xCC, 0x63,
  0x18, 0xC0, 0x1C, 0x3E, 0x77, 0x67, 0x06, 0x0E, 0x0C, 0x18, 0x30, 0x70,
  0xFE, 0xFE, 0x1C, 0x3E, 0x77, 0x07, 0x06, 0x1E, 0x1C, 0x06, 0x06, 0xCE,
  0x7C, 0x78, 0x06, 0x0E, 0x0E, 0x1E, 0x36, 0x3E, 0x6C, 0xFE, 0xFE, 0x0C,
  0x0C, 0x0C, 0x3F, 0x3F, 0x30, 0x30, 0x7C, 0x7E, 0x06, 0x06, 0x06, 0xEE,
  0x7C, 0x38, 0x1C, 0xF7, 0x18, 0xFB, 0xFC, 0xF3, 0xCF, 0x3F, 0x9C, 0xFF,
  0xFC, 0x30, 0x61, 0xC3, 0x0E, 0x18, 0x70, 0xC3, 0x86, 0x00, 0x1C, 0x3E,
  0x37, 0x37, 0x36, 0x3E, 0x3C, 0x66, 0x66, 0xEE, 0x7C, 0x38, 0x39, 0xF6,
  0xF3, 0xCF, 0x3F, 0xDF, 0x1C, 0x67, 0x38, 0x73, 0x00, 0x00, 0xE6, 0x38,
  0xC0, 0x00, 0x00, 0xC4, 0x63, 0x10, 0x02, 0x18, 0xF3, 0x8E, 0x0F, 0x07,
  0x04, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x40, 0xE0, 0xF0, 0x71, 0xCF, 0x18,
  0x40, 0x79, 0xFC, 0xC3, 0x18, 0xE3, 0x18, 0x00, 0x06, 0x18, 0x07, 0x83,
  0x98, 0x40, 0x93, 0x96, 0xDA, 0x92, 0x56, 0x4E, 0xD9, 0xDB, 0x7B, 0x6B,
  0x36, 0x60, 0x04, 0x00, 0xE4, 0x0F, 0x80, 0x03, 0x03, 0x81, 0xC1, 0xE0,
  0xF0, 0xD8, 0x66, 0x73, 0x3F, 0xBF, 0xD8, 0x6C, 0x30, 0x3E, 0x1F, 0x8C,
  0xCE, 0x67, 0x33, 0xF9, 0xF8, 0xCE, 0x63, 0x73, 0xBF, 0x9F, 0x80, 0x1C,
  0x7E, 0x63, 0xE3, 0xC0, 0xC0, 0xC0, 0xC0, 0xC6, 0xCE, 0xFC, 0x78, 0x3E,
  0x3F, 0x33, 0x73, 0x73, 0x63, 0x63, 0x63, 0x63, 0xE6, 0xFE, 0xF8, 0x3F,
  0x3F, 0x30, 0x70, 0x70, 0x7E, 0x7E, 0x60, 0x60, 0xE0, 0xFE, 0xFE, 0x3F,
  0x3F, 0x30, 0x70, 0x70, 0x7E, 0x7E, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0x1E,
  0x7E, 0x63, 0xE3, 0xC0, 0xCF, 0xCE, 0xC6, 0xC6, 0xC6, 0xFE, 0x78, 0x31,
  0xCC, 0x73, 0x19, 0xC6, 0x71, 0x9F, 0xE7, 0xF9, 0x8E, 0x63, 0x38, 0xCE,
  0x33, 0x0C, 0x33, 0x33, 0x76, 0x66, 0x66, 0xEC, 0x03, 0x07, 0x07, 0x06,
  0x06, 0x06, 0x06, 0x0E, 0xCE, 0xCC, 0x7C, 0x78, 0x31, 0x8C, 0xE3, 0x71,
  0xD8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x6E, 0x39, 0x8E, 0x63, 0x1C, 0x30,
  0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0xF7, 0xE0, 0x38, 0x73,
  0x8F, 0x38, 0xF7, 0x8E, 0x69, 0xE6, 0x9E, 0x6B, 0x66, 0xF6, 0x6E, 0xEE,
  0xEC, 0xEE, 0xCC, 0xCC, 0x31, 0xCE, 0x73, 0x99, 0xE6, 0x79, 0x9B, 0x66,
  0xF9, 0xBE, 0x67, 0x39, 0xCE, 0x73, 0x1C, 0x1C, 0x7E, 0x63, 0xE3, 0xC3,
  0xC3, 0xC3, 0xC7, 0xC6, 0xC6, 0xFC, 0x78, 0x3E, 0x1F, 0x8C, 0xEE, 0x37,
  0x3B, 0x19, 0xFC, 0xFC, 0x60, 0x70, 0x38, 0x18, 0x00, 0x1C, 0x7E, 0x63,
  0xE3, 0xC3, 0xC3, 0xC3, 0xC7, 0xC6, 0xC6, 0xFC, 0x7C, 0x0E, 0x04, 0x3E,
  0x1F, 0x8C, 0xCE, 0x77, 0x33, 0x19, 0xF8, 0xF8, 0x6E, 0x33, 0x39, 0x98,
  0xC0, 0x1E, 0x3F, 0x33, 0x70, 0x30, 0x3C, 0x1E, 0x06, 0xE7, 0x66, 0x7E,
  0x3C, 0xFF, 0xFF, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x70, 0x63, 0x63, 0x63, 0xE7, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0xCE, 0xFC,
  0x78, 0xE3, 0xF1, 0x99, 0xCC, 0xC6, 0x63, 0x71, 0xB0, 0xD8, 0x78, 0x3C,
  0x1E, 0x06, 0x00, 0xE6, 0x7D, 0xCF, 0xBB, 0xF7, 0x6F, 0xED, 0xFD, 0x9F,
  0xE3, 0xBC, 0x77, 0x8E, 0xE1, 0x9C, 0x33, 0x80, 0x18, 0xC6, 0x71, 0x98,
  0x7C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1F, 0x0C, 0xC7, 0x31, 0x8E, 0xE3,
  0x33, 0x99, 0x8D, 0xC6, 0xC1, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E,
  0x00, 0x3F, 0xBF, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x30,
  0x3F, 0x9F, 0xC0, 0x39, 0xCC, 0x67, 0x31, 0x8C, 0x63, 0x19, 0xCC, 0x63,
  0x9C, 0xCE, 0x66, 0x66, 0x66, 0x73, 0x33, 0x30, 0x18, 0xE1, 0x86, 0x18,
  0x63, 0x8C, 0x30, 0xC3, 0x0C, 0x71, 0x8E, 0x38, 0x31, 0x9C, 0xAD, 0xCC,
  0xFF, 0xF0, 0xCC, 0x3C, 0xFD, 0x98, 0x73, 0xDD, 0xB3, 0x7E, 0x7C, 0x30,
  0x60, 0xC3, 0xE7, 0xEC, 0xD9, 0xB3, 0x67, 0xCF, 0xF6, 0xE0, 0x3C, 0xFD,
  0x9B, 0x0E, 0x18, 0x3B, 0x3E, 0x38, 0x03, 0x03, 0x03, 0x3F, 0x7E, 0x66,
  0x66, 0xE6, 0xC6, 0xEE, 0x7C, 0x7C, 0x3C, 0xFD, 0x9B, 0xF7, 0xFC, 0x19,
  0x3E, 0x38, 0x1C, 0xF3, 0x1E, 0x78, 0xC7, 0x18, 0x61, 0x86, 0x18, 0x3B,
  0x7E, 0x66, 0x66, 0xE6, 0xE6, 0xEE, 0x7C, 0x7C, 0x0C, 0xFC, 0x78, 0x30,
  0x60, 0xC3, 0xE7, 0xEC, 0xD9, 0xB3, 0x6F, 0x9B, 0x36, 0x60, 0x33, 0x07,
  0x66, 0x66, 0x6E, 0xCC, 0x0C, 0x30, 0x07, 0x18, 0x61, 0x86, 0x18, 0xE3,
  0x0C, 0x33, 0xCE, 0x00, 0x30, 0x30, 0x30, 0x77, 0x6E, 0x7C, 0x78, 0x78,
  0x78, 0xEC, 0xCC, 0xCC, 0x33, 0x33, 0x76, 0x66, 0x66, 0xCC, 0x6D, 0xCF,
  0xFD, 0x99, 0xB3, 0x36, 0x6E, 0xDD, 0xBB, 0x36, 0x66, 0xCC, 0xC0, 0x6C,
  0xFD, 0x9B, 0x36, 0x7D, 0xF3, 0x66, 0xCC, 0x3C, 0xFD, 0x9B, 0x3E, 0x7C,
  0xFB, 0xBE, 0x38, 0x36, 0x3F, 0x33, 0x33, 0x33, 0x33, 0x73, 0x7E, 0x6C,
  0x60, 0x60, 0xE0, 0x3E, 0x7E, 0x66, 0x66, 0xE6, 0xCE, 0xEC, 0x7C, 0x7C,
  0x0C, 0x0C, 0x1C, 0x6B, 0xDC, 0xC6, 0x33, 0x98, 0xC0, 0x3C, 0xFD, 0x9B,
  0x83, 0x83, 0xB3, 0x7E, 0x78, 0x66, 0xFF, 0xEC, 0xCC, 0xCE, 0xE0, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x6E, 0xEC, 0x7C, 0x7C, 0xCF, 0x3D, 0xB6, 0xDB,
  0xCF, 0x18, 0x60, 0xC9, 0xEC, 0xF6, 0xDF, 0xEF, 0xF7, 0x73, 0xB9, 0xDC,
  0xCC, 0x00, 0x33, 0x37, 0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x76, 0x66, 0x66,
  0xCD, 0xB3, 0x67, 0x8F, 0x1E, 0x18, 0x30, 0xC3, 0x86, 0x00, 0x7E, 0xFC,
  0x30, 0xC3, 0x86, 0x18, 0x7E, 0xFC, 0x08, 0xCC, 0x63, 0x18, 0xCC, 0xC3,
  0x18, 0xC6, 0x31, 0x84, 0x32, 0x22, 0x22, 0x66, 0x44, 0x44, 0xCC, 0x10,
  0xC6, 0x31, 0x8C, 0x63, 0x31, 0x8C, 0x66, 0x31, 0x00, 0x67, 0xEE, 0x74,
  0x60,
};

const GFXglyph RobotoCondensed_BoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 12, 4, 0, -12 },
  { 7, 5, 4, 5, 1, -12 },
  { 10, 8, 12, 8, 0, -12 },
  { 22, 8, 16, 8, 0, -14 },
  { 38, 8, 12, 10, 1, -12 },
  { 50, 8, 12, 9, 0, -12 },
  { 62, 2, 4, 3, 1, -12 },
  { 63, 5, 17, 5, 1, -13 },
  { 74, 5, 17, 5, -1, -13 },
  { 85, 7, 7, 7, 1, -12 },
  { 92, 7, 8, 7, 0, -9 },
  { 99, 3, 5, 4, -1, -2 },
  { 101, 4, 2, 6, 1, -6 },
  { 102, 3, 2, 5, 0, -2 },
  { 103, 7, 13, 5, -1, -12 },
  { 115, 7, 12, 8, 1, -12 },
  { 126, 5, 12, 8, 2, -12 },
  { 134, 8, 12, 8, 0, -12 },
  { 146, 8, 12, 8, 0, -12 },
  { 158, 8, 12, 8, 0, -12 },
  { 170, 8, 12, 8, 0, -12 },
  { 182, 6, 12, 8, 1, -12 },
  { 191, 7, 12, 8, 1, -12 },
  { 202, 8, 12, 8, 0, -12 },
  { 214, 6, 12, 8, 1, -12 },
  { 223, 4, 8, 4, 0, -8 },
  { 227, 5, 11, 4, -1, -8 },
  { 234, 7, 8, 7, 0, -9 },
  { 241, 6, 6, 8, 1, -8 },
  { 246, 7, 8, 7, 0, -9 },
  { 253, 6, 12, 7, 1, -12 },
  { 262, 11, 15, 12, 0, -11 },
  { 283, 9, 12, 9, -1, -12 },
  { 297, 9, 12, 9, 0, -12 },
  { 311, 8, 12, 9, 1, -12 },
  { 323, 8, 12, 9, 0, -12 },
  { 335, 8, 12, 8, 0, -12 },
  { 347, 8, 12, 7, 0, -12 },
  { 359, 8, 12, 9, 1, -12 },
  { 371, 10, 12, 10, 0, -12 },
  { 386, 4, 12, 4, 0, -12 },
  { 392, 8, 12, 8, 0, -12 },
  { 404, 10, 12, 9, 0, -12 },
  { 419, 7, 12, 7, 0, -12 },
  { 430, 12, 12, 12, 0, -12 },
  { 448, 10, 12, 10, 0, -12 },
  { 463, 8, 12, 9, 1, -12 },
  { 475, 9, 12, 9, 0, -12 },
  { 489, 8, 14, 9, 1, -12 },
  { 503, 9, 12, 9, 0, -12 },
  { 517, 8, 12, 8, 0, -12 },
  { 529, 8, 12, 8, 1, -12 },
  { 541, 8, 12, 9, 1, -12 },
  { 553, 9, 12, 9, 1, -12 },
  { 567, 11, 12, 12, 1, -12 },
  { 584, 10, 12, 9, -1, -12 },
  { 599, 9, 12, 8, 1, -12 },
  { 613, 9, 12, 8, 0, -12 },
  { 627, 5, 16, 4, 0, -13 },
  { 637, 4, 13, 6, 1, -12 },
  { 644, 6, 16, 4, -1, -13 },
  { 656, 5, 6, 6, 1, -12 },
  { 660, 6, 2, 6, -1, 0 },
  { 662, 3, 2, 5, 2, -12 },
  { 663, 7, 9, 7, 0, -9 },
  { 671, 7, 12, 8, 0, -12 },
  { 682, 7, 9, 7, 0, -9 },
  { 690, 8, 12, 8, 0, -12 },
  { 702, 7, 9, 7, 0, -9 },
  { 710, 6, 12, 5, 0, -12 },
  { 719, 8, 12, 8, 0, -9 },
  { 731, 7, 12, 8, 0, -12 },
  { 742, 4, 12, 4, 0, -12 },
  { 748, 6, 15, 4, -2, -12 },
  { 760, 8, 12, 7, 0, -12 },
  { 772, 4, 12, 4, 0, -12 },
  { 778, 11, 9, 12, 0, -9 },
  { 791, 7, 9, 8, 0, -9 },
  { 799, 7, 9, 8, 0, -9 },
  { 807, 8, 12, 8, -1, -9 },
  { 819, 8, 12, 8, 0, -9 },
  { 831, 5, 9, 5, 0, -9 },
  { 837, 7, 9, 7, 0, -9 },
  { 845, 4, 11, 5, 1, -11 },
  { 851, 8, 9, 8, 0, -9 },
  { 860, 6, 9, 7, 1, -9 },
  { 867, 9, 9, 10, 1, -9 },
  { 878, 8, 9, 7, -1, -9 },
  { 887, 7, 12, 7, 0, -9 },
  { 898, 7, 9, 7, 0, -9 },
  { 906, 5, 16, 5, 0, -13 },
  { 916, 4, 14, 4, 0, -12 },
  { 923, 5, 15, 5, -1, -12 },
  { 933, 7, 4, 9, 1, -7 },
};

const GFXfont RobotoCondensed_BoldItalic16pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic16pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _ROBOTOCONDENSED_BOLDITALIC16PT7B_H_
