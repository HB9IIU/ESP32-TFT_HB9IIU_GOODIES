#ifndef _ROBOTOCONDENSED_BOLDITALIC32PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x78, 0x78, 0x78, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0xF0, 0xF0, 0xE0,
  0x73, 0xB9, 0xDC, 0xEE, 0x76, 0x37, 0x3B, 0x9D, 0xCE, 0xE6, 0x00, 0x01,
  0xCE, 0x01, 0xCC, 0x01, 0x9C, 0x03, 0x9C, 0x03, 0x9C, 0x03, 0xB8, 0x3F,
  0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0C,
  0xE0, 0x1C, 0xE0, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x39, 0x80, 0x33,
  0x80, 0x73, 0x80, 0x73, 0x80, 0x77, 0x00, 0x67, 0x00, 0x00, 0x60, 0x01,
  0x80, 0x0E, 0x00, 0xF8, 0x07, 0xF8, 0x3F, 0xE1, 0xFF, 0xC7, 0x8F, 0x3E,
  0x3C, 0xF0, 0xF3, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFC, 0x01, 0xF0, 0x03, 0xEF, 0x0F, 0xBC, 0x1E, 0xF0, 0xFB, 0xE3, 0xC7,
  0xFF, 0x1F, 0xF8, 0x3F, 0xC0, 0x7E, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x3C, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0x38, 0xEE, 0x71, 0xDC, 0xE7, 0x39,
  0xDC, 0x73, 0xB8, 0xFF, 0xE0, 0xFF, 0x80, 0xF7, 0x00, 0x1C, 0x00, 0x77,
  0x81, 0xDF, 0x83, 0xFF, 0x0E, 0xE7, 0x3B, 0x8E, 0x77, 0x1D, 0xCE, 0x3F,
  0x1C, 0xE2, 0x1F, 0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x03, 0xF8,
  0x07, 0xFC, 0x0F, 0xFC, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C,
  0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC7, 0x3F, 0xEF,
  0x7D, 0xEF, 0x79, 0xFF, 0x78, 0xFE, 0x78, 0xFE, 0x78, 0x7C, 0x7F, 0xFC,
  0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0x9F, 0x77, 0x77, 0x7E, 0xEE, 0xE0, 0x00,
  0x40, 0x70, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03,
  0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x01, 0xC0, 0x20, 0x04, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03,
  0xC1, 0xE0, 0x78, 0x3C, 0x0E, 0x02, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x06, 0x0E, 0x73, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0x01, 0xFC, 0x1E,
  0xE0, 0xE3, 0x86, 0x1C, 0x10, 0x40, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x3C, 0x70, 0xE3,
  0xC7, 0x9E, 0x3C, 0xF0, 0x40, 0xFF, 0xFE, 0xFE, 0xFE, 0x77, 0xBF, 0xE7,
  0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x1F,
  0xC0, 0xFF, 0x87, 0xFF, 0x3E, 0x3C, 0xF0, 0xF3, 0xC3, 0xDF, 0x0F, 0x7C,
  0x3D, 0xE0, 0xF7, 0x87, 0xDE, 0x1F, 0x78, 0x7B, 0xE1, 0xEF, 0x87, 0xBE,
  0x1E, 0xF0, 0xFB, 0xC3, 0xC7, 0x8F, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x01,
  0xF0, 0x00, 0x00, 0xC0, 0xF1, 0xFD, 0xFF, 0x7F, 0x9F, 0xE4, 0x78, 0x1E,
  0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x0F, 0xF8, 0x3F,
  0xF0, 0xFF, 0xF1, 0xE3, 0xE7, 0xC3, 0xCF, 0x87, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF,
  0x3F, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE3,
  0xE3, 0xC3, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x07, 0xF8, 0x0F, 0xE0,
  0x1F, 0x80, 0x7F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0xF8, 0x7C, 0xF0,
  0xF9, 0xE3, 0xE3, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0xFF,
  0x01, 0xDE, 0x07, 0xFC, 0x1E, 0xF0, 0x39, 0xE0, 0xF3, 0xC3, 0xC7, 0x87,
  0x9F, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFD, 0xFF, 0xF8, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F,
  0xF0, 0xFF, 0xE1, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xC0,
  0x7F, 0xE1, 0xFF, 0xC3, 0xEF, 0xC0, 0x87, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0xF0, 0x79, 0xE1, 0xF3, 0xE3, 0xC3, 0xFF, 0x87, 0xFE, 0x07, 0xF8,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0xC1, 0xFC, 0x1F, 0xE0, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0x80, 0x3D, 0xE3, 0xFF, 0x9F, 0xFE, 0xFF, 0xF7, 0x87,
  0xBC, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x7B, 0xC7, 0xDE, 0x3C, 0xFF, 0xE3,
  0xFE, 0x1F, 0xE0, 0x3E, 0x00, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x3F, 0xE0, 0xFF, 0x87, 0xFF, 0x1E, 0x3C, 0xF8, 0xF3,
  0xC3, 0xCF, 0x0F, 0x3E, 0x7C, 0x7F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xF1,
  0xE3, 0xCF, 0x8F, 0x3C, 0x3E, 0xF0, 0xFB, 0xC3, 0xCF, 0x8F, 0x3F, 0xFC,
  0x7F, 0xE0, 0xFF, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x7F,
  0xE7, 0xCF, 0x3C, 0x3D, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F, 0x87, 0xFE, 0x3F,
  0xF1, 0xE7, 0xDF, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x01, 0xE0, 0x1E, 0x01,
  0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x01, 0xC0, 0x00, 0x1C, 0x7C, 0xF9, 0xF1,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3C, 0x7C, 0xF0, 0xE0,
  0x07, 0x07, 0x83, 0xE1, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x87,
  0x83, 0x80, 0x80, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x1F, 0xF7, 0xF8,
  0xFE, 0x0F, 0x80, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFC, 0x07, 0xC0, 0x1C,
  0x00, 0x40, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x9F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0x20, 0x03,
  0x80, 0x3E, 0x03, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF0, 0x1F, 0x07, 0xF1,
  0xFE, 0xFF, 0x8F, 0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x0F, 0x83, 0xFE,
  0x7F, 0xE7, 0xFF, 0xF8, 0xFF, 0x8F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x07, 0x80, 0x7C, 0x07, 0x80, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xE0, 0x1C, 0x0F, 0x00, 0x38, 0x38, 0x00,
  0xE1, 0xC0, 0x01, 0x8F, 0x0F, 0x86, 0x38, 0x7F, 0x1D, 0xC3, 0xFC, 0x77,
  0x1E, 0x71, 0xDC, 0x71, 0xC7, 0xE3, 0x87, 0x1F, 0x8E, 0x38, 0x6E, 0x78,
  0xE1, 0xB9, 0xE3, 0x8E, 0xE7, 0x0E, 0x3B, 0x1C, 0x70, 0xCC, 0x79, 0xC7,
  0x31, 0xFF, 0xB8, 0xC3, 0xEF, 0xC3, 0x87, 0x1E, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x20, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1E, 0xE0, 0x07, 0xBC, 0x03, 0xEF,
  0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xC0,
  0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xE3, 0xC0, 0x79, 0xF0,
  0x1E, 0x7C, 0x07, 0xBE, 0x01, 0xEF, 0x80, 0x78, 0x0F, 0xF8, 0x07, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x3E, 0x3C,
  0x1F, 0x1E, 0x0F, 0x1F, 0x1F, 0x8F, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0xE1,
  0xE0, 0xF0, 0xF0, 0x78, 0xF8, 0x3C, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E, 0x0F,
  0x8F, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0x80, 0x01, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xF0, 0xF1, 0xF0, 0x7C, 0xF0, 0x3E,
  0xF8, 0x1F, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3C, 0xF8, 0x1E, 0x7C, 0x1F, 0x1E,
  0x1F, 0x0F, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xF0,
  0x07, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xF0, 0xF0, 0xF8, 0x7C, 0x78,
  0x3E, 0x3C, 0x1F, 0x1E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xE3,
  0xC0, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF8, 0x3E, 0x7C, 0x1E, 0x3E, 0x1F,
  0x1E, 0x1F, 0x0F, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0x03, 0xFE, 0x00, 0x0F,
  0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF,
  0x83, 0xFF, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0,
  0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0xFC, 0x3F, 0xFC,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0xF1, 0xF0, 0x7C, 0xF0,
  0x1E, 0x78, 0x0F, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x1F, 0xE7,
  0x8F, 0xF7, 0xC7, 0xFB, 0xE0, 0x7D, 0xF0, 0x3C, 0xF8, 0x1E, 0x3C, 0x0F,
  0x1F, 0x0F, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x0F,
  0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xE1, 0xF0, 0x1E, 0x1F, 0x03, 0xE1,
  0xF0, 0x3E, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC3, 0xFF, 0xFC,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xC0, 0x78, 0x3C, 0x07,
  0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x78, 0x0F, 0x07, 0x80,
  0xF0, 0x78, 0x0F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x00, 0x0F, 0x87, 0x83,
  0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xE1,
  0xE0, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE0, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0xF8, 0x78, 0xF8, 0xF8, 0xF8,
  0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0x03, 0xE0,
  0xF0, 0x7C, 0x0F, 0x0F, 0xC1, 0xF1, 0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xE0,
  0x1E, 0x7C, 0x01, 0xE7, 0xC0, 0x1E, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xEF,
  0x80, 0x7C, 0x78, 0x07, 0xC7, 0xC0, 0x78, 0x7C, 0x07, 0x83, 0xC0, 0x78,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE,
  0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xC1, 0xFE, 0x1F, 0xE1, 0xFE,
  0x3F, 0xE3, 0xFC, 0x3F, 0xE3, 0xBC, 0x3D, 0xE7, 0xBC, 0x3C, 0xE7, 0x3C,
  0x3C, 0xEF, 0x7C, 0x3C, 0xEF, 0x7C, 0x7C, 0xEE, 0x78, 0x7C, 0xFE, 0x78,
  0x7C, 0xFC, 0x78, 0x78, 0xFC, 0xF8, 0x78, 0xF8, 0xF8, 0x78, 0xF8, 0xF8,
  0xF8, 0x70, 0xF0, 0xF8, 0x70, 0xF0, 0x0F, 0x81, 0xE0, 0xF8, 0x1E, 0x0F,
  0x81, 0xE1, 0xF8, 0x3E, 0x1F, 0xC3, 0xE1, 0xFC, 0x3E, 0x1F, 0xC3, 0xC1,
  0xFC, 0x3C, 0x1F, 0xE3, 0xC3, 0xEE, 0x7C, 0x3E, 0xE7, 0xC3, 0xEE, 0x7C,
  0x3C, 0x77, 0x83, 0xC7, 0x78, 0x3C, 0x77, 0x87, 0xC7, 0xF8, 0x7C, 0x3F,
  0x87, 0xC3, 0xF8, 0x78, 0x3F, 0x07, 0x83, 0xF0, 0x78, 0x1F, 0x0F, 0x81,
  0xF0, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xE1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF0, 0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xBC,
  0x07, 0xDE, 0x03, 0xEF, 0x01, 0xF7, 0x80, 0xFF, 0xC0, 0x7B, 0xE0, 0x3D,
  0xF0, 0x3E, 0xF8, 0x1F, 0x3C, 0x0F, 0x1F, 0x0F, 0x8F, 0xFF, 0x83, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x7F, 0xFE, 0x1F, 0x07, 0x87, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E,
  0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF,
  0x03, 0xFF, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x03,
  0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF0, 0x1E,
  0xF8, 0x0F, 0x7C, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xEF, 0x01, 0xF7, 0x80,
  0xF7, 0xC0, 0x7B, 0xE0, 0x3D, 0xF0, 0x3E, 0xF8, 0x1F, 0x3C, 0x0F, 0x1F,
  0x0F, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x1C, 0x00, 0x04, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x1E, 0x3C, 0x0F,
  0x1E, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF,
  0xC0, 0xFF, 0xE0, 0xF8, 0xF0, 0x7C, 0x78, 0x3E, 0x3E, 0x1E, 0x1F, 0x0F,
  0x0F, 0x87, 0x83, 0xC7, 0xC1, 0xF3, 0xE0, 0xF8, 0x01, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF8, 0x7C, 0x7F, 0xF8,
  0x7F, 0xF8, 0x3F, 0xE0, 0x0F, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x07, 0x8F, 0x03, 0xCF, 0x81, 0xE7, 0xC1,
  0xF3, 0xE0, 0xF9, 0xE0, 0x7C, 0xF0, 0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x3E,
  0x0F, 0x9F, 0x07, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC0, 0xF3, 0xE0, 0x79,
  0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1E, 0x3E, 0x1F, 0x0F, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0x00, 0x78, 0x07, 0xDE, 0x03, 0xE7, 0x80, 0xF9,
  0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x7C, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C,
  0x03, 0xDF, 0x00, 0xF7, 0x80, 0x3F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x78, 0x7F,
  0xC3, 0xE1, 0xEF, 0x0F, 0x87, 0xBC, 0x3E, 0x3E, 0xF1, 0xF8, 0xF3, 0xC7,
  0xE3, 0xCF, 0x1F, 0x9F, 0x3C, 0xFE, 0x78, 0xF3, 0xF9, 0xE3, 0xCF, 0xEF,
  0x8F, 0x7F, 0xBC, 0x3D, 0xFE, 0xF0, 0xF7, 0x7B, 0xC3, 0xFD, 0xFE, 0x0F,
  0xF3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xC0,
  0x00, 0x0F, 0x83, 0xF0, 0xF8, 0x3E, 0x07, 0x87, 0xC0, 0x7C, 0x7C, 0x07,
  0xCF, 0x80, 0x7C, 0xF8, 0x03, 0xDF, 0x00, 0x3D, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0xBC, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x03, 0xE1, 0xE0, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x00, 0xF0,
  0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0x78, 0x78, 0x78, 0xF8, 0x78,
  0xF0, 0x79, 0xF0, 0x3D, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xC7,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xC0, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xE0, 0x3C, 0x07, 0xE0, 0xFC, 0x3F, 0x00, 0xF1, 0xE3, 0xC7, 0x8F,
  0x1F, 0x3E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0xCF, 0x8F, 0x1E, 0x3C, 0x78,
  0xF1, 0xE3, 0xE3, 0xC7, 0x8F, 0x1E, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x07, 0xE1, 0xF8, 0x3F,
  0x00, 0x03, 0x80, 0xF0, 0x3E, 0x07, 0xC1, 0xFC, 0x3B, 0x8F, 0x71, 0xCE,
  0x79, 0xCE, 0x3B, 0xC7, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x78,
  0xF0, 0xF0, 0xE1, 0xE0, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xBE, 0x3C,
  0x78, 0x01, 0xE0, 0x07, 0x83, 0xFE, 0x3F, 0xF9, 0xFF, 0xE7, 0x8F, 0xBE,
  0x3C, 0xF8, 0xF3, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x1E, 0xF0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xBC,
  0x1F, 0xF8, 0xFF, 0xF3, 0xFF, 0xCF, 0x8F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3,
  0xDF, 0x0F, 0x7C, 0x3D, 0xE0, 0xF7, 0x87, 0xDE, 0x1E, 0x7F, 0xFB, 0xFF,
  0xCF, 0x7F, 0x3C, 0xF0, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0x8F,
  0xFC, 0x3F, 0xC1, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE1, 0xEF,
  0x1E, 0x7F, 0xF1, 0xFF, 0x0F, 0xF8, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x07, 0x9E, 0x3F,
  0xBC, 0x7F, 0xF9, 0xFF, 0xF3, 0xC3, 0xCF, 0x87, 0x9E, 0x0F, 0x3C, 0x1E,
  0x78, 0x7C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0xFF, 0x1F,
  0xFE, 0x1F, 0xF8, 0x1E, 0xF0, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x7F, 0xF7,
  0x87, 0xBC, 0x3F, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0,
  0x0F, 0x84, 0x7F, 0xF1, 0xFF, 0xC7, 0xFC, 0x1F, 0x80, 0x01, 0xE0, 0xFC,
  0x3F, 0x87, 0xF1, 0xF0, 0x3C, 0x07, 0x83, 0xFE, 0x7F, 0x9F, 0xF0, 0xF8,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0x07, 0xDE, 0x1F, 0xFC, 0x7F, 0xF9,
  0xFF, 0xF3, 0xC3, 0xEF, 0x87, 0x9F, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0,
  0xF9, 0xE1, 0xF3, 0xC3, 0xC7, 0x87, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFC,
  0x1E, 0xF8, 0x01, 0xE0, 0x03, 0xC2, 0x0F, 0x87, 0xFE, 0x1F, 0xFC, 0x3F,
  0xF0, 0x1F, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xBC, 0x1F, 0xF8, 0xFF, 0xF3, 0xFF, 0xCF, 0x0F,
  0x3C, 0x3C, 0xF0, 0xF7, 0xC7, 0xDF, 0x1F, 0x78, 0x79, 0xE1, 0xE7, 0x87,
  0x9E, 0x1E, 0xF8, 0xFB, 0xE3, 0xEF, 0x0F, 0x3C, 0x3C, 0x06, 0x0F, 0x0F,
  0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0xF8, 0x00, 0xC0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x7F, 0x0F,
  0xC1, 0xF0, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x3E, 0x1E, 0x7E, 0x3E, 0x7C,
  0x3E, 0xF8, 0x3D, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x7D, 0xE0, 0x79, 0xF0, 0x79, 0xF0, 0xF8, 0xF0,
  0xF0, 0xF8, 0xF0, 0xF8, 0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x78,
  0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x7C, 0x3E,
  0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0x1E, 0xF0, 0xF0, 0x7F, 0xEF,
  0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3E, 0x7C, 0x7C, 0xF0, 0xF1, 0xF3,
  0xC3, 0xC7, 0xCF, 0x1F, 0x1E, 0x7C, 0x78, 0x79, 0xF1, 0xE1, 0xE7, 0x87,
  0x87, 0x9E, 0x1E, 0x3E, 0x78, 0x78, 0xF9, 0xE3, 0xE3, 0xCF, 0x8F, 0x0F,
  0x3E, 0x3C, 0x3C, 0xF0, 0xF0, 0xF0, 0x1E, 0xF0, 0xFF, 0xE3, 0xFF, 0xCF,
  0xFF, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xDF, 0x1F, 0x7C, 0x7D, 0xE1, 0xE7,
  0x87, 0x9E, 0x1E, 0x78, 0x7B, 0xE3, 0xEF, 0x8F, 0xBC, 0x3C, 0xF0, 0xF0,
  0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0xFF, 0xF7, 0x87, 0xBC, 0x3F, 0xE1, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x0F, 0x7F, 0xF9, 0xFF,
  0x87, 0xF8, 0x1F, 0x00, 0x0F, 0x78, 0x1F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF1,
  0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x3E, 0x1E, 0x7C, 0x3C, 0xF0,
  0x79, 0xE1, 0xF3, 0xC3, 0xC7, 0xFF, 0x9F, 0xFE, 0x3F, 0xFC, 0x79, 0xE0,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x0F, 0x3C, 0xFE, 0xF3, 0xFF, 0xDF, 0xFF, 0x78, 0x7B, 0xE1, 0xEF,
  0x07, 0xBC, 0x1E, 0xF0, 0xFB, 0xC3, 0xEF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3,
  0xFF, 0xCF, 0xFF, 0x1F, 0xFC, 0x3D, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x1E, 0xE3, 0xFC, 0xFF, 0x9F,
  0xF3, 0xF0, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0xFE,
  0x7C, 0xF3, 0xC7, 0x9E, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0x7D, 0xE1, 0xEF, 0x0F, 0x7C, 0xF9, 0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x1E,
  0x0F, 0x07, 0x83, 0xC7, 0xFF, 0xFF, 0xFE, 0x78, 0x3C, 0x1E, 0x0F, 0x0F,
  0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0x1F, 0x8F, 0xC3, 0xC0, 0x3C,
  0x3C, 0xF0, 0xF7, 0xC7, 0xDE, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0xBE,
  0x3E, 0xF8, 0xFB, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF1, 0xF3, 0xFF, 0xCF,
  0xFF, 0x1F, 0xF8, 0x3D, 0xE0, 0xF0, 0xFF, 0x87, 0xBC, 0x7D, 0xE3, 0xCF,
  0x1E, 0x79, 0xE3, 0xCF, 0x1E, 0x78, 0x77, 0x83, 0xBC, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x00, 0xF1, 0xE3, 0xFC,
  0x78, 0xFF, 0x1E, 0x7F, 0xCF, 0x9E, 0xF3, 0xE7, 0xBD, 0xFB, 0xCF, 0x7E,
  0xF3, 0xFF, 0xBC, 0xFE, 0xFE, 0x3F, 0xBF, 0x8F, 0xEF, 0xE3, 0xF3, 0xF0,
  0xFC, 0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0x70, 0x00,
  0x1E, 0x1E, 0x1F, 0x3E, 0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x1E, 0xF0, 0x3E, 0xF0, 0x7C, 0xF0, 0x78, 0xF8, 0xF8, 0x78, 0x1E, 0x1F,
  0x1E, 0x1E, 0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x1E, 0x78,
  0x1E, 0xF8, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x1F, 0xFC,
  0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xFF, 0xCF, 0xFF,
  0x3F, 0xF8, 0xFF, 0xE0, 0x00, 0x80, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x1F, 0x0F, 0x83, 0x80,
  0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x07, 0x01, 0xE0, 0x38, 0x0E, 0x00, 0x80, 0x06, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x06, 0x1C, 0x38, 0x70, 0xE1, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0x83, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x80, 0x04, 0x03, 0x80, 0xF0, 0x1C,
  0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01,
  0xE0, 0x7C, 0x0F, 0x0F, 0x83, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x38, 0x0C, 0x00, 0x1E, 0x00,
  0x7E, 0x1D, 0xFE, 0x3B, 0xFF, 0xFF, 0x3F, 0xDC, 0x3F, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 23, 8, 1, -23 },
  { 24, 9, 9, 10, 2, -24 },
  { 35, 16, 23, 16, 1, -23 },
  { 81, 14, 29, 16, 1, -26 },
  { 132, 15, 23, 20, 3, -23 },
  { 176, 16, 23, 18, 0, -23 },
  { 222, 4, 9, 5, 2, -24 },
  { 227, 10, 32, 10, 1, -25 },
  { 267, 10, 32, 10, -1, -25 },
  { 307, 13, 14, 14, 2, -23 },
  { 330, 13, 16, 15, 1, -19 },
  { 356, 7, 10, 8, -2, -4 },
  { 365, 8, 4, 11, 2, -12 },
  { 369, 5, 5, 9, 1, -5 },
  { 373, 14, 25, 10, -2, -23 },
  { 417, 14, 23, 16, 1, -23 },
  { 458, 10, 23, 16, 3, -23 },
  { 487, 15, 23, 16, 0, -23 },
  { 531, 15, 23, 16, 0, -23 },
  { 575, 15, 23, 16, 0, -23 },
  { 619, 15, 23, 16, 1, -23 },
  { 663, 13, 23, 16, 1, -23 },
  { 701, 15, 23, 16, 1, -23 },
  { 745, 14, 23, 16, 1, -23 },
  { 786, 13, 23, 16, 2, -23 },
  { 824, 7, 18, 9, 1, -18 },
  { 840, 9, 24, 8, -1, -18 },
  { 867, 12, 15, 14, 1, -17 },
  { 890, 14, 11, 16, 1, -16 },
  { 910, 12, 15, 14, 1, -17 },
  { 933, 12, 23, 14, 2, -23 },
  { 968, 22, 29, 24, 1, -22 },
  { 1048, 18, 23, 19, -1, -23 },
  { 1100, 17, 23, 17, 0, -23 },
  { 1149, 17, 23, 18, 1, -23 },
  { 1198, 17, 23, 18, 0, -23 },
  { 1247, 17, 23, 15, 0, -23 },
  { 1296, 16, 23, 15, 0, -23 },
  { 1342, 17, 23, 18, 1, -23 },
  { 1391, 20, 23, 19, 0, -23 },
  { 1449, 9, 23, 8, 0, -23 },
  { 1475, 16, 23, 15, 0, -23 },
  { 1521, 20, 23, 17, 0, -23 },
  { 1579, 13, 23, 15, 0, -23 },
  { 1617, 24, 23, 24, 0, -23 },
  { 1686, 20, 23, 19, 0, -23 },
  { 1744, 17, 23, 19, 1, -23 },
  { 1793, 18, 23, 18, 0, -23 },
  { 1845, 17, 27, 19, 1, -23 },
  { 1903, 17, 23, 17, 0, -23 },
  { 1952, 16, 23, 17, 1, -23 },
  { 1998, 16, 23, 17, 2, -23 },
  { 2044, 17, 23, 18, 1, -23 },
  { 2093, 18, 23, 18, 2, -23 },
  { 2145, 22, 23, 23, 3, -23 },
  { 2209, 20, 23, 17, -1, -23 },
  { 2267, 16, 23, 17, 3, -23 },
  { 2313, 18, 23, 16, 0, -23 },
  { 2365, 11, 31, 8, -1, -26 },
  { 2408, 7, 25, 12, 3, -23 },
  { 2430, 11, 31, 8, -2, -26 },
  { 2473, 11, 11, 12, 1, -23 },
  { 2489, 12, 4, 12, -2, 0 },
  { 2495, 7, 5, 10, 3, -24 },
  { 2500, 14, 17, 15, 0, -17 },
  { 2530, 14, 24, 15, 0, -24 },
  { 2572, 13, 17, 14, 1, -17 },
  { 2600, 15, 24, 15, 1, -24 },
  { 2645, 13, 17, 15, 1, -17 },
  { 2673, 11, 24, 10, 1, -24 },
  { 2706, 15, 24, 16, 0, -17 },
  { 2751, 14, 24, 15, 0, -24 },
  { 2793, 8, 24, 8, 0, -24 },
  { 2817, 11, 31, 8, -3, -24 },
  { 2860, 16, 24, 15, 0, -24 },
  { 2908, 9, 24, 8, 0, -24 },
  { 2935, 22, 17, 23, 0, -17 },
  { 2982, 14, 17, 15, 0, -17 },
  { 3012, 13, 17, 15, 1, -17 },
  { 3040, 15, 24, 15, -1, -17 },
  { 3085, 14, 24, 15, 1, -17 },
  { 3127, 11, 17, 10, 0, -17 },
  { 3151, 13, 17, 14, 0, -17 },
  { 3179, 9, 21, 10, 1, -21 },
  { 3203, 14, 17, 15, 1, -17 },
  { 3233, 13, 17, 14, 2, -17 },
  { 3261, 18, 17, 20, 2, -17 },
  { 3300, 16, 17, 14, -1, -17 },
  { 3334, 16, 24, 14, -1, -17 },
  { 3382, 14, 17, 14, 0, -17 },
  { 3412, 10, 31, 9, 1, -25 },
  { 3451, 7, 27, 8, 0, -23 },
  { 3475, 10, 31, 9, -1, -25 },
  { 3514, 15, 7, 17, 1, -13 },
};

const GFXfont RobotoCondensed_BoldItalic32pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic32pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOCONDENSED_BOLDITALIC32PT7B_H_
