#ifndef _ROBOTOCONDENSED_BOLDITALIC34PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x78, 0x78, 0x78, 0x00, 0x00, 0x00, 0x70, 0xF0, 0xF8, 0xF0,
  0x70, 0x79, 0xDE, 0xF7, 0x3D, 0xCE, 0x73, 0x9C, 0xEE, 0x3B, 0x8C, 0xE7,
  0x00, 0x00, 0xE7, 0x00, 0x73, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x0E, 0x70, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x81, 0xCE,
  0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x83, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF,
  0xFC, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x18, 0x03, 0x9C, 0x01,
  0xCE, 0x00, 0xE6, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00,
  0x1F, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0x3E, 0x3C, 0x3C, 0xF8,
  0x79, 0xF0, 0xF1, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xCF, 0x87, 0xDF, 0x0F, 0xBE, 0x1E, 0x7C,
  0x7C, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0xF3, 0x86, 0xE3,
  0x8E, 0xE3, 0x9C, 0xE3, 0xB8, 0xE7, 0xB8, 0xFF, 0x70, 0x7E, 0xE0, 0x3C,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x3C, 0x07, 0xFE, 0x0E, 0xFF, 0x1D,
  0xE7, 0x1D, 0xC7, 0x39, 0xC7, 0x71, 0xC7, 0xE1, 0xCE, 0x21, 0xFE, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0xF9, 0xE0, 0x78, 0xF0, 0x3C, 0x78, 0x1E, 0x7C, 0x0F, 0x7C, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x39, 0xFF, 0x3C, 0xF7, 0xDE, 0xFB,
  0xEF, 0x78, 0xFF, 0x3C, 0x3F, 0x9E, 0x1F, 0x8F, 0x87, 0xC7, 0xFF, 0xE1,
  0xFF, 0xF8, 0xFF, 0xFC, 0x1F, 0x1F, 0x7B, 0xDE, 0xE7, 0x3B, 0xDC, 0xE0,
  0x00, 0x80, 0x70, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F,
  0x03, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0,
  0x1C, 0x07, 0x01, 0xE0, 0x38, 0x06, 0x00, 0x80, 0x04, 0x01, 0x80, 0xF0,
  0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC0,
  0xF0, 0x38, 0x08, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x63,
  0x8F, 0xEF, 0xFF, 0xFF, 0xCF, 0xFE, 0x0F, 0x80, 0x7E, 0x03, 0xDC, 0x1E,
  0x70, 0x71, 0xE1, 0xC3, 0x82, 0x08, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F,
  0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xC7, 0x9F, 0x3C, 0xF0, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xE1, 0xE3, 0xE7, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x7C, 0x3E,
  0xF8, 0x7D, 0xF0, 0xFB, 0xE1, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x7C,
  0x3E, 0xF8, 0x7D, 0xF0, 0xF1, 0xE1, 0xE3, 0xC7, 0xC7, 0xFF, 0x0F, 0xFC,
  0x0F, 0xF0, 0x07, 0xC0, 0x00, 0xC1, 0xF1, 0xFF, 0xFE, 0xFF, 0xBF, 0xEC,
  0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78,
  0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x01, 0xF8,
  0x03, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F,
  0x3E, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x01, 0xF8,
  0x07, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF0,
  0x03, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x78, 0x3E, 0x78, 0x3C,
  0x7C, 0x7C, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0xF0, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x03, 0xBE, 0x07, 0xBC, 0x0F, 0x3C, 0x0F, 0x7C, 0x1E, 0x7C,
  0x3C, 0x7C, 0x3C, 0x78, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0xFF,
  0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3D, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF8, 0x18, 0x7C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0xF0, 0x7C, 0xF8, 0x78,
  0xF8, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x7C,
  0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80,
  0x3D, 0xF0, 0xFF, 0xE7, 0xFF, 0x9F, 0xFF, 0x7C, 0x7D, 0xE0, 0xF7, 0x83,
  0xFE, 0x0F, 0xF8, 0x3D, 0xE1, 0xF7, 0x87, 0xDE, 0x3E, 0x7F, 0xF8, 0xFF,
  0xC1, 0xFE, 0x03, 0xE0, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xF1, 0xF3, 0xE3, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3E, 0x3E,
  0x3C, 0x78, 0x7F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFE, 0x1F, 0x3E, 0x7C,
  0x3C, 0xF8, 0x79, 0xF0, 0xF3, 0xE1, 0xE7, 0xC7, 0xCF, 0xFF, 0x8F, 0xFE,
  0x0F, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x7C,
  0x79, 0xF1, 0xF7, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xDE,
  0x3E, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xBC, 0x00, 0xF0, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0x1E, 0x7C,
  0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x7C,
  0xF9, 0xF1, 0xC0, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xC0, 0x20, 0x00, 0x00,
  0x08, 0x01, 0xC0, 0x3E, 0x07, 0xF0, 0xFF, 0x3F, 0xF3, 0xFC, 0x1F, 0x80,
  0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFE, 0x01, 0xF0, 0x03, 0x80,
  0x08, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xE0, 0x20, 0x01,
  0xC0, 0x0F, 0x80, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x01,
  0xF8, 0x7F, 0xCF, 0xF9, 0xFF, 0x0F, 0xE0, 0x7C, 0x03, 0x80, 0x10, 0x00,
  0x0F, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xF7, 0xCF, 0xBC, 0x7F, 0xE3, 0xE0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x07, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0x03, 0xC0, 0x78, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x03, 0x0E,
  0x0F, 0x87, 0x3C, 0x3F, 0x8E, 0x70, 0xFF, 0x9C, 0xE3, 0xCE, 0x3B, 0x8F,
  0x1C, 0x77, 0x1C, 0x38, 0xEE, 0x78, 0xF1, 0xF8, 0xF1, 0xC3, 0xF1, 0xC3,
  0x87, 0xE3, 0x87, 0x0D, 0xC7, 0x0E, 0x3B, 0x8E, 0x38, 0x77, 0x1C, 0x70,
  0xCE, 0x39, 0xE3, 0x9C, 0x7F, 0xFE, 0x38, 0xFD, 0xF8, 0x70, 0xF1, 0xE0,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x80, 0x7D, 0xF0, 0x0F,
  0x9E, 0x01, 0xE3, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x03, 0xE1, 0xE0, 0x7F,
  0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0x03, 0xE7, 0xC0,
  0x7C, 0xF8, 0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x1E, 0x0F, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F, 0x0F, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x83, 0xE1, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F,
  0xFC, 0x0F, 0xFF, 0xC3, 0xE1, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1F, 0x03,
  0xC7, 0xC1, 0xF1, 0xF0, 0xFC, 0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xFF, 0xC3,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F,
  0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x7C, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x0F, 0x3E, 0x07, 0xC7, 0x81, 0xF1, 0xF0, 0xF8, 0x7F,
  0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0x0F, 0x87, 0xC1, 0xE1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x07, 0x8F, 0x81, 0xE3, 0xE0, 0xF8, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x07,
  0xC7, 0xC1, 0xF1, 0xF1, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFF, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7F,
  0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1,
  0xFF, 0xE0, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC1,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF1, 0xFE, 0x7C, 0x7F, 0x9E, 0x1F, 0xE7, 0x87, 0xFB, 0xE0, 0x3E, 0xF8,
  0x0F, 0x1E, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF,
  0x81, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0,
  0x3C, 0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0xF0, 0x1F, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0xF8, 0x7C,
  0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0x78,
  0x3C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE1, 0xF0, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x7C,
  0x3E, 0x3E, 0x1E, 0x1F, 0x1F, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0x80,
  0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE1, 0xF8, 0x1E, 0x1F,
  0x80, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xFC, 0x03, 0xEF, 0xC0, 0x1F,
  0x7C, 0x00, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xEF, 0x80, 0x7E, 0x7C, 0x03, 0xE3,
  0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3C, 0x1F, 0x83,
  0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE, 0x0F,
  0xC0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE,
  0x0F, 0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x07, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xB8, 0x7F, 0xC1, 0xEE, 0x1F, 0xF0, 0xFB,
  0x8F, 0x7C, 0x3E, 0xE3, 0xDE, 0x0F, 0xBD, 0xE7, 0x83, 0xCF, 0x7B, 0xE0,
  0xF3, 0xDC, 0xF8, 0x7C, 0xFF, 0x3E, 0x1F, 0x3F, 0x8F, 0x87, 0xC7, 0xE3,
  0xC1, 0xF1, 0xF9, 0xF0, 0x7C, 0x7C, 0x7C, 0x1E, 0x1F, 0x1F, 0x0F, 0x87,
  0x87, 0xC3, 0xE1, 0xE1, 0xE0, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xF0,
  0x3C, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x0F, 0xE0, 0xF8, 0x7F, 0x87, 0xC3,
  0xFC, 0x3C, 0x1F, 0xE1, 0xE0, 0xF7, 0x9F, 0x07, 0xBC, 0xF8, 0x7C, 0xE7,
  0xC3, 0xE7, 0x3E, 0x1F, 0x3D, 0xE0, 0xF9, 0xEF, 0x07, 0x87, 0xF8, 0x7C,
  0x3F, 0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0xF0, 0xF8, 0x3F, 0x07, 0xC1, 0xF8,
  0x3C, 0x0F, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC1, 0xF3, 0xE0, 0x7C,
  0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C,
  0x07, 0xDE, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0x9E, 0x03,
  0xE7, 0xC1, 0xF1, 0xF0, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0,
  0xF0, 0x7C, 0x3E, 0x07, 0x87, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3,
  0xC0, 0xF8, 0x78, 0x1F, 0x1F, 0x07, 0xE3, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0x81, 0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC1,
  0xF3, 0xE0, 0x7C, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D,
  0xF0, 0x1F, 0x7C, 0x07, 0xDE, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x3E, 0xF8,
  0x0F, 0x9E, 0x03, 0xC7, 0x81, 0xF1, 0xF0, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xC0,
  0x00, 0x20, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F,
  0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x81,
  0xF1, 0xE1, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0xC0,
  0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C,
  0x3E, 0x1E, 0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x7C, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF1, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0xF0, 0x3E, 0x78, 0x1F, 0x3E, 0x0F,
  0x9F, 0x0F, 0x87, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x03, 0xE3, 0xE0, 0x78, 0x7C, 0x1F, 0x0F, 0x03, 0xE3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3C, 0x3C, 0x0F, 0x87,
  0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0xF0, 0xF8, 0x1E, 0x1E,
  0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xF8, 0x3E,
  0x3F, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0xF8,
  0x0F, 0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7E, 0xF8, 0x1F, 0x3E, 0x07,
  0xCF, 0x83, 0xE1, 0xE0, 0xF8, 0x78, 0x7C, 0x1E, 0x1F, 0x07, 0x87, 0x81,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x7C, 0x07, 0xDF, 0x00, 0xF7, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x7C, 0x3F, 0xF0, 0xF8, 0x7F, 0xE1,
  0xF0, 0xF7, 0xC7, 0xE3, 0xEF, 0x8F, 0xC7, 0xDF, 0x1F, 0x8F, 0x3E, 0x7F,
  0x1E, 0x7C, 0xFE, 0x7C, 0xF9, 0xFC, 0xF1, 0xF7, 0xF9, 0xE3, 0xEF, 0xF7,
  0xC7, 0xDF, 0xEF, 0x8F, 0xFB, 0xDE, 0x1F, 0xF7, 0xFC, 0x3F, 0xCF, 0xF8,
  0x7F, 0x9F, 0xE0, 0xFF, 0x3F, 0xC1, 0xFC, 0x7F, 0x83, 0xF8, 0xFE, 0x07,
  0xF1, 0xFC, 0x0F, 0xC3, 0xF8, 0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xC0, 0x7C,
  0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x7E, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0x87,
  0xC0, 0x7C, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0xBE, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7C,
  0xF0, 0x07, 0xE7, 0xC0, 0x3E, 0x3E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0xC1,
  0xF0, 0x3E, 0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0xFC, 0x0F, 0xBE, 0x07, 0xCF,
  0x07, 0xC7, 0x83, 0xE3, 0xE3, 0xE1, 0xF1, 0xE0, 0x79, 0xF0, 0x3C, 0xF0,
  0x1E, 0xF8, 0x0F, 0x78, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07,
  0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xF0, 0xF0, 0xF8, 0xF8,
  0xF8, 0xF8, 0x78, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C,
  0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1F, 0x1F, 0x1F, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0x03, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0x79, 0xE7,
  0x38, 0xEF, 0x1D, 0xE3, 0xF8, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x0E, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0xC7,
  0xFF, 0x3E, 0x3C, 0xF8, 0xF0, 0x03, 0xC1, 0xFF, 0x1F, 0xFC, 0xFF, 0xF7,
  0xC7, 0x9E, 0x1E, 0xF8, 0x7B, 0xE3, 0xEF, 0xFF, 0x9F, 0xFE, 0x7F, 0xF8,
  0x7B, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0xF8, 0x3F, 0xF8, 0x7F, 0xF9, 0xFF,
  0xF3, 0xE3, 0xE7, 0xC3, 0xCF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0xF8, 0x7D,
  0xF0, 0xFB, 0xE1, 0xF7, 0x83, 0xCF, 0x8F, 0x9F, 0xFF, 0x7F, 0xFC, 0xFF,
  0xF1, 0xE7, 0xC0, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFE, 0x7C, 0x79,
  0xE1, 0xEF, 0x87, 0xFE, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x3C,
  0xF0, 0xF3, 0xE7, 0xCF, 0xFF, 0x1F, 0xF8, 0x3F, 0xC0, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x0F, 0xBE, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFC, 0x7C,
  0x7C, 0x78, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0xF8, 0xF0, 0xF8, 0xF8, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F,
  0xF0, 0x3E, 0xF0, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0xFE, 0x7C, 0x7D,
  0xE0, 0xF7, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00,
  0xF8, 0x03, 0xE1, 0x87, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0, 0x3E, 0x00, 0x01,
  0xF0, 0x3F, 0x07, 0xF0, 0xFF, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x7F,
  0xC7, 0xFC, 0x7F, 0xCF, 0xFC, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x07, 0xCF, 0x0F, 0xEF, 0x1F, 0xFF, 0x3F, 0xFF, 0x3E, 0x3F,
  0x3C, 0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3E, 0x78, 0x3E,
  0x78, 0x3C, 0x78, 0x3C, 0x7C, 0x7C, 0x7F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC,
  0x1F, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x61, 0xF8, 0x7F, 0xF0, 0xFF, 0xE0,
  0x7F, 0xC0, 0x3F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0xF8, 0x3F, 0xF8, 0xFF,
  0xF1, 0xFF, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x9E, 0x1F, 0x7C, 0x3E,
  0xF8, 0x79, 0xF0, 0xF3, 0xC3, 0xE7, 0x87, 0xCF, 0x0F, 0xBE, 0x1E, 0x7C,
  0x3C, 0xF8, 0x79, 0xE1, 0xF0, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0x70, 0x00,
  0x00, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x78, 0x3C,
  0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE1, 0xF0, 0xF8, 0x00, 0x00, 0x70,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x07, 0xF0, 0x3F, 0x03, 0xF8,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x1F, 0x0F, 0x1F, 0x87,
  0x9F, 0x87, 0xCF, 0x83, 0xEF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFE, 0x07, 0xDF, 0x03, 0xC7,
  0x81, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x78, 0x7C, 0x3E, 0x00, 0x0F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE0,
  0xF0, 0xF8, 0x7C, 0x00, 0x1E, 0x78, 0x78, 0x3F, 0xFB, 0xF8, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xE3, 0xF3, 0xE7, 0xC7, 0xC7, 0xCF, 0x0F, 0x8F,
  0x9E, 0x1F, 0x1F, 0x3C, 0x3C, 0x3E, 0xF8, 0x78, 0x7D, 0xF1, 0xF0, 0xF3,
  0xE3, 0xE1, 0xE7, 0x87, 0xC7, 0xCF, 0x0F, 0x8F, 0x9E, 0x1E, 0x1F, 0x7C,
  0x3C, 0x3C, 0xF8, 0xF8, 0x79, 0xF1, 0xF0, 0xF0, 0x1E, 0x78, 0x3F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x9E, 0x1F, 0x7C,
  0x3E, 0xF8, 0x79, 0xF0, 0xF3, 0xE3, 0xE7, 0x87, 0xCF, 0x0F, 0xBE, 0x1E,
  0x7C, 0x3C, 0xF8, 0x79, 0xF1, 0xF0, 0x07, 0xE0, 0x3F, 0xC3, 0xFF, 0x8F,
  0xFF, 0x7C, 0x7D, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x07, 0xFC, 0x1F, 0xF0, 0x7B, 0xE3, 0xEF, 0xFF, 0x1F, 0xFC, 0x3F, 0xE0,
  0x7E, 0x00, 0x0F, 0x7C, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x1F,
  0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x1F, 0x3E, 0x1F,
  0x3E, 0x1F, 0x3C, 0x1E, 0x3E, 0x3E, 0x3F, 0xFE, 0x7F, 0xFC, 0x7F, 0xF8,
  0x7D, 0xF0, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x9E, 0x3F, 0xBC, 0xFF, 0xFB, 0xFF, 0xE7,
  0xC7, 0xCF, 0x07, 0xBE, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xE0, 0xF3, 0xC1,
  0xE7, 0x87, 0xCF, 0x0F, 0x9F, 0x1F, 0x3F, 0xFE, 0x7F, 0xF8, 0x7F, 0xF0,
  0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x1E, 0xF1, 0xFE, 0x1F, 0xE3, 0xFE, 0x3F, 0xE3, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F,
  0xDF, 0x3E, 0x3C, 0xF0, 0xF3, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3E, 0xF0, 0x7B, 0xE3, 0xE7, 0xDF, 0x9F, 0xFC, 0x3F, 0xE0,
  0x3E, 0x00, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x7F, 0xFF, 0xEF, 0xFB, 0xFE,
  0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0xE1, 0xF8, 0x7E, 0x0F, 0x80, 0x3C, 0x3E, 0x78, 0x7C, 0xF0, 0xFB,
  0xE1, 0xE7, 0xC3, 0xCF, 0x8F, 0x9E, 0x1F, 0x3C, 0x3E, 0xF8, 0x7D, 0xF0,
  0xF3, 0xE1, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F, 0x1F, 0x3F, 0xFE, 0x7F, 0xF8,
  0x7F, 0xF0, 0x79, 0xE0, 0xF0, 0x7B, 0xC3, 0xEF, 0x0F, 0xBC, 0x3C, 0xF9,
  0xF3, 0xE7, 0x8F, 0x9E, 0x1E, 0xF0, 0x7B, 0xC1, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x3E, 0x00, 0xF0, 0x00,
  0xF0, 0xE1, 0xFF, 0x0E, 0x1E, 0xF1, 0xF3, 0xEF, 0x1F, 0x3C, 0xF3, 0xF3,
  0xCF, 0x3F, 0x7C, 0xF7, 0xF7, 0x8F, 0x7F, 0x78, 0xF7, 0x7F, 0x8F, 0xF7,
  0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x07, 0x87, 0x80, 0x1F, 0x1F, 0x0F,
  0x8F, 0x83, 0xCF, 0x81, 0xE7, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xF7, 0xC0, 0xFB, 0xE0, 0xF8, 0xF0, 0x7C, 0x78, 0x7C, 0x3E, 0x00,
  0x1E, 0x0F, 0x8F, 0x8F, 0x87, 0xC7, 0xC3, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9,
  0xE0, 0x7D, 0xF0, 0x1E, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0xFF, 0xF1,
  0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xFC, 0x7F, 0xF8,
  0xFF, 0xF1, 0xFF, 0xE0, 0x00, 0xC0, 0x70, 0x3C, 0x1E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x0F, 0xC3, 0xE0,
  0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x08, 0x00, 0x0E, 0x1C,
  0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x18,
  0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x00, 0x04,
  0x03, 0x80, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC1, 0xF0, 0xF0, 0x7C,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1E,
  0x0F, 0x03, 0x80, 0xC0, 0x00, 0x1E, 0x00, 0x3F, 0x07, 0x7F, 0x87, 0x7F,
  0xCF, 0x71, 0xFE, 0xF1, 0xFE, 0xF0, 0xFC, 0x00, 0x78,
};

const GFXglyph RobotoCondensed_BoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 24, 9, 1, -24 },
  { 25, 10, 9, 11, 2, -26 },
  { 37, 17, 24, 17, 1, -24 },
  { 88, 15, 31, 17, 1, -28 },
  { 147, 16, 24, 21, 3, -24 },
  { 195, 17, 24, 19, 0, -24 },
  { 246, 5, 9, 5, 2, -26 },
  { 252, 10, 35, 11, 2, -27 },
  { 296, 10, 35, 11, -1, -27 },
  { 340, 14, 15, 15, 2, -24 },
  { 367, 14, 17, 16, 1, -19 },
  { 397, 7, 10, 8, -2, -4 },
  { 406, 8, 4, 12, 2, -12 },
  { 410, 5, 5, 10, 1, -5 },
  { 414, 15, 26, 11, -2, -24 },
  { 463, 15, 24, 17, 1, -24 },
  { 508, 10, 24, 17, 4, -24 },
  { 538, 16, 24, 17, 0, -24 },
  { 586, 16, 24, 17, 0, -24 },
  { 634, 16, 24, 17, 0, -24 },
  { 682, 16, 24, 17, 1, -24 },
  { 730, 14, 24, 17, 1, -24 },
  { 772, 17, 24, 17, 1, -24 },
  { 823, 15, 24, 17, 1, -24 },
  { 868, 14, 24, 17, 2, -24 },
  { 910, 7, 19, 9, 1, -19 },
  { 927, 10, 25, 9, -2, -19 },
  { 959, 13, 16, 15, 1, -18 },
  { 985, 15, 11, 17, 1, -16 },
  { 1006, 13, 16, 15, 1, -18 },
  { 1032, 13, 24, 15, 2, -24 },
  { 1071, 23, 32, 25, 1, -24 },
  { 1163, 19, 24, 20, -1, -24 },
  { 1220, 18, 24, 19, 0, -24 },
  { 1274, 18, 24, 19, 1, -24 },
  { 1328, 18, 24, 19, 0, -24 },
  { 1382, 18, 24, 16, 0, -24 },
  { 1436, 17, 24, 16, 0, -24 },
  { 1487, 18, 24, 19, 1, -24 },
  { 1541, 21, 24, 20, 0, -24 },
  { 1604, 9, 24, 9, 0, -24 },
  { 1631, 17, 24, 16, 0, -24 },
  { 1682, 21, 24, 18, 0, -24 },
  { 1745, 14, 24, 16, 0, -24 },
  { 1787, 26, 24, 25, 0, -24 },
  { 1865, 21, 24, 20, 0, -24 },
  { 1928, 18, 24, 20, 1, -24 },
  { 1982, 19, 24, 19, 0, -24 },
  { 2039, 18, 28, 20, 1, -24 },
  { 2102, 18, 24, 18, 0, -24 },
  { 2156, 17, 24, 18, 1, -24 },
  { 2207, 17, 24, 18, 3, -24 },
  { 2258, 19, 24, 19, 1, -24 },
  { 2315, 18, 24, 19, 3, -24 },
  { 2369, 23, 24, 25, 3, -24 },
  { 2438, 21, 24, 18, -1, -24 },
  { 2501, 17, 24, 18, 3, -24 },
  { 2552, 19, 24, 17, 0, -24 },
  { 2609, 12, 34, 9, -1, -28 },
  { 2660, 8, 26, 13, 3, -24 },
  { 2686, 12, 34, 9, -2, -28 },
  { 2737, 11, 12, 13, 1, -24 },
  { 2754, 13, 4, 13, -2, 0 },
  { 2761, 8, 5, 11, 3, -25 },
  { 2766, 14, 18, 16, 0, -18 },
  { 2798, 15, 26, 16, 0, -26 },
  { 2847, 14, 18, 15, 1, -18 },
  { 2879, 16, 26, 16, 1, -26 },
  { 2931, 14, 18, 16, 1, -18 },
  { 2963, 12, 26, 11, 1, -26 },
  { 3002, 16, 25, 17, 0, -18 },
  { 3052, 15, 26, 16, 0, -26 },
  { 3101, 9, 25, 8, 0, -25 },
  { 3130, 13, 32, 8, -4, -25 },
  { 3182, 17, 26, 16, 0, -26 },
  { 3238, 9, 26, 8, 0, -26 },
  { 3268, 23, 18, 24, 0, -18 },
  { 3320, 15, 18, 16, 0, -18 },
  { 3354, 14, 18, 16, 1, -18 },
  { 3386, 16, 25, 16, -1, -18 },
  { 3436, 15, 25, 16, 1, -18 },
  { 3483, 12, 18, 11, 0, -18 },
  { 3510, 14, 18, 15, 0, -18 },
  { 3542, 10, 22, 10, 1, -22 },
  { 3570, 15, 18, 16, 1, -18 },
  { 3604, 14, 18, 15, 2, -18 },
  { 3636, 20, 18, 21, 2, -18 },
  { 3681, 17, 18, 15, -1, -18 },
  { 3720, 17, 25, 15, -1, -18 },
  { 3774, 15, 18, 15, 0, -18 },
  { 3808, 10, 33, 10, 1, -27 },
  { 3850, 7, 28, 8, 1, -24 },
  { 3875, 10, 33, 10, -1, -27 },
  { 3917, 16, 8, 18, 1, -14 },
};

const GFXfont RobotoCondensed_BoldItalic34pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic34pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic34pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _ROBOTOCONDENSED_BOLDITALIC34PT7B_H_
