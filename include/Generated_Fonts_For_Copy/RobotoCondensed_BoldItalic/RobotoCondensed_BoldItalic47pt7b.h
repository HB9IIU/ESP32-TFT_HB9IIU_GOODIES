#ifndef _ROBOTOCONDENSED_BOLDITALIC47PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xC0, 0x78, 0x00, 0x3C, 0x78, 0xF1, 0xE7, 0xC7, 0x9F, 0x3E, 0x7C, 0xF9,
  0xE3, 0xE7, 0x8F, 0x1E, 0x3C, 0xF8, 0xF3, 0xC3, 0xCF, 0x1E, 0x3C, 0x78,
  0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE0, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0,
  0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x3E, 0x00, 0x3C, 0x78, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x0F,
  0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC7,
  0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0x3F, 0x83, 0xF8, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0x87,
  0xE0, 0x7E, 0x1F, 0x83, 0xF8, 0x7F, 0xBF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7C, 0xF0, 0x31, 0xE3,
  0xC1, 0xEF, 0x8F, 0x8F, 0xBE, 0x3E, 0x3C, 0xF0, 0xF1, 0xE3, 0xC3, 0xCF,
  0x0F, 0x0F, 0x7C, 0x3E, 0x7D, 0xE0, 0x7F, 0xEF, 0x01, 0xFF, 0xFC, 0x03,
  0xFD, 0xE0, 0x07, 0xCF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xEF, 0x80, 0x0F,
  0xFF, 0x00, 0x7B, 0xFE, 0x03, 0xDF, 0xFC, 0x1F, 0xF8, 0xF0, 0x7B, 0xC3,
  0xC3, 0xCF, 0x0F, 0x1F, 0x3C, 0x3C, 0x78, 0xF0, 0xF3, 0xC3, 0xC3, 0xDE,
  0x0F, 0x1F, 0x78, 0x3C, 0x78, 0x40, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xF8, 0xFC,
  0x03, 0xE1, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x1F, 0x80,
  0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x3E, 0x1F, 0xF8, 0x7C, 0xFF, 0xF1, 0xF9, 0xFF,
  0xF3, 0xF7, 0xE7, 0xF7, 0xDF, 0xCF, 0xFF, 0xBF, 0x8F, 0xFF, 0x7E, 0x1F,
  0xFC, 0xFC, 0x1F, 0xF9, 0xF8, 0x1F, 0xE3, 0xF8, 0x3F, 0x87, 0xF8, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFE, 0xFC,
  0x07, 0xE1, 0xFC, 0x3C, 0x79, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0xF9, 0xF3,
  0xC7, 0x8F, 0x00, 0x00, 0x04, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x18, 0x00,
  0x20, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x02, 0x07, 0x82, 0x3C, 0x78, 0xF7, 0xF7, 0x7F, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x07, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xBC, 0x01, 0xF1, 0xE0, 0x3E, 0x1F, 0x03, 0xC1, 0xF0, 0x18,
  0x0E, 0x00, 0x80, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE1,
  0xF8, 0x7E, 0x1F, 0x0F, 0xC7, 0xE1, 0xF0, 0x78, 0x04, 0x00, 0x7F, 0xF7,
  0xFF, 0x7F, 0xF7, 0xFE, 0xFF, 0xE0, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xCF,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFE, 0x7F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0,
  0x3F, 0x3F, 0x03, 0xF7, 0xF0, 0x3F, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E,
  0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xEF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC,
  0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFC, 0x1F, 0x87, 0xE7, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x0C, 0x00, 0xF0, 0x1F, 0xC3, 0xFF, 0x3F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9F,
  0xFE, 0xF9, 0xFB, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0x80,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F,
  0xCF, 0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7F, 0x03,
  0xF1, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF3, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0,
  0x3F, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x7F,
  0x3F, 0x87, 0xF1, 0xFE, 0x7F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x03, 0xEF, 0xC0, 0x3E, 0x7E, 0x03, 0xF7, 0xF0, 0x1F, 0x3F, 0x81, 0xF9,
  0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x87,
  0xE1, 0xFC, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0x8F, 0xE0, 0x08, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE1, 0xF8, 0x3F, 0x87, 0xE0, 0xFC,
  0x1F, 0xEF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x01, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFE, 0x81, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x9F, 0x03, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0x9F, 0xFF, 0xE1, 0xFF,
  0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xDF, 0x81, 0xF9, 0xF8, 0x7F, 0x3F, 0x9F, 0xC7,
  0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF9, 0xFC, 0x3F,
  0x87, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E,
  0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x07, 0xF3, 0xF8, 0x1F, 0xFF, 0x80, 0x7F,
  0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0x1F, 0x87,
  0xF0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x9F, 0xC0, 0xFC, 0xFE, 0x07,
  0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF0, 0xFE, 0x7F, 0x87, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xBF,
  0x8F, 0xC3, 0xF3, 0xF8, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x7E,
  0x7F, 0x3F, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x1F, 0xBF, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x03,
  0xF8, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x0F, 0xF1, 0xFC,
  0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xE1, 0xFC, 0x3F,
  0x87, 0xF0, 0x7E, 0x07, 0x80, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F,
  0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8,
  0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x03,
  0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0xEF, 0xE7, 0xE1,
  0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0xC0, 0x00, 0x0F, 0x0F, 0x80, 0xFC, 0x0F, 0x0F, 0x03, 0xFE, 0x0F,
  0x1F, 0x07, 0xFF, 0x8F, 0x1E, 0x0F, 0xFF, 0x8F, 0x3E, 0x1F, 0x8F, 0x0F,
  0x3C, 0x1F, 0x0F, 0x0F, 0x3C, 0x3E, 0x0F, 0x0F, 0x7C, 0x3E, 0x1F, 0x0F,
  0x78, 0x7C, 0x1E, 0x0F, 0x78, 0x7C, 0x1E, 0x0F, 0x78, 0x7C, 0x1E, 0x0F,
  0xF8, 0x78, 0x3E, 0x0F, 0xF0, 0xF8, 0x3E, 0x0E, 0xF0, 0xF8, 0x3C, 0x1E,
  0xF0, 0xF8, 0x3C, 0x1E, 0xF0, 0xF8, 0x7C, 0x1C, 0xF0, 0xF8, 0x7C, 0x3C,
  0xF0, 0xF8, 0xFC, 0x3C, 0xF0, 0xF9, 0xFC, 0x78, 0xF0, 0xFF, 0xFF, 0xF0,
  0xF0, 0x7F, 0xBF, 0xF0, 0xF0, 0x7F, 0x3F, 0xE0, 0xF0, 0x1E, 0x0F, 0x80,
  0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xEF,
  0x80, 0x01, 0xFB, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x1F,
  0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F,
  0x80, 0xFE, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x07,
  0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80,
  0xFE, 0x1F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0x7E, 0x1F, 0xC0, 0x7F,
  0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x7F, 0xDF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x81,
  0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x7F,
  0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x87,
  0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF0,
  0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFE,
  0x1F, 0xC0, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0x80,
  0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x0F,
  0xFE, 0xFE, 0x0F, 0xFE, 0xFE, 0x0F, 0xFE, 0xFE, 0x0F, 0xFE, 0xFE, 0x1F,
  0xFE, 0xFE, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01,
  0xFC, 0xFE, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC,
  0x0F, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F,
  0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00,
  0x3F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0x00,
  0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE,
  0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x1F,
  0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x00,
  0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x7F, 0x03, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x1F, 0x80,
  0xFF, 0x80, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x07, 0xF8,
  0x03, 0xF8, 0x7F, 0x80, 0x1F, 0x83, 0xFC, 0x00, 0xFC, 0x3F, 0xC0, 0x07,
  0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0xFD, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xF7,
  0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x07, 0xF0,
  0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07,
  0xF0, 0x3F, 0x80, 0x3F, 0x01, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x80, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F,
  0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFE,
  0x07, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF8, 0x1F, 0xBE,
  0x0F, 0xBF, 0x07, 0xF7, 0xC3, 0xF7, 0xE0, 0xFC, 0xF8, 0x7D, 0xFC, 0x1F,
  0x9F, 0x0F, 0xBF, 0x03, 0xF3, 0xE3, 0xE7, 0xE0, 0x7E, 0x7C, 0x7C, 0xFC,
  0x0F, 0xCF, 0x9F, 0x1F, 0x83, 0xF9, 0xF3, 0xE7, 0xF0, 0x7F, 0x3E, 0xFC,
  0xFE, 0x0F, 0xE3, 0xDF, 0x1F, 0x81, 0xF8, 0x7B, 0xE3, 0xF0, 0x3F, 0x0F,
  0xF8, 0xFE, 0x07, 0xE1, 0xFF, 0x1F, 0xC1, 0xFC, 0x3F, 0xC3, 0xF8, 0x3F,
  0x87, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8,
  0x1F, 0x83, 0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x0F, 0xE0, 0xFE, 0x07, 0x81,
  0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x00,
  0xFC, 0x0F, 0xF0, 0x07, 0xE0, 0x7F, 0xC0, 0x7F, 0x03, 0xFE, 0x03, 0xF8,
  0x1F, 0xF0, 0x1F, 0xC0, 0xFF, 0x80, 0xFC, 0x07, 0xFE, 0x07, 0xE0, 0x7F,
  0xF0, 0x3F, 0x03, 0xFF, 0x83, 0xF8, 0x1F, 0xFE, 0x1F, 0xC0, 0xFD, 0xF0,
  0xFE, 0x07, 0xEF, 0x87, 0xE0, 0x7F, 0x3C, 0x3F, 0x03, 0xF9, 0xF3, 0xF8,
  0x1F, 0xCF, 0x9F, 0xC0, 0xFE, 0x7C, 0xFE, 0x07, 0xE1, 0xE7, 0xE0, 0x3F,
  0x0F, 0xBF, 0x03, 0xF8, 0x7D, 0xF8, 0x1F, 0xC3, 0xFF, 0xC0, 0xFE, 0x0F,
  0xFE, 0x07, 0xE0, 0x7F, 0xF0, 0x3F, 0x03, 0xFF, 0x01, 0xF8, 0x0F, 0xF8,
  0x1F, 0xC0, 0x7F, 0xC0, 0xFE, 0x03, 0xFE, 0x07, 0xF0, 0x1F, 0xF0, 0x3F,
  0x00, 0x7F, 0x81, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x81, 0xFC,
  0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F,
  0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80,
  0x1F, 0xDF, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0,
  0x03, 0xF9, 0xFC, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x80, 0x7F,
  0x07, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x3F,
  0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7,
  0xF0, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E,
  0x7E, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x0F,
  0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xF9, 0xFC, 0x01,
  0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0,
  0x7F, 0x07, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0x80,
  0x7F, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC0, 0xFC,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x07,
  0xF0, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F,
  0xE0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE,
  0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xE1,
  0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F,
  0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0xC0, 0x7E, 0x07, 0xF0,
  0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xEF, 0xE0,
  0x0F, 0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E,
  0x03, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80,
  0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0,
  0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x3E, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0xFE, 0x07,
  0xE0, 0x7F, 0xFE, 0x07, 0xE0, 0x7F, 0xFE, 0x0F, 0xE0, 0x7E, 0xFE, 0x0F,
  0xE0, 0xFE, 0xFE, 0x1F, 0xE0, 0xFE, 0xFC, 0x1F, 0xE0, 0xFC, 0xFC, 0x1F,
  0xE1, 0xFC, 0xFC, 0x3F, 0xE1, 0xFC, 0xFC, 0x3F, 0xE1, 0xF8, 0xFC, 0x3F,
  0xE1, 0xF8, 0xFC, 0x7F, 0xE3, 0xF8, 0xFC, 0x7F, 0xE3, 0xF0, 0xFC, 0x7F,
  0xE3, 0xF0, 0xFC, 0xFF, 0xE7, 0xF0, 0xFC, 0xFB, 0xE7, 0xE0, 0xFC, 0xFB,
  0xE7, 0xE0, 0xFD, 0xFB, 0xEF, 0xE0, 0xFD, 0xF3, 0xEF, 0xC0, 0xFD, 0xF3,
  0xEF, 0xC0, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xE3, 0xFF, 0x80, 0x7F, 0xE3,
  0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x7E, 0x7F, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0x7F, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC,
  0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0x7E, 0x01, 0xFC, 0x7E, 0x03,
  0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x0F,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0xBF,
  0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xE1, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F,
  0x80, 0xFF, 0x80, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFF, 0x07, 0xFE, 0x0F, 0x3C, 0x3E, 0x78, 0x7C, 0xF1,
  0xF1, 0xE3, 0xE3, 0xEF, 0x87, 0xDF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3E, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE,
  0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFC, 0x7F, 0x1F,
  0xC7, 0xF1, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x8F, 0xE7, 0xF0, 0xFC,
  0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x0F, 0xC7, 0xE3, 0xFC, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0x8F, 0xC0, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF3, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE3, 0xFC, 0xFF, 0x1F, 0xC3, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0,
  0x7E, 0x3F, 0x03, 0xF3, 0xF8, 0x1F, 0x9F, 0xC0, 0xFC, 0xFC, 0x07, 0xE7,
  0xE0, 0x7F, 0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0x9F, 0xC0, 0xFC, 0xFE, 0x07,
  0xE7, 0xF0, 0x7F, 0x3F, 0xCF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFD,
  0xFF, 0x87, 0xE7, 0xF8, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x9F, 0xCF, 0xC1, 0xFB,
  0xF8, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xDF,
  0x83, 0xF3, 0xF8, 0x7E, 0x3F, 0x9F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x07, 0xC7, 0xE0, 0x3F, 0xCF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x1F, 0xE7, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x07, 0xE1, 0xF8,
  0x1F, 0xC3, 0xF0, 0x3F, 0x8F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x81,
  0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F,
  0x07, 0xE0, 0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0xE7, 0xF8, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFC, 0xFE, 0x3F, 0x87, 0xE3, 0xF0, 0x3E, 0x7E, 0x03, 0xE7, 0xE0,
  0x3F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0x07,
  0xF9, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0,
  0x3F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0xFF, 0x87, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x7E, 0x07, 0xFD, 0xF8,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC, 0xFF, 0x87,
  0xF0, 0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC,
  0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xF0, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F,
  0x83, 0xFE, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x02, 0x01, 0xF8, 0x0F, 0x0F, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF3, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFC, 0xFE, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0xC7, 0xE0,
  0xFE, 0x7F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0xFE, 0x3F, 0x07, 0xF3, 0xF8, 0x3F, 0x1F, 0xC1, 0xF8, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xF1, 0xF8, 0x3F, 0x9F, 0xC1, 0xF8, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF0, 0x01, 0xE0, 0x3F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x00,
  0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x81, 0x3F,
  0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF8, 0x7E, 0x1F, 0xE0, 0xFC,
  0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xF3, 0xFC, 0x0F, 0xEF, 0xF0, 0x1F, 0x9F,
  0xC0, 0x3F, 0x7F, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFE, 0x01, 0xFE, 0xFC, 0x03, 0xF9, 0xFC, 0x07, 0xE1, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x0F, 0xE1, 0xF8,
  0x1F, 0xC3, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0,
  0x3F, 0x80, 0x0F, 0xCF, 0xC1, 0xF8, 0x0F, 0xDF, 0xE3, 0xFC, 0x0F, 0xFF,
  0xF7, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xE7,
  0xFE, 0xFF, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0x83, 0xF8, 0x7F, 0x1F, 0x83,
  0xF0, 0x7F, 0x1F, 0x83, 0xF0, 0x7F, 0x3F, 0x83, 0xF0, 0x7F, 0x3F, 0x83,
  0xF0, 0x7E, 0x3F, 0x07, 0xF0, 0x7E, 0x3F, 0x07, 0xF0, 0x7E, 0x3F, 0x07,
  0xE0, 0x7E, 0x3F, 0x07, 0xE0, 0xFE, 0x7F, 0x07, 0xE0, 0xFE, 0x7F, 0x07,
  0xE0, 0xFC, 0x7E, 0x0F, 0xE0, 0xFC, 0x7E, 0x0F, 0xE0, 0xFC, 0x7E, 0x0F,
  0xC0, 0xFC, 0x7E, 0x0F, 0xC1, 0xFC, 0xFE, 0x0F, 0xC1, 0xFC, 0xFC, 0x0F,
  0xC1, 0xF8, 0xFC, 0x1F, 0xC1, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0xFF, 0x03,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xF3, 0xF8, 0x7F, 0x0F,
  0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF9, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7E,
  0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF8, 0xFC, 0x1F, 0xCF, 0xE0, 0xFC,
  0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0,
  0xFE, 0x7F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE3, 0xFC, 0xFE, 0x3F, 0x87, 0xF7, 0xF0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0,
  0x3F, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xE0, 0xFE, 0xFE, 0x0F, 0xC7,
  0xF3, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0,
  0x07, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0x3F, 0xC1, 0xFC, 0x3F, 0x83,
  0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7F,
  0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x87, 0xE0,
  0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0x3F,
  0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0x9F, 0xE0,
  0x3F, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF1, 0xF8, 0x3F,
  0xCF, 0xC3, 0xFF, 0x7E, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xE7, 0xF9,
  0xFC, 0x1F, 0xCF, 0xE0, 0x7E, 0x7E, 0x07, 0xF3, 0xF0, 0x3F, 0xBF, 0x81,
  0xF9, 0xFC, 0x0F, 0xCF, 0xE0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x9F,
  0x81, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x83, 0xF1, 0xFE, 0x7F,
  0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F,
  0x9F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xCF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x7E, 0x1F, 0x87, 0xF1,
  0xF8, 0x7F, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xC7, 0xE1, 0xFC, 0x7F, 0xFF, 0x87, 0xFF,
  0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFC, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x00,
  0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8,
  0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xF3,
  0xF8, 0x3F, 0x9F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07,
  0xF1, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F,
  0x87, 0xF1, 0xFE, 0x7F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x07, 0xFB, 0xF0, 0x0F, 0x9F, 0x80, 0xFE, 0x07, 0xE7, 0xE0, 0xFE, 0x7E,
  0x0F, 0xE7, 0xE0, 0xFC, 0x7E, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE3, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x3E, 0x7E, 0x03, 0xE7, 0xE0,
  0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x07,
  0xFF, 0x87, 0xE1, 0xFF, 0xF0, 0xFC, 0x3F, 0x7E, 0x1F, 0x87, 0xEF, 0xC7,
  0xF1, 0xF9, 0xF8, 0xFE, 0x3F, 0x3F, 0x3F, 0xC7, 0xE7, 0xE7, 0xF9, 0xF8,
  0xFC, 0xFF, 0x3F, 0x1F, 0xBF, 0xE7, 0xE3, 0xF7, 0xFD, 0xF8, 0x7F, 0xF7,
  0xBF, 0x0F, 0xBE, 0xF7, 0xC1, 0xF7, 0x9F, 0xF8, 0x3F, 0xF3, 0xFF, 0x07,
  0xFE, 0x7F, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F,
  0x83, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0xFE, 0x07, 0xF0, 0xFE, 0x03, 0xF1, 0xFC, 0x03, 0xF1, 0xFC, 0x03, 0xF3,
  0xF8, 0x03, 0xF3, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x07, 0xEF, 0xC0, 0x0F, 0xEF, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0xCF,
  0xC0, 0x1F, 0x87, 0xE0, 0x3F, 0x87, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xF0, 0x7E, 0x0F,
  0xC0, 0xFC, 0x3F, 0x81, 0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF8,
  0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x3E, 0xFE, 0x00,
  0x7D, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x17, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xC0, 0x02, 0x00, 0x03, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x00, 0x01,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x01, 0xF0, 0x03, 0x80, 0x04, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0x81, 0xF3, 0xFF, 0x07, 0xDF, 0xFE, 0x3E, 0x7F,
  0xFD, 0xFB, 0xFF, 0xFF, 0xEF, 0x87, 0xFF, 0x3E, 0x0F, 0xF8, 0xF0, 0x1F,
  0xE0, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 33, 12, 1, -33 },
  { 51, 14, 13, 15, 3, -35 },
  { 74, 23, 33, 24, 1, -33 },
  { 169, 22, 42, 23, 1, -38 },
  { 285, 22, 33, 29, 4, -33 },
  { 376, 23, 33, 26, 1, -33 },
  { 471, 7, 13, 7, 3, -35 },
  { 483, 15, 47, 15, 2, -37 },
  { 572, 15, 48, 15, -2, -37 },
  { 662, 20, 20, 21, 2, -33 },
  { 712, 20, 24, 22, 1, -28 },
  { 772, 10, 14, 11, -3, -6 },
  { 790, 12, 5, 16, 2, -17 },
  { 798, 7, 7, 13, 1, -7 },
  { 805, 21, 36, 15, -3, -33 },
  { 900, 20, 33, 23, 2, -33 },
  { 983, 14, 33, 23, 5, -33 },
  { 1041, 22, 33, 23, 0, -33 },
  { 1132, 21, 33, 23, 1, -33 },
  { 1219, 21, 33, 23, 1, -33 },
  { 1306, 22, 33, 23, 1, -33 },
  { 1397, 19, 33, 23, 2, -33 },
  { 1476, 22, 33, 23, 2, -33 },
  { 1567, 21, 33, 23, 1, -33 },
  { 1654, 19, 33, 23, 3, -33 },
  { 1733, 11, 26, 13, 1, -26 },
  { 1769, 13, 34, 12, -2, -26 },
  { 1825, 19, 22, 20, 1, -25 },
  { 1878, 19, 14, 23, 2, -22 },
  { 1912, 19, 22, 21, 1, -25 },
  { 1965, 18, 33, 20, 3, -33 },
  { 2040, 32, 43, 35, 1, -33 },
  { 2212, 26, 33, 27, -2, -33 },
  { 2320, 25, 33, 26, 0, -33 },
  { 2424, 24, 33, 26, 2, -33 },
  { 2523, 25, 33, 26, 0, -33 },
  { 2627, 25, 33, 22, 0, -33 },
  { 2731, 24, 33, 22, 0, -33 },
  { 2830, 24, 33, 27, 2, -33 },
  { 2929, 29, 33, 28, 0, -33 },
  { 3049, 13, 33, 12, 0, -33 },
  { 3103, 23, 33, 22, 0, -33 },
  { 3198, 29, 33, 25, 0, -33 },
  { 3318, 19, 33, 22, 0, -33 },
  { 3397, 35, 33, 35, 0, -33 },
  { 3542, 29, 33, 28, 0, -33 },
  { 3662, 25, 33, 28, 2, -33 },
  { 3766, 26, 33, 26, 0, -33 },
  { 3874, 25, 39, 28, 2, -33 },
  { 3996, 25, 33, 25, 0, -33 },
  { 4100, 24, 33, 25, 1, -33 },
  { 4199, 23, 33, 25, 4, -33 },
  { 4294, 26, 33, 26, 1, -33 },
  { 4402, 25, 33, 26, 4, -33 },
  { 4506, 32, 33, 34, 4, -33 },
  { 4638, 30, 33, 26, -2, -33 },
  { 4762, 24, 33, 25, 4, -33 },
  { 4861, 27, 33, 24, -1, -33 },
  { 4973, 16, 47, 12, -1, -39 },
  { 5067, 11, 36, 17, 4, -33 },
  { 5117, 16, 47, 12, -3, -39 },
  { 5211, 15, 17, 18, 2, -33 },
  { 5243, 18, 5, 18, -3, 0 },
  { 5255, 10, 7, 15, 5, -35 },
  { 5264, 20, 25, 21, 0, -25 },
  { 5327, 21, 35, 23, 0, -35 },
  { 5419, 19, 25, 21, 1, -25 },
  { 5479, 23, 35, 23, 1, -35 },
  { 5580, 20, 25, 22, 1, -25 },
  { 5643, 17, 35, 15, 1, -35 },
  { 5718, 23, 35, 23, 0, -25 },
  { 5819, 21, 35, 22, 0, -35 },
  { 5911, 12, 35, 11, 0, -35 },
  { 5964, 17, 45, 11, -5, -35 },
  { 6060, 23, 35, 22, 0, -35 },
  { 6161, 13, 35, 11, 0, -35 },
  { 6218, 32, 25, 34, 0, -25 },
  { 6318, 21, 25, 22, 0, -25 },
  { 6384, 20, 25, 23, 1, -25 },
  { 6447, 23, 35, 23, -2, -25 },
  { 6548, 21, 35, 23, 1, -25 },
  { 6640, 16, 25, 15, 0, -25 },
  { 6690, 20, 25, 21, 0, -25 },
  { 6753, 13, 31, 14, 2, -31 },
  { 6804, 21, 25, 22, 1, -25 },
  { 6870, 20, 25, 20, 2, -25 },
  { 6933, 27, 25, 29, 3, -25 },
  { 7018, 24, 25, 21, -2, -25 },
  { 7093, 23, 35, 20, -1, -25 },
  { 7194, 22, 25, 21, -1, -25 },
  { 7263, 14, 45, 14, 1, -37 },
  { 7342, 10, 39, 12, 1, -33 },
  { 7391, 15, 45, 14, -2, -37 },
  { 7476, 22, 10, 25, 2, -19 },
};

const GFXfont RobotoCondensed_BoldItalic47pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic47pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic47pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOCONDENSED_BOLDITALIC47PT7B_H_
