#ifndef _ROBOTOCONDENSED_BOLDITALIC39PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xC0,
  0x3C, 0xF3, 0xCF, 0x38, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xC7, 0x1C,
  0x71, 0xCF, 0x3C, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x01, 0xCF, 0x00, 0x79,
  0xC0, 0x0E, 0x38, 0x01, 0xCF, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x81, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x38,
  0x01, 0xC7, 0x00, 0x39, 0xE0, 0x0F, 0x38, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x81, 0xC7, 0x00, 0x39, 0xE0, 0x0F, 0x38, 0x01, 0xC7, 0x00,
  0x39, 0xE0, 0x0F, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xDF, 0x87, 0xE3, 0xE1, 0xF0, 0xFC, 0x7C,
  0x3F, 0x1F, 0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3F, 0x0F, 0xC7, 0xC3, 0xE1, 0xFF,
  0xF8, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3C, 0xE0, 0x87, 0x1E, 0x3C, 0xE3, 0xC7, 0x1C, 0x79, 0xE7,
  0x8F, 0x78, 0x71, 0xCE, 0x0F, 0x7B, 0xC1, 0xFF, 0xF0, 0x1F, 0xDC, 0x01,
  0xE7, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x78, 0x03, 0xFF, 0x80,
  0xF7, 0xF8, 0x1D, 0xE7, 0x07, 0xB8, 0xF1, 0xE7, 0x1E, 0x39, 0xE3, 0xCE,
  0x3C, 0x73, 0xC7, 0x8E, 0x30, 0x7B, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0xFD, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x1F, 0x01,
  0xF7, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF8, 0x79, 0xFF, 0x9F, 0x7F, 0xF3, 0xEF, 0xBF, 0x7B, 0xE3, 0xFF, 0x7C,
  0x7F, 0xEF, 0x87, 0xF9, 0xF0, 0xFF, 0x3E, 0x0F, 0xC7, 0xF7, 0xF8, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xE7, 0xE0, 0x3C, 0xF3, 0xDE,
  0x79, 0xE7, 0x9E, 0x71, 0xCF, 0x00, 0x00, 0x20, 0x06, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0,
  0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x0C, 0x00, 0x40, 0x01, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x01, 0xC0, 0x08, 0x00, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x41, 0xC0, 0x71, 0xC7, 0xFD,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xE0, 0x1E,
  0xF0, 0x3C, 0x70, 0x78, 0x78, 0x30, 0x70, 0x10, 0x20, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x7F,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF0,
  0x20, 0x7F, 0xFF, 0xEF, 0xFB, 0xFE, 0x7B, 0xFF, 0xFF, 0xF9, 0xE0, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xBF, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFD, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xE0, 0x1F, 0x80, 0x00, 0x30, 0x1F, 0x07, 0xF3, 0xFE, 0x7F, 0xE7, 0xFE,
  0x7F, 0xEF, 0x3E, 0x87, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFC, 0xFC, 0x3F, 0x0F, 0x87,
  0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F,
  0xFE, 0x1F, 0x9F, 0x8F, 0xC3, 0xE3, 0xF0, 0xF8, 0xF8, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7C, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xFB, 0xF8, 0x7F, 0xFC,
  0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFE, 0x01, 0xFF, 0x80, 0x7B, 0xE0, 0x3D, 0xF8, 0x1F, 0x7C, 0x07, 0x9F,
  0x03, 0xE7, 0xC1, 0xF1, 0xF0, 0x78, 0xFC, 0x3E, 0x3F, 0x1F, 0x0F, 0x87,
  0xFF, 0xFD, 0xFF, 0xFE, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xFF,
  0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xBE, 0x03, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0x8F, 0xC0, 0x41, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0xF8, 0x3F, 0x3E, 0x0F, 0x8F,
  0xC3, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0xF0, 0x7F, 0xFC, 0x7F,
  0xFC, 0xFF, 0xFE, 0xFE, 0x7E, 0xFC, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xF8, 0x7C, 0xFF,
  0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0x80, 0x3F, 0xFF, 0xCF,
  0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x0F, 0xDF, 0x87,
  0xE3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF1,
  0xF8, 0x3E, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0,
  0x7E, 0x3E, 0x1F, 0x0F, 0x8F, 0xC3, 0xF3, 0xF0, 0xFC, 0xF8, 0x3F, 0x3E,
  0x0F, 0x8F, 0xC7, 0xE3, 0xFB, 0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xE7, 0xFF,
  0xCF, 0x87, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFF, 0x0F, 0xFF, 0x3F, 0x7F, 0xFE, 0x7F, 0xFC, 0x7F,
  0xF8, 0x7F, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x3F, 0xF0,
  0x7F, 0xC0, 0xFF, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0E, 0x0F, 0x87, 0xE3,
  0xF1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x7E, 0x3F, 0x1F, 0x8F, 0xC3, 0xC0, 0x01, 0xC0, 0x7C,
  0x1F, 0x83, 0xF0, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x3C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x7C, 0x03,
  0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xC3, 0xFF,
  0x9F, 0xFC, 0x7F, 0xC0, 0xFE, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x20, 0x1F,
  0xFF, 0x9F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF,
  0xCF, 0xFF, 0xE0, 0x10, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xFC, 0x03, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x7E, 0x01, 0xFC, 0x0F, 0xF8,
  0xFF, 0xE7, 0xFF, 0x1F, 0xF8, 0x3F, 0x80, 0x7C, 0x00, 0xE0, 0x01, 0x00,
  0x00, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xF1, 0xFF,
  0x87, 0xFE, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x0E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x7E, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x07, 0x01, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x0E, 0x0E, 0x07, 0xC1, 0xC3, 0xC3, 0xFE, 0x38,
  0x70, 0xFF, 0xC7, 0x1E, 0x3F, 0x78, 0xF3, 0x87, 0x8F, 0x1E, 0xF1, 0xE1,
  0xE3, 0xDE, 0x3C, 0x38, 0x7B, 0x87, 0x07, 0x0E, 0xF1, 0xE1, 0xE1, 0xDE,
  0x3C, 0x3C, 0x3B, 0xC7, 0x87, 0x07, 0x70, 0xF0, 0xE1, 0xEE, 0x3E, 0x3C,
  0x39, 0xC7, 0x87, 0x87, 0x38, 0x79, 0xF1, 0xC7, 0x0F, 0x7E, 0x78, 0xE1,
  0xFF, 0xFE, 0x1C, 0x3F, 0xBF, 0x83, 0x83, 0xC3, 0xE0, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x08, 0x00, 0x3F, 0x8F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x3E,
  0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x00, 0xFC, 0x3E,
  0x03, 0xE0, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xF8, 0x0F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00,
  0xFC, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x00, 0x1F, 0x07, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE0,
  0xF8, 0x3E, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0x87,
  0xE0, 0xFC, 0x3E, 0x0F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x3F, 0x0F, 0x80, 0xF8, 0x7C,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3F, 0x01, 0xF9, 0xF0,
  0x0F, 0xCF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x01,
  0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF8, 0x3F, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xE1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81,
  0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xE1, 0xF8,
  0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x81,
  0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1,
  0xF8, 0x3E, 0x3F, 0x03, 0xF3, 0xE0, 0x3F, 0x7E, 0x01, 0xF7, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC3, 0xFE, 0xFC, 0x7F,
  0xEF, 0x87, 0xFE, 0xF8, 0x7F, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xFC, 0xFC, 0x0F, 0xC7, 0xFF, 0xF8, 0x7F,
  0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x3F,
  0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x3E,
  0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x7C,
  0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0x00, 0xF8,
  0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x7E, 0x01, 0xF0,
  0x7E, 0x01, 0xF0, 0x7E, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xF0,
  0x7C, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x7E, 0x0F, 0x8F,
  0xC3, 0xF1, 0xF8, 0x7C, 0x3F, 0x1F, 0x83, 0xFF, 0xF0, 0x7F, 0xFC, 0x07,
  0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7F, 0x07, 0xC0,
  0xFE, 0x07, 0xC1, 0xFC, 0x0F, 0xC3, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC7,
  0xF0, 0x0F, 0x8F, 0xE0, 0x0F, 0x8F, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0xBF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF,
  0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC,
  0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x07,
  0xF8, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0,
  0xFB, 0xC1, 0xFF, 0x87, 0xDE, 0x0F, 0xFC, 0x3E, 0xF0, 0xFF, 0xC1, 0xF7,
  0x87, 0xBE, 0x0F, 0xBC, 0x7D, 0xF0, 0xFD, 0xE3, 0xCF, 0x87, 0xEF, 0x1E,
  0xFC, 0x3E, 0x79, 0xE7, 0xC1, 0xF3, 0xCF, 0x3E, 0x0F, 0x8E, 0xF9, 0xF0,
  0x7C, 0x7F, 0x8F, 0x87, 0xE3, 0xFC, 0xFC, 0x3F, 0x1F, 0xC7, 0xE1, 0xF8,
  0xFE, 0x3E, 0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE1, 0xF0,
  0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0x3C, 0x3F, 0x00, 0x07, 0xC0, 0x3F,
  0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3E, 0x0F, 0xE0, 0x3E, 0x0F, 0xE0, 0x3E,
  0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF8, 0x7C,
  0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7C, 0x1F, 0x78, 0xFC, 0x1F, 0x3C, 0xFC,
  0x1F, 0x3C, 0xFC, 0x3F, 0x3C, 0xF8, 0x3F, 0x3C, 0xF8, 0x3F, 0x1E, 0xF8,
  0x3E, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x3E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0,
  0x7E, 0x0F, 0xF0, 0x7E, 0x0F, 0xF0, 0x7C, 0x07, 0xF0, 0x7C, 0x07, 0xF0,
  0x7C, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x03, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xE0,
  0xF8, 0x7E, 0x07, 0xE3, 0xE0, 0x3F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xCF,
  0x80, 0x3E, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07,
  0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8,
  0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x03, 0xF1, 0xF8, 0x3F, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x7E, 0x03, 0xE1, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x1F, 0x03, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xE3, 0xE0,
  0x3F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0xFC, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01,
  0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x3E,
  0x03, 0xF1, 0xF8, 0x3F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x3E,
  0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7C,
  0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0x8F, 0xC0, 0x7C, 0x3E, 0x07,
  0xE1, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x0F,
  0xC3, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE1, 0xF8, 0x7E,
  0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0xF8, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xFC, 0x1F, 0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xE0,
  0x7E, 0x1F, 0x01, 0xF8, 0x7C, 0x07, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C,
  0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3E,
  0x03, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x7C, 0x07,
  0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x0F, 0xC1,
  0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0x1F,
  0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xC0, 0x7E, 0x3E, 0x03, 0xF1, 0xF0,
  0x3F, 0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0,
  0xFC, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF,
  0x80, 0x3E, 0x7C, 0x01, 0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x03,
  0xFF, 0x83, 0xE0, 0xFF, 0xF0, 0x7C, 0x1F, 0x7E, 0x1F, 0x83, 0xEF, 0xC3,
  0xF0, 0xFC, 0xF8, 0x7E, 0x1F, 0x1F, 0x1F, 0xC3, 0xE3, 0xE3, 0xF8, 0xFC,
  0x7C, 0x7F, 0x1F, 0x0F, 0x9F, 0xE3, 0xE1, 0xF3, 0xFC, 0x7C, 0x3E, 0x7F,
  0x9F, 0x07, 0xDF, 0xF3, 0xE0, 0xFB, 0xDE, 0x7C, 0x1F, 0x7B, 0xDF, 0x03,
  0xFF, 0x7B, 0xE0, 0x7F, 0xCF, 0x7C, 0x0F, 0xF9, 0xFF, 0x81, 0xFF, 0x3F,
  0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x1F,
  0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC,
  0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFC, 0x03, 0xE1, 0xF8, 0x03,
  0xF1, 0xF8, 0x03, 0xF3, 0xF0, 0x01, 0xF3, 0xF0, 0x01, 0xF7, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xEF, 0x80, 0x0F, 0xCF, 0x80, 0x0F,
  0xCF, 0xC0, 0x1F, 0x8F, 0xC0, 0x3F, 0x87, 0xC0, 0x3F, 0x07, 0xE0, 0x7F,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF7, 0xC0,
  0x7E, 0x7C, 0x07, 0xE7, 0xC0, 0xFC, 0x7E, 0x0F, 0xC3, 0xE1, 0xF8, 0x3E,
  0x1F, 0x03, 0xE3, 0xF0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x1F, 0x7C, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3E, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xC0,
  0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87, 0xC3, 0xE1,
  0xF0, 0xF8, 0x7C, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x3F, 0xC1,
  0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xE0,
  0x7F, 0x03, 0xF8, 0x3D, 0xC1, 0xCE, 0x1E, 0x71, 0xF3, 0xCF, 0x1E, 0xF8,
  0xF7, 0x87, 0xFC, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0,
  0xFC, 0x7C, 0x3E, 0x3E, 0x1F, 0x0F, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0x83, 0xFF, 0xE1, 0xF9, 0xF1, 0xF8, 0xF8, 0xFC, 0x7C, 0x00, 0x3E, 0x03,
  0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0xE7, 0xE7, 0xE3, 0xE3, 0xE1, 0xF3,
  0xF0, 0xF9, 0xF8, 0x7C, 0xFC, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xFF,
  0xC1, 0xF3, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xBE, 0x07,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xC3, 0xE3, 0xF0,
  0xF8, 0xFC, 0x3F, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E,
  0x7E, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF9, 0xF8, 0x7C, 0x7F, 0x7F, 0x1F,
  0xFF, 0x8F, 0xBF, 0xE3, 0xEF, 0xF0, 0xF9, 0xF0, 0x00, 0x03, 0xF0, 0x0F,
  0xFC, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0x7E, 0x7E, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x3C, 0xF8, 0x7C, 0xF8, 0x7C, 0xFE, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F,
  0xE0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xCF,
  0x81, 0xFD, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xF7, 0xF8, 0xFC, 0x3F,
  0x1F, 0x07, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xFC,
  0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xF0,
  0xFE, 0xFE, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xF7, 0xC0,
  0x03, 0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x1F, 0xFE, 0x3F, 0x3F, 0x7E, 0x1F,
  0x7C, 0x1F, 0x7C, 0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x18, 0x7F, 0x7C, 0x7F, 0xFC,
  0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC1,
  0xFF, 0x07, 0xF8, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x7F, 0xF1, 0xFF, 0xC7,
  0xFF, 0x1F, 0xF8, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xE3, 0xE0,
  0xFF, 0x7C, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7E, 0x1F, 0x8F,
  0x83, 0xF1, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3E,
  0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x7F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0xFB, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x81, 0x03, 0xF0, 0x79, 0xFC, 0x1F, 0xFF, 0x83, 0xFF,
  0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0xBE, 0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF1, 0xFB, 0xF8, 0xF8, 0x7C,
  0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xEF, 0xC3,
  0xE7, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x7E, 0x7C, 0x3F, 0x7E,
  0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE0, 0x03, 0x81, 0xF0, 0xFC,
  0x3F, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x87,
  0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x00, 0x00, 0x30, 0x01,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0x80,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x8F, 0xE3,
  0xF1, 0xF8, 0x7C, 0x7E, 0x0F, 0x9F, 0x81, 0xF7, 0xF0, 0x3E, 0xFC, 0x0F,
  0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xFC, 0x07, 0xFF, 0x80, 0xFD, 0xF0, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C,
  0x7E, 0x0F, 0x8F, 0xC3, 0xF0, 0xF8, 0x7C, 0x1F, 0x8F, 0x83, 0xF0, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1,
  0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0xF8, 0x00,
  0x1F, 0x3E, 0x1F, 0x07, 0xFF, 0xCF, 0xE1, 0xFF, 0xF7, 0xFC, 0x7F, 0xFF,
  0xFF, 0x1F, 0xBF, 0xEF, 0xC7, 0xC3, 0xE1, 0xF3, 0xF0, 0xF8, 0x7C, 0xF8,
  0x3E, 0x1F, 0x3E, 0x0F, 0x87, 0xCF, 0x87, 0xE1, 0xF3, 0xE1, 0xF0, 0x7C,
  0xF8, 0x7C, 0x3F, 0x7E, 0x1F, 0x0F, 0xDF, 0x07, 0xC3, 0xE7, 0xC1, 0xF0,
  0xF9, 0xF0, 0xFC, 0x3E, 0x7C, 0x3E, 0x0F, 0x9F, 0x0F, 0x87, 0xEF, 0xC3,
  0xE1, 0xFB, 0xE0, 0xF8, 0x7C, 0xF8, 0x3E, 0x1F, 0x00, 0x1F, 0x3E, 0x0F,
  0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF1, 0xFB, 0xF9, 0xF8, 0x7C, 0xFC, 0x3E,
  0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x0F, 0xCF, 0x87, 0xEF, 0xC3, 0xE7, 0xC1,
  0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x7E, 0x7C, 0x3F, 0x7E, 0x1F, 0x3E,
  0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE0, 0x03, 0xF0, 0x03, 0xFE, 0x07, 0xFF,
  0x83, 0xFF, 0xC3, 0xF3, 0xF3, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0xFC,
  0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB,
  0xE0, 0xF9, 0xF8, 0x7C, 0xFE, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE,
  0x00, 0xFC, 0x00, 0x0F, 0x9F, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFC, 0xFC, 0x1F, 0x0F, 0x87, 0xE1, 0xF0, 0xF8, 0x3F, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xF0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x3F, 0xBF, 0x8F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x3E, 0xFF, 0x07, 0xCF, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC7, 0x87, 0xF7, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xF7, 0xFB, 0xF0,
  0xFD, 0xF0, 0x7C, 0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x0F, 0xBE, 0x0F, 0xDF,
  0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0xFC, 0xFE, 0xFE,
  0x7F, 0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x81, 0xF7, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x38, 0xFF, 0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x8F, 0xE4,
  0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x3E,
  0x1F, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x7E, 0xF8, 0x3E, 0xF8, 0x3E, 0xFC, 0x7E, 0x7F,
  0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC1, 0xF8, 0xFF, 0xDF, 0xFB, 0xFF, 0xFF, 0xE3, 0xE0, 0xFC, 0x1F, 0x83,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x03, 0xE0, 0x3F, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xE7, 0xC1, 0xF3, 0xE1, 0xFB, 0xF0, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E,
  0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x0F, 0xDF, 0x87, 0xCF, 0xC3, 0xE7, 0xC1,
  0xF3, 0xE0, 0xF9, 0xF0, 0xFC, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFF, 0x0F,
  0xFF, 0x81, 0xE7, 0xC0, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E,
  0xF8, 0x7C, 0x7C, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x7D, 0xF0, 0x7D, 0xF0,
  0x7D, 0xF0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xF8, 0x78,
  0x3F, 0xF0, 0xF0, 0xFB, 0xE1, 0xF1, 0xF7, 0xC7, 0xE3, 0xEF, 0x8F, 0xCF,
  0x9F, 0x3F, 0x9F, 0x3E, 0x7F, 0x3E, 0x7C, 0xFE, 0xF8, 0x7B, 0xFD, 0xF0,
  0xF7, 0xFB, 0xC1, 0xFE, 0xFF, 0x83, 0xFD, 0xFF, 0x07, 0xFB, 0xFC, 0x0F,
  0xE7, 0xF8, 0x1F, 0xCF, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC,
  0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0x81, 0xE0, 0x00, 0x1F,
  0x87, 0xE1, 0xF1, 0xF8, 0x3E, 0x3F, 0x07, 0xCF, 0xC0, 0x7D, 0xF0, 0x0F,
  0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFB,
  0xE0, 0x3F, 0x7C, 0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3,
  0xF0, 0x1F, 0x07, 0xE3, 0xE0, 0xFC, 0x7E, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8,
  0xF8, 0x1F, 0x3F, 0x03, 0xE7, 0xC0, 0x7D, 0xF8, 0x0F, 0xBE, 0x01, 0xF7,
  0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF,
  0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x00, 0x20,
  0x0E, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0xFE, 0x0F,
  0x80, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03,
  0xC0, 0x1E, 0x01, 0xC0, 0x04, 0x00, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x03, 0xF0, 0x1E, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x0E, 0x00, 0xC0, 0x00, 0x0F,
  0x00, 0x03, 0xF8, 0x3C, 0xFF, 0x07, 0x1F, 0xF1, 0xE7, 0xFF, 0xFC, 0xF1,
  0xFF, 0x9E, 0x1F, 0xE7, 0x81, 0xF8, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 28, 10, 1, -28 },
  { 36, 12, 10, 12, 2, -29 },
  { 51, 19, 28, 20, 1, -28 },
  { 118, 18, 36, 19, 1, -32 },
  { 199, 19, 28, 24, 3, -28 },
  { 266, 19, 28, 22, 1, -28 },
  { 333, 6, 11, 6, 2, -29 },
  { 342, 12, 40, 12, 2, -31 },
  { 402, 13, 40, 12, -2, -31 },
  { 467, 16, 17, 17, 2, -28 },
  { 501, 16, 20, 18, 1, -23 },
  { 541, 8, 12, 9, -2, -5 },
  { 553, 10, 4, 14, 2, -14 },
  { 558, 6, 6, 11, 1, -6 },
  { 563, 18, 30, 13, -3, -28 },
  { 631, 16, 28, 19, 2, -28 },
  { 687, 12, 28, 19, 4, -28 },
  { 729, 19, 28, 19, 0, -28 },
  { 796, 18, 28, 19, 1, -28 },
  { 859, 18, 28, 19, 0, -28 },
  { 922, 18, 28, 19, 1, -28 },
  { 985, 16, 28, 19, 2, -28 },
  { 1041, 18, 28, 19, 2, -28 },
  { 1104, 18, 28, 19, 1, -28 },
  { 1167, 15, 28, 19, 3, -28 },
  { 1220, 9, 22, 11, 1, -22 },
  { 1245, 11, 29, 10, -2, -22 },
  { 1285, 15, 18, 17, 1, -21 },
  { 1319, 17, 13, 19, 1, -18 },
  { 1347, 15, 18, 17, 1, -21 },
  { 1381, 14, 28, 17, 3, -28 },
  { 1430, 27, 36, 29, 1, -27 },
  { 1552, 22, 28, 23, -2, -28 },
  { 1629, 21, 28, 21, 0, -28 },
  { 1703, 21, 28, 22, 1, -28 },
  { 1777, 21, 28, 21, 0, -28 },
  { 1851, 20, 28, 19, 0, -28 },
  { 1921, 20, 28, 18, 0, -28 },
  { 1991, 20, 28, 22, 2, -28 },
  { 2061, 24, 28, 23, 0, -28 },
  { 2145, 11, 28, 10, 0, -28 },
  { 2184, 19, 28, 19, 0, -28 },
  { 2251, 24, 28, 21, 0, -28 },
  { 2335, 16, 28, 18, 0, -28 },
  { 2391, 29, 28, 29, 0, -28 },
  { 2493, 24, 28, 23, 0, -28 },
  { 2577, 21, 28, 23, 1, -28 },
  { 2651, 22, 28, 22, 0, -28 },
  { 2728, 21, 33, 23, 1, -28 },
  { 2815, 21, 28, 21, 0, -28 },
  { 2889, 20, 28, 20, 1, -28 },
  { 2959, 19, 28, 21, 3, -28 },
  { 3026, 22, 28, 22, 1, -28 },
  { 3103, 21, 28, 22, 3, -28 },
  { 3177, 27, 28, 28, 3, -28 },
  { 3272, 24, 28, 21, -1, -28 },
  { 3356, 20, 28, 21, 3, -28 },
  { 3426, 23, 28, 20, -1, -28 },
  { 3507, 13, 38, 10, -1, -32 },
  { 3569, 9, 30, 14, 3, -28 },
  { 3603, 13, 38, 10, -2, -32 },
  { 3665, 13, 14, 15, 1, -28 },
  { 3688, 15, 4, 15, -2, 0 },
  { 3696, 8, 6, 13, 4, -29 },
  { 3702, 17, 21, 18, 0, -21 },
  { 3747, 18, 29, 19, 0, -29 },
  { 3813, 16, 21, 17, 1, -21 },
  { 3855, 19, 29, 19, 1, -29 },
  { 3924, 16, 21, 18, 1, -21 },
  { 3966, 14, 29, 12, 1, -29 },
  { 4017, 19, 29, 19, 0, -21 },
  { 4086, 17, 29, 19, 0, -29 },
  { 4148, 10, 29, 10, 0, -29 },
  { 4185, 14, 37, 9, -4, -29 },
  { 4250, 19, 29, 18, 0, -29 },
  { 4319, 10, 29, 10, 0, -29 },
  { 4356, 26, 21, 28, 0, -21 },
  { 4425, 17, 21, 19, 0, -21 },
  { 4470, 17, 21, 19, 1, -21 },
  { 4515, 19, 29, 19, -1, -21 },
  { 4584, 17, 29, 19, 1, -21 },
  { 4646, 13, 21, 13, 0, -21 },
  { 4681, 16, 21, 17, 0, -21 },
  { 4723, 11, 26, 12, 1, -26 },
  { 4759, 17, 21, 19, 1, -21 },
  { 4804, 16, 21, 17, 2, -21 },
  { 4846, 23, 21, 24, 2, -21 },
  { 4907, 19, 21, 17, -1, -21 },
  { 4957, 19, 29, 17, -1, -21 },
  { 5026, 18, 21, 17, -1, -21 },
  { 5074, 12, 37, 11, 1, -30 },
  { 5130, 8, 33, 10, 1, -28 },
  { 5163, 12, 37, 11, -1, -30 },
  { 5219, 19, 9, 21, 1, -16 },
};

const GFXfont RobotoCondensed_BoldItalic39pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic39pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic39pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOCONDENSED_BOLDITALIC39PT7B_H_
