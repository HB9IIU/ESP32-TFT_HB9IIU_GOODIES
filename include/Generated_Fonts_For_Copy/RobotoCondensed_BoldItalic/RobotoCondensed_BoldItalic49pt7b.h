#ifndef _ROBOTOCONDENSED_BOLDITALIC49PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0x78, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7, 0xDF,
  0x1F, 0x7C, 0x79, 0xF1, 0xE7, 0x87, 0x9E, 0x3E, 0x78, 0xF3, 0xE3, 0xCF,
  0x0F, 0x3C, 0x3C, 0xF0, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x7C, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78, 0xF0, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00,
  0xF1, 0xE0, 0x01, 0xE3, 0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xE3, 0xC0, 0x03,
  0xC7, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0xC7, 0x80, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x0F, 0x1E, 0x00, 0x0F,
  0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E,
  0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0x8F,
  0xE0, 0xFE, 0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07,
  0xF0, 0xFE, 0x1F, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07,
  0xCF, 0x81, 0x8F, 0x0F, 0x07, 0x9E, 0x1E, 0x1F, 0x3C, 0x3C, 0x3C, 0xF8,
  0x78, 0xF1, 0xF0, 0xF3, 0xE3, 0xE3, 0xE7, 0x83, 0xC7, 0x9E, 0x07, 0xFF,
  0x7C, 0x0F, 0xFD, 0xF0, 0x0F, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x0F, 0x7F,
  0x80, 0x3D, 0xFF, 0x80, 0xFB, 0xFF, 0x83, 0xEF, 0x9F, 0x07, 0x9E, 0x1E,
  0x1E, 0x3C, 0x3C, 0x7C, 0xF8, 0x78, 0xF1, 0xF0, 0xF3, 0xC3, 0xE1, 0xEF,
  0x87, 0xC7, 0xCE, 0x07, 0x8F, 0x08, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07,
  0xF1, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xE1, 0xF8, 0x07,
  0xE3, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xEF, 0xE0, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xFC, 0x1F, 0x1F, 0xFE, 0x3F, 0x3F, 0xFE, 0x3F, 0x7F, 0x7F, 0x3F, 0x7F,
  0x3F, 0xFE, 0xFE, 0x3F, 0xFE, 0xFE, 0x1F, 0xFE, 0xFE, 0x1F, 0xFC, 0xFE,
  0x0F, 0xFC, 0xFE, 0x0F, 0xF8, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F,
  0xF8, 0xFE, 0x00, 0x80, 0x00, 0x3E, 0x7C, 0xFB, 0xE7, 0xCF, 0x9F, 0x3C,
  0x79, 0xF3, 0xE7, 0xCF, 0x00, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x07,
  0x00, 0x04, 0x00, 0x00, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x10, 0x1E, 0x00, 0xE0, 0xE0, 0xEF, 0xCF, 0x3F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xF3, 0xC0, 0x1F, 0x1F, 0x01, 0xF0, 0x78,
  0x0F, 0x83, 0xE0, 0x38, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xF8,
  0x7E, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0xFC, 0x1E, 0x01, 0x00, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFC, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0x7C, 0xFE, 0xFF, 0xFF,
  0xFE, 0x7E, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0x0F, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF9,
  0xFC, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0xBF, 0x81,
  0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7E, 0x03, 0xFB, 0xF0, 0x1F, 0x9F,
  0x80, 0xFD, 0xFC, 0x0F, 0xEF, 0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F,
  0xDF, 0x80, 0xFC, 0xFC, 0x07, 0xE7, 0xE0, 0x7F, 0x3F, 0x03, 0xF1, 0xFC,
  0x1F, 0x8F, 0xE1, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x7C,
  0x03, 0xF8, 0x3F, 0xE1, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x7F,
  0xFC, 0xE3, 0xF2, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x3F, 0x87, 0xF0,
  0x7F, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1,
  0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x7F, 0x3F, 0x81, 0xF8,
  0xFE, 0x0F, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7E, 0xFC, 0x01, 0xF7, 0xF0, 0x0F, 0xDF, 0xC0, 0x7E,
  0x7F, 0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFE,
  0x0F, 0xC3, 0xF8, 0x7E, 0x0F, 0xE1, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFD, 0xF0, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0x9F,
  0xE0, 0x0C, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF1, 0xFC, 0x07, 0xE3,
  0xF8, 0x1F, 0xC3, 0xF0, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xBF, 0x03, 0xF7,
  0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xEF, 0xE0, 0xFE,
  0x7E, 0x1F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC,
  0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC1, 0xF8, 0x3F,
  0x8F, 0xE0, 0x7F, 0x7F, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x8F, 0xE0, 0xFC, 0x1F, 0x87,
  0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0,
  0x7F, 0x3F, 0x81, 0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x3F, 0x87, 0xE3, 0xF0, 0x7E, 0x7F, 0x07, 0xF7, 0xF0,
  0x7F, 0x7E, 0x07, 0xF7, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xFF, 0xE0, 0x7E, 0xFE, 0x07, 0xE7, 0xF0, 0xFE, 0x7F, 0x1F, 0xE7,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7D, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFE,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x7F, 0x8F, 0xF0, 0xFE, 0x1F,
  0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0xC7,
  0xF8, 0xFE, 0x0F, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x07, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xC0, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x1F, 0xFE,
  0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0,
  0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9F, 0xC7, 0xF3, 0xF8, 0x7E, 0xFE, 0x0F, 0xFF, 0xC1, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x01, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x3E, 0x07,
  0xFC, 0x1E, 0x0F, 0x03, 0xFF, 0xC3, 0x87, 0xC1, 0xFF, 0xF0, 0xF1, 0xE0,
  0xFC, 0x7C, 0x3C, 0xF8, 0x3E, 0x1E, 0x0F, 0x3E, 0x1F, 0x0F, 0x83, 0xCF,
  0x07, 0xC3, 0xE0, 0xF7, 0xC3, 0xE0, 0xF8, 0x3D, 0xF0, 0xF8, 0x3C, 0x1E,
  0x78, 0x7C, 0x0F, 0x07, 0x9E, 0x1F, 0x07, 0xC1, 0xEF, 0x87, 0xC1, 0xF0,
  0x7B, 0xE1, 0xF0, 0x78, 0x1E, 0xF8, 0x7C, 0x1E, 0x07, 0x3C, 0x3F, 0x0F,
  0x83, 0xCF, 0x0F, 0x83, 0xE0, 0xF3, 0xC3, 0xE0, 0xF8, 0x38, 0xF0, 0xFC,
  0x7C, 0x1E, 0x3C, 0x1F, 0x1F, 0x8F, 0x8F, 0x07, 0xFF, 0xE7, 0xC3, 0xC1,
  0xFF, 0x7F, 0xE0, 0xF0, 0x3F, 0x9F, 0xF0, 0x3E, 0x0F, 0xC3, 0xF8, 0x0F,
  0x80, 0x40, 0x30, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x40,
  0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFC, 0x00,
  0xFC, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0x7F,
  0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80,
  0x7F, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xC1, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xCF,
  0xE0, 0x0F, 0xE7, 0xF0, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x7F, 0x00,
  0x7E, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x3F, 0x83, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x81,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFC, 0x07,
  0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F,
  0x9F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x83, 0xFF, 0x9F, 0x83, 0xFF, 0xDF, 0xC1, 0xFF, 0xEF, 0xE0,
  0xFF, 0xF7, 0xF0, 0x7F, 0xFB, 0xF8, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0xFE,
  0x00, 0xFE, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7,
  0xF8, 0x3F, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00,
  0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F,
  0x80, 0x1F, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x03,
  0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00,
  0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x0F, 0xE0, 0x7F, 0x1F, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x07, 0xFC, 0x0F, 0xE0, 0x3F, 0xE0,
  0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x1F,
  0xC1, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x3F, 0xC0, 0x07, 0xF1,
  0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF9, 0xFE,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFE, 0x7F, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFE,
  0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xF8,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x1F, 0xFE, 0x07, 0xEF, 0x81, 0xFF,
  0xF0, 0x3F, 0x7C, 0x0F, 0xBF, 0x01, 0xFB, 0xE0, 0xFD, 0xF8, 0x1F, 0xDF,
  0x07, 0xCF, 0xC0, 0xFE, 0xF8, 0x7E, 0xFE, 0x07, 0xF7, 0xE3, 0xE7, 0xF0,
  0x3F, 0x1F, 0x1F, 0x3F, 0x01, 0xF8, 0xF9, 0xF9, 0xF8, 0x0F, 0xC7, 0xCF,
  0x9F, 0xC0, 0xFE, 0x3E, 0xFC, 0xFE, 0x07, 0xF1, 0xF7, 0xC7, 0xF0, 0x3F,
  0x8F, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0xE1, 0xF8, 0x0F, 0xE3, 0xFF, 0x1F,
  0xC0, 0x7E, 0x1F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x87, 0xF0, 0x3F, 0x83,
  0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0,
  0x7F, 0x07, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x81, 0xF0,
  0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0xC0,
  0x1F, 0xC0, 0xFF, 0x00, 0x7E, 0x07, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0x0F,
  0xE0, 0x7F, 0xE0, 0x3F, 0x81, 0xFF, 0x80, 0xFE, 0x07, 0xFE, 0x03, 0xF0,
  0x1F, 0xF8, 0x1F, 0xC0, 0xFF, 0xF0, 0x7F, 0x03, 0xFF, 0xC1, 0xFC, 0x0F,
  0xFF, 0x07, 0xF0, 0x3F, 0xBE, 0x1F, 0xC0, 0xFE, 0xF8, 0x7E, 0x03, 0xF3,
  0xE3, 0xF8, 0x1F, 0xCF, 0x8F, 0xE0, 0x7F, 0x1F, 0x3F, 0x81, 0xFC, 0x7C,
  0xFE, 0x07, 0xF1, 0xF3, 0xF8, 0x1F, 0xC7, 0xCF, 0xC0, 0x7E, 0x0F, 0xFF,
  0x03, 0xF8, 0x3F, 0xFC, 0x0F, 0xE0, 0xFF, 0xF0, 0x3F, 0x83, 0xFF, 0xC0,
  0xFE, 0x07, 0xFF, 0x03, 0xF8, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x7F,
  0x00, 0xFF, 0x81, 0xFC, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xC0,
  0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0x07,
  0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE3, 0xF8,
  0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7,
  0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x0F,
  0xE7, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80,
  0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F,
  0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0x07,
  0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07,
  0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7E,
  0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xF8, 0x7F, 0x80, 0xFE, 0x1F, 0xC0, 0x3F,
  0x8F, 0xE0, 0x07, 0xE3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0x00,
  0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x7E, 0x7F,
  0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE,
  0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x07,
  0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x01,
  0xFE, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x7F, 0x00,
  0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F,
  0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x1F, 0x80, 0x7F, 0x8F,
  0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xC1,
  0xFC, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x87, 0xE0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xE1, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE,
  0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x7F, 0x87, 0xF0, 0x7F, 0x83, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFC, 0x01, 0xFC,
  0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xE1, 0xFC, 0x03,
  0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8,
  0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7E, 0x1F, 0xC0, 0x3F,
  0x87, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80,
  0x3F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0xF8,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFB, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x7F,
  0x3F, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x01,
  0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0,
  0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7F,
  0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x07, 0xEF, 0xE0,
  0x7F, 0x03, 0xFB, 0xF8, 0x1F, 0xC0, 0xFE, 0xFE, 0x07, 0xF0, 0x3F, 0x3F,
  0x83, 0xFC, 0x1F, 0xCF, 0xE0, 0xFF, 0x07, 0xF3, 0xF8, 0x3F, 0xC1, 0xF8,
  0xFE, 0x1F, 0xF0, 0x7E, 0x3F, 0x87, 0xFC, 0x3F, 0x8F, 0xE1, 0xFF, 0x0F,
  0xC1, 0xF8, 0xFF, 0xC3, 0xF0, 0x7E, 0x3F, 0xF1, 0xFC, 0x1F, 0x8F, 0xFC,
  0x7F, 0x07, 0xE7, 0xFF, 0x1F, 0x81, 0xF9, 0xF7, 0xCF, 0xE0, 0x7E, 0x7D,
  0xF3, 0xF8, 0x1F, 0xBF, 0x7C, 0xFC, 0x07, 0xEF, 0x9F, 0x7F, 0x01, 0xFB,
  0xE7, 0xDF, 0xC0, 0x7F, 0xF9, 0xF7, 0xE0, 0x1F, 0xFC, 0x7D, 0xF8, 0x07,
  0xFF, 0x1F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0xC0,
  0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F,
  0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x03,
  0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFD,
  0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x01,
  0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x3F, 0xCF, 0xE0, 0x1F, 0xC7,
  0xF0, 0x1F, 0xE3, 0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0,
  0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xE3, 0xF8, 0x03, 0xF1, 0xF8,
  0x01, 0xF9, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80,
  0x00, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xBC, 0x0F,
  0xBE, 0x1F, 0x3E, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x7E, 0x1E, 0x7C,
  0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83,
  0xF0, 0x7C, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xF3, 0xF8, 0x7F, 0x0F, 0xE3, 0xF8, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0xFF, 0x1F, 0xCF, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0,
  0x7F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xC7, 0xF3, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xEF, 0xC0, 0x7E, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF9, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0x07,
  0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xF3,
  0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFC, 0x07, 0xF3, 0xF0,
  0x1F, 0x8F, 0xC0, 0x7E, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x7F,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x3F,
  0x3F, 0xE0, 0xFC, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0x87, 0xF3, 0xF0,
  0x3F, 0x7F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xE1, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8,
  0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xF1, 0xFC, 0x07, 0xFD,
  0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7E, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x07,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xEF, 0xC0, 0x0F, 0xCF,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x7F, 0x03,
  0xF3, 0xF8, 0x1F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x40, 0xFE, 0x07, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x7E, 0x03, 0xFE, 0x7E, 0x07, 0xFF, 0x7E, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x80, 0xFC,
  0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xFC,
  0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x7F, 0x07, 0xF0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xF7, 0xE0, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x20, 0x0F, 0xE0, 0x30, 0x1F, 0xC0, 0x7C, 0x7F, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xCF, 0x80, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFE, 0x1F, 0xC7,
  0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x9F, 0xC0, 0xFC, 0xFE, 0x0F,
  0xE7, 0xF0, 0x7F, 0x3F, 0x03, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0xFC, 0xFE,
  0x07, 0xE7, 0xF0, 0x7F, 0x3F, 0x83, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0xFE,
  0x7E, 0x07, 0xE7, 0xF0, 0x3F, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xCF, 0xC0,
  0xFE, 0x00, 0x01, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x0F, 0xE1, 0xFE,
  0x0F, 0xE3, 0xFC, 0x0F, 0xC7, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0xCF, 0xF0,
  0x1F, 0xDF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x7F, 0x9F, 0x80,
  0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xE0,
  0x00, 0x0F, 0xE7, 0xC0, 0xFC, 0x07, 0xEF, 0xF8, 0xFF, 0x03, 0xFF, 0xFC,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0x0F, 0xF0, 0xFE, 0x3F, 0x83, 0xF8, 0x3F, 0x1F, 0xC1,
  0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x0F, 0xE7, 0xF0,
  0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x83, 0xF9, 0xFC, 0x1F, 0xC1, 0xF8, 0xFC,
  0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE0, 0x7E, 0x3F, 0x07, 0xF0, 0x7F, 0x3F,
  0x83, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x0F, 0xC7,
  0xE0, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x83, 0xF9,
  0xFC, 0x1F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE0, 0xFE, 0x7F, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0xC7, 0xC0, 0x7E, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0x0F, 0xE3, 0xF8, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0xCF, 0xE0, 0x7E, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F,
  0x81, 0xFC, 0xFC, 0x0F, 0xE7, 0xE0, 0x7E, 0x7F, 0x03, 0xF3, 0xF8, 0x3F,
  0x9F, 0xC1, 0xFC, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0x3F, 0x03, 0xF3, 0xF8,
  0x1F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xE0, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF8, 0xFE, 0x0F, 0xE7, 0xE0, 0x7F, 0x7F, 0x03, 0xFB, 0xF8, 0x1F,
  0xDF, 0x80, 0xFE, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xF8,
  0xFE, 0x1F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF1, 0xF0, 0x03, 0xF7,
  0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0,
  0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0,
  0xFE, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xBF, 0xE0, 0x3F, 0x8F,
  0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x1F, 0xF3,
  0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3,
  0xF8, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xF8, 0x0F, 0xE7, 0xE0,
  0x3F, 0x3F, 0x80, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F,
  0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0xFE, 0x3F,
  0x83, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xEF,
  0x87, 0xEF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F,
  0xFC, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8, 0x7E, 0x0F,
  0xC3, 0xF0, 0x7F, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xE7, 0x80, 0x7F, 0x3F, 0x03, 0xF9, 0xFC, 0x1F, 0xC7, 0xE1,
  0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0xF1, 0xFF,
  0x87, 0xFC, 0x3F, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x7F, 0x07,
  0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFE, 0x07, 0xE3,
  0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC7, 0xF0,
  0x3F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x7F,
  0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F,
  0x87, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xEF, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xF3, 0xF0, 0x3F,
  0x9F, 0x81, 0xFC, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xE1, 0xF8,
  0x7F, 0x0F, 0xC3, 0xF0, 0x7F, 0x1F, 0x81, 0xF9, 0xFC, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7E, 0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x03, 0xFF, 0xC1, 0xF0, 0x7F, 0xFC,
  0x1F, 0x07, 0xEF, 0xC3, 0xF8, 0x7E, 0xFC, 0x3F, 0x8F, 0xEF, 0xC7, 0xF8,
  0xFC, 0xFC, 0x7F, 0x8F, 0xCF, 0xC7, 0xF9, 0xFC, 0xFC, 0xFF, 0x9F, 0x8F,
  0xCF, 0xF9, 0xF8, 0xFD, 0xFF, 0xBF, 0x0F, 0xDF, 0xFB, 0xF0, 0xFD, 0xFF,
  0xBF, 0x0F, 0xFE, 0xFB, 0xE0, 0xFF, 0xEF, 0xFE, 0x0F, 0xFC, 0x7F, 0xE0,
  0xFF, 0xC7, 0xFC, 0x0F, 0xFC, 0x7F, 0xC0, 0xFF, 0x87, 0xF8, 0x0F, 0xF8,
  0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0x80,
  0x3F, 0x9F, 0xC0, 0x0F, 0xDF, 0xC0, 0x07, 0xEF, 0xE0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFD,
  0xFC, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0xFF, 0x1F, 0x80, 0x7F,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFF,
  0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0xC1, 0xFC, 0x0F, 0xC1, 0xFC,
  0x0F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xE7, 0xF0,
  0x07, 0xE7, 0xF0, 0x07, 0xEF, 0xE0, 0x07, 0xEF, 0xE0, 0x07, 0xEF, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x04, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07,
  0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x10, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xC0, 0x7C, 0xFF, 0xC0, 0xF9, 0xFF, 0xC3, 0xE7, 0xFF,
  0xC7, 0xCF, 0xFF, 0xFF, 0xBF, 0x1F, 0xFE, 0x7C, 0x1F, 0xFC, 0xF8, 0x1F,
  0xF1, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 35, 12, 1, -35 },
  { 54, 14, 13, 15, 3, -37 },
  { 77, 24, 35, 25, 1, -35 },
  { 182, 23, 45, 24, 1, -40 },
  { 312, 23, 35, 30, 4, -35 },
  { 413, 24, 36, 27, 1, -35 },
  { 521, 7, 13, 8, 3, -37 },
  { 533, 15, 50, 15, 2, -39 },
  { 627, 15, 50, 15, -2, -39 },
  { 721, 21, 21, 22, 2, -35 },
  { 777, 21, 25, 23, 1, -28 },
  { 843, 10, 15, 12, -3, -6 },
  { 862, 13, 6, 17, 2, -18 },
  { 872, 8, 7, 14, 1, -7 },
  { 879, 22, 38, 16, -3, -35 },
  { 984, 21, 35, 24, 2, -35 },
  { 1076, 15, 35, 24, 5, -35 },
  { 1142, 23, 35, 24, 0, -35 },
  { 1243, 22, 35, 24, 1, -35 },
  { 1340, 22, 35, 24, 1, -35 },
  { 1437, 23, 35, 24, 1, -35 },
  { 1538, 20, 35, 24, 2, -35 },
  { 1626, 23, 35, 24, 2, -35 },
  { 1727, 22, 35, 24, 1, -35 },
  { 1824, 20, 35, 24, 3, -35 },
  { 1912, 11, 27, 13, 1, -27 },
  { 1950, 14, 36, 12, -2, -27 },
  { 2013, 19, 24, 21, 1, -27 },
  { 2070, 20, 17, 24, 2, -24 },
  { 2113, 20, 23, 22, 1, -26 },
  { 2171, 19, 35, 21, 3, -35 },
  { 2255, 34, 45, 36, 1, -34 },
  { 2447, 27, 35, 28, -2, -35 },
  { 2566, 26, 35, 27, 0, -35 },
  { 2680, 25, 35, 27, 2, -35 },
  { 2790, 26, 35, 27, 0, -35 },
  { 2904, 26, 35, 23, 0, -35 },
  { 3018, 25, 35, 23, 0, -35 },
  { 3128, 25, 35, 28, 2, -35 },
  { 3238, 30, 35, 29, 0, -35 },
  { 3370, 13, 35, 13, 0, -35 },
  { 3427, 24, 35, 23, 0, -35 },
  { 3532, 30, 35, 26, 0, -35 },
  { 3664, 20, 35, 23, 0, -35 },
  { 3752, 37, 35, 36, 0, -35 },
  { 3914, 30, 35, 29, 0, -35 },
  { 4046, 26, 35, 29, 2, -35 },
  { 4160, 27, 35, 27, 0, -35 },
  { 4279, 26, 41, 29, 2, -35 },
  { 4413, 26, 35, 26, 0, -35 },
  { 4527, 25, 35, 26, 1, -35 },
  { 4637, 24, 35, 26, 4, -35 },
  { 4742, 26, 35, 27, 2, -35 },
  { 4856, 26, 35, 27, 4, -35 },
  { 4970, 34, 35, 36, 4, -35 },
  { 5119, 31, 35, 27, -2, -35 },
  { 5255, 25, 35, 26, 4, -35 },
  { 5365, 28, 35, 25, -1, -35 },
  { 5488, 17, 49, 13, -1, -41 },
  { 5593, 12, 38, 18, 4, -35 },
  { 5650, 17, 49, 13, -3, -41 },
  { 5755, 16, 17, 19, 2, -35 },
  { 5789, 19, 5, 19, -3, 0 },
  { 5801, 10, 7, 16, 5, -36 },
  { 5810, 21, 26, 22, 0, -26 },
  { 5879, 22, 37, 24, 0, -37 },
  { 5981, 20, 26, 22, 1, -26 },
  { 6046, 24, 37, 24, 1, -37 },
  { 6157, 21, 26, 23, 1, -26 },
  { 6226, 18, 38, 16, 1, -38 },
  { 6312, 24, 36, 24, 0, -26 },
  { 6420, 21, 37, 23, 0, -37 },
  { 6518, 13, 36, 12, 0, -36 },
  { 6577, 18, 46, 12, -5, -36 },
  { 6681, 24, 37, 23, 0, -37 },
  { 6792, 13, 37, 12, 0, -37 },
  { 6853, 33, 26, 35, 0, -26 },
  { 6961, 21, 26, 23, 0, -26 },
  { 7030, 21, 26, 24, 1, -26 },
  { 7099, 24, 36, 24, -2, -26 },
  { 7207, 22, 36, 24, 1, -26 },
  { 7306, 17, 26, 16, 0, -26 },
  { 7362, 21, 26, 22, 0, -26 },
  { 7431, 13, 32, 15, 2, -32 },
  { 7483, 22, 26, 23, 1, -26 },
  { 7555, 21, 26, 21, 2, -26 },
  { 7624, 28, 26, 30, 3, -26 },
  { 7715, 25, 26, 21, -2, -26 },
  { 7797, 24, 36, 21, -1, -26 },
  { 7905, 22, 26, 21, -1, -26 },
  { 7977, 15, 47, 14, 1, -38 },
  { 8066, 10, 41, 12, 1, -35 },
  { 8118, 15, 47, 14, -2, -38 },
  { 8207, 23, 11, 27, 2, -20 },
};

const GFXfont RobotoCondensed_BoldItalic49pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic49pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic49pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _ROBOTOCONDENSED_BOLDITALIC49PT7B_H_
