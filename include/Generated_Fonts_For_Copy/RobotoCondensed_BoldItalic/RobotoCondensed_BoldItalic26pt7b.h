#ifndef _ROBOTOCONDENSED_BOLDITALIC26PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xE1, 0xC3, 0x8F, 0x1E, 0x38, 0x70, 0xE1, 0xC3,
  0x80, 0x00, 0x38, 0xF1, 0xE1, 0xC0, 0x67, 0xDF, 0xBE, 0x6C, 0xD9, 0xB3,
  0x00, 0x01, 0x98, 0x1D, 0xC0, 0xCC, 0x06, 0x60, 0x37, 0x03, 0x30, 0x7F,
  0xE7, 0xFF, 0x0E, 0xC0, 0x66, 0x03, 0x30, 0xFF, 0xE7, 0xFE, 0x0C, 0xC0,
  0xEE, 0x06, 0x60, 0x33, 0x01, 0xB8, 0x19, 0x80, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x78, 0x1F, 0xC3, 0xFE, 0x3C, 0xE3, 0x8E, 0x38, 0xE3, 0x80, 0x3C,
  0x03, 0xE0, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0xE1, 0xCE, 0x1C, 0xF3,
  0xCF, 0xF8, 0x7F, 0x03, 0xE0, 0x18, 0x01, 0x80, 0x3C, 0x03, 0xF0, 0x19,
  0x89, 0xCC, 0xEE, 0x66, 0x73, 0x63, 0xBF, 0x0F, 0xB0, 0x3B, 0x00, 0x38,
  0x01, 0xB8, 0x1B, 0xE1, 0xFB, 0x1D, 0x98, 0xCC, 0xCC, 0x66, 0x63, 0x30,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x7F, 0x03, 0xF8, 0x3D, 0xE1, 0xC7, 0x0E,
  0x70, 0x77, 0x83, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xCE, 0xFF, 0x77, 0x3F,
  0xF9, 0xFB, 0xC7, 0xCE, 0x3C, 0x7F, 0xF1, 0xFF, 0x87, 0x9E, 0x7F, 0xFD,
  0xB0, 0x01, 0x03, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x30, 0x70, 0x70,
  0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60,
  0x70, 0x30, 0x30, 0x10, 0x08, 0x0C, 0x0C, 0x0E, 0x06, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C,
  0x1C, 0x38, 0x38, 0x70, 0xF0, 0xE0, 0x80, 0x07, 0x00, 0xE0, 0x18, 0x33,
  0x37, 0xFE, 0x7F, 0x83, 0x80, 0xF8, 0x3B, 0x0E, 0x70, 0x84, 0x00, 0x07,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE1, 0xFF, 0xBF, 0xF7, 0xFE, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0xC0, 0x39, 0xCE, 0xE7, 0x7B, 0x98, 0x7E, 0xFF,
  0xF0, 0xEF, 0xFE, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x00, 0x07,
  0x83, 0xF8, 0xFF, 0x9C, 0x77, 0x8E, 0xF1, 0xDC, 0x3B, 0x87, 0x70, 0xFE,
  0x3F, 0xC7, 0xF8, 0xFF, 0x1D, 0xC3, 0xB8, 0xF7, 0x9C, 0x7F, 0x8F, 0xE0,
  0xF8, 0x00, 0x03, 0x1E, 0x7E, 0xFE, 0xFE, 0x9E, 0x1E, 0x1C, 0x1C, 0x1C,
  0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x38, 0x78, 0x78, 0x78, 0x07, 0xC0, 0xFE,
  0x1F, 0xF3, 0xCF, 0x3C, 0x73, 0x87, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xEF, 0xFE,
  0xFF, 0xE0, 0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xCF, 0x3C, 0x70, 0x07, 0x00,
  0xF0, 0x0F, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0xF1,
  0xE7, 0x1E, 0x7F, 0xC7, 0xF8, 0x1F, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0,
  0x3F, 0x03, 0xF0, 0x7E, 0x0E, 0xE0, 0xFE, 0x1D, 0xE1, 0xDE, 0x39, 0xE7,
  0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x1F, 0xF1, 0xFF, 0x3F, 0xE3, 0x80, 0x38, 0x03, 0x80, 0x7F, 0x07, 0xF8,
  0x7F, 0xC1, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0xE3, 0xCF, 0x3C,
  0xFF, 0x87, 0xF0, 0x3E, 0x00, 0x01, 0xC0, 0xF8, 0x3F, 0x0F, 0x03, 0xC0,
  0x70, 0x1F, 0xE3, 0xFE, 0x7F, 0xDE, 0x3B, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3,
  0xBC, 0x77, 0x9E, 0x7F, 0x8F, 0xE0, 0x78, 0x00, 0x7F, 0xF7, 0xFF, 0x7F,
  0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0,
  0x00, 0x07, 0x83, 0xF8, 0xFF, 0x9E, 0x73, 0x8E, 0x71, 0xCE, 0x39, 0xCF,
  0x3F, 0xC3, 0xF1, 0xFE, 0x39, 0xEF, 0x1D, 0xC3, 0xB8, 0xF7, 0x9E, 0xFF,
  0x8F, 0xE0, 0xF8, 0x00, 0x0F, 0x0F, 0xE7, 0xF9, 0xCF, 0xF1, 0xFC, 0x7E,
  0x1F, 0x87, 0xE3, 0xFC, 0xFF, 0xFD, 0xFE, 0x3B, 0x81, 0xE0, 0xF0, 0x78,
  0xFE, 0x3E, 0x0F, 0x00, 0x3B, 0xDE, 0x70, 0x00, 0x00, 0x00, 0x39, 0xEF,
  0x70, 0x0E, 0x3C, 0x78, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3,
  0x87, 0x0E, 0x38, 0x71, 0xC1, 0x00, 0x00, 0x40, 0x70, 0xF8, 0xFE, 0xFE,
  0x3E, 0x0F, 0x03, 0xF0, 0x7F, 0x07, 0xC0, 0x70, 0x04, 0x7F, 0xEF, 0xFD,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xBF, 0xF7, 0xFC, 0x30, 0x07, 0x00, 0xF8,
  0x1F, 0xC0, 0xFE, 0x03, 0xC0, 0xF8, 0xFE, 0x7F, 0x0F, 0x81, 0xC0, 0x20,
  0x00, 0x1E, 0x1F, 0xEF, 0xFB, 0xCE, 0xE3, 0x80, 0xE0, 0x78, 0x3C, 0x1F,
  0x07, 0x83, 0xC0, 0xE0, 0x38, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x07,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x38, 0x38, 0x1C, 0x06, 0x0E, 0x00,
  0xC7, 0x1E, 0x31, 0x8F, 0xCC, 0xE7, 0x33, 0x33, 0x9C, 0xDC, 0xE7, 0x36,
  0x31, 0x8D, 0x9C, 0x63, 0x67, 0x38, 0xD9, 0xCE, 0x7E, 0x73, 0x1B, 0x9D,
  0xEE, 0xE7, 0xFF, 0x18, 0xE7, 0x86, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0F, 0x18, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x01, 0xF8, 0x0E, 0xE0, 0x3B, 0x81, 0xEE, 0x07, 0x38, 0x3C,
  0xE0, 0xE3, 0x87, 0x8E, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xDE, 0x0F, 0x78,
  0x1D, 0xC0, 0x7F, 0x01, 0xC0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0x87, 0x0F,
  0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x3F, 0xF0, 0xFF, 0x83, 0xFF,
  0x1E, 0x1C, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x1C, 0x3C, 0x7F, 0xF3, 0xFF,
  0x8F, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0xFE, 0x78, 0xF3, 0x83, 0xBC,
  0x1D, 0xE0, 0xEE, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x3B, 0xC3, 0xDE, 0x3C, 0x7F, 0xE1, 0xFE, 0x07, 0xC0, 0x1F, 0xC0,
  0x7F, 0xC1, 0xFF, 0x87, 0x1E, 0x1C, 0x38, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F,
  0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x8F,
  0x1C, 0x7C, 0x7F, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xE1,
  0xFF, 0x87, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xE0,
  0xFF, 0x83, 0xFE, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x7F, 0xE3, 0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xE1, 0xFF, 0x0F, 0xF8,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C,
  0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x1E, 0x38, 0x39, 0xE0, 0xF7,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC7, 0xEF, 0x1F, 0xBC, 0xFE, 0xF0, 0x73,
  0xC1, 0xCF, 0x0F, 0x1E, 0x3C, 0x7F, 0xF0, 0xFF, 0x81, 0xF8, 0x00, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0E, 0x1C, 0x0E, 0x3C, 0x1E, 0x3C,
  0x1E, 0x3C, 0x1E, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x3C, 0x78, 0x38, 0x70, 0x38, 0x70, 0x38, 0xF0, 0x78, 0xF0,
  0x78, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x8F, 0x1E, 0x3C, 0x78, 0xE1, 0xC7,
  0x8F, 0x1E, 0x3C, 0x71, 0xE3, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x78, 0xF3, 0xC7, 0x1E, 0x78, 0x7F, 0x83, 0xFC, 0x0F,
  0x80, 0x1E, 0x1F, 0x1E, 0x3E, 0x1E, 0x3C, 0x1C, 0x78, 0x1C, 0xF0, 0x3D,
  0xF0, 0x3D, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F,
  0xC0, 0x7D, 0xE0, 0x79, 0xE0, 0x79, 0xE0, 0x70, 0xF0, 0x70, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x7F, 0xFF, 0xFB, 0xFF, 0x00, 0x1F, 0x01, 0xE1, 0xF0, 0x3E, 0x1F,
  0x03, 0xE1, 0xF0, 0x7E, 0x1F, 0x07, 0xE3, 0xF0, 0xFE, 0x3F, 0x8F, 0xC3,
  0xB8, 0xFC, 0x3B, 0x9D, 0xC3, 0xB9, 0xFC, 0x3B, 0xBB, 0xC7, 0xBB, 0xBC,
  0x7B, 0xB3, 0x87, 0xBF, 0x38, 0x79, 0xF7, 0x87, 0x1E, 0x78, 0x71, 0xE7,
  0x8F, 0x1C, 0x78, 0xF1, 0xC7, 0x00, 0x1E, 0x0F, 0x1E, 0x0F, 0x1F, 0x0E,
  0x1F, 0x0E, 0x1F, 0x0E, 0x3F, 0x1E, 0x3F, 0x9E, 0x3F, 0x9E, 0x3F, 0x9C,
  0x39, 0x9C, 0x39, 0xFC, 0x79, 0xFC, 0x79, 0xFC, 0x78, 0xFC, 0x78, 0xF8,
  0x70, 0xF8, 0x70, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x07, 0xE0, 0x3F, 0xC1,
  0xFF, 0x8F, 0x1E, 0x38, 0x39, 0xE0, 0xF7, 0x83, 0xDC, 0x0F, 0x70, 0x3B,
  0xC0, 0xEF, 0x03, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0x1E, 0x7C,
  0x7F, 0xE0, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0xC7,
  0x0F, 0x1C, 0x1C, 0xF0, 0x73, 0xC3, 0xCF, 0x0F, 0x3C, 0x7C, 0xFF, 0xE3,
  0xFF, 0x1F, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x1E, 0x38,
  0x39, 0xE0, 0xF7, 0x83, 0xDC, 0x0F, 0x70, 0x3B, 0xC0, 0xEF, 0x03, 0xBC,
  0x1E, 0xF0, 0x7B, 0xC1, 0xCF, 0x0F, 0x1E, 0x7C, 0x7F, 0xE0, 0xFF, 0x01,
  0xFC, 0x00, 0x78, 0x00, 0xE0, 0x01, 0x00, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF,
  0x87, 0x0F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0E, 0x3C, 0x78, 0xFF,
  0xC3, 0xFE, 0x1F, 0xF0, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1C, 0x38, 0x70,
  0xF3, 0xC3, 0xCF, 0x0F, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x87, 0x9E,
  0x3C, 0x3C, 0xF0, 0xF3, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3E,
  0x00, 0x3C, 0x00, 0xF1, 0xC1, 0xC7, 0x0F, 0x1E, 0x3C, 0x7F, 0xE0, 0xFF,
  0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x3C,
  0xF0, 0xF3, 0x83, 0xCE, 0x0E, 0x78, 0x39, 0xE1, 0xE7, 0x87, 0x9E, 0x1E,
  0x70, 0x79, 0xC1, 0xCF, 0x07, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0E,
  0x3C, 0x78, 0x7F, 0xC1, 0xFF, 0x01, 0xF0, 0x00, 0xF0, 0x3F, 0xC1, 0xEF,
  0x07, 0xBC, 0x1E, 0x70, 0xF1, 0xC3, 0xC7, 0x0E, 0x1C, 0x78, 0x71, 0xC1,
  0xEF, 0x07, 0xBC, 0x1E, 0xE0, 0x7F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0xF1, 0xE3, 0xFC, 0x78, 0xFF, 0x1E,
  0x3B, 0xCF, 0x9E, 0xF3, 0xE7, 0xBC, 0xF9, 0xCF, 0x7E, 0x73, 0xDF, 0xBC,
  0xF7, 0xEE, 0x3F, 0xBB, 0x8F, 0xEF, 0xE3, 0xFB, 0xF0, 0xFC, 0xFC, 0x1F,
  0x3F, 0x07, 0xCF, 0xC1, 0xE3, 0xE0, 0x78, 0xF8, 0x1E, 0x3E, 0x07, 0x0F,
  0x00, 0x1E, 0x0F, 0x0F, 0x1F, 0x0F, 0x1E, 0x0F, 0x3C, 0x07, 0x3C, 0x07,
  0x78, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0x70, 0x3C, 0x78, 0x78,
  0x78, 0xF8, 0x78, 0xF0, 0x7F, 0x83, 0xDC, 0x3C, 0xE1, 0xC7, 0x9E, 0x3C,
  0xE0, 0xEF, 0x07, 0x70, 0x3F, 0x81, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x1F, 0xFC,
  0x7F, 0xF3, 0xFF, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0xFF, 0xF3, 0xFF, 0xCF, 0xFE, 0x00, 0x0F, 0x87, 0xC3, 0xE1,
  0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0,
  0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x7C,
  0x3C, 0x00, 0xF3, 0xCF, 0x1C, 0x71, 0xC7, 0x1E, 0x79, 0xE7, 0x8E, 0x38,
  0xE3, 0x8F, 0x3C, 0xF1, 0xC7, 0x1C, 0x0F, 0x1F, 0x1F, 0x0F, 0x0F, 0x0F,
  0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x38, 0x38, 0x38, 0x78, 0xF8, 0xF8, 0xF0, 0x0E, 0x07, 0x07, 0x83,
  0xE3, 0xF1, 0x99, 0xCC, 0xC6, 0xE3, 0x00, 0x7F, 0xCF, 0xFB, 0xFF, 0x00,
  0xF3, 0x9C, 0x70, 0x0F, 0x83, 0xF8, 0xFF, 0x9C, 0xF0, 0x1E, 0x3F, 0xCF,
  0xFB, 0xCE, 0xF1, 0xDE, 0x3B, 0xCF, 0x7F, 0xE7, 0xFC, 0x7F, 0x80, 0x1E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3F, 0xC3, 0xFE, 0x3F,
  0xE3, 0x8F, 0x38, 0xF7, 0x8F, 0x78, 0xF7, 0x8E, 0x70, 0xE7, 0x0E, 0x71,
  0xEF, 0xFC, 0xFF, 0xCE, 0x78, 0x1F, 0x0F, 0xE7, 0xFD, 0xC7, 0xF1, 0xF8,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0xEE, 0x3B, 0xFE, 0x7F, 0x0F, 0x00, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x1E, 0xE3, 0xFE, 0x7F,
  0xEF, 0x1E, 0xF1, 0xEE, 0x1C, 0xE1, 0xCE, 0x3C, 0xE3, 0xCE, 0x3C, 0xE3,
  0xCF, 0xF8, 0xFF, 0x87, 0xB8, 0x0F, 0x0F, 0xE7, 0xFD, 0xC7, 0xF1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x0F, 0x13, 0xFE, 0x7F, 0x8F, 0x80, 0x07,
  0x87, 0xC7, 0xE3, 0x83, 0xC1, 0xE3, 0xFD, 0xFC, 0xFE, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x00, 0x0F, 0x70,
  0xFF, 0x8F, 0xFC, 0x71, 0xE7, 0x8F, 0x38, 0x79, 0xC3, 0x8E, 0x1C, 0x70,
  0xE3, 0x8F, 0x1C, 0x78, 0xFF, 0xC7, 0xFC, 0x1E, 0xE0, 0x0F, 0x08, 0x78,
  0xFF, 0x87, 0xF8, 0x1F, 0x80, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0,
  0x78, 0x0F, 0xF1, 0xFF, 0x3F, 0xE7, 0x1D, 0xE3, 0xBC, 0x77, 0x8E, 0xE3,
  0xDC, 0x7B, 0x8F, 0xF1, 0xDE, 0x3B, 0xC7, 0x71, 0xE0, 0x0C, 0x3C, 0x78,
  0xE0, 0x00, 0x0F, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8F, 0x1E, 0x38, 0x70,
  0xE3, 0xC7, 0x80, 0x01, 0x80, 0xF0, 0x3C, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x0F, 0xC3, 0xE0, 0xF0, 0x00, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF3, 0xE7, 0xBE,
  0x39, 0xE1, 0xDE, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFE, 0x0E,
  0x70, 0x73, 0xC7, 0x9E, 0x3C, 0xF1, 0xE3, 0xC0, 0x1E, 0x3C, 0x78, 0xE1,
  0xC3, 0x8F, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8F, 0x1E, 0x38, 0x70, 0xE3,
  0xC7, 0x80, 0x3F, 0xC7, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xE3, 0xCF, 0x38,
  0xE3, 0xDE, 0x38, 0xF7, 0x8E, 0x39, 0xE7, 0x8E, 0x71, 0xE3, 0x9C, 0x79,
  0xE7, 0x1C, 0x7B, 0xC7, 0x1E, 0xF1, 0xC7, 0x3C, 0xF1, 0xC0, 0x3B, 0xC7,
  0xFC, 0xFF, 0x9C, 0x77, 0x8E, 0xF1, 0xDE, 0x3B, 0x8F, 0x71, 0xEE, 0x3F,
  0xC7, 0x78, 0xEF, 0x1D, 0xC7, 0x80, 0x1F, 0x07, 0xF1, 0xFF, 0x38, 0xEF,
  0x1F, 0xC3, 0xF8, 0x7F, 0x0E, 0xE1, 0xDC, 0x3B, 0xCF, 0x7F, 0xC7, 0xF0,
  0x7C, 0x00, 0x1D, 0xE0, 0xFF, 0x87, 0xFC, 0x38, 0xF1, 0xC7, 0x9E, 0x3C,
  0xF1, 0xE7, 0x8E, 0x38, 0x71, 0xC3, 0x8E, 0x3C, 0xFF, 0xC7, 0xFE, 0x39,
  0xE1, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x1E, 0xE7, 0xDD,
  0xFF, 0xF8, 0xFF, 0x1F, 0xC3, 0xB8, 0x77, 0x1E, 0xE3, 0xDC, 0x7B, 0x8E,
  0x7F, 0xCF, 0xF8, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x00,
  0x3F, 0x9F, 0xCF, 0xE7, 0xE3, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C,
  0x1E, 0x0F, 0x07, 0x80, 0x0F, 0x83, 0xF8, 0xFF, 0x9C, 0xF7, 0x80, 0x78,
  0x0F, 0xC0, 0xFC, 0x07, 0xDC, 0x7B, 0xCF, 0x7F, 0xC7, 0xF8, 0x3C, 0x00,
  0x3C, 0x78, 0xF7, 0xFF, 0xFF, 0xDE, 0x3C, 0x70, 0xE1, 0xC3, 0x8F, 0x1E,
  0x3E, 0x3C, 0x78, 0x78, 0xEE, 0x3D, 0xC7, 0xB8, 0xFF, 0x1F, 0xE3, 0xBC,
  0x77, 0x9E, 0xE3, 0xDC, 0x7B, 0x8E, 0x7F, 0xCF, 0xF8, 0xF7, 0x00, 0xF1,
  0xFE, 0x39, 0xCF, 0x39, 0xE7, 0x38, 0xEF, 0x1D, 0xC3, 0xB8, 0x7E, 0x0F,
  0xC1, 0xF8, 0x1E, 0x03, 0xC0, 0x70, 0x00, 0xE3, 0x1D, 0xCE, 0x3B, 0x9C,
  0xF7, 0x79, 0xCE, 0xFB, 0x9D, 0xFF, 0x3F, 0xFC, 0x7D, 0xF8, 0xFB, 0xF1,
  0xF7, 0xC3, 0xCF, 0x87, 0x9E, 0x0E, 0x3C, 0x1C, 0x38, 0x00, 0x1C, 0x78,
  0xE7, 0x87, 0xBC, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F,
  0x80, 0xFE, 0x0F, 0x70, 0x73, 0x87, 0x9C, 0x78, 0xF0, 0x3C, 0x79, 0xE3,
  0x87, 0x3C, 0x39, 0xE1, 0xDE, 0x0E, 0xF0, 0x77, 0x03, 0xF8, 0x1F, 0x80,
  0xFC, 0x07, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x7C,
  0x07, 0xC0, 0x3C, 0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x81, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x7F, 0xEF, 0xF9, 0xFF, 0x00,
  0x02, 0x0E, 0x0E, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF0,
  0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0, 0x60, 0x70, 0x70,
  0x10, 0x0C, 0x31, 0xC6, 0x18, 0x61, 0x86, 0x38, 0xE3, 0x0C, 0x30, 0xC3,
  0x1C, 0x61, 0x86, 0x18, 0x63, 0x80, 0x08, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x07, 0x0F, 0x1C, 0x1C, 0x3C, 0x38,
  0x38, 0x38, 0x38, 0x78, 0x70, 0xE0, 0xC0, 0x38, 0x37, 0xE7, 0x7E, 0x7E,
  0x7E, 0xE3, 0xE0, 0x1C,
};

const GFXglyph RobotoCondensed_BoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 19, 7, 0, -19 },
  { 18, 7, 7, 8, 2, -20 },
  { 25, 13, 19, 13, 0, -19 },
  { 56, 12, 24, 13, 1, -22 },
  { 92, 13, 19, 16, 2, -19 },
  { 123, 13, 19, 15, 0, -19 },
  { 154, 3, 7, 4, 2, -20 },
  { 157, 8, 27, 8, 1, -21 },
  { 184, 8, 27, 8, -1, -21 },
  { 211, 11, 11, 11, 1, -19 },
  { 227, 11, 13, 12, 1, -15 },
  { 245, 5, 8, 6, -1, -3 },
  { 250, 7, 3, 9, 1, -9 },
  { 253, 4, 4, 7, 1, -4 },
  { 255, 12, 21, 8, -2, -19 },
  { 287, 11, 19, 13, 1, -19 },
  { 314, 8, 19, 13, 3, -19 },
  { 333, 12, 19, 13, 0, -19 },
  { 362, 12, 19, 13, 0, -19 },
  { 391, 12, 19, 13, 0, -19 },
  { 420, 12, 19, 13, 1, -19 },
  { 449, 11, 19, 13, 1, -19 },
  { 476, 12, 19, 13, 1, -19 },
  { 505, 11, 19, 13, 1, -19 },
  { 532, 10, 19, 13, 2, -19 },
  { 556, 5, 14, 7, 1, -14 },
  { 565, 7, 19, 7, -1, -14 },
  { 582, 10, 12, 11, 1, -14 },
  { 597, 11, 8, 13, 1, -12 },
  { 608, 11, 12, 11, 0, -14 },
  { 625, 10, 19, 11, 2, -19 },
  { 649, 18, 24, 19, 0, -18 },
  { 703, 14, 19, 15, -1, -19 },
  { 737, 14, 19, 14, 0, -19 },
  { 771, 13, 19, 14, 1, -19 },
  { 802, 14, 19, 14, 0, -19 },
  { 836, 14, 19, 12, 0, -19 },
  { 870, 13, 19, 12, 0, -19 },
  { 901, 14, 19, 15, 1, -19 },
  { 935, 16, 19, 15, 0, -19 },
  { 973, 7, 19, 7, 0, -19 },
  { 990, 13, 19, 12, 0, -19 },
  { 1021, 16, 19, 14, 0, -19 },
  { 1059, 11, 19, 12, 0, -19 },
  { 1086, 20, 19, 19, 0, -19 },
  { 1134, 16, 19, 15, 0, -19 },
  { 1172, 14, 19, 15, 1, -19 },
  { 1206, 14, 19, 14, 0, -19 },
  { 1240, 14, 22, 15, 1, -19 },
  { 1279, 14, 19, 14, 0, -19 },
  { 1313, 14, 19, 14, 0, -19 },
  { 1347, 13, 19, 14, 2, -19 },
  { 1378, 14, 19, 14, 1, -19 },
  { 1412, 14, 19, 15, 2, -19 },
  { 1446, 18, 19, 19, 2, -19 },
  { 1489, 16, 19, 14, -1, -19 },
  { 1527, 13, 19, 14, 2, -19 },
  { 1558, 14, 19, 13, 0, -19 },
  { 1592, 9, 26, 7, -1, -22 },
  { 1622, 6, 21, 10, 2, -19 },
  { 1638, 8, 26, 7, -1, -22 },
  { 1664, 9, 9, 10, 1, -19 },
  { 1675, 11, 3, 10, -2, 0 },
  { 1680, 5, 4, 8, 3, -20 },
  { 1683, 11, 14, 12, 0, -14 },
  { 1703, 12, 20, 13, 0, -20 },
  { 1733, 10, 14, 12, 1, -14 },
  { 1751, 12, 20, 13, 1, -20 },
  { 1781, 10, 14, 12, 1, -14 },
  { 1799, 9, 20, 8, 1, -20 },
  { 1822, 13, 19, 13, 0, -14 },
  { 1853, 11, 20, 12, 0, -20 },
  { 1881, 7, 20, 6, 0, -20 },
  { 1899, 10, 25, 6, -3, -20 },
  { 1931, 13, 20, 12, 0, -20 },
  { 1964, 7, 20, 6, 0, -20 },
  { 1982, 18, 14, 19, 0, -14 },
  { 2014, 11, 14, 12, 0, -14 },
  { 2034, 11, 14, 13, 1, -14 },
  { 2054, 13, 19, 13, -1, -14 },
  { 2085, 11, 19, 13, 1, -14 },
  { 2112, 9, 14, 8, 0, -14 },
  { 2128, 11, 14, 11, 0, -14 },
  { 2148, 7, 17, 8, 1, -17 },
  { 2163, 11, 14, 12, 1, -14 },
  { 2183, 11, 14, 11, 1, -14 },
  { 2203, 15, 14, 16, 2, -14 },
  { 2230, 13, 14, 11, -1, -14 },
  { 2253, 13, 19, 11, -1, -14 },
  { 2284, 11, 14, 11, 0, -14 },
  { 2304, 8, 25, 8, 1, -20 },
  { 2329, 6, 22, 6, 0, -19 },
  { 2346, 8, 25, 8, -1, -20 },
  { 2371, 12, 6, 14, 1, -11 },
};

const GFXfont RobotoCondensed_BoldItalic26pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic26pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic26pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _ROBOTOCONDENSED_BOLDITALIC26PT7B_H_
