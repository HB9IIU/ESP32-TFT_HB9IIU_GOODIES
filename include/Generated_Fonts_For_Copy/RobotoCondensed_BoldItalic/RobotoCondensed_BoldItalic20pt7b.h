#ifndef _ROBOTOCONDENSED_BOLDITALIC20PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCE, 0x73, 0x18, 0xCE, 0x70, 0x00, 0xCE, 0x30, 0x6D, 0xB4,
  0xF2, 0xD8, 0x06, 0xC1, 0xA0, 0x58, 0x36, 0x3F, 0xCF, 0xF1, 0xB0, 0x6C,
  0x7F, 0xBF, 0xE3, 0x60, 0x90, 0x6C, 0x1B, 0x00, 0x06, 0x02, 0x07, 0x87,
  0xE7, 0x33, 0x9D, 0xCE, 0xE0, 0x3C, 0x0F, 0x03, 0x98, 0xEC, 0x77, 0x73,
  0xF8, 0xF0, 0x30, 0x18, 0x00, 0x70, 0x7C, 0x36, 0x7B, 0x6D, 0xE7, 0xE1,
  0xF0, 0x3E, 0x3F, 0x9E, 0xDB, 0x79, 0xB0, 0xF8, 0x38, 0x0F, 0x07, 0xE1,
  0xB8, 0xE6, 0x3B, 0x07, 0xC1, 0xE0, 0xF3, 0x7E, 0xD9, 0xFE, 0x7B, 0xDE,
  0x7F, 0x8F, 0x70, 0x6D, 0xEC, 0x04, 0x31, 0x8C, 0x31, 0x86, 0x18, 0xE3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0x86, 0x08, 0x10, 0x60, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1C, 0x61, 0x8E, 0x31, 0x8E, 0x20, 0x0C,
  0x0C, 0x08, 0xEF, 0x7F, 0x38, 0x7C, 0x66, 0x44, 0x1C, 0x1C, 0x1C, 0x18,
  0xFF, 0xFF, 0xFF, 0x38, 0x38, 0x30, 0x30, 0x37, 0x76, 0xEC, 0xFF, 0xC0,
  0x6F, 0x60, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0x00, 0x1E, 0x3F, 0x77, 0x63, 0x63,
  0xE3, 0xE3, 0xE7, 0xE7, 0xC7, 0xC6, 0xEE, 0xFC, 0x78, 0x04, 0xF7, 0xFF,
  0x18, 0x63, 0x8E, 0x38, 0xE3, 0x0C, 0x71, 0xC0, 0x0F, 0x07, 0xE3, 0xB8,
  0xC6, 0x71, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF,
  0x3F, 0xC0, 0x0F, 0x07, 0xE3, 0xB8, 0xC6, 0x01, 0x80, 0xE0, 0xF0, 0x7C,
  0x03, 0x00, 0xEE, 0x33, 0x9C, 0x7E, 0x0F, 0x00, 0x03, 0x81, 0xC1, 0xE1,
  0xF0, 0xF8, 0xD8, 0xEC, 0x6E, 0x67, 0x7F, 0xFF, 0xE0, 0xC0, 0x60, 0x70,
  0x3F, 0x9F, 0xCC, 0x0E, 0x06, 0x03, 0xF1, 0xF8, 0xCE, 0x07, 0x03, 0xB1,
  0xDD, 0xCF, 0xE3, 0xC0, 0x07, 0x1E, 0x3C, 0x70, 0x70, 0xFE, 0xFF, 0xE7,
  0xE7, 0xE7, 0xE7, 0xEE, 0x7E, 0x38, 0x7F, 0xBF, 0xC0, 0xE0, 0xE0, 0x70,
  0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x00, 0x1E, 0x1F,
  0x9D, 0xCE, 0x67, 0x33, 0xB8, 0xF8, 0xFC, 0xE6, 0x63, 0xB1, 0x9D, 0xCF,
  0xE3, 0xC0, 0x1E, 0x3F, 0x77, 0x63, 0xE3, 0xE3, 0xE7, 0x7F, 0x3F, 0x06,
  0x0E, 0x3C, 0x78, 0x70, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x67, 0x98, 0x18,
  0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC3, 0x1C, 0x61, 0x84, 0x00, 0x01,
  0x07, 0x1F, 0x7E, 0x78, 0x70, 0xFC, 0x1E, 0x0E, 0x02, 0x7F, 0x7F, 0x00,
  0x00, 0xFE, 0xFE, 0x20, 0x38, 0x3C, 0x1F, 0x07, 0x0F, 0x3E, 0x78, 0x60,
  0x80, 0x3C, 0x7E, 0x77, 0xE7, 0x06, 0x0E, 0x1C, 0x38, 0x30, 0x00, 0x00,
  0x60, 0x70, 0x60, 0x03, 0xE0, 0x1F, 0xE0, 0xC1, 0x86, 0x03, 0x31, 0xCC,
  0xCF, 0x96, 0x66, 0x59, 0x93, 0x6C, 0xCF, 0x33, 0x3C, 0xCC, 0xF3, 0x76,
  0xCF, 0xF9, 0x1B, 0xC6, 0x00, 0x18, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x01,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x6C, 0x1D, 0x83, 0x30, 0xE6, 0x1C, 0xE7,
  0xFC, 0xFF, 0xB8, 0x77, 0x0F, 0xC1, 0xC0, 0x3F, 0x87, 0xF8, 0xE7, 0x1C,
  0x73, 0x8C, 0x63, 0x9F, 0xE3, 0xFC, 0x71, 0xCE, 0x39, 0xC7, 0x31, 0xCF,
  0xF9, 0xFC, 0x00, 0x0F, 0x0F, 0xE7, 0x9D, 0xC7, 0x61, 0xF8, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0xEE, 0x3B, 0x9C, 0x7F, 0x0F, 0x00, 0x3F, 0x07, 0xF0,
  0xE7, 0x1C, 0x63, 0x8C, 0x61, 0x9C, 0x33, 0x8E, 0x71, 0xCE, 0x39, 0xC6,
  0x33, 0xCF, 0xF1, 0xF8, 0x00, 0x3F, 0xCF, 0xF3, 0x80, 0xE0, 0x38, 0x0C,
  0x07, 0xF9, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xFF, 0x3F, 0xC0, 0x3F,
  0xCF, 0xF3, 0x80, 0xE0, 0x38, 0x0C, 0x07, 0xF1, 0xFC, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0xE0, 0x38, 0x00, 0x0F, 0x0F, 0xE7, 0x9D, 0xC7, 0x61, 0xF8,
  0x0E, 0x03, 0x9F, 0xE7, 0xB8, 0x6E, 0x3B, 0xDE, 0x7F, 0x8F, 0x80, 0x38,
  0x73, 0x87, 0x38, 0x73, 0x87, 0x38, 0x63, 0x0E, 0x7F, 0xE7, 0xFE, 0x70,
  0xE7, 0x0E, 0x70, 0xC6, 0x1C, 0xE1, 0xCE, 0x1C, 0x19, 0xCE, 0x73, 0x98,
  0xCE, 0x73, 0x9C, 0xCE, 0x70, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x01, 0xCE, 0x73, 0xBC, 0x7E, 0x0F, 0x00, 0x38,
  0xF3, 0x8E, 0x39, 0xC3, 0xB8, 0x3F, 0x83, 0x70, 0x7E, 0x07, 0xF0, 0x7F,
  0x07, 0x70, 0x73, 0x86, 0x38, 0xE3, 0x8E, 0x3C, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x30, 0x70, 0x70, 0x70, 0x70, 0x70, 0x60, 0xFF, 0xFF, 0x3C, 0x1E,
  0x78, 0x3C, 0xF0, 0xF9, 0xE1, 0xE3, 0xE7, 0xC7, 0xCF, 0x9D, 0x9F, 0x3B,
  0x6E, 0x76, 0xDC, 0xEF, 0x31, 0x9E, 0xE3, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x00, 0x38, 0x73, 0xC7, 0x3C, 0x73, 0xC7, 0x3C, 0x63, 0x6E, 0x76, 0xE7,
  0x6E, 0x73, 0xE7, 0x3E, 0x73, 0xC6, 0x3C, 0xE1, 0xCE, 0x1C, 0x0F, 0x0F,
  0xE3, 0x9D, 0xC7, 0x60, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3B,
  0xDE, 0x7F, 0x0F, 0x00, 0x3F, 0x87, 0xF8, 0xE7, 0x9C, 0x73, 0x8E, 0x61,
  0xDC, 0x73, 0xFE, 0x7F, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x00,
  0x0F, 0x0F, 0xE7, 0x9D, 0xC7, 0x60, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x3B, 0xDE, 0x7F, 0x0F, 0x80, 0x70, 0x0C, 0x02, 0x00, 0x3F, 0x87,
  0xF8, 0xE7, 0x1C, 0x73, 0x8E, 0x61, 0x9C, 0xF3, 0xFC, 0x7F, 0x0E, 0xE1,
  0xCE, 0x31, 0xCE, 0x39, 0xC7, 0x00, 0x0F, 0x83, 0xF8, 0xF7, 0x1C, 0x73,
  0x80, 0x78, 0x07, 0x80, 0x7C, 0x03, 0x9C, 0x31, 0x86, 0x39, 0xC7, 0xF0,
  0x3C, 0x00, 0xFF, 0xBF, 0xE1, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x70, 0xCE, 0x19, 0xC7,
  0x38, 0xE6, 0x1D, 0xC3, 0xB8, 0x67, 0x1C, 0xE3, 0x9C, 0x73, 0x8E, 0x73,
  0x8F, 0xF0, 0x78, 0x00, 0xE1, 0xF8, 0x7E, 0x3B, 0x8E, 0xE7, 0x39, 0xCE,
  0x63, 0xB8, 0x6E, 0x1B, 0x07, 0xC1, 0xE0, 0x78, 0x1C, 0x00, 0xC7, 0x1E,
  0x39, 0xF1, 0xCF, 0x9E, 0x6C, 0xF7, 0x67, 0xBB, 0x6D, 0x9B, 0x7C, 0xFB,
  0xE7, 0x9E, 0x3C, 0xF1, 0xE7, 0x8E, 0x38, 0x71, 0xC0, 0x1C, 0x78, 0xE3,
  0x83, 0x38, 0x1D, 0xC0, 0xFC, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80,
  0xFC, 0x07, 0x60, 0x73, 0x87, 0x1C, 0x38, 0xE0, 0xE3, 0xF8, 0xEE, 0x73,
  0x9C, 0x6E, 0x1B, 0x87, 0xC1, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x00, 0x3F, 0xE7, 0xFC, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0F, 0xF9, 0xFF, 0x00, 0x1C, 0xF3,
  0x8E, 0x38, 0xE3, 0x0C, 0x71, 0xC7, 0x1C, 0x61, 0x8E, 0x38, 0xE3, 0x8F,
  0x38, 0xCC, 0xEE, 0xEE, 0x66, 0x67, 0x77, 0x73, 0x30, 0x1E, 0x38, 0x30,
  0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x70,
  0xE3, 0xC7, 0x80, 0x18, 0xE3, 0xDB, 0x6F, 0xBC, 0xC0, 0xFE, 0xFE, 0xE7,
  0x30, 0x1E, 0x3F, 0x73, 0x03, 0x3F, 0x7F, 0xE7, 0xE7, 0xE7, 0x7E, 0x77,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x71, 0xFD, 0xCE, 0xE7, 0x73, 0xB9, 0xD8,
  0xEC, 0x7F, 0x77, 0xFB, 0xF8, 0x1E, 0x1F, 0x9C, 0xCE, 0x76, 0x03, 0x03,
  0x81, 0xCE, 0x67, 0x3F, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x1D,
  0x8F, 0xE7, 0x39, 0xCE, 0x63, 0x98, 0xEE, 0x33, 0x8C, 0x67, 0x1F, 0xC3,
  0xF0, 0x1E, 0x1F, 0x9C, 0xEE, 0x77, 0xFB, 0xFD, 0x80, 0xC0, 0x72, 0x3F,
  0x8F, 0x80, 0x1E, 0x7C, 0xE1, 0x8F, 0xDF, 0x1C, 0x38, 0x60, 0xC3, 0x87,
  0x0E, 0x1C, 0x30, 0x00, 0x1D, 0xCF, 0xE7, 0x39, 0xCE, 0x63, 0x98, 0xEE,
  0x3B, 0x8C, 0x77, 0x1F, 0xC3, 0xF0, 0x1C, 0x4E, 0x3F, 0x87, 0x80, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x71, 0xF9, 0xCE, 0xE7, 0x73, 0xB9, 0x98, 0xDC,
  0xEE, 0x77, 0x3B, 0x9C, 0x19, 0xC6, 0x03, 0x98, 0xCE, 0x73, 0x9C, 0xC6,
  0x73, 0x80, 0x06, 0x1C, 0x18, 0x00, 0xE1, 0x83, 0x0E, 0x1C, 0x38, 0x70,
  0xC3, 0x87, 0x0E, 0x1C, 0x71, 0xE3, 0x80, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x33, 0xCC, 0xE7, 0x71, 0xF8, 0x7C, 0x1F, 0x07, 0xE1, 0xB8, 0xE6, 0x39,
  0xCE, 0x70, 0x19, 0xCE, 0x73, 0x98, 0xCE, 0x73, 0x9C, 0xC6, 0x73, 0x80,
  0x37, 0x78, 0xFF, 0xE7, 0x39, 0xDC, 0xE7, 0x73, 0x99, 0xCC, 0x66, 0x33,
  0x99, 0xCE, 0xE7, 0x3B, 0x9C, 0xEE, 0x73, 0x00, 0x37, 0x3F, 0xDC, 0xEE,
  0x77, 0x3B, 0x99, 0x8D, 0xCE, 0xE7, 0x73, 0xB9, 0xC0, 0x1E, 0x1F, 0x9C,
  0xEE, 0x76, 0x3B, 0x1F, 0x8E, 0xC6, 0x77, 0x3F, 0x0F, 0x00, 0x1B, 0x87,
  0xF3, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x1C, 0xC7, 0x7B, 0x9F, 0xE7, 0xF1,
  0xC0, 0x60, 0x18, 0x0E, 0x00, 0x1D, 0x9F, 0xDC, 0xEE, 0x76, 0x3B, 0x1F,
  0x8D, 0xCE, 0x67, 0x3F, 0x8F, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x36, 0x7D,
  0xFB, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x80, 0x1E, 0x3F, 0x73, 0x70,
  0x78, 0x3E, 0x0E, 0x07, 0xE7, 0x7E, 0x3C, 0x33, 0xBF, 0xF7, 0x31, 0x9C,
  0xE7, 0x39, 0xE7, 0x00, 0x63, 0xE7, 0xE7, 0xE7, 0xE7, 0xE7, 0xC6, 0xCE,
  0xCE, 0xFE, 0x7E, 0xE7, 0xE7, 0xE6, 0xEE, 0xEC, 0x7C, 0x7C, 0x78, 0x78,
  0x70, 0x70, 0xE6, 0x7E, 0xE6, 0xEE, 0xEE, 0xEE, 0xFE, 0xCF, 0xFC, 0xF7,
  0x8F, 0x78, 0xF7, 0x8E, 0x30, 0xE3, 0x00, 0x39, 0xC6, 0x61, 0xB8, 0x7C,
  0x1F, 0x03, 0x81, 0xE0, 0xFC, 0x3F, 0x1C, 0xC7, 0x30, 0x39, 0xCE, 0x73,
  0xB8, 0xEE, 0x3B, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0, 0x60,
  0x38, 0x1C, 0x06, 0x00, 0x3F, 0xBF, 0xC1, 0xC1, 0xC0, 0xC0, 0xE0, 0xE0,
  0xE0, 0x60, 0x7F, 0x3F, 0x80, 0x04, 0x1C, 0x70, 0xC1, 0x83, 0x0E, 0x1C,
  0x30, 0xC3, 0x83, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC0, 0xC0, 0x80, 0x18,
  0x84, 0x63, 0x18, 0xC4, 0x23, 0x18, 0xC6, 0x31, 0x08, 0xC0, 0x10, 0x61,
  0xC7, 0x1C, 0x71, 0xC6, 0x1C, 0x31, 0xC6, 0x38, 0xC3, 0x0C, 0x31, 0xCE,
  0x10, 0x71, 0xFC, 0xF7, 0xD8, 0xE0,
};

const GFXglyph RobotoCondensed_BoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 14, 5, 0, -14 },
  { 10, 6, 5, 6, 1, -15 },
  { 14, 10, 14, 10, 0, -14 },
  { 32, 9, 18, 10, 1, -16 },
  { 53, 9, 14, 12, 2, -14 },
  { 69, 10, 14, 11, 0, -14 },
  { 87, 3, 5, 3, 1, -15 },
  { 89, 6, 20, 6, 1, -16 },
  { 104, 6, 20, 6, -1, -16 },
  { 119, 8, 9, 9, 1, -14 },
  { 128, 8, 11, 9, 1, -12 },
  { 139, 4, 6, 5, -1, -2 },
  { 142, 5, 2, 7, 1, -7 },
  { 144, 4, 3, 6, 0, -3 },
  { 146, 9, 15, 6, -1, -14 },
  { 163, 8, 14, 10, 1, -14 },
  { 177, 6, 14, 10, 2, -14 },
  { 188, 10, 14, 10, 0, -14 },
  { 206, 10, 14, 10, 0, -14 },
  { 224, 9, 14, 10, 0, -14 },
  { 240, 9, 14, 10, 1, -14 },
  { 256, 8, 14, 10, 1, -14 },
  { 270, 9, 14, 10, 1, -14 },
  { 286, 9, 14, 10, 1, -14 },
  { 302, 8, 14, 10, 1, -14 },
  { 316, 5, 11, 5, 0, -11 },
  { 323, 6, 15, 5, -1, -11 },
  { 335, 8, 10, 9, 0, -11 },
  { 345, 8, 6, 10, 1, -9 },
  { 351, 8, 10, 9, 0, -11 },
  { 361, 8, 14, 9, 1, -14 },
  { 375, 14, 18, 15, 0, -14 },
  { 407, 11, 14, 12, -1, -14 },
  { 427, 11, 14, 11, 0, -14 },
  { 447, 10, 14, 11, 1, -14 },
  { 465, 11, 14, 11, 0, -14 },
  { 485, 10, 14, 10, 0, -14 },
  { 503, 10, 14, 9, 0, -14 },
  { 521, 10, 14, 11, 1, -14 },
  { 539, 12, 14, 12, 0, -14 },
  { 560, 5, 14, 5, 0, -14 },
  { 569, 10, 14, 10, 0, -14 },
  { 587, 12, 14, 11, 0, -14 },
  { 608, 8, 14, 9, 0, -14 },
  { 622, 15, 14, 15, 0, -14 },
  { 649, 12, 14, 12, 0, -14 },
  { 670, 10, 14, 12, 1, -14 },
  { 688, 11, 14, 11, 0, -14 },
  { 708, 10, 17, 12, 1, -14 },
  { 730, 11, 14, 11, 0, -14 },
  { 750, 11, 14, 10, 0, -14 },
  { 770, 10, 14, 11, 2, -14 },
  { 788, 11, 14, 11, 1, -14 },
  { 808, 10, 14, 11, 2, -14 },
  { 826, 13, 14, 15, 2, -14 },
  { 849, 13, 14, 11, -1, -14 },
  { 872, 10, 14, 11, 2, -14 },
  { 890, 11, 14, 10, 0, -14 },
  { 910, 6, 20, 5, 0, -17 },
  { 925, 4, 15, 7, 2, -14 },
  { 933, 7, 20, 5, -1, -17 },
  { 951, 6, 7, 8, 1, -14 },
  { 957, 8, 2, 8, -1, 0 },
  { 959, 4, 3, 6, 2, -15 },
  { 961, 8, 11, 9, 0, -11 },
  { 972, 9, 15, 10, 0, -15 },
  { 989, 9, 11, 9, 0, -11 },
  { 1002, 10, 15, 10, 0, -15 },
  { 1021, 9, 11, 9, 0, -11 },
  { 1034, 7, 15, 6, 1, -15 },
  { 1048, 10, 15, 10, 0, -11 },
  { 1067, 9, 15, 10, 0, -15 },
  { 1084, 5, 15, 5, 0, -15 },
  { 1094, 7, 19, 5, -2, -15 },
  { 1111, 10, 15, 9, 0, -15 },
  { 1130, 5, 15, 5, 0, -15 },
  { 1140, 14, 11, 14, 0, -11 },
  { 1160, 9, 11, 10, 0, -11 },
  { 1173, 9, 11, 10, 0, -11 },
  { 1186, 10, 15, 10, -1, -11 },
  { 1205, 9, 15, 10, 0, -11 },
  { 1222, 7, 11, 6, 0, -11 },
  { 1232, 8, 11, 9, 0, -11 },
  { 1243, 5, 13, 6, 1, -13 },
  { 1252, 8, 11, 10, 1, -11 },
  { 1263, 8, 11, 9, 1, -11 },
  { 1274, 12, 11, 12, 1, -11 },
  { 1291, 10, 11, 9, -1, -11 },
  { 1305, 10, 15, 9, -1, -11 },
  { 1324, 9, 11, 9, 0, -11 },
  { 1337, 7, 20, 6, 0, -16 },
  { 1355, 5, 17, 5, 0, -14 },
  { 1366, 6, 20, 6, -1, -16 },
  { 1381, 9, 4, 11, 1, -8 },
};

const GFXfont RobotoCondensed_BoldItalic20pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic20pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic20pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _ROBOTOCONDENSED_BOLDITALIC20PT7B_H_
