#ifndef _ROBOTOCONDENSED_BOLDITALIC29PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C,
  0x3C, 0x3C, 0x38, 0x38, 0x00, 0x00, 0x70, 0x78, 0x78, 0x70, 0x77, 0x77,
  0x67, 0xE7, 0xE6, 0xE6, 0xCE, 0xCE, 0x01, 0x98, 0x0E, 0x60, 0x33, 0x80,
  0xCC, 0x07, 0x30, 0x1D, 0xC3, 0xFF, 0xCF, 0xFF, 0x0E, 0xE0, 0x33, 0x81,
  0xCC, 0x07, 0x70, 0x19, 0xC3, 0xFF, 0xCF, 0xFF, 0x0C, 0xE0, 0x33, 0x01,
  0xCC, 0x06, 0x70, 0x19, 0x80, 0xE6, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0x7B, 0xC7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3C, 0x01, 0xE7, 0x87,
  0x3C, 0x39, 0xE3, 0xCF, 0xBE, 0x3F, 0xE0, 0xFE, 0x03, 0xE0, 0x0C, 0x00,
  0x60, 0x07, 0x00, 0x3C, 0x03, 0xF0, 0x3B, 0x81, 0xCC, 0x7C, 0x67, 0x63,
  0x33, 0x3B, 0x1D, 0xF8, 0xFF, 0x83, 0xD8, 0x01, 0xC0, 0x1D, 0xC0, 0xDF,
  0x0F, 0xDC, 0xEC, 0x66, 0x63, 0x77, 0x3F, 0x39, 0xD0, 0xEE, 0x07, 0xE0,
  0x1E, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7B, 0xC0, 0xE3, 0x83,
  0xCF, 0x07, 0x9C, 0x07, 0x78, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x01, 0xFC,
  0x73, 0xFD, 0xEF, 0x7B, 0x9E, 0x7F, 0x3C, 0xFE, 0x78, 0xF8, 0xF3, 0xF1,
  0xFF, 0xE1, 0xFF, 0xE1, 0xF3, 0xC0, 0x77, 0x6E, 0xEE, 0xEC, 0x00, 0x81,
  0xC1, 0xE0, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x1C, 0x1E, 0x0E, 0x07,
  0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0,
  0xE0, 0x70, 0x18, 0x0E, 0x03, 0x00, 0x80, 0x08, 0x06, 0x03, 0x80, 0xC0,
  0x70, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0E, 0x07, 0x03, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x38,
  0x3C, 0x1C, 0x08, 0x00, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x07, 0x37,
  0x3F, 0xFC, 0xFF, 0xC1, 0xE0, 0x1F, 0x81, 0xFC, 0x1E, 0x70, 0xE3, 0x80,
  0x08, 0x00, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x71, 0xCF, 0x3C, 0xE7, 0x9C, 0x20, 0x7F, 0x7E, 0x7E,
  0xFF, 0xFE, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x7D, 0xE3, 0xC7,
  0x9C, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC7, 0x9E, 0x3D, 0xE1, 0xEF,
  0x0F, 0x78, 0x7B, 0xC3, 0x9E, 0x3C, 0xF1, 0xE3, 0xDE, 0x1F, 0xF0, 0x7F,
  0x01, 0xF0, 0x00, 0x01, 0x83, 0xCF, 0xCF, 0xEF, 0xF7, 0x78, 0x3C, 0x1E,
  0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0x80, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x87, 0x9E, 0x1C, 0x3C,
  0xF0, 0xF3, 0xC3, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xFF,
  0x3F, 0xFC, 0xFF, 0xF0, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x87, 0xDE, 0x3E,
  0x3C, 0xF0, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x1F, 0xC0, 0x7C, 0x01,
  0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x3C, 0x3C, 0x70, 0xF1, 0xF7, 0xC7,
  0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7E,
  0x01, 0xF8, 0x0F, 0xE0, 0x77, 0x81, 0xFC, 0x0E, 0xF0, 0x7B, 0xC3, 0xCF,
  0x0E, 0x3C, 0x78, 0xF1, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x70, 0x7F, 0xE3, 0xFF, 0x0E, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xDE, 0x1C, 0xF1, 0xE7, 0xDF, 0x1F,
  0xF0, 0xFF, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x3E, 0x0F, 0xE0, 0xFC, 0x1E,
  0x03, 0xC0, 0x3C, 0x07, 0xBC, 0x7F, 0xE7, 0xFE, 0x7D, 0xFF, 0x8F, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF1, 0xE7, 0xBE, 0x7F, 0xC3, 0xF8, 0x1F,
  0x00, 0x3F, 0xFC, 0xFF, 0xF7, 0xFF, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x7D, 0xE3, 0xC7, 0x9E, 0x3C,
  0xF1, 0xE7, 0x9E, 0x3C, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x87, 0x9E, 0x78,
  0xF3, 0xC3, 0x9E, 0x3C, 0xF1, 0xE7, 0xDF, 0x3F, 0xF0, 0xFF, 0x01, 0xF0,
  0x00, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0xDE, 0x78, 0xEF, 0x0E, 0xF0, 0xEF,
  0x0E, 0xF1, 0xEF, 0x1E, 0xF3, 0xE7, 0xFE, 0x7F, 0xE3, 0xDC, 0x03, 0xC0,
  0x38, 0x07, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0x70, 0x00, 0x3C, 0xF3, 0xCE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCF, 0x38, 0x0F, 0x1F, 0x1F,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3C,
  0x38, 0x38, 0x78, 0x78, 0xF0, 0xE0, 0x40, 0x00, 0x20, 0x1C, 0x0F, 0x87,
  0xF3, 0xFD, 0xFC, 0x3E, 0x07, 0x80, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xC0,
  0x38, 0x01, 0x00, 0x3F, 0xF7, 0xFF, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xEF, 0xFE, 0xFF, 0xE0, 0x20, 0x07, 0x01, 0xF0, 0x3F, 0x83, 0xFC,
  0x0F, 0xC0, 0x78, 0x3F, 0x1F, 0xEF, 0xF3, 0xF8, 0x7C, 0x0E, 0x01, 0x00,
  0x00, 0x1F, 0x07, 0xF9, 0xFF, 0x3D, 0xFF, 0x1F, 0xE3, 0xC0, 0xF0, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00,
  0xF8, 0xF8, 0x0F, 0x01, 0xC0, 0x70, 0x07, 0x07, 0x00, 0x18, 0x70, 0xF0,
  0xC3, 0x0F, 0xE6, 0x38, 0xF7, 0x31, 0xCE, 0x31, 0xDC, 0x71, 0x8C, 0xE7,
  0x1C, 0x67, 0x38, 0xE3, 0x31, 0xC7, 0x19, 0x8E, 0x31, 0xCC, 0x73, 0x8C,
  0xE3, 0x9C, 0x63, 0x1F, 0xE6, 0x18, 0xFB, 0xF0, 0xC3, 0x9E, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xEE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xDC, 0x03, 0xDC, 0x03, 0x9C, 0x07, 0x9E, 0x07,
  0x9E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x1E, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x7C, 0x0F, 0x78, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0x0F, 0xF0, 0x3F,
  0xF8, 0x7F, 0xF8, 0xF1, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x9E, 0x0F,
  0x3C, 0x3C, 0x7F, 0xF8, 0xFF, 0xC1, 0xFF, 0xC3, 0xC3, 0xCF, 0x07, 0x9E,
  0x0F, 0x3C, 0x1E, 0x78, 0x7C, 0xF1, 0xF1, 0xFF, 0xE7, 0xFF, 0x8F, 0xFC,
  0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFB, 0xF3, 0xC1, 0xE7, 0x83,
  0xDE, 0x07, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x0F, 0x78, 0x3C, 0xF0, 0x78, 0xFB, 0xF1, 0xFF,
  0xC1, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF0, 0xF3,
  0xE1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x9F, 0x0F, 0x3C, 0x1E, 0x78, 0x3C,
  0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xEF, 0x07, 0x9E, 0x0F, 0x3C, 0x1E, 0x78,
  0x78, 0xF3, 0xF1, 0xFF, 0xC7, 0xFF, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x3F,
  0xFC, 0x7F, 0xF8, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFF, 0xC7, 0xFF, 0x8F, 0xFF,
  0x00, 0x0F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF0, 0xFB,
  0xF3, 0xC1, 0xE7, 0x83, 0xDE, 0x07, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE3, 0xFF, 0xCF, 0xEF, 0x1F, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0x78,
  0x7C, 0xFB, 0xF1, 0xFF, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0x03, 0xC7,
  0xC1, 0xF1, 0xE0, 0x78, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0x78, 0xF8, 0x3C, 0x3C, 0x0F, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3C, 0x0F, 0x1E, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E,
  0x07, 0x87, 0x81, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x00, 0x0F, 0x0F, 0x1F,
  0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x78,
  0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x3C, 0x3C, 0xF1, 0xE3,
  0xEF, 0x87, 0xFC, 0x1F, 0xE0, 0x1F, 0x00, 0x0F, 0x0F, 0x87, 0xC3, 0xE1,
  0xE1, 0xF0, 0x78, 0xF8, 0x1E, 0x7C, 0x07, 0x9E, 0x01, 0xEF, 0x80, 0xFF,
  0xC0, 0x3D, 0xE0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x1F, 0xFC, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0x78, 0xF8, 0x1E, 0x1E, 0x07,
  0x87, 0x83, 0xC1, 0xF0, 0xF0, 0x7C, 0x00, 0x0F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x87,
  0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xE1, 0xF8, 0x3F, 0x8F, 0xF1,
  0xFE, 0x3D, 0xC7, 0x70, 0xF7, 0x3F, 0xC3, 0xDC, 0xEF, 0x0F, 0x73, 0xBC,
  0x3D, 0xDC, 0xF1, 0xE7, 0x73, 0xC7, 0x9F, 0xDE, 0x1E, 0x7E, 0x78, 0x79,
  0xF9, 0xE1, 0xE7, 0xC7, 0x87, 0x8F, 0x1E, 0x3C, 0x38, 0xF0, 0xF0, 0xE3,
  0xC0, 0x0F, 0x03, 0xC7, 0xC1, 0xE1, 0xF0, 0x78, 0x7E, 0x1E, 0x1F, 0x87,
  0x87, 0xE1, 0xE1, 0xF8, 0x78, 0xFF, 0x3C, 0x3D, 0xCF, 0x0F, 0x73, 0xC3,
  0xDC, 0xF0, 0xF3, 0xBC, 0x3C, 0xEF, 0x1E, 0x3F, 0x87, 0x87, 0xE1, 0xE1,
  0xF8, 0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x83, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C,
  0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFB, 0xF3, 0xE1, 0xE7, 0x83,
  0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0x78, 0x78, 0xF9, 0xF1, 0xFF,
  0xC1, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1E,
  0x3E, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x3C,
  0x1E, 0x3C, 0x7E, 0x3F, 0xFC, 0x3F, 0xF8, 0x7F, 0xE0, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03,
  0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFB, 0xF3, 0xC1, 0xE7, 0x83, 0xDE, 0x07,
  0xBC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xFE,
  0x07, 0xBC, 0x0F, 0x78, 0x1E, 0x78, 0x78, 0xFB, 0xF1, 0xFF, 0xC1, 0xFF,
  0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x20, 0x0F, 0xF0,
  0x1F, 0xFC, 0x1F, 0xFE, 0x1E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x7C, 0x3F, 0xFC, 0x3F, 0xF0, 0x3F, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF8, 0x78, 0x78, 0x78, 0x78,
  0xF0, 0x78, 0xF0, 0x7C, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0xDF, 0x3C,
  0x3C, 0xF0, 0xF3, 0xC0, 0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xF0, 0x03, 0xCF, 0x07, 0xBC, 0x1E, 0xF0, 0xF3, 0xFF, 0xC7,
  0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0x7F, 0xFE, 0xFF, 0xFB, 0xFF, 0xF0, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3E, 0x0F, 0x3C,
  0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0x78,
  0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xFD, 0xF0, 0x7F, 0xF0, 0x3F,
  0xE0, 0x1F, 0x80, 0xF8, 0x1F, 0xF8, 0x1E, 0x78, 0x3E, 0x78, 0x3C, 0x78,
  0x3C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x79,
  0xE0, 0x39, 0xE0, 0x39, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0xF0, 0xE1, 0xFE,
  0x3C, 0x3F, 0x87, 0x87, 0xF0, 0xF1, 0xEE, 0x3E, 0x3D, 0xC7, 0xC7, 0xB8,
  0xF9, 0xE7, 0x3F, 0x3C, 0xE7, 0xE7, 0x9C, 0xFC, 0xE3, 0xBF, 0xBC, 0x77,
  0x77, 0x8E, 0xEE, 0xE1, 0xFD, 0xFC, 0x3F, 0x3F, 0x87, 0xE7, 0xE0, 0xF8,
  0xFC, 0x1F, 0x1F, 0x83, 0xE1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x80, 0x0F,
  0x07, 0xC3, 0xC1, 0xE0, 0xF8, 0xF8, 0x1E, 0x3C, 0x07, 0x9E, 0x01, 0xEF,
  0x80, 0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0x7D, 0xE0, 0x1E,
  0x7C, 0x0F, 0x8F, 0x03, 0xC3, 0xC1, 0xF0, 0xF0, 0xF8, 0x3E, 0x00, 0x78,
  0x3E, 0xF0, 0x79, 0xE1, 0xF3, 0xC3, 0xC7, 0x8F, 0x87, 0x1E, 0x0F, 0x7C,
  0x1E, 0xF0, 0x3D, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x07, 0xC1, 0xF0,
  0x7C, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0xF0, 0xE1,
  0xC3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x1C, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x80, 0x07, 0xC1, 0xF0, 0xFC, 0x0F,
  0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1C, 0x0F, 0x07, 0xC1, 0xF0, 0xFC, 0x00, 0x07, 0x03, 0xC0, 0xF0,
  0x7E, 0x1F, 0x8E, 0xE3, 0xB9, 0xCE, 0x71, 0xB8, 0x70, 0x7F, 0xE7, 0xFE,
  0xFF, 0xE0, 0xF1, 0xE3, 0x87, 0x07, 0xC1, 0xFE, 0x1F, 0xF3, 0xCF, 0x3C,
  0xF0, 0x0F, 0x0F, 0xF3, 0xFF, 0x7C, 0xF7, 0x8E, 0xF1, 0xEF, 0x1E, 0xFB,
  0xE7, 0xFE, 0x7F, 0xE3, 0xDE, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x7F, 0x87, 0xFE, 0x3F, 0xF9, 0xF7, 0xCF, 0x1E, 0x78,
  0xF3, 0x87, 0xBC, 0x3D, 0xE1, 0xEF, 0x0F, 0x78, 0x73, 0xC7, 0x9E, 0x7D,
  0xFF, 0xCF, 0xFE, 0x7B, 0xC0, 0x0F, 0x83, 0xF8, 0xFF, 0xBC, 0xF7, 0x0F,
  0xE1, 0xFC, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x87, 0x78, 0xEF, 0x3D, 0xFF,
  0x1F, 0xE1, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE1, 0xE7, 0x8F, 0xDE, 0x7F, 0xF1, 0xE7, 0xCF, 0x0F, 0x3C, 0x3C,
  0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x3C, 0x78, 0xE1, 0xE3, 0xC7, 0x8F, 0xBE,
  0x3F, 0xF0, 0x7F, 0xC0, 0xF7, 0x00, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0xDE,
  0x78, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x00, 0xF0, 0x0F, 0x00,
  0xF9, 0xC7, 0xFC, 0x7F, 0xC1, 0xF0, 0x03, 0xC3, 0xF0, 0xFC, 0x7C, 0x1E,
  0x07, 0x87, 0xFB, 0xFC, 0xFF, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x07, 0xBC,
  0x7F, 0xF3, 0xFF, 0xCF, 0xBE, 0x7C, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E,
  0x78, 0x79, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x7D, 0xF1, 0xFF, 0xC3, 0xFF,
  0x07, 0xF8, 0x01, 0xE0, 0x07, 0x86, 0x3E, 0x3F, 0xF0, 0xFF, 0x80, 0xF8,
  0x00, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x77,
  0x87, 0xFE, 0x3F, 0xF1, 0xF7, 0xCF, 0x1E, 0x78, 0xF7, 0x87, 0xBC, 0x79,
  0xE3, 0xCF, 0x1E, 0x78, 0xF3, 0xC7, 0xBC, 0x3D, 0xE1, 0xCF, 0x1E, 0x78,
  0xF0, 0x0E, 0x1E, 0x1E, 0x0E, 0x00, 0x00, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0x01,
  0xC0, 0xF0, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x0E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x3F, 0x0F, 0x83, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC7, 0xCF, 0x3E,
  0x3C, 0xF0, 0xF7, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xF0, 0x7B, 0xC1, 0xEF, 0x07, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC3,
  0xC0, 0x0F, 0x0F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x38, 0x78, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0x1D,
  0xE3, 0xC3, 0xFF, 0x7E, 0x3F, 0xFF, 0xE3, 0xEF, 0xDF, 0x3C, 0x78, 0xF3,
  0xC7, 0x8F, 0x38, 0x70, 0xF7, 0x8F, 0x1E, 0x78, 0xF1, 0xE7, 0x8F, 0x1E,
  0x78, 0xF1, 0xE7, 0x8F, 0x1E, 0x70, 0xE1, 0xEF, 0x1E, 0x3C, 0xF1, 0xE3,
  0xCF, 0x1E, 0x3C, 0x3D, 0xE1, 0xFF, 0x8F, 0xFC, 0x7D, 0xF3, 0xC7, 0x9E,
  0x3D, 0xE1, 0xEF, 0x1E, 0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0xF1, 0xEF, 0x0F,
  0x78, 0x73, 0xC7, 0x9E, 0x3C, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0xDF, 0x78,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xEF, 0x1E, 0xF3,
  0xE7, 0xFC, 0x7F, 0x83, 0xF0, 0x0E, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xDF,
  0x1E, 0x3C, 0x78, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3,
  0x8F, 0x1E, 0x7C, 0xF9, 0xFF, 0xC7, 0xFF, 0x1E, 0xF0, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x79, 0xFB, 0x9F,
  0xFC, 0xF3, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xDE, 0x1C, 0xF1, 0xE7, 0x8F,
  0x38, 0x79, 0xE3, 0xCF, 0xBE, 0x7F, 0xE1, 0xFF, 0x07, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1D, 0xCF, 0xF3, 0xFC,
  0xFE, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70,
  0x3C, 0x0F, 0x03, 0xC0, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0xCF, 0x38, 0xF3,
  0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xEF, 0x1E, 0xF1, 0xE7,
  0xFC, 0x7F, 0xC1, 0xF0, 0x1E, 0x1E, 0x3C, 0xFF, 0xFF, 0xFF, 0x3C, 0x38,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xF8, 0xFC, 0x7C, 0x3C, 0x78,
  0x7B, 0xC3, 0x9E, 0x3C, 0xF1, 0xE7, 0x8F, 0x3C, 0x7B, 0xC3, 0xDE, 0x1C,
  0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xE3, 0xCF, 0x3E, 0x7F, 0xE1, 0xFF, 0x07,
  0xF8, 0x70, 0xF7, 0x0F, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0xBC, 0x7B, 0xC7,
  0xB8, 0x7F, 0x87, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x03,
  0xC0, 0xE3, 0x87, 0x71, 0xE7, 0xB8, 0xF3, 0xDC, 0xF9, 0xCE, 0x7D, 0xE7,
  0x7E, 0xF3, 0xBF, 0x71, 0xDF, 0xF8, 0xFD, 0xF8, 0x7E, 0xFC, 0x3F, 0x7E,
  0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0x8F, 0x83, 0xC7, 0x81, 0xE1, 0xC0, 0x1E,
  0x3C, 0x79, 0xF1, 0xE7, 0x83, 0xBC, 0x0F, 0xF0, 0x3F, 0x80, 0x7E, 0x01,
  0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xF8, 0x3D, 0xE1, 0xF7, 0x87,
  0x8F, 0x3E, 0x3C, 0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xE0, 0xF3, 0xC1, 0xE7,
  0x83, 0xDE, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x00, 0x3F, 0xF9, 0xFF,
  0x8F, 0xFC, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x7F, 0xF3, 0xFF, 0x1F, 0xF8, 0x01,
  0x03, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x07,
  0x87, 0x87, 0x83, 0x81, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x3C, 0x0E, 0x02, 0x00, 0x0E, 0x18, 0x30, 0x60, 0xC3,
  0x87, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x61, 0xC3,
  0x87, 0x0C, 0x18, 0x30, 0x60, 0x08, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0xE0, 0x78, 0x1C, 0x3E, 0x3C, 0x1C,
  0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x78, 0x38, 0x18,
  0x00, 0x3C, 0x1D, 0xFC, 0xE7, 0xFB, 0xBD, 0xFE, 0xE3, 0xF0, 0x07, 0x80,
};

const GFXglyph RobotoCondensed_BoldItalic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 8, 21, 7, 0, -21 },
  { 22, 8, 8, 9, 2, -22 },
  { 30, 14, 21, 15, 1, -21 },
  { 67, 13, 27, 14, 1, -24 },
  { 111, 13, 21, 18, 3, -21 },
  { 146, 15, 21, 16, 0, -21 },
  { 186, 4, 8, 5, 2, -22 },
  { 190, 9, 29, 9, 1, -23 },
  { 223, 9, 29, 9, -1, -23 },
  { 256, 13, 13, 13, 1, -21 },
  { 278, 12, 16, 13, 1, -18 },
  { 302, 6, 9, 7, -2, -3 },
  { 309, 8, 3, 10, 1, -10 },
  { 312, 4, 4, 8, 1, -4 },
  { 314, 13, 23, 9, -2, -21 },
  { 352, 13, 21, 14, 1, -21 },
  { 387, 9, 21, 14, 3, -21 },
  { 411, 14, 21, 14, 0, -21 },
  { 448, 14, 21, 14, 0, -21 },
  { 485, 14, 21, 14, 0, -21 },
  { 522, 13, 21, 14, 1, -21 },
  { 557, 12, 21, 14, 1, -21 },
  { 589, 14, 21, 14, 1, -21 },
  { 626, 13, 21, 14, 1, -21 },
  { 661, 12, 21, 14, 2, -21 },
  { 693, 6, 16, 8, 1, -16 },
  { 705, 8, 22, 7, -1, -16 },
  { 727, 11, 14, 13, 1, -16 },
  { 747, 12, 9, 14, 1, -14 },
  { 761, 11, 14, 13, 1, -16 },
  { 781, 11, 21, 13, 2, -21 },
  { 810, 21, 26, 22, 0, -20 },
  { 879, 16, 21, 17, -1, -21 },
  { 921, 15, 21, 16, 0, -21 },
  { 961, 15, 21, 16, 1, -21 },
  { 1001, 15, 21, 16, 0, -21 },
  { 1041, 15, 21, 14, 0, -21 },
  { 1081, 15, 21, 13, 0, -21 },
  { 1121, 15, 21, 16, 1, -21 },
  { 1161, 18, 21, 17, 0, -21 },
  { 1209, 8, 21, 8, 0, -21 },
  { 1230, 14, 21, 14, 0, -21 },
  { 1267, 18, 21, 16, 0, -21 },
  { 1315, 12, 21, 13, 0, -21 },
  { 1347, 22, 21, 21, 0, -21 },
  { 1405, 18, 21, 17, 0, -21 },
  { 1453, 15, 21, 17, 1, -21 },
  { 1493, 16, 21, 16, 0, -21 },
  { 1535, 15, 25, 17, 1, -21 },
  { 1582, 16, 21, 16, 0, -21 },
  { 1624, 14, 21, 15, 1, -21 },
  { 1661, 15, 21, 15, 2, -21 },
  { 1701, 16, 21, 16, 1, -21 },
  { 1743, 16, 21, 16, 2, -21 },
  { 1785, 19, 21, 21, 3, -21 },
  { 1835, 18, 21, 16, -1, -21 },
  { 1883, 15, 21, 15, 2, -21 },
  { 1923, 16, 21, 15, 0, -21 },
  { 1965, 10, 29, 7, -1, -24 },
  { 2002, 7, 23, 11, 2, -21 },
  { 2023, 10, 29, 7, -2, -24 },
  { 2060, 10, 10, 11, 1, -21 },
  { 2073, 12, 3, 11, -2, 0 },
  { 2078, 6, 4, 9, 3, -21 },
  { 2081, 12, 16, 13, 0, -16 },
  { 2105, 13, 22, 14, 0, -22 },
  { 2141, 11, 16, 13, 1, -16 },
  { 2163, 14, 22, 14, 1, -22 },
  { 2202, 12, 16, 13, 1, -16 },
  { 2226, 10, 22, 9, 1, -22 },
  { 2254, 14, 22, 14, 0, -16 },
  { 2293, 13, 22, 14, 0, -22 },
  { 2329, 8, 22, 7, 0, -22 },
  { 2351, 10, 28, 7, -3, -22 },
  { 2386, 14, 22, 13, 0, -22 },
  { 2425, 8, 22, 7, 0, -22 },
  { 2447, 20, 16, 21, 0, -16 },
  { 2487, 13, 16, 14, 0, -16 },
  { 2513, 12, 16, 14, 1, -16 },
  { 2537, 14, 22, 14, -1, -16 },
  { 2576, 13, 22, 14, 1, -16 },
  { 2612, 10, 16, 9, 0, -16 },
  { 2632, 12, 16, 13, 0, -16 },
  { 2656, 8, 19, 9, 1, -19 },
  { 2675, 13, 16, 14, 1, -16 },
  { 2701, 12, 16, 13, 1, -16 },
  { 2725, 17, 16, 18, 2, -16 },
  { 2759, 14, 16, 13, -1, -16 },
  { 2787, 15, 22, 13, -1, -16 },
  { 2829, 13, 16, 13, 0, -16 },
  { 2855, 9, 28, 8, 1, -23 },
  { 2887, 7, 25, 7, 0, -21 },
  { 2909, 9, 28, 8, -1, -23 },
  { 2941, 14, 6, 16, 1, -11 },
};

const GFXfont RobotoCondensed_BoldItalic29pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic29pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic29pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOCONDENSED_BOLDITALIC29PT7B_H_
