#ifndef _ROBOTOCONDENSED_BOLDITALIC25PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x70, 0xE1, 0xC7, 0x8E, 0x1C, 0x38, 0x70, 0xE1, 0x80,
  0x00, 0x18, 0x78, 0xF0, 0xC0, 0x77, 0x77, 0x76, 0x66, 0x66, 0x66, 0x6C,
  0x01, 0xB0, 0x19, 0x80, 0xCC, 0x06, 0xC0, 0x66, 0x1F, 0xFC, 0xFF, 0xE1,
  0x98, 0x0C, 0xC0, 0x6E, 0x07, 0x60, 0xFF, 0xC7, 0xFE, 0x1D, 0x80, 0xCC,
  0x06, 0xE0, 0x36, 0x03, 0x30, 0x00, 0x01, 0x00, 0x60, 0x0C, 0x07, 0xC1,
  0xFC, 0x7F, 0x8E, 0x79, 0xC7, 0x38, 0xE7, 0x00, 0xF0, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0xF7, 0x1E, 0xE3, 0xDC, 0x73, 0xFE, 0x3F, 0x83, 0xE0, 0x30,
  0x06, 0x00, 0x3C, 0x07, 0xC0, 0x6E, 0x6E, 0x66, 0xCE, 0xCE, 0xDC, 0x7D,
  0x87, 0xB0, 0x07, 0x00, 0x60, 0x0D, 0xE1, 0xBE, 0x1B, 0x33, 0x73, 0x67,
  0x36, 0x77, 0x03, 0xE0, 0x1C, 0x07, 0x80, 0x7E, 0x03, 0xF8, 0x39, 0xC1,
  0xCE, 0x0E, 0x70, 0x77, 0x03, 0xF0, 0x0F, 0x01, 0xF9, 0xDF, 0xCE, 0xEF,
  0xE7, 0x3F, 0x79, 0xF9, 0xC7, 0x8F, 0xFC, 0x7F, 0xF0, 0xF3, 0x80, 0x77,
  0x76, 0x66, 0x60, 0x02, 0x07, 0x0E, 0x0E, 0x1C, 0x18, 0x38, 0x30, 0x70,
  0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x60,
  0x60, 0x60, 0x30, 0x30, 0x10, 0x08, 0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C,
  0x1C, 0x38, 0x38, 0x70, 0xF0, 0xE0, 0x80, 0x07, 0x00, 0xC0, 0x18, 0x33,
  0x3F, 0xFE, 0x7F, 0x87, 0x81, 0xF0, 0x73, 0x0E, 0x70, 0x88, 0x00, 0x0F,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x3F, 0xFF, 0xFF, 0xFF, 0x1C, 0x07, 0x01,
  0xC0, 0xF0, 0x38, 0x00, 0x39, 0xDC, 0xE7, 0x73, 0x00, 0x7D, 0xFB, 0xF0,
  0xDF, 0xF0, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x0F, 0x83, 0xF8, 0xFF,
  0x1C, 0xF7, 0x8E, 0xE1, 0xDC, 0x7B, 0x8F, 0xF1, 0xFE, 0x3B, 0xC7, 0x70,
  0xEE, 0x1D, 0xC7, 0x38, 0xE3, 0xFC, 0x7F, 0x07, 0x80, 0x02, 0x3F, 0xFF,
  0xFF, 0xE3, 0x87, 0x0E, 0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x1E, 0x3C, 0x70,
  0xE0, 0x07, 0xC0, 0xFE, 0x1F, 0xE3, 0xCF, 0x38, 0xF3, 0x8F, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0xFE, 0xFF, 0xCF, 0xFC, 0x07, 0x81, 0xFE, 0x1F, 0xE3, 0xCF, 0x38, 0xF0,
  0x0F, 0x00, 0xE0, 0x7E, 0x0F, 0x80, 0xFC, 0x01, 0xC0, 0x1E, 0x01, 0xEF,
  0x1E, 0x71, 0xC7, 0xFC, 0x7F, 0x81, 0xE0, 0x00, 0xF0, 0x1F, 0x01, 0xE0,
  0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0xE1, 0xDC, 0x1D, 0xC3, 0x9C, 0x71, 0xC7,
  0xFE, 0xFF, 0xEF, 0xFE, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x1F, 0xE3,
  0xFC, 0xFF, 0x9C, 0x03, 0x80, 0x70, 0x1D, 0xC3, 0xFC, 0x7F, 0xC0, 0x78,
  0x07, 0x00, 0xE0, 0x1D, 0xC7, 0xB8, 0xE7, 0xFC, 0x7F, 0x07, 0xC0, 0x03,
  0xC1, 0xF1, 0xF8, 0x78, 0x3C, 0x1E, 0x07, 0x71, 0xFE, 0xFF, 0xFC, 0x7F,
  0x1F, 0x87, 0xE1, 0xF8, 0xFF, 0x39, 0xFE, 0x7F, 0x0F, 0x80, 0x7F, 0xF7,
  0xFF, 0x7F, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x9C, 0xF7, 0x9E, 0xF3, 0xCE, 0x71, 0xFE,
  0x1F, 0x8F, 0xF3, 0xCE, 0x71, 0xEE, 0x3D, 0xC7, 0xB8, 0xE7, 0xFC, 0x7F,
  0x07, 0xC0, 0x1E, 0x0F, 0xC7, 0xFB, 0xCE, 0xE3, 0xB8, 0xFE, 0x3F, 0x8E,
  0xE3, 0xBF, 0xE7, 0xF8, 0xFE, 0x07, 0x03, 0xC1, 0xE3, 0xF0, 0xF8, 0x38,
  0x00, 0x33, 0xDE, 0x70, 0x00, 0x00, 0x00, 0x39, 0xCE, 0x70, 0x0C, 0x3C,
  0x78, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x87, 0x1C, 0x38,
  0xE0, 0x80, 0x00, 0x81, 0xC3, 0xE7, 0xFF, 0xE7, 0x83, 0xC1, 0xF8, 0x7F,
  0x0F, 0x81, 0xC0, 0x40, 0x7F, 0xDF, 0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xEF,
  0xFB, 0xFE, 0x20, 0x0E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x70, 0xFC, 0xFE,
  0x7C, 0x1C, 0x04, 0x00, 0x3E, 0x3F, 0xBF, 0xFE, 0xFE, 0x78, 0x3C, 0x1C,
  0x1E, 0x1E, 0x1C, 0x0E, 0x0E, 0x00, 0x00, 0x01, 0x81, 0xE0, 0xF0, 0x30,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x78, 0x70, 0x38, 0x06, 0x0C, 0x01,
  0x86, 0x1C, 0x63, 0x9F, 0xCC, 0xC6, 0x63, 0x33, 0x98, 0xD8, 0xC6, 0x36,
  0x73, 0x99, 0x9C, 0xE6, 0x66, 0x31, 0xB9, 0x9C, 0x6E, 0x77, 0x33, 0x9F,
  0xF8, 0x63, 0x9C, 0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x60,
  0x07, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xDE, 0x0F, 0x38, 0x38, 0xE1, 0xE3,
  0x87, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0x83, 0x9E, 0x0F, 0x70, 0x3F, 0xC0,
  0xF0, 0x1F, 0xE0, 0xFF, 0x87, 0xFE, 0x38, 0xF3, 0xC3, 0x9E, 0x3C, 0xF1,
  0xE7, 0xFE, 0x3F, 0xE1, 0xFF, 0x1E, 0x3C, 0xF0, 0xE7, 0x87, 0x38, 0x79,
  0xC3, 0xCF, 0xFC, 0xFF, 0xC7, 0xFC, 0x00, 0x07, 0xC0, 0xFF, 0x87, 0xFC,
  0x78, 0xF7, 0x87, 0xB8, 0x3D, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x0F, 0x78, 0x73, 0xC7, 0x8F, 0xF8, 0x7F, 0x80, 0xF8,
  0x00, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x38, 0xF3, 0xC3, 0x9E, 0x1C, 0xF0,
  0xE7, 0x07, 0x38, 0x79, 0xC3, 0xDE, 0x1E, 0xF0, 0xE7, 0x87, 0x38, 0x79,
  0xC7, 0x8F, 0xF8, 0xFF, 0x87, 0xF8, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xFC, 0x3F, 0xE1, 0xFE, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x00, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x3F, 0xE1, 0xFF, 0x1F, 0xF0, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x07, 0xC0, 0xFF, 0x87, 0xFC,
  0x78, 0xF7, 0x87, 0xBC, 0x1D, 0xC0, 0x0E, 0x00, 0xF3, 0xF7, 0x9F, 0xBC,
  0xFD, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3, 0xCF, 0xFC, 0x3F, 0xE0, 0xFC,
  0x00, 0x1E, 0x0E, 0x38, 0x1C, 0x70, 0x78, 0xE0, 0xF3, 0xC1, 0xE7, 0x83,
  0x8F, 0x07, 0x1F, 0xFE, 0x3F, 0xFC, 0x7F, 0xF9, 0xE0, 0xE3, 0xC1, 0xC7,
  0x83, 0x8E, 0x07, 0x1C, 0x1E, 0x38, 0x3C, 0xF0, 0x71, 0xE0, 0xE0, 0x1E,
  0x3C, 0x70, 0xE1, 0xC7, 0x8F, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x8F, 0x1C,
  0x38, 0x71, 0xE0, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0xF1, 0xCF, 0x3C,
  0xF3, 0xC7, 0xF8, 0x7F, 0x03, 0xE0, 0x1E, 0x1E, 0x38, 0x78, 0x71, 0xE0,
  0xE7, 0xC3, 0xCF, 0x07, 0xBC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F,
  0x01, 0xFF, 0x03, 0xFE, 0x07, 0x9C, 0x0E, 0x3C, 0x1C, 0x78, 0x38, 0x70,
  0xF0, 0xF1, 0xE1, 0xE0, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x0F, 0x83,
  0xE3, 0xF0, 0xFC, 0x7E, 0x1F, 0x8E, 0xC7, 0xF1, 0xD8, 0xFE, 0x3B, 0x1B,
  0x87, 0x67, 0x71, 0xEE, 0xEE, 0x3D, 0xFB, 0xC7, 0xBF, 0x78, 0xE7, 0xCE,
  0x1C, 0xF9, 0xC3, 0x8E, 0x38, 0xF1, 0xCF, 0x1E, 0x31, 0xE0, 0x1E, 0x0E,
  0x3C, 0x1C, 0x78, 0x78, 0xF8, 0xF3, 0xF1, 0xE7, 0xE3, 0x8F, 0xC7, 0x1D,
  0xDE, 0x3B, 0xBC, 0x73, 0x79, 0xE6, 0xE3, 0xCF, 0xC7, 0x9F, 0x8E, 0x1F,
  0x1C, 0x3E, 0x38, 0x7C, 0xF0, 0xF1, 0xE0, 0xE0, 0x07, 0xC0, 0x7F, 0x87,
  0xFC, 0x78, 0xF7, 0x87, 0xBC, 0x1D, 0xC0, 0xEE, 0x07, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xEE, 0x07, 0x78, 0x7B, 0xC7, 0x8F, 0xFC, 0x3F, 0xC0,
  0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x87, 0x0E, 0x3C, 0x3C, 0xF0,
  0xF3, 0xC3, 0xCE, 0x0E, 0x38, 0x78, 0xFF, 0xC7, 0xFF, 0x1F, 0xF0, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x7F, 0x87, 0xFC, 0x78, 0xF7, 0x87, 0xBC, 0x1D, 0xC0, 0xEE, 0x07, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xEE, 0x07, 0x78, 0x7B, 0xC7, 0x8F, 0xFC,
  0x3F, 0xC0, 0xFE, 0x00, 0x78, 0x03, 0xC0, 0x08, 0x00, 0x1F, 0xE0, 0xFF,
  0x87, 0xFE, 0x38, 0xF3, 0xC3, 0x9E, 0x1C, 0xF1, 0xE7, 0x0F, 0x3F, 0xF1,
  0xFF, 0x1F, 0xF0, 0xF3, 0x87, 0x9C, 0x38, 0xF1, 0xC7, 0x8E, 0x3C, 0xF0,
  0xE7, 0x87, 0x80, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x3C, 0xF3, 0xC3, 0x9E,
  0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE7, 0x0F,
  0x38, 0x79, 0xE3, 0x8F, 0xFC, 0x3F, 0xC0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x39, 0xC1, 0xCE, 0x0E, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xC1, 0xCE,
  0x0E, 0x70, 0x77, 0x87, 0xBC, 0x3D, 0xE1, 0xCE, 0x0E, 0x70, 0x73, 0xC7,
  0x9F, 0xF8, 0x7F, 0x81, 0xF8, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1D, 0xE1,
  0xEF, 0x0F, 0x38, 0xF1, 0xC7, 0x8E, 0x38, 0x73, 0xC3, 0x9C, 0x1C, 0xE0,
  0xEF, 0x07, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x00,
  0xF1, 0xC3, 0xF8, 0xE3, 0xFC, 0xF1, 0xFE, 0x78, 0xEF, 0x3C, 0xF7, 0xBE,
  0x7B, 0xDF, 0x39, 0xEF, 0x9C, 0xFE, 0xDE, 0x7F, 0x6E, 0x3F, 0xB7, 0x1F,
  0x9F, 0x8F, 0xCF, 0x87, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1, 0xE0, 0xF8, 0xF0,
  0x78, 0x78, 0x00, 0x1E, 0x1F, 0x0E, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C, 0x07,
  0x78, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0x70, 0x78,
  0x78, 0xF8, 0x78, 0xF0, 0x7F, 0x87, 0x9C, 0x38, 0xE3, 0xC7, 0x1C, 0x3D,
  0xE0, 0xEE, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x00, 0x1F, 0xFC, 0xFF,
  0xF3, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3F,
  0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0x1F, 0x1F, 0x1C, 0x1C, 0x1C, 0x3C,
  0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0x70, 0x70,
  0xF0, 0xF0, 0xE0, 0xF8, 0xF0, 0xF0, 0xE3, 0x8F, 0x3C, 0x71, 0xC7, 0x1C,
  0x71, 0xE7, 0x8E, 0x38, 0xE3, 0x8E, 0x3C, 0xF3, 0xC7, 0x1F, 0x1F, 0x1F,
  0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF8, 0xF0, 0xF0, 0x0E, 0x0E,
  0x1E, 0x1E, 0x3E, 0x37, 0x77, 0x63, 0xE3, 0x7F, 0xDF, 0xF7, 0xFC, 0x70,
  0xE3, 0x87, 0x0F, 0x83, 0xF8, 0xFF, 0x1C, 0xE0, 0x1C, 0x3F, 0x9F, 0xF3,
  0xCE, 0xF3, 0xDE, 0x7B, 0xFE, 0x3F, 0xC3, 0xB8, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x03, 0xC0, 0x78, 0x0E, 0xF1, 0xFF, 0x3F, 0xE7, 0x1D, 0xE3, 0xBC,
  0x77, 0x0E, 0xE1, 0xDC, 0x7B, 0x8E, 0xFF, 0xDD, 0xF3, 0x9C, 0x00, 0x1F,
  0x0F, 0xE7, 0xFB, 0xCF, 0xE1, 0xF8, 0x0E, 0x03, 0x80, 0xE3, 0xB9, 0xEF,
  0xF3, 0xF8, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x3B, 0xC7, 0xFC, 0x3F, 0xE3, 0xCF, 0x1C, 0x38, 0xE3, 0xC7,
  0x1E, 0x38, 0xE1, 0xC7, 0x0E, 0x38, 0x7F, 0xC3, 0xFE, 0x0F, 0x70, 0x1F,
  0x0F, 0xE7, 0xFD, 0xC7, 0xE1, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x38, 0x4F,
  0xF9, 0xFC, 0x3E, 0x00, 0x07, 0x8F, 0x87, 0xC7, 0x83, 0xC1, 0xC3, 0xF9,
  0xFC, 0xFE, 0x3C, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70,
  0x38, 0x00, 0x0F, 0x73, 0xF7, 0x3F, 0xF7, 0x8E, 0x70, 0xE7, 0x0E, 0x71,
  0xE7, 0x1E, 0x71, 0xE7, 0x1C, 0x7F, 0xC7, 0xFC, 0x3F, 0xC0, 0x3C, 0x43,
  0x8F, 0xF8, 0xFF, 0x07, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0,
  0x78, 0x0E, 0xF1, 0xFE, 0x3F, 0xEF, 0x3D, 0xE3, 0xBC, 0xF7, 0x1E, 0xE3,
  0x9C, 0x77, 0x8E, 0xF1, 0xDC, 0x7B, 0x8F, 0x00, 0x08, 0x38, 0x70, 0xE0,
  0x00, 0x0F, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x71, 0xE3,
  0xC0, 0x01, 0x01, 0xC0, 0xE0, 0x70, 0x00, 0x00, 0x1E, 0x0F, 0x07, 0x03,
  0x81, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81,
  0xC3, 0xE3, 0xE1, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0xF3, 0x9E, 0x3B, 0xC3, 0xB8, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x87, 0x38, 0xF3, 0x8F, 0x3C, 0xE3, 0xC0, 0x1E, 0x38, 0x70,
  0xE1, 0xC7, 0x8F, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x71,
  0xE3, 0xC0, 0x3B, 0xCF, 0x1F, 0xFF, 0x8F, 0xFF, 0xE7, 0x3C, 0xF7, 0x9E,
  0x3B, 0xCF, 0x3D, 0xC7, 0x9E, 0xE3, 0x8E, 0x71, 0xC7, 0x38, 0xE3, 0xBC,
  0xF1, 0xDE, 0x79, 0xEE, 0x38, 0xF0, 0x3B, 0xC7, 0xFC, 0xFF, 0x9C, 0xF7,
  0x8E, 0xF3, 0xDC, 0x7B, 0x8E, 0x71, 0xDE, 0x3B, 0xC7, 0x79, 0xEE, 0x3C,
  0x1F, 0x0F, 0xE7, 0xFF, 0xC7, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF8,
  0xEF, 0xF9, 0xFC, 0x3E, 0x00, 0x1D, 0xE1, 0xFF, 0x1F, 0xF1, 0xC7, 0x3C,
  0x73, 0xC7, 0x38, 0x73, 0x87, 0x38, 0xF3, 0x8E, 0x7F, 0xE7, 0xFC, 0x73,
  0x87, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0x1C, 0xEF, 0xFD, 0xFF,
  0x78, 0xEE, 0x1D, 0xC7, 0xB8, 0xF7, 0x1C, 0xE3, 0x9C, 0x73, 0xFE, 0x7F,
  0xC7, 0xF8, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3B, 0x1F, 0x8F,
  0xC7, 0xA7, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x00,
  0x0F, 0x07, 0xF8, 0xFF, 0x3C, 0xE7, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03,
  0xDC, 0x73, 0xFE, 0x3F, 0xC3, 0xE0, 0x3C, 0x70, 0xE7, 0xFF, 0xFF, 0x9E,
  0x38, 0x70, 0xE1, 0xC7, 0x8F, 0x1F, 0x3E, 0x3C, 0x71, 0xEE, 0x3D, 0xC7,
  0x38, 0xEF, 0x1D, 0xE7, 0xB8, 0xF7, 0x1C, 0xE3, 0x9C, 0x73, 0xFE, 0x7F,
  0xC7, 0xF8, 0xF1, 0xDE, 0x79, 0xCE, 0x39, 0xC7, 0x78, 0xEE, 0x1D, 0xC3,
  0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0x80, 0xF3, 0x8F, 0xE7, 0x39,
  0xDE, 0x73, 0xBC, 0xE7, 0x7B, 0x8F, 0xF7, 0x1F, 0x6E, 0x3E, 0xF8, 0x7D,
  0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0x8F, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0xE7,
  0x87, 0x78, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x81,
  0xFC, 0x0E, 0xF0, 0xF3, 0x8F, 0x1C, 0x00, 0x3C, 0x71, 0xE7, 0x87, 0x3C,
  0x39, 0xC1, 0xDE, 0x0E, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0,
  0x3C, 0x0F, 0x03, 0xFE, 0x7F, 0xCF, 0xF8, 0x02, 0x1C, 0x70, 0xE3, 0xC7,
  0x0E, 0x1C, 0x38, 0xF3, 0xC7, 0x0E, 0x1C, 0x1C, 0x38, 0x71, 0xC3, 0x87,
  0x0E, 0x0E, 0x1C, 0x18, 0x0C, 0x71, 0x86, 0x18, 0x61, 0x8E, 0x30, 0xC3,
  0x0C, 0x30, 0xC7, 0x18, 0x61, 0x86, 0x18, 0xE0, 0x08, 0x1C, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x07, 0x0F, 0x1C, 0x3C, 0x38,
  0x38, 0x38, 0x38, 0x78, 0x70, 0xE0, 0xC0, 0x38, 0x77, 0xC6, 0x7E, 0x6E,
  0x7E, 0xE7, 0xCC, 0x38,
};

const GFXglyph RobotoCondensed_BoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 18, 6, 0, -18 },
  { 17, 8, 7, 8, 1, -19 },
  { 24, 13, 18, 13, 0, -18 },
  { 54, 11, 23, 12, 1, -21 },
  { 86, 12, 18, 15, 2, -18 },
  { 113, 13, 18, 14, 0, -18 },
  { 143, 4, 7, 4, 1, -19 },
  { 147, 8, 26, 8, 1, -20 },
  { 173, 8, 26, 8, -1, -20 },
  { 199, 11, 11, 11, 1, -18 },
  { 215, 10, 13, 12, 1, -15 },
  { 232, 5, 7, 6, -1, -3 },
  { 237, 7, 3, 9, 1, -9 },
  { 240, 3, 4, 7, 1, -4 },
  { 242, 12, 20, 8, -2, -18 },
  { 272, 11, 18, 12, 1, -18 },
  { 297, 7, 18, 12, 3, -18 },
  { 313, 12, 18, 12, 0, -18 },
  { 340, 12, 18, 12, 0, -18 },
  { 367, 12, 18, 12, 0, -18 },
  { 394, 11, 18, 12, 1, -18 },
  { 419, 10, 18, 12, 1, -18 },
  { 442, 12, 18, 12, 1, -18 },
  { 469, 11, 18, 12, 1, -18 },
  { 494, 10, 18, 12, 2, -18 },
  { 517, 5, 14, 7, 1, -14 },
  { 526, 7, 18, 6, -1, -14 },
  { 542, 9, 12, 11, 1, -14 },
  { 556, 10, 8, 12, 1, -12 },
  { 566, 10, 11, 11, 0, -13 },
  { 580, 9, 18, 11, 2, -18 },
  { 601, 18, 23, 19, 0, -17 },
  { 653, 14, 18, 14, -1, -18 },
  { 685, 13, 18, 14, 0, -18 },
  { 715, 13, 18, 14, 1, -18 },
  { 745, 13, 18, 14, 0, -18 },
  { 775, 13, 18, 12, 0, -18 },
  { 805, 13, 18, 12, 0, -18 },
  { 835, 13, 18, 14, 1, -18 },
  { 865, 15, 18, 15, 0, -18 },
  { 899, 7, 18, 7, 0, -18 },
  { 915, 12, 18, 12, 0, -18 },
  { 942, 15, 18, 13, 0, -18 },
  { 976, 10, 18, 12, 0, -18 },
  { 999, 19, 18, 18, 0, -18 },
  { 1042, 15, 18, 15, 0, -18 },
  { 1076, 13, 18, 15, 1, -18 },
  { 1106, 14, 18, 14, 0, -18 },
  { 1138, 13, 21, 15, 1, -18 },
  { 1173, 13, 18, 13, 0, -18 },
  { 1203, 13, 18, 13, 0, -18 },
  { 1233, 12, 18, 13, 2, -18 },
  { 1260, 13, 18, 14, 1, -18 },
  { 1290, 13, 18, 14, 2, -18 },
  { 1320, 17, 18, 18, 2, -18 },
  { 1359, 16, 18, 14, -1, -18 },
  { 1395, 13, 18, 13, 2, -18 },
  { 1425, 14, 18, 13, 0, -18 },
  { 1457, 8, 25, 6, 0, -21 },
  { 1482, 6, 20, 9, 2, -18 },
  { 1497, 8, 25, 6, -1, -21 },
  { 1522, 8, 9, 9, 1, -18 },
  { 1531, 10, 3, 10, -2, 0 },
  { 1535, 6, 4, 8, 2, -19 },
  { 1538, 11, 13, 11, 0, -13 },
  { 1556, 11, 19, 12, 0, -19 },
  { 1583, 10, 13, 11, 1, -13 },
  { 1600, 13, 19, 12, 0, -19 },
  { 1631, 10, 13, 12, 1, -13 },
  { 1648, 9, 19, 8, 1, -19 },
  { 1670, 12, 18, 12, 0, -13 },
  { 1697, 11, 19, 12, 0, -19 },
  { 1724, 7, 19, 6, 0, -19 },
  { 1741, 9, 24, 6, -3, -19 },
  { 1768, 12, 19, 12, 0, -19 },
  { 1797, 7, 19, 6, 0, -19 },
  { 1814, 17, 13, 18, 0, -13 },
  { 1842, 11, 13, 12, 0, -13 },
  { 1860, 10, 13, 12, 1, -13 },
  { 1877, 12, 18, 12, -1, -13 },
  { 1904, 11, 18, 12, 1, -13 },
  { 1929, 9, 13, 8, 0, -13 },
  { 1944, 11, 13, 11, 0, -13 },
  { 1962, 7, 16, 7, 1, -16 },
  { 1976, 11, 13, 12, 1, -13 },
  { 1994, 11, 13, 11, 1, -13 },
  { 2012, 15, 13, 15, 1, -13 },
  { 2037, 13, 13, 11, -1, -13 },
  { 2059, 13, 18, 11, -1, -13 },
  { 2089, 11, 13, 11, 0, -13 },
  { 2107, 7, 24, 7, 1, -20 },
  { 2128, 6, 21, 6, 0, -18 },
  { 2144, 8, 23, 7, -1, -19 },
  { 2167, 12, 6, 14, 1, -11 },
};

const GFXfont RobotoCondensed_BoldItalic25pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic25pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic25pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOCONDENSED_BOLDITALIC25PT7B_H_
