#ifndef _ROBOTOCONDENSED_BOLDITALIC27PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x1E, 0x3C, 0x70, 0xE1, 0xC3,
  0x80, 0x00, 0x38, 0x70, 0xE1, 0xC0, 0x66, 0xE6, 0xEE, 0xEE, 0xCE, 0xCC,
  0xCC, 0x03, 0x30, 0x19, 0x81, 0xDC, 0x0C, 0xC0, 0x66, 0x07, 0x70, 0xFF,
  0xEF, 0xFF, 0x1D, 0xC0, 0xCC, 0x06, 0x61, 0xFF, 0xCF, 0xFE, 0x19, 0x80,
  0xCC, 0x0E, 0xE0, 0x66, 0x03, 0x30, 0x3B, 0x80, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x7C, 0x1F, 0xE1, 0xFE, 0x3C, 0xF3, 0x8F, 0x38, 0xF3, 0x80, 0x3C,
  0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0xE1, 0xEF, 0x1C, 0xF3,
  0xCF, 0xFC, 0x7F, 0x83, 0xE0, 0x18, 0x01, 0x80, 0x18, 0x00, 0x3C, 0x03,
  0xF0, 0x1D, 0x84, 0xCE, 0x6E, 0x67, 0x73, 0x71, 0xBB, 0x0F, 0xF0, 0x3B,
  0x80, 0x18, 0x01, 0xBC, 0x1F, 0xE1, 0xFB, 0x8D, 0x8C, 0xCC, 0x6E, 0x67,
  0x63, 0xB8, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x1F, 0x80, 0xFF, 0x03, 0x9C,
  0x1C, 0x70, 0x71, 0xC1, 0xEE, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x73, 0xF9,
  0xDE, 0xEE, 0x7B, 0xF9, 0xC7, 0xEF, 0x1F, 0x1E, 0x78, 0x7F, 0xF0, 0xFF,
  0xE1, 0xF7, 0x80, 0x7F, 0xFF, 0xB0, 0x01, 0x01, 0x81, 0xC1, 0xC1, 0xE0,
  0xE0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x04,
  0x00, 0x08, 0x0C, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x3C, 0x38,
  0x70, 0xF0, 0xE0, 0x80, 0x03, 0x00, 0x30, 0x07, 0x04, 0x72, 0x7E, 0xF7,
  0xFF, 0x0F, 0x81, 0xF0, 0x3B, 0x07, 0xB8, 0x71, 0x82, 0x10, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x80, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x71, 0xCE, 0x39, 0xE7, 0x18, 0x7E, 0xFF,
  0xF8, 0xEF, 0xFE, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x00, 0x07,
  0x81, 0xFE, 0x1F, 0xE3, 0xCE, 0x38, 0xF7, 0x8F, 0x78, 0xF7, 0x0F, 0x70,
  0xEF, 0x0E, 0xF0, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E, 0xF1, 0xCF, 0x3C, 0x7F,
  0x87, 0xF0, 0x3E, 0x00, 0x03, 0x0F, 0x7F, 0xFE, 0xFE, 0x8E, 0x1E, 0x1E,
  0x1E, 0x1C, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x78, 0x03,
  0xC0, 0x7F, 0x87, 0xFC, 0x78, 0xF3, 0xC7, 0x9E, 0x3C, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x80, 0xFF, 0xE7, 0xFF, 0x3F, 0xF8, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x78,
  0xF3, 0xC7, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x07, 0xE0, 0x3E, 0x01, 0xF8,
  0x01, 0xC0, 0x0F, 0x78, 0x7B, 0xC3, 0x8F, 0x3C, 0x7F, 0xC1, 0xFE, 0x07,
  0xC0, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x03, 0xF8, 0x1F,
  0xC1, 0xDC, 0x1C, 0xE0, 0xEF, 0x0E, 0x78, 0xF3, 0xC7, 0xFF, 0x7F, 0xFB,
  0xFF, 0xC0, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF3, 0xC0, 0x38, 0x03, 0x80, 0x3F, 0x87, 0xFC, 0x7F, 0xC3, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xEE, 0x1E, 0xF1, 0xCF, 0x3C, 0x7F, 0x87, 0xF8, 0x1E,
  0x00, 0x01, 0xE0, 0xF8, 0x3F, 0x0F, 0x83, 0xC0, 0x78, 0x1F, 0xE3, 0xFE,
  0x7F, 0xEF, 0x3F, 0xC7, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7B, 0x9E, 0x7F,
  0xC7, 0xF0, 0x78, 0x00, 0x3F, 0xFB, 0xFF, 0xDF, 0xFC, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0x07,
  0x81, 0xFE, 0x1F, 0xE3, 0xCF, 0x38, 0xF3, 0x8F, 0x38, 0xF3, 0x9E, 0x1F,
  0xC1, 0xF8, 0x7F, 0xC7, 0x1C, 0xF1, 0xCE, 0x1C, 0xE1, 0xCF, 0x3C, 0xFF,
  0xC7, 0xF8, 0x3E, 0x00, 0x0F, 0x07, 0xF1, 0xFF, 0x3C, 0xEF, 0x1D, 0xE3,
  0xBC, 0x7F, 0x0E, 0xF1, 0xDE, 0x7B, 0xFF, 0x3F, 0xE3, 0xF8, 0x0F, 0x01,
  0xC0, 0xF8, 0x7E, 0x1F, 0x83, 0xC0, 0x00, 0x39, 0xF7, 0xCE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0xF3, 0xCE, 0x00, 0x0E, 0x3C, 0x78, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x87, 0x0E, 0x1C, 0x70, 0xE3, 0x82,
  0x00, 0x00, 0x40, 0x70, 0x7C, 0x7F, 0x7F, 0x3F, 0x0F, 0x03, 0xE0, 0xFE,
  0x0F, 0xE0, 0xF0, 0x1C, 0x01, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xF7, 0xFE, 0xFF, 0xC0, 0x10, 0x07, 0x80, 0xF8, 0x1F,
  0xC0, 0x7E, 0x03, 0xC0, 0xF8, 0xFF, 0x7F, 0x0F, 0x81, 0xC0, 0x20, 0x00,
  0x1F, 0x1F, 0xE7, 0xFF, 0xCF, 0xF3, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x07,
  0x83, 0xC0, 0xE0, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00,
  0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F, 0x0E, 0x03, 0x80, 0xE0, 0xE0, 0x0C,
  0x38, 0x00, 0xC6, 0x1E, 0x19, 0xC7, 0xF3, 0x31, 0xEE, 0x66, 0x31, 0x8D,
  0xCE, 0x31, 0xB1, 0xCE, 0x36, 0x71, 0xC6, 0xCE, 0x31, 0x99, 0xC6, 0x37,
  0x39, 0xC6, 0xE7, 0xF9, 0x8C, 0x7F, 0xE1, 0x8F, 0x38, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0F, 0x1C, 0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00,
  0xEE, 0x03, 0xDC, 0x07, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0xF1, 0xE1, 0xFF,
  0xC7, 0xFF, 0x8F, 0xFF, 0x1C, 0x0E, 0x78, 0x1E, 0xF0, 0x3F, 0xC0, 0x78,
  0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0x8F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3,
  0xCF, 0x0F, 0x3F, 0xF8, 0xFF, 0x83, 0xFF, 0x1E, 0x1E, 0x78, 0x79, 0xE1,
  0xE7, 0x87, 0x9E, 0x3E, 0x7F, 0xF3, 0xFF, 0x8F, 0xFC, 0x00, 0x03, 0xE0,
  0x3F, 0xC1, 0xFF, 0x8F, 0x9E, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x7B, 0xC1, 0xCF, 0x0F,
  0x1E, 0x7C, 0x7F, 0xE0, 0xFF, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xC1,
  0xFF, 0x87, 0x9F, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C,
  0xF0, 0xF3, 0x83, 0xDE, 0x0F, 0x78, 0x39, 0xE1, 0xE7, 0x87, 0x9E, 0x7C,
  0x7F, 0xE3, 0xFF, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7,
  0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xF0, 0xFF, 0x83,
  0xFE, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7F, 0xE3,
  0xFF, 0x8F, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0x87, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0x9F, 0x3C, 0x3D, 0xE0,
  0xF7, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC7, 0xEF, 0x1F, 0xBC, 0x7E, 0xF0,
  0x7B, 0xC1, 0xEF, 0x07, 0x9E, 0x3E, 0x7F, 0xF0, 0xFF, 0x81, 0xF8, 0x00,
  0x1E, 0x07, 0x0F, 0x03, 0x87, 0x83, 0xC3, 0xC1, 0xE1, 0xC0, 0xF1, 0xE0,
  0x78, 0xF0, 0x38, 0x78, 0x3C, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F,
  0x03, 0xC7, 0x81, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x70, 0x3C,
  0x78, 0x1C, 0x3C, 0x0E, 0x00, 0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xC7, 0x8F, 0x1E, 0x3C, 0x70, 0xE3, 0xC0, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x78, 0xF3, 0xC7, 0x9E, 0x78,
  0x7F, 0xC3, 0xFC, 0x07, 0x80, 0x1E, 0x1F, 0x0F, 0x0F, 0x07, 0x8F, 0x83,
  0xCF, 0x81, 0xCF, 0x81, 0xE7, 0x80, 0xF7, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC, 0x07, 0xDE, 0x03, 0xCF, 0x01, 0xE3,
  0xC0, 0xF1, 0xE0, 0x70, 0xF0, 0x78, 0x7C, 0x3C, 0x1E, 0x00, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F,
  0x87, 0xF3, 0xF8, 0x7E, 0x3F, 0x87, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xB9, 0xDE, 0x3B, 0x9D, 0xC7, 0xBB, 0x9C, 0x79, 0xBB, 0xC7, 0x9B, 0x3C,
  0x79, 0xF3, 0xC7, 0x9F, 0x3C, 0x71, 0xE3, 0x8F, 0x1E, 0x78, 0xF1, 0xC7,
  0x80, 0x1E, 0x07, 0x0F, 0x87, 0x87, 0xC3, 0xC3, 0xE1, 0xE1, 0xF0, 0xF1,
  0xFC, 0x78, 0xFE, 0x38, 0x7F, 0x3C, 0x3D, 0x9E, 0x1E, 0xEF, 0x0E, 0x77,
  0x8F, 0x3B, 0x87, 0x8D, 0xC3, 0xC7, 0xE1, 0xE3, 0xF0, 0xF0, 0xF8, 0x70,
  0x7C, 0x78, 0x3C, 0x3C, 0x1E, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F,
  0x9F, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x70, 0x3F, 0xC0, 0xFF,
  0x03, 0xFC, 0x0F, 0xF0, 0x3B, 0xC1, 0xEF, 0x07, 0x9E, 0x3C, 0x7F, 0xE0,
  0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xF1, 0xE1,
  0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x1E, 0x3C, 0x7C, 0x7F, 0xF0, 0xFF,
  0xC3, 0xFF, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9F, 0x3C,
  0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x70, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3B, 0xC1, 0xEF, 0x07, 0x9E, 0x3C, 0x7F, 0xE0, 0xFF, 0x01,
  0xFE, 0x00, 0x7C, 0x00, 0xE0, 0x01, 0x00, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF,
  0xC7, 0x8F, 0x1C, 0x3C, 0xF0, 0x73, 0xC3, 0xCF, 0x0F, 0x3C, 0x7C, 0xFF,
  0xE3, 0xFF, 0x1F, 0xF8, 0x79, 0xE1, 0xE7, 0x87, 0x8F, 0x1E, 0x3C, 0x70,
  0xF3, 0xC3, 0xCF, 0x07, 0x80, 0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0x78, 0xF3,
  0x87, 0xBC, 0x3C, 0xE0, 0x07, 0xC0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x03,
  0xC0, 0x0F, 0x70, 0x7B, 0x83, 0xDE, 0x3C, 0xFF, 0xE3, 0xFE, 0x07, 0xC0,
  0x7F, 0xFB, 0xFF, 0xEF, 0xFF, 0x81, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x1C,
  0x78, 0x38, 0xF0, 0xF1, 0xC1, 0xE3, 0x83, 0xCF, 0x07, 0x9E, 0x0E, 0x3C,
  0x1C, 0x78, 0x78, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x1E, 0x1E,
  0x3C, 0x3C, 0x7C, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0xF0, 0x3D,
  0xE0, 0x7B, 0xC1, 0xF3, 0x83, 0xC7, 0x07, 0x8F, 0x1E, 0x1E, 0x3C, 0x3C,
  0x70, 0x79, 0xE0, 0xF3, 0xC1, 0xEF, 0x01, 0xDE, 0x03, 0xB8, 0x07, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0xE1,
  0xFE, 0x3C, 0x3B, 0xC7, 0x8F, 0x78, 0xF1, 0xEF, 0x3E, 0x39, 0xE7, 0xCF,
  0x3C, 0xF9, 0xE3, 0xBF, 0x38, 0x77, 0xE7, 0x0E, 0xFD, 0xE1, 0xF9, 0xB8,
  0x3F, 0x37, 0x07, 0xE7, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0,
  0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x87, 0x87,
  0x83, 0xC7, 0x81, 0xE3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1F, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x79, 0xE0, 0x7C, 0xF0, 0x3C, 0x78, 0x3C, 0x3C, 0x3E, 0x0F,
  0x00, 0xF0, 0x3D, 0xC1, 0xE7, 0x87, 0x9E, 0x3C, 0x78, 0xE0, 0xE7, 0x83,
  0x9C, 0x0E, 0xF0, 0x3B, 0x80, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1F,
  0xFE, 0x3F, 0xFC, 0xFF, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xF1, 0xFF, 0xE3, 0xFF, 0xC0, 0x07,
  0xC3, 0xE0, 0xF8, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x00, 0xF1, 0xE3, 0xC3, 0x87,
  0x0E, 0x1E, 0x3C, 0x78, 0xF0, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x3C, 0x38,
  0x70, 0xE1, 0xE0, 0x07, 0xC3, 0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0xC1, 0xF0, 0x7C, 0x1F, 0x00,
  0x0E, 0x07, 0x83, 0xC3, 0xE1, 0xB1, 0xD8, 0xCC, 0xE7, 0x63, 0xF1, 0xC0,
  0x7F, 0xEF, 0xFF, 0xFF, 0x00, 0xF3, 0x8E, 0x70, 0x07, 0x83, 0xF8, 0xFF,
  0x9E, 0x73, 0x8E, 0x01, 0xC7, 0xF9, 0xFF, 0x79, 0xFE, 0x3F, 0xC7, 0x79,
  0xEF, 0xFC, 0xFF, 0x8F, 0x70, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3D, 0xC3, 0xFE, 0x3F, 0xF3, 0xCF, 0x38, 0x73, 0x87, 0x78,
  0xF7, 0x8F, 0x78, 0xF7, 0x0F, 0x70, 0xE7, 0x9E, 0xFF, 0xEF, 0xFC, 0xE7,
  0x80, 0x0F, 0x07, 0xF1, 0xFF, 0x3C, 0xEF, 0x1D, 0xE3, 0xF8, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x8F, 0x79, 0xCF, 0xF8, 0xFE, 0x0F, 0x80, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x7B, 0xC7, 0xFE, 0x7F,
  0xE3, 0xCF, 0x3C, 0x79, 0xE3, 0xCE, 0x1E, 0x70, 0xF3, 0x87, 0x1C, 0x38,
  0xE3, 0xC7, 0x9E, 0x3F, 0xF1, 0xFF, 0x87, 0xB8, 0x00, 0x0F, 0x07, 0xF9,
  0xFF, 0x3C, 0xFF, 0x1F, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80,
  0x78, 0xCF, 0xF8, 0xFF, 0x0F, 0x80, 0x07, 0x87, 0xC7, 0xE3, 0xC1, 0xC1,
  0xE3, 0xFD, 0xFE, 0xFF, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0,
  0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x00, 0x0F, 0x38, 0xFF, 0xCF, 0xFE, 0x79,
  0xE7, 0x87, 0x3C, 0x79, 0xE3, 0xCE, 0x1E, 0x70, 0xF3, 0x87, 0x1C, 0x38,
  0xF3, 0xC7, 0xFE, 0x1F, 0xF0, 0x77, 0x80, 0x38, 0x43, 0xC7, 0xFC, 0x3F,
  0xE0, 0x7C, 0x00, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x3D, 0xC3, 0xFE, 0x3F, 0xF3, 0xCF, 0x38, 0xF7, 0x8F, 0x78, 0xF7, 0x8E,
  0x78, 0xE7, 0x1E, 0x71, 0xEF, 0x1E, 0xF1, 0xEF, 0x1C, 0xF1, 0xC0, 0x0C,
  0x3C, 0x78, 0x60, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xE1, 0xC3, 0x8F, 0x1E,
  0x3C, 0x70, 0xE1, 0xC7, 0x8F, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x06, 0x00,
  0x00, 0x00, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC3, 0xF0,
  0xF8, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xF1, 0xE7, 0x9E, 0x3D, 0xE1, 0xDF, 0x0E, 0xF0, 0x7F, 0x07, 0xF0,
  0x3F, 0xC1, 0xFE, 0x0F, 0x70, 0x73, 0xC3, 0x9E, 0x3C, 0xF1, 0xE3, 0xCF,
  0x1E, 0x00, 0x0E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x1E, 0x3C, 0x78, 0xF1,
  0xC3, 0x8F, 0x1E, 0x3C, 0x78, 0xE1, 0xC7, 0x8F, 0x00, 0x3D, 0xC7, 0x8F,
  0xFB, 0xF3, 0xFF, 0xFC, 0xF3, 0xCF, 0x38, 0xF1, 0xCE, 0x3C, 0x77, 0x8F,
  0x3D, 0xE3, 0x8F, 0x78, 0xE3, 0xDC, 0x78, 0xF7, 0x1E, 0x39, 0xC7, 0x8E,
  0xF1, 0xE7, 0xBC, 0x71, 0xEF, 0x1C, 0x78, 0x3D, 0xC3, 0xFE, 0x3F, 0xF3,
  0xCF, 0x38, 0xF7, 0x8F, 0x78, 0xF7, 0x8E, 0x78, 0xE7, 0x1E, 0x71, 0xEF,
  0x1E, 0xF1, 0xEF, 0x1C, 0xF1, 0xC0, 0x0F, 0x87, 0xF9, 0xFF, 0x3C, 0xFF,
  0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x87, 0x79, 0xEF, 0xF8,
  0xFE, 0x0F, 0x80, 0x1E, 0xE0, 0xFF, 0x87, 0xFE, 0x3C, 0xF1, 0xC7, 0x9E,
  0x1C, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xC3, 0xCE, 0x1C, 0xF9, 0xE7, 0xFF,
  0x3F, 0xF1, 0xEF, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00,
  0x1E, 0xF3, 0xFF, 0x7F, 0xE7, 0x9E, 0xF1, 0xEF, 0x1E, 0xE1, 0xEE, 0x1C,
  0xE1, 0xCE, 0x3C, 0xE3, 0xCF, 0x3C, 0xFF, 0xCF, 0xF8, 0x7B, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xC3,
  0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC0, 0x0F,
  0x83, 0xF8, 0xFF, 0x9C, 0x73, 0x80, 0x78, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x7B, 0xC7, 0x78, 0xE7, 0xFC, 0xFF, 0x07, 0x80, 0x1C, 0x78, 0xF7, 0xFF,
  0xFF, 0xCE, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x1E, 0x3C, 0x7C, 0x78, 0x70,
  0x78, 0xF7, 0x8F, 0x78, 0xE7, 0x1E, 0x71, 0xEF, 0x1E, 0xF1, 0xEF, 0x1E,
  0xF1, 0xCE, 0x1C, 0xE3, 0xCF, 0x3C, 0xFF, 0xCF, 0xFC, 0x7B, 0x80, 0xF1,
  0xEE, 0x3D, 0xC7, 0x39, 0xE7, 0x3C, 0xE7, 0x1D, 0xE3, 0xB8, 0x77, 0x0F,
  0xE1, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE3, 0x8F, 0xCF, 0x3F,
  0x9E, 0x77, 0x3C, 0xEE, 0xFB, 0xDD, 0xF7, 0x3B, 0xEE, 0x7F, 0xFC, 0xFD,
  0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0x8F, 0x0F, 0x1E, 0x1E, 0x38, 0x38, 0x70,
  0x00, 0x1C, 0x78, 0xF3, 0xC7, 0xBC, 0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0xFE, 0x07, 0x70, 0x7B, 0x83, 0x9E, 0x3C, 0xF3,
  0xC7, 0x80, 0x3C, 0x78, 0x71, 0xE1, 0xC7, 0x87, 0x3C, 0x1C, 0xF0, 0x77,
  0x81, 0xDE, 0x07, 0x70, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C,
  0x00, 0x3F, 0xF3, 0xFF, 0x3F, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xFF, 0xCF, 0xFC, 0xFF, 0xC0,
  0x02, 0x07, 0x0E, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0xF0,
  0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0x70, 0x70,
  0x30, 0x10, 0x0C, 0x30, 0xC7, 0x1C, 0x61, 0x86, 0x18, 0xE3, 0x8C, 0x30,
  0xC3, 0x0C, 0x71, 0xC6, 0x18, 0x61, 0x8E, 0x00, 0x08, 0x0C, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x07, 0x0F, 0x1E, 0x1C,
  0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF0, 0xE0, 0xC0, 0x3C, 0x3B,
  0xF1, 0x9F, 0xDD, 0xCF, 0xEE, 0x3E, 0x00, 0xE0,
};

const GFXglyph RobotoCondensed_BoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 19, 7, 0, -19 },
  { 18, 8, 7, 8, 2, -20 },
  { 25, 13, 19, 14, 1, -19 },
  { 56, 12, 25, 13, 1, -22 },
  { 94, 13, 19, 17, 2, -19 },
  { 125, 14, 19, 15, 0, -19 },
  { 159, 3, 7, 4, 2, -20 },
  { 162, 9, 27, 8, 1, -21 },
  { 193, 8, 27, 8, -1, -21 },
  { 220, 12, 12, 12, 1, -19 },
  { 238, 11, 13, 12, 1, -15 },
  { 256, 6, 8, 6, -2, -3 },
  { 262, 7, 3, 9, 1, -10 },
  { 265, 4, 4, 8, 1, -4 },
  { 267, 12, 21, 9, -2, -19 },
  { 299, 12, 19, 13, 1, -19 },
  { 328, 8, 19, 13, 3, -19 },
  { 347, 13, 19, 13, 0, -19 },
  { 378, 13, 19, 13, 0, -19 },
  { 409, 13, 19, 13, 0, -19 },
  { 440, 12, 19, 13, 1, -19 },
  { 469, 11, 19, 13, 1, -19 },
  { 496, 13, 19, 13, 1, -19 },
  { 527, 12, 19, 13, 1, -19 },
  { 556, 11, 19, 13, 2, -19 },
  { 583, 6, 15, 7, 1, -15 },
  { 595, 7, 20, 7, -1, -15 },
  { 613, 10, 13, 12, 1, -15 },
  { 630, 11, 9, 13, 1, -13 },
  { 643, 11, 12, 12, 0, -14 },
  { 660, 10, 19, 12, 2, -19 },
  { 684, 19, 25, 20, 0, -19 },
  { 744, 15, 19, 16, -1, -19 },
  { 780, 14, 19, 15, 0, -19 },
  { 814, 14, 19, 15, 1, -19 },
  { 848, 14, 19, 15, 0, -19 },
  { 882, 14, 19, 13, 0, -19 },
  { 916, 14, 19, 12, 0, -19 },
  { 950, 14, 19, 15, 1, -19 },
  { 984, 17, 19, 16, 0, -19 },
  { 1025, 7, 19, 7, 0, -19 },
  { 1042, 13, 19, 13, 0, -19 },
  { 1073, 17, 19, 14, 0, -19 },
  { 1114, 11, 19, 13, 0, -19 },
  { 1141, 20, 19, 20, 0, -19 },
  { 1189, 17, 19, 16, 0, -19 },
  { 1230, 14, 19, 16, 1, -19 },
  { 1264, 15, 19, 15, 0, -19 },
  { 1300, 14, 22, 16, 1, -19 },
  { 1339, 14, 19, 14, 0, -19 },
  { 1373, 13, 19, 14, 1, -19 },
  { 1404, 14, 19, 14, 2, -19 },
  { 1438, 15, 19, 15, 1, -19 },
  { 1474, 15, 19, 15, 2, -19 },
  { 1510, 19, 19, 20, 2, -19 },
  { 1556, 17, 19, 15, -1, -19 },
  { 1597, 14, 19, 14, 2, -19 },
  { 1631, 15, 19, 14, 0, -19 },
  { 1667, 10, 26, 7, -1, -22 },
  { 1700, 7, 21, 10, 2, -19 },
  { 1719, 10, 26, 7, -2, -22 },
  { 1752, 9, 10, 10, 1, -19 },
  { 1764, 11, 3, 10, -2, 0 },
  { 1769, 5, 4, 9, 3, -20 },
  { 1772, 11, 15, 12, 0, -15 },
  { 1793, 12, 21, 13, 0, -21 },
  { 1825, 11, 15, 12, 1, -15 },
  { 1846, 13, 21, 13, 1, -21 },
  { 1881, 11, 15, 13, 1, -15 },
  { 1902, 9, 21, 9, 1, -21 },
  { 1926, 13, 20, 13, 0, -15 },
  { 1959, 12, 21, 13, 0, -21 },
  { 1991, 7, 21, 7, 0, -21 },
  { 2010, 10, 26, 6, -3, -21 },
  { 2043, 13, 21, 13, 0, -21 },
  { 2078, 7, 21, 7, 0, -21 },
  { 2097, 18, 15, 19, 0, -15 },
  { 2131, 12, 15, 13, 0, -15 },
  { 2154, 11, 15, 13, 1, -15 },
  { 2175, 13, 20, 13, -1, -15 },
  { 2208, 12, 20, 13, 1, -15 },
  { 2238, 9, 15, 9, 0, -15 },
  { 2255, 11, 15, 12, 0, -15 },
  { 2276, 7, 18, 8, 1, -18 },
  { 2292, 12, 15, 13, 1, -15 },
  { 2315, 11, 15, 12, 1, -15 },
  { 2336, 15, 15, 17, 2, -15 },
  { 2365, 13, 15, 12, -1, -15 },
  { 2390, 14, 20, 12, -1, -15 },
  { 2425, 12, 15, 12, 0, -15 },
  { 2448, 8, 26, 8, 1, -21 },
  { 2474, 6, 23, 7, 0, -19 },
  { 2492, 8, 26, 8, -1, -21 },
  { 2518, 13, 6, 15, 1, -11 },
};

const GFXfont RobotoCondensed_BoldItalic27pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic27pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _ROBOTOCONDENSED_BOLDITALIC27PT7B_H_
