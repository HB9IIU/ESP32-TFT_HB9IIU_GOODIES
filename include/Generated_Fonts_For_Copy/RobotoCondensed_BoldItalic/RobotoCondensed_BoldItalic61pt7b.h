#ifndef _ROBOTOCONDENSED_BOLDITALIC61PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0x00, 0x3E, 0x00, 0x08, 0x00, 0x3F, 0x0F, 0x9F, 0x8F, 0xCF, 0xC7, 0xE7,
  0xE3, 0xF7, 0xE1, 0xFB, 0xF0, 0xF9, 0xF8, 0x7C, 0xFC, 0x7E, 0x7C, 0x3F,
  0x3E, 0x1F, 0x3F, 0x0F, 0x9F, 0x87, 0xCF, 0x83, 0xE7, 0xC3, 0xE3, 0xE1,
  0xF1, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x3E,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8, 0x1F, 0xE1,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0,
  0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xF0, 0x3F, 0xE1,
  0xFE, 0x0F, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x41, 0xF8, 0x7C, 0x07, 0x0F, 0xC3, 0xE0, 0x7E, 0x7C, 0x1F, 0x03, 0xE3,
  0xE0, 0xF8, 0x3F, 0x1F, 0x07, 0xC3, 0xF1, 0xF8, 0x3E, 0x1F, 0x0F, 0xC1,
  0xF1, 0xF0, 0x7E, 0x1F, 0x9F, 0x81, 0xF0, 0xFC, 0xF8, 0x0F, 0xFF, 0xCF,
  0x80, 0x7F, 0xFE, 0xFC, 0x01, 0xFF, 0xEF, 0xC0, 0x07, 0xFE, 0x7C, 0x00,
  0x1F, 0xE7, 0xE0, 0x00, 0x10, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF1,
  0xFE, 0x00, 0x1F, 0xBF, 0xF8, 0x01, 0xFB, 0xFF, 0xE0, 0x0F, 0x9F, 0xFF,
  0x00, 0xFD, 0xFD, 0xF8, 0x0F, 0xCF, 0xC7, 0xE0, 0x7C, 0xFC, 0x3F, 0x07,
  0xE7, 0xE0, 0xF8, 0x7E, 0x3E, 0x0F, 0xC3, 0xE1, 0xF0, 0x7E, 0x3E, 0x0F,
  0x83, 0xF3, 0xF0, 0x7C, 0x1F, 0x9F, 0x03, 0xE0, 0xF8, 0xF0, 0x1F, 0x8F,
  0xC3, 0x80, 0xFE, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xDF, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0x7F,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x01,
  0xFD, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x7F, 0x0F, 0xFF, 0xE1, 0xFC, 0x7F, 0xFF, 0x87,
  0xF1, 0xFF, 0xFF, 0x1F, 0xCF, 0xF3, 0xFC, 0xFF, 0x7F, 0xCF, 0xFB, 0xF9,
  0xFE, 0x1F, 0xEF, 0xEF, 0xF8, 0x7F, 0xFF, 0xBF, 0xE0, 0xFF, 0xFC, 0xFF,
  0x83, 0xFF, 0xF3, 0xFE, 0x07, 0xFF, 0x8F, 0xF8, 0x1F, 0xFE, 0x3F, 0xE0,
  0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFE, 0xFF, 0x01, 0xFF, 0xE3, 0xFE, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x3F, 0x3F, 0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0xFC, 0xFC,
  0xFC, 0xFC, 0xF8, 0xF8, 0x00, 0x00, 0x80, 0x00, 0x38, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00, 0x20, 0x00, 0x03,
  0x00, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x7C, 0x06, 0x3E, 0x1F, 0x0F,
  0x9F, 0xE7, 0xDF, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0xC7, 0xE0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0x78, 0x07,
  0xC0, 0x0C, 0x01, 0xC0, 0x01, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x1F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x87, 0xF0, 0xFE, 0x0F, 0xE0,
  0x7C, 0x01, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0x00, 0x1E, 0x0F, 0xC7, 0xFB, 0xFF, 0xFF, 0xFF,
  0xF7, 0xF9, 0xFE, 0x3F, 0x02, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xF3, 0xFE, 0x0F,
  0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFF,
  0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00,
  0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x1F, 0xF7, 0xF8, 0x07, 0xF9, 0xFE,
  0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xEF, 0xF8, 0x07, 0xFB,
  0xFC, 0x01, 0xFE, 0xFF, 0x00, 0xFF, 0xBF, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F,
  0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xE0,
  0x1F, 0xE3, 0xF8, 0x07, 0xF8, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x8F,
  0xE0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xF7, 0xFE,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xFF, 0x87,
  0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF,
  0xF3, 0xE3, 0xFC, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0xE7, 0xFE, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0,
  0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0xFF,
  0x87, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xE7, 0xFE, 0x0F, 0xFC, 0x1F,
  0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x7F,
  0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF,
  0x81, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0x7F, 0x80,
  0x07, 0xF7, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xC7, 0xF8, 0x01, 0xFC,
  0xFF, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x0F, 0xF0,
  0x0F, 0xE0, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xC1, 0xFE, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x0F, 0xC0, 0xFF, 0x00, 0x08,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xCF, 0xC0, 0x3F,
  0xDF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFB, 0xFF, 0x87, 0xFD, 0xFF, 0x03, 0xFE,
  0xFF, 0x80, 0xFF, 0x7F, 0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F,
  0xEF, 0xF0, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01,
  0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F, 0x9F, 0xE0,
  0x7F, 0xCF, 0xF8, 0x7F, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x3F, 0xF3, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x3F,
  0xE0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F,
  0xC3, 0xFC, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x87,
  0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07,
  0xF8, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F,
  0x80, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFF, 0xDF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xFB, 0xFE, 0x3F, 0xE1, 0xFE,
  0x3F, 0xC0, 0xFF, 0x7F, 0xC0, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF,
  0x7F, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x81, 0xFF, 0x7F, 0x83, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x03, 0xF3, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xE0, 0x0F,
  0xE0, 0x7F, 0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0xC3,
  0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00,
  0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x10, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x04, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x7F, 0xC3, 0xFE, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x01,
  0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xFF, 0xC0, 0x7C, 0x1F, 0x80, 0xFF, 0xF8,
  0x1F, 0x0F, 0xC0, 0x7F, 0xFF, 0x07, 0xC3, 0xF0, 0x3F, 0xFF, 0xC1, 0xF0,
  0xF8, 0x1F, 0xE3, 0xF0, 0x7C, 0x7E, 0x07, 0xF0, 0xFC, 0x1F, 0x1F, 0x03,
  0xF8, 0x3F, 0x07, 0xCF, 0xC0, 0xFC, 0x0F, 0x81, 0xF3, 0xF0, 0x7E, 0x07,
  0xE0, 0x7C, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x3E, 0x0F, 0xE0, 0x7E, 0x07,
  0xDF, 0x83, 0xF0, 0x1F, 0x01, 0xF7, 0xE0, 0xFC, 0x0F, 0xC0, 0x7D, 0xF0,
  0x3F, 0x03, 0xF0, 0x3E, 0x7C, 0x1F, 0xC0, 0xFC, 0x0F, 0xBF, 0x07, 0xE0,
  0x3E, 0x03, 0xEF, 0xC1, 0xF8, 0x1F, 0x80, 0xFB, 0xF0, 0x7E, 0x07, 0xE0,
  0x3C, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x3F, 0x07, 0xE0, 0xFC, 0x07, 0xCF,
  0xC1, 0xF8, 0x3F, 0x03, 0xE3, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0xF8, 0x1F,
  0x87, 0xF0, 0x7C, 0x3E, 0x07, 0xFF, 0xFE, 0x3F, 0x0F, 0xC1, 0xFF, 0xFF,
  0xFF, 0x83, 0xF0, 0x3F, 0xFB, 0xFF, 0xC0, 0xFC, 0x0F, 0xFC, 0xFF, 0xE0,
  0x3F, 0x01, 0xFE, 0x1F, 0xF0, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0xC1, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0xFF, 0x7F,
  0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0xFF,
  0x1F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF0, 0x1F,
  0xE0, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07,
  0xFC, 0x3F, 0xE0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x1F, 0xF1, 0xFF, 0x00,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x07, 0xF9, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x07, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF,
  0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFE,
  0x07, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xF8,
  0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF8,
  0x3F, 0xC0, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFE,
  0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x1F, 0xF0, 0x01, 0xFF,
  0x1F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFF,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF8,
  0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0,
  0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x03, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF,
  0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFE,
  0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x07, 0xF8,
  0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07,
  0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFE, 0x7F, 0xC0, 0xFF, 0xFE, 0x7F,
  0xC0, 0xFF, 0xFE, 0x7F, 0xC0, 0xFF, 0xFC, 0x7F, 0x80, 0xFF, 0xFC, 0x7F,
  0x81, 0xFF, 0xFC, 0x7F, 0x81, 0xFF, 0xFC, 0x7F, 0x80, 0x07, 0xFC, 0x7F,
  0x80, 0x07, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xC0,
  0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFF, 0x80,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0,
  0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x1F,
  0xF0, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF8, 0x03,
  0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0xFF,
  0xC0, 0x07, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x03, 0xFE,
  0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0x07, 0xF8, 0x7F, 0xE0, 0x00, 0x3F, 0xC7, 0xFE, 0x00, 0x03, 0xFE, 0x3F,
  0xE0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00, 0x07,
  0xFB, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x0F,
  0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0x3F, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFE, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0xFB, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xEF, 0xC0,
  0x7F, 0x7F, 0x80, 0x7F, 0xBF, 0x01, 0xFD, 0xFE, 0x03, 0xFC, 0xFC, 0x0F,
  0xEF, 0xF0, 0x0F, 0xF3, 0xF0, 0x3F, 0xBF, 0xC0, 0x3F, 0xCF, 0xE1, 0xFC,
  0xFF, 0x00, 0xFF, 0x3F, 0x87, 0xF3, 0xFC, 0x03, 0xFC, 0xFE, 0x1F, 0x8F,
  0xF0, 0x0F, 0xF3, 0xF8, 0xFE, 0x7F, 0xC0, 0x7F, 0xC7, 0xE3, 0xF1, 0xFE,
  0x01, 0xFE, 0x1F, 0x9F, 0xC7, 0xF8, 0x07, 0xF8, 0x7E, 0x7E, 0x1F, 0xE0,
  0x1F, 0xE1, 0xFB, 0xF8, 0xFF, 0x80, 0x7F, 0x87, 0xEF, 0xE3, 0xFE, 0x03,
  0xFE, 0x1F, 0xBF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7F, 0xFC, 0x3F, 0xC0, 0x3F,
  0xE1, 0xFF, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xFF, 0x83, 0xFC, 0x03, 0xFC,
  0x0F, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0,
  0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x07, 0xFC, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0xFF,
  0x03, 0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x7F, 0xE0, 0x03, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF8,
  0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xC0,
  0x7F, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F,
  0xFE, 0x01, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF,
  0x80, 0xFF, 0xFE, 0x07, 0xFC, 0x07, 0xFB, 0xF8, 0x3F, 0xC0, 0x3F, 0xCF,
  0xC1, 0xFE, 0x01, 0xFE, 0x7E, 0x0F, 0xF0, 0x1F, 0xF3, 0xF0, 0xFF, 0x80,
  0xFF, 0x9F, 0xC7, 0xFC, 0x07, 0xFC, 0x7E, 0x3F, 0xE0, 0x3F, 0xC3, 0xF1,
  0xFE, 0x01, 0xFE, 0x1F, 0x8F, 0xF0, 0x0F, 0xF0, 0x7E, 0x7F, 0x80, 0xFF,
  0x83, 0xF7, 0xFC, 0x07, 0xFC, 0x1F, 0xBF, 0xE0, 0x3F, 0xE0, 0xFD, 0xFE,
  0x01, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0x01,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x3F,
  0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x03, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC,
  0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x7F,
  0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03,
  0xFE, 0x7F, 0xC0, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80,
  0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8,
  0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xE0, 0x3F,
  0xE0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x81,
  0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F,
  0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x01,
  0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x0F, 0xF9, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x03, 0xFC, 0x7F, 0x80,
  0x01, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x3F,
  0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x03,
  0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFC, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0,
  0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF8, 0x03, 0xFE,
  0x07, 0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFF,
  0x81, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x1F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF1,
  0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07,
  0xFE, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00,
  0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0,
  0x03, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0xFC, 0x1F,
  0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x3F, 0xE0,
  0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8,
  0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0xFF, 0xDF, 0xF0, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x7F, 0xE7, 0xFC, 0x00, 0x3F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F, 0xFC,
  0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3,
  0xFC, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x03, 0xFD,
  0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xFF, 0xE0,
  0x1F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFB, 0xFE, 0x03, 0xFE,
  0x01, 0xFE, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x3F, 0xE0, 0x3F,
  0xCF, 0xF8, 0x1F, 0xF8, 0x0F, 0xF3, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x7F,
  0x81, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0xFF, 0xE0, 0x7F, 0x87, 0xF8, 0x3F,
  0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFF, 0x83,
  0xFC, 0x1F, 0xE1, 0xFF, 0xE0, 0xFF, 0x07, 0xF8, 0x7F, 0xF8, 0x7F, 0x81,
  0xFE, 0x3F, 0xFE, 0x1F, 0xE0, 0x7F, 0x8F, 0xFF, 0x87, 0xF8, 0x1F, 0xE3,
  0xFF, 0xE3, 0xFC, 0x07, 0xF9, 0xFD, 0xF8, 0xFF, 0x01, 0xFE, 0x7F, 0x7E,
  0x3F, 0xC0, 0x7F, 0x1F, 0x9F, 0x9F, 0xE0, 0x1F, 0xCF, 0xE7, 0xE7, 0xF8,
  0x07, 0xF3, 0xF9, 0xF9, 0xFE, 0x01, 0xFC, 0xFC, 0x7E, 0xFF, 0x00, 0x7F,
  0x7F, 0x1F, 0xBF, 0xC0, 0x1F, 0xDF, 0xC7, 0xEF, 0xF0, 0x07, 0xF7, 0xE1,
  0xFB, 0xF8, 0x01, 0xFF, 0xF8, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x00, 0xFF,
  0x87, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0xFF, 0x80,
  0x00, 0x1F, 0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x7F,
  0x80, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0xFF,
  0x80, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xF9,
  0xFE, 0x00, 0x3F, 0xF3, 0xFE, 0x00, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x8F,
  0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x00, 0xFF,
  0x07, 0xFC, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8,
  0xFF, 0x80, 0x07, 0xF1, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xEF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0x7C, 0x03, 0xF7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0xFC, 0x7E,
  0x0F, 0xC7, 0xE1, 0xFC, 0x3E, 0x1F, 0x83, 0xE3, 0xF8, 0x3F, 0x3F, 0x03,
  0xF7, 0xF0, 0x3F, 0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0x81,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF1, 0xFE, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0x0F, 0xF0, 0xFF, 0x83,
  0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFE,
  0x07, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0xFF, 0x87, 0xFC, 0x7F, 0xE1,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xF7, 0xF8, 0x07, 0xF9, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x7F, 0x80, 0x3F, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0,
  0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE3,
  0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01,
  0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF9, 0xFF, 0x00, 0xFF, 0x3F,
  0xC0, 0x1F, 0xE7, 0xF8, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x1F,
  0xE3, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0xFF, 0x9F, 0xF8, 0x3F, 0xE3, 0xFF,
  0xDF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFD, 0xFF, 0xF8,
  0x7F, 0xBF, 0xFE, 0x0F, 0xF3, 0xFF, 0x81, 0xFE, 0x3F, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0xF3, 0xFE, 0x1F, 0xE0, 0x7F, 0x9F, 0xF0, 0x3F, 0xCF, 0xF0, 0x1F,
  0xE7, 0xF8, 0x0F, 0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x03, 0xF8, 0xFE, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC1, 0xFE, 0x1F,
  0xFB, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF1, 0xFF, 0x00, 0x7F, 0xF7,
  0xF8, 0x07, 0xFF, 0xDF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFD, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x03,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80,
  0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x1F,
  0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFD,
  0xFC, 0x00, 0x3F, 0xE7, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xF7, 0xFE,
  0x1F, 0xF0, 0x7F, 0x87, 0xF8, 0x0F, 0xE3, 0xFC, 0x03, 0xFC, 0xFF, 0x00,
  0xFF, 0x3F, 0xC0, 0x3F, 0xDF, 0xF0, 0x0F, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x18, 0x1F, 0xF0, 0x1E, 0x07, 0xFF,
  0xBF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xF1, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xFE, 0x1F,
  0xC0, 0x3F, 0xF9, 0xFE, 0x03, 0xFF, 0xEF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xDF, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xF8, 0x07, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x87,
  0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xE1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x1F,
  0xE1, 0xFF, 0x01, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x03, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x03, 0x00, 0x3F, 0xE0, 0x1E, 0x03, 0xFE, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x20,
  0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xDF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xEF, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0x1F, 0xF0,
  0x3F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F, 0xF1, 0xFE, 0x03,
  0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x3F,
  0xE0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x3F,
  0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xC1,
  0xFE, 0x07, 0xFE, 0x07, 0xF8, 0x3F, 0xF0, 0x1F, 0xE1, 0xFF, 0x80, 0x7F,
  0x87, 0xFC, 0x03, 0xFE, 0x3F, 0xF0, 0x0F, 0xF1, 0xFF, 0x80, 0x3F, 0xCF,
  0xFC, 0x00, 0xFF, 0x3F, 0xE0, 0x03, 0xFD, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0x7F, 0x80, 0x0F, 0xF9, 0xFE, 0x00, 0x3F, 0xC7, 0xFC, 0x01, 0xFE, 0x0F,
  0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0x81, 0xFE,
  0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0,
  0xFF, 0x00, 0xFF, 0x83, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xFF, 0xF3, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFD, 0xFF, 0xFB, 0xFF, 0x0F, 0xF8, 0x3F,
  0xF0, 0x7F, 0x87, 0xF8, 0x1F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF8, 0x1F,
  0xE1, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x8F, 0xF0, 0x3F, 0xE0, 0x7F,
  0x8F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF0, 0x1F, 0xE3, 0xFC,
  0x07, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0xFF, 0x01, 0xFE,
  0x07, 0xFC, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x7F, 0xC0, 0xFF, 0x01, 0xFE,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0,
  0x1F, 0xE0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF8,
  0x1F, 0xE3, 0xFE, 0x07, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x1F, 0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xF7, 0xFF, 0x0F, 0xF8, 0x3F,
  0xE1, 0xFE, 0x07, 0xFC, 0x3F, 0xC0, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFE,
  0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE,
  0x1F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xE0,
  0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3,
  0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03,
  0xFC, 0x3F, 0xC0, 0x7F, 0x8F, 0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xF7, 0xFE,
  0x1F, 0xF0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00,
  0xFF, 0x7F, 0xC0, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE,
  0x00, 0xFF, 0x7F, 0x80, 0x3F, 0xDF, 0xE0, 0x0F, 0xF7, 0xF8, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xE7, 0xF8, 0x07,
  0xF9, 0xFE, 0x03, 0xFE, 0x7F, 0x80, 0xFF, 0x1F, 0xF0, 0x7F, 0xC7, 0xFE,
  0x7F, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xF7, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F,
  0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07,
  0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F,
  0xC1, 0xFE, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x07,
  0xFF, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0x7F, 0xFC, 0x07, 0xF9, 0xFF, 0xC0, 0x3F, 0xC7, 0xFC,
  0x01, 0xFE, 0x06, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0xCF, 0xF0, 0x7F, 0xFC, 0xFE, 0x07,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xDF,
  0xFE, 0x3F, 0xF0, 0x7F, 0xC3, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3,
  0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x07, 0xFC, 0x7F, 0x80,
  0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8,
  0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x0F, 0xF0,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x81, 0xFF,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0xE7, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFB, 0xFC, 0x00, 0x08, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xCF, 0xC1, 0xFE, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F,
  0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xF1, 0xFE,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F,
  0xC0, 0x7F, 0x87, 0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF8, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x01, 0x80, 0x00, 0x1F, 0xE0, 0x3F,
  0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE,
  0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x3F, 0xE0,
  0x3F, 0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3,
  0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x3F, 0xE3, 0xFC, 0x07,
  0xFC, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xFB, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFE, 0xFE, 0x00, 0xFF, 0x9F, 0xC0, 0x01, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xBF, 0xE0, 0x7F, 0xDF, 0xF0,
  0x3F, 0xE7, 0xF8, 0x1F, 0xE3, 0xFC, 0x1F, 0xF1, 0xFE, 0x0F, 0xF0, 0xFF,
  0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xC3, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F,
  0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x7F, 0x80,
  0x7F, 0x3F, 0x80, 0x3F, 0x9F, 0xC0, 0x1F, 0xDF, 0xE0, 0x0F, 0xEF, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x1F, 0xFF, 0xC0, 0x7E,
  0x03, 0xFB, 0xF8, 0x1F, 0xC0, 0xFF, 0x7F, 0x03, 0xF8, 0x1F, 0xEF, 0xE0,
  0xFF, 0x03, 0xF9, 0xFC, 0x1F, 0xE0, 0xFF, 0x3F, 0x83, 0xFC, 0x1F, 0xE7,
  0xF0, 0xFF, 0x83, 0xF8, 0xFE, 0x1F, 0xF8, 0xFF, 0x1F, 0xC7, 0xFF, 0x1F,
  0xC3, 0xF8, 0xFF, 0xE3, 0xF8, 0x7F, 0x3F, 0xFC, 0xFF, 0x0F, 0xE7, 0xFF,
  0x9F, 0xC1, 0xFC, 0xFF, 0xF3, 0xF8, 0x3F, 0xBF, 0xFE, 0xFF, 0x07, 0xF7,
  0xEF, 0xDF, 0xC0, 0xFF, 0xFD, 0xFB, 0xF8, 0x1F, 0xFF, 0x3F, 0xFE, 0x03,
  0xFF, 0xE7, 0xFF, 0xC0, 0x7F, 0xF8, 0xFF, 0xF8, 0x0F, 0xFF, 0x1F, 0xFE,
  0x01, 0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xF8, 0x3F, 0xF8, 0x07, 0xFF, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF,
  0x80, 0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0xFF, 0x80,
  0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0xFF, 0x7F, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xDF, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x3F,
  0xE7, 0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0,
  0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x3F, 0xE0, 0x1F,
  0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC,
  0xFF, 0x80, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F, 0x7F,
  0x80, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x40,
  0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x0F, 0xC3, 0xFF, 0x80, 0x7E, 0x3F, 0xFE, 0x07, 0xE1, 0xFF, 0xF0,
  0x3F, 0x1F, 0xFF, 0xC1, 0xF8, 0xFF, 0xFF, 0x1F, 0xCF, 0xE3, 0xFF, 0xFC,
  0x7F, 0x0F, 0xFF, 0xE3, 0xF0, 0x3F, 0xFE, 0x1F, 0x81, 0xFF, 0xF1, 0xF8,
  0x07, 0xFF, 0x0F, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x3E, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 44, 15, 1, -43 },
  { 89, 17, 16, 19, 4, -46 },
  { 123, 31, 43, 31, 1, -43 },
  { 290, 27, 57, 30, 2, -50 },
  { 483, 29, 45, 38, 5, -44 },
  { 647, 30, 45, 34, 1, -44 },
  { 816, 8, 16, 10, 4, -46 },
  { 832, 19, 62, 19, 3, -48 },
  { 980, 20, 62, 19, -3, -48 },
  { 1135, 26, 26, 27, 3, -43 },
  { 1220, 25, 32, 28, 2, -37 },
  { 1320, 12, 18, 14, -3, -7 },
  { 1347, 15, 7, 21, 3, -22 },
  { 1361, 10, 10, 17, 1, -9 },
  { 1374, 27, 47, 20, -4, -43 },
  { 1533, 26, 45, 30, 3, -44 },
  { 1680, 18, 43, 30, 7, -43 },
  { 1777, 29, 44, 30, 0, -44 },
  { 1937, 28, 45, 30, 1, -44 },
  { 2095, 28, 43, 30, 1, -43 },
  { 2246, 28, 44, 30, 2, -43 },
  { 2400, 25, 44, 30, 2, -43 },
  { 2538, 28, 43, 30, 3, -43 },
  { 2689, 27, 45, 30, 2, -44 },
  { 2841, 24, 44, 30, 4, -44 },
  { 2973, 14, 34, 16, 1, -33 },
  { 3033, 18, 44, 15, -3, -33 },
  { 3132, 24, 29, 26, 1, -33 },
  { 3219, 26, 20, 30, 2, -29 },
  { 3284, 25, 29, 27, 1, -33 },
  { 3375, 23, 45, 26, 4, -44 },
  { 3505, 42, 56, 45, 1, -42 },
  { 3799, 35, 43, 35, -3, -43 },
  { 3988, 32, 43, 33, 0, -43 },
  { 4160, 32, 45, 34, 2, -44 },
  { 4340, 32, 43, 33, 0, -43 },
  { 4512, 32, 43, 29, 0, -43 },
  { 4684, 31, 43, 28, 0, -43 },
  { 4851, 32, 45, 35, 2, -44 },
  { 5031, 37, 43, 36, 0, -43 },
  { 5230, 16, 43, 16, 1, -43 },
  { 5316, 30, 44, 29, 0, -43 },
  { 5481, 37, 43, 33, 0, -43 },
  { 5680, 25, 43, 28, 0, -43 },
  { 5815, 46, 43, 45, 0, -43 },
  { 6063, 37, 43, 36, 0, -43 },
  { 6262, 33, 45, 36, 2, -44 },
  { 6448, 34, 43, 34, 0, -43 },
  { 6631, 33, 52, 36, 2, -44 },
  { 6846, 33, 43, 33, 0, -43 },
  { 7024, 31, 45, 32, 1, -44 },
  { 7199, 30, 43, 32, 5, -43 },
  { 7361, 33, 44, 34, 2, -43 },
  { 7543, 33, 43, 34, 5, -43 },
  { 7721, 42, 43, 44, 5, -43 },
  { 7947, 38, 43, 33, -2, -43 },
  { 8152, 31, 43, 32, 5, -43 },
  { 8319, 35, 43, 31, -1, -43 },
  { 8508, 21, 60, 16, -1, -50 },
  { 8666, 15, 47, 23, 5, -43 },
  { 8755, 20, 60, 16, -3, -50 },
  { 8905, 20, 22, 23, 2, -43 },
  { 8960, 24, 7, 24, -4, 0 },
  { 8981, 13, 9, 20, 6, -46 },
  { 8996, 26, 34, 28, 0, -33 },
  { 9107, 27, 47, 29, 0, -46 },
  { 9266, 25, 34, 27, 1, -33 },
  { 9373, 30, 47, 29, 1, -46 },
  { 9550, 26, 34, 28, 1, -33 },
  { 9661, 21, 47, 19, 2, -47 },
  { 9785, 29, 45, 30, 0, -33 },
  { 9949, 27, 46, 29, 0, -46 },
  { 10105, 16, 45, 15, 0, -45 },
  { 10195, 23, 57, 15, -7, -45 },
  { 10359, 30, 46, 28, 0, -46 },
  { 10532, 16, 46, 15, 0, -46 },
  { 10624, 41, 33, 44, 0, -33 },
  { 10794, 27, 33, 29, 0, -33 },
  { 10906, 26, 34, 29, 1, -33 },
  { 11017, 29, 45, 29, -2, -33 },
  { 11181, 28, 45, 29, 1, -33 },
  { 11339, 21, 33, 20, 0, -33 },
  { 11426, 26, 34, 27, 0, -33 },
  { 11537, 17, 41, 18, 2, -40 },
  { 11625, 27, 33, 29, 2, -32 },
  { 11737, 25, 32, 27, 3, -32 },
  { 11837, 35, 32, 37, 4, -32 },
  { 11977, 30, 32, 27, -2, -32 },
  { 12097, 30, 44, 26, -2, -32 },
  { 12262, 28, 32, 27, -1, -32 },
  { 12374, 19, 59, 18, 1, -48 },
  { 12515, 13, 51, 15, 1, -43 },
  { 12598, 19, 59, 18, -2, -48 },
  { 12739, 29, 14, 33, 2, -25 },
};

const GFXfont RobotoCondensed_BoldItalic61pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic61pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic61pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOCONDENSED_BOLDITALIC61PT7B_H_
