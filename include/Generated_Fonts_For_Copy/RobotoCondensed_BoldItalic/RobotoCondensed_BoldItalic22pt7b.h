#ifndef _ROBOTOCONDENSED_BOLDITALIC22PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xCE, 0x38, 0xE3, 0x8E, 0x30, 0xC7, 0x00, 0x01, 0x8F,
  0x18, 0x66, 0xDD, 0xB3, 0x64, 0xD9, 0x80, 0x03, 0x60, 0xCC, 0x1B, 0x03,
  0x63, 0xFE, 0x7F, 0xC3, 0x60, 0x4C, 0x1B, 0x03, 0x61, 0xFF, 0x7F, 0xE3,
  0x60, 0x6C, 0x19, 0x03, 0x60, 0x02, 0x00, 0x80, 0xF0, 0xFE, 0x3F, 0x9C,
  0x67, 0x1D, 0xC0, 0x38, 0x0F, 0x01, 0xF0, 0x1C, 0x07, 0x38, 0xCE, 0x73,
  0xFC, 0x7E, 0x0F, 0x01, 0x00, 0xC0, 0x78, 0x1E, 0x0C, 0xCF, 0x36, 0xCD,
  0xBE, 0xC7, 0x60, 0x30, 0x0C, 0x06, 0xE3, 0x7C, 0xDB, 0x6C, 0xF3, 0x34,
  0x7C, 0x1E, 0x07, 0x01, 0xF0, 0x7F, 0x0C, 0xE1, 0x9C, 0x37, 0x07, 0xC0,
  0xF0, 0x3E, 0x6F, 0xDD, 0xDF, 0xF3, 0xEE, 0x3C, 0xEF, 0x9F, 0xF1, 0xEF,
  0x6D, 0xB7, 0x80, 0x04, 0x1C, 0x70, 0xC3, 0x86, 0x1C, 0x30, 0x60, 0xC3,
  0x87, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x81, 0x83, 0x03, 0x04, 0x00, 0x10,
  0x30, 0x30, 0x60, 0xE1, 0xC1, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x87,
  0x0E, 0x18, 0x70, 0xC3, 0x0E, 0x10, 0x00, 0x0C, 0x06, 0x03, 0x0D, 0xBF,
  0xF8, 0xF0, 0xF0, 0xEC, 0x66, 0x01, 0x00, 0x0E, 0x06, 0x07, 0x03, 0x8F,
  0xFF, 0xFF, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x33, 0x77, 0x6E, 0xC0,
  0x7F, 0xEF, 0x80, 0x7F, 0x60, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x60, 0x30,
  0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x01, 0x81, 0xC0, 0xC0,
  0x00, 0x0F, 0x1F, 0xCE, 0xEE, 0x77, 0x1B, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x6E, 0x77, 0xF9, 0xF8, 0x78, 0x06, 0x3D, 0xFB, 0xED, 0xC3,
  0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x0F, 0x87, 0xF3,
  0xFC, 0xE7, 0x31, 0xC0, 0x70, 0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xE0, 0xF0,
  0x78, 0x1F, 0xEF, 0xFB, 0xFE, 0x0F, 0x07, 0xF3, 0xFC, 0xE7, 0x01, 0xC0,
  0x70, 0x3C, 0x3C, 0x0F, 0x80, 0xE0, 0x1B, 0x86, 0xE3, 0x9F, 0xE7, 0xF0,
  0xF8, 0x01, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC3, 0xE1, 0xF8, 0x6E, 0x3B,
  0x9C, 0xE7, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x70, 0x1C, 0x3F, 0xCF, 0xF3,
  0xF8, 0xC0, 0x70, 0x1F, 0x87, 0xF1, 0xDC, 0x03, 0x80, 0xE0, 0x3B, 0x8C,
  0xE7, 0x3F, 0xC7, 0xE0, 0xF0, 0x07, 0x07, 0x87, 0xC7, 0x07, 0x03, 0xF1,
  0xFD, 0xEF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x77, 0xF9, 0xF8, 0x78, 0x7F,
  0xDF, 0xF7, 0xFC, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0x0F, 0x1F, 0xCE, 0xEE, 0x77,
  0x3B, 0x9C, 0xFE, 0x7E, 0x7F, 0x73, 0xB9, 0xDC, 0xEE, 0x77, 0xFB, 0xF8,
  0x78, 0x1E, 0x1F, 0x8F, 0xEE, 0x77, 0x3B, 0x9D, 0x8E, 0xE7, 0x77, 0xBF,
  0xCF, 0xC0, 0xE0, 0xE3, 0xF1, 0xF0, 0xE0, 0x39, 0xCE, 0x00, 0x00, 0x00,
  0x03, 0xBC, 0xC0, 0x1C, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x0C,
  0x71, 0xCE, 0x10, 0x00, 0x81, 0xC3, 0xEF, 0xC7, 0x83, 0x81, 0xF0, 0x3E,
  0x07, 0x01, 0x00, 0x7F, 0xBF, 0xDF, 0xE0, 0x00, 0x07, 0xFB, 0xFD, 0xFE,
  0x20, 0x1C, 0x0F, 0x03, 0xE0, 0x78, 0x1C, 0x3E, 0xFC, 0x78, 0x30, 0x20,
  0x00, 0x1E, 0x3F, 0x9F, 0xEE, 0x70, 0x38, 0x38, 0x3C, 0x3C, 0x1C, 0x1C,
  0x0E, 0x00, 0x00, 0x03, 0x81, 0xC0, 0xE0, 0x01, 0xF0, 0x07, 0xFC, 0x0E,
  0x0E, 0x1C, 0x06, 0x18, 0x02, 0x31, 0xE2, 0x33, 0xF3, 0x67, 0x33, 0x66,
  0x62, 0x66, 0x62, 0x6E, 0x66, 0xCC, 0x66, 0xCE, 0xE4, 0xCF, 0xFC, 0xC7,
  0x78, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x01,
  0xC0, 0x1E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x0E, 0xE0, 0xE6, 0x0E,
  0x61, 0xC7, 0x1F, 0xF3, 0xFF, 0x3F, 0xF7, 0x07, 0x70, 0x7F, 0x07, 0x1F,
  0xC1, 0xFE, 0x3F, 0xE3, 0x8F, 0x38, 0xF3, 0x8E, 0x39, 0xE3, 0xFC, 0x7F,
  0xC7, 0x1C, 0x70, 0xE7, 0x0E, 0x71, 0xC7, 0xFC, 0xFF, 0x8F, 0xF0, 0x0F,
  0x83, 0xF8, 0xFF, 0xB8, 0x77, 0x0E, 0xE1, 0xF8, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0xEE, 0x1D, 0xFF, 0x1F, 0xE1, 0xF0, 0x1F, 0x81, 0xFC,
  0x3F, 0xE3, 0x8E, 0x38, 0x63, 0x87, 0x38, 0xF3, 0x8E, 0x70, 0xE7, 0x0E,
  0x70, 0xE7, 0x0E, 0x71, 0xC7, 0xF8, 0xFF, 0x8F, 0xE0, 0x1F, 0xE1, 0xFE,
  0x3F, 0xE3, 0x80, 0x38, 0x03, 0x80, 0x3F, 0xC3, 0xF8, 0x7F, 0x87, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0xF8, 0xFF, 0x8F, 0xF8, 0x1F, 0xE3, 0xFC,
  0xFF, 0x9C, 0x03, 0x80, 0x70, 0x0F, 0xE1, 0xFC, 0x7F, 0x8E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0xBC,
  0x77, 0x0E, 0xE0, 0x3C, 0x07, 0x00, 0xE7, 0xFC, 0xFF, 0x87, 0x70, 0xEE,
  0x1C, 0xFF, 0x9F, 0xE1, 0xF8, 0x1C, 0x38, 0xE1, 0xCE, 0x0E, 0x70, 0x73,
  0x83, 0x9C, 0x3C, 0xFF, 0xC7, 0xFE, 0x7F, 0xF3, 0x83, 0x9C, 0x1C, 0xE1,
  0xE7, 0x0E, 0x38, 0x73, 0x83, 0x9C, 0x1C, 0x1C, 0x71, 0xCE, 0x38, 0xE3,
  0x8E, 0x79, 0xC7, 0x1C, 0x71, 0xCF, 0x38, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x71, 0xCE,
  0x39, 0xFE, 0x1F, 0x81, 0xE0, 0x1C, 0x78, 0x71, 0xC3, 0x8F, 0x0E, 0x78,
  0x3B, 0xC0, 0xEE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xB8,
  0x1C, 0xE0, 0x73, 0xC1, 0xC7, 0x0E, 0x1C, 0x38, 0x78, 0x1C, 0x0E, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0xFF, 0xFF, 0xFF, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x87, 0xC7, 0xC3, 0xE3,
  0xE1, 0xF1, 0xF1, 0xF8, 0xF8, 0xD8, 0x6C, 0xFC, 0x76, 0x6E, 0x3B, 0xB7,
  0x1D, 0xFB, 0x8E, 0xF9, 0xC7, 0x3D, 0xC3, 0x9C, 0xE3, 0x8E, 0x71, 0xC6,
  0x38, 0x1C, 0x38, 0xE1, 0xCF, 0x0E, 0x7C, 0x73, 0xE3, 0x9F, 0x3C, 0xF9,
  0xC7, 0x6E, 0x73, 0x73, 0x9B, 0x9C, 0xFC, 0xE3, 0xC7, 0x1E, 0x38, 0xF3,
  0x87, 0x9C, 0x1C, 0x0F, 0x83, 0xF8, 0xFF, 0xBC, 0x77, 0x0E, 0xE1, 0xF8,
  0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xEE, 0x1D, 0xFF, 0x1F, 0xE1,
  0xF0, 0x1F, 0xC1, 0xFE, 0x3F, 0xF3, 0x87, 0x38, 0x73, 0x87, 0x38, 0xF3,
  0xFE, 0x7F, 0xC7, 0xF8, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0x0F, 0x83, 0xF8, 0xFF, 0xBC, 0x77, 0x0E, 0xE1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xEE, 0x1C, 0xFF, 0x1F, 0xC1, 0xF8, 0x03,
  0x80, 0x70, 0x04, 0x00, 0x1F, 0xC1, 0xFE, 0x3F, 0xE3, 0x87, 0x38, 0x73,
  0x87, 0x38, 0xE3, 0xFE, 0x7F, 0xC7, 0xF8, 0x73, 0x87, 0x38, 0x73, 0xC7,
  0x1C, 0xE1, 0xCE, 0x1C, 0x07, 0x81, 0xFE, 0x1F, 0xE3, 0x8E, 0x38, 0x73,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xCF, 0x1C, 0x71, 0xC7,
  0xFC, 0x3F, 0x81, 0xF0, 0xFF, 0xFF, 0xFB, 0xFF, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0x38, 0x77, 0x8E, 0x70, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x70,
  0xEF, 0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0x8F, 0xF8, 0x7F,
  0x03, 0xE0, 0xE0, 0xEE, 0x0E, 0xE1, 0xEE, 0x1C, 0xE3, 0xCE, 0x38, 0xE3,
  0x87, 0x70, 0x77, 0x07, 0x70, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x78,
  0x03, 0x80, 0xE3, 0x8F, 0xC7, 0x1F, 0x9E, 0x77, 0x3C, 0xEE, 0x79, 0xDD,
  0xF7, 0x3B, 0xEE, 0x76, 0xDC, 0xFD, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF,
  0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x70, 0x70, 0xE0, 0x1C, 0x3C, 0x78, 0xE0,
  0xE7, 0x83, 0x9C, 0x0E, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0x80,
  0x3F, 0x00, 0xFC, 0x07, 0x70, 0x3D, 0xC0, 0xE3, 0x87, 0x8E, 0x1C, 0x38,
  0xE1, 0xFC, 0x3B, 0x8F, 0x39, 0xC7, 0x78, 0xEE, 0x1F, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x3F, 0xF3,
  0xFF, 0x3F, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFC, 0xFF, 0xCF, 0xFC, 0x1E, 0x3C,
  0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x00, 0xE7, 0x39, 0xCE, 0x31, 0xCE, 0x73,
  0x9C, 0xE7, 0x1C, 0xE7, 0x38, 0x1E, 0x3C, 0x38, 0x70, 0xE3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x8F, 0x1E,
  0x00, 0x1C, 0x38, 0xF1, 0xE7, 0xEC, 0xF9, 0xE3, 0xFF, 0xFF, 0x73, 0x8E,
  0x0F, 0x1F, 0xCE, 0xEE, 0x70, 0x38, 0xFD, 0xFF, 0xE7, 0xE3, 0x7B, 0x9F,
  0xCF, 0xE0, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xE3, 0xF8, 0xFF,
  0x71, 0xDC, 0x77, 0x1D, 0xC7, 0x71, 0xDC, 0xEF, 0xFB, 0xFC, 0xEE, 0x00,
  0x0F, 0x1F, 0xCE, 0xEE, 0x37, 0x1B, 0x81, 0xC0, 0xC0, 0x63, 0xBB, 0x9F,
  0xC7, 0xC0, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x3B, 0x8F, 0xF3,
  0xFE, 0x71, 0xCE, 0x39, 0xC6, 0x31, 0xCE, 0x39, 0xC7, 0x1F, 0xE3, 0xFC,
  0x3B, 0x00, 0x1E, 0x3F, 0x9D, 0xDC, 0x7E, 0x3F, 0xFF, 0xFD, 0xC0, 0xE0,
  0x7F, 0x3F, 0x87, 0x80, 0x0E, 0x3C, 0xF9, 0xC3, 0x9F, 0xBF, 0x38, 0x70,
  0xE1, 0xC3, 0x8E, 0x1C, 0x38, 0x70, 0xE0, 0x1E, 0xC7, 0xF8, 0xFF, 0x38,
  0xE7, 0x1C, 0xE3, 0x9C, 0xE3, 0x1C, 0x73, 0x8F, 0xF1, 0xFE, 0x1D, 0xC0,
  0x70, 0xDE, 0x3F, 0x83, 0xE0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0xE3, 0xF9, 0xFF, 0x71, 0xDC, 0x77, 0x39, 0xCE, 0x73, 0xB8, 0xEE, 0x3B,
  0x8E, 0xE7, 0x00, 0x18, 0x71, 0x80, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x1C,
  0x71, 0x8E, 0x38, 0x06, 0x0F, 0x06, 0x00, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0xF8, 0xF0, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x73, 0xCE, 0xF1, 0xBC, 0x77, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0x70, 0xCE, 0x39, 0xC7, 0x3C, 0xE3, 0x80, 0x1C,
  0x71, 0x8E, 0x38, 0xE3, 0x8E, 0x31, 0xC7, 0x1C, 0x71, 0xC6, 0x38, 0xE0,
  0x3F, 0xBC, 0x7F, 0xFC, 0xEF, 0xFB, 0x8E, 0x77, 0x18, 0xEE, 0x71, 0xDC,
  0xE3, 0xB9, 0xCE, 0x63, 0x9D, 0xC7, 0x3B, 0x8E, 0x77, 0x38, 0xE0, 0x3F,
  0x8F, 0xE7, 0xFD, 0xC7, 0x71, 0xDC, 0xE7, 0x39, 0xCE, 0xE3, 0xB8, 0xEE,
  0x3B, 0x9C, 0x0F, 0x0F, 0xE3, 0xBD, 0xC7, 0x71, 0xDC, 0x77, 0x1D, 0x87,
  0x73, 0x9F, 0xE7, 0xF0, 0xF8, 0x1F, 0xC3, 0xF8, 0x7F, 0x9C, 0x73, 0x8E,
  0x71, 0xCE, 0x39, 0xC7, 0x71, 0xCF, 0xF9, 0xFE, 0x3B, 0x87, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0x1E, 0xCF, 0xF7, 0xBD, 0xC7, 0x71, 0xDC, 0xE6, 0x3B,
  0x8E, 0x63, 0x9F, 0xE7, 0xF8, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x3E,
  0x3E, 0x3E, 0x78, 0x70, 0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0x1F,
  0x1F, 0xDE, 0xEE, 0x77, 0x81, 0xF0, 0x7C, 0x0E, 0xE3, 0x73, 0x9F, 0xC7,
  0x80, 0x38, 0xEF, 0xFF, 0x71, 0xC7, 0x1C, 0xE3, 0x8E, 0x3C, 0xF1, 0xC0,
  0x73, 0xB9, 0xF8, 0xFC, 0x7E, 0x3F, 0x3B, 0x9D, 0xCE, 0xE7, 0x7F, 0xBF,
  0xCE, 0xC0, 0xE3, 0xF3, 0xF9, 0xDC, 0xE6, 0xE3, 0x71, 0xB0, 0xF8, 0x7C,
  0x3C, 0x1E, 0x0E, 0x00, 0xE7, 0x3F, 0x39, 0xF9, 0xDD, 0xDE, 0xEE, 0xF6,
  0x7F, 0xF3, 0xEF, 0x8F, 0x78, 0x73, 0xC3, 0x9E, 0x1C, 0xE0, 0xC7, 0x00,
  0x38, 0xE3, 0xB8, 0x77, 0x0F, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x3B,
  0x07, 0x71, 0xCE, 0x39, 0xC0, 0x38, 0xE7, 0x3C, 0xE7, 0x1C, 0xE1, 0xB8,
  0x37, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0xF0,
  0x1E, 0x07, 0x00, 0x3F, 0xCF, 0xE7, 0xF8, 0x1C, 0x0E, 0x07, 0x81, 0xC0,
  0xE0, 0x70, 0x3F, 0xCF, 0xF3, 0xFC, 0x02, 0x1C, 0x30, 0xE1, 0xC3, 0x06,
  0x0C, 0x38, 0x71, 0xC3, 0x07, 0x06, 0x1C, 0x38, 0x70, 0xE1, 0xC1, 0x81,
  0x00, 0x18, 0xC6, 0x31, 0x18, 0xC6, 0x31, 0x88, 0xC6, 0x31, 0x8C, 0x62,
  0x30, 0x18, 0x30, 0x30, 0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x18, 0x38, 0xF1,
  0xC7, 0x0E, 0x1C, 0x30, 0x61, 0xC7, 0x04, 0x00, 0x38, 0xDF, 0x3F, 0xFF,
  0x3E, 0xC7, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 16, 6, 0, -16 },
  { 13, 7, 6, 7, 1, -17 },
  { 19, 11, 16, 11, 0, -16 },
  { 41, 10, 20, 11, 1, -18 },
  { 66, 10, 16, 14, 2, -16 },
  { 86, 11, 16, 12, 0, -16 },
  { 108, 3, 6, 3, 1, -17 },
  { 111, 7, 22, 7, 1, -17 },
  { 131, 7, 22, 7, -1, -17 },
  { 151, 9, 10, 10, 1, -16 },
  { 163, 9, 11, 10, 1, -13 },
  { 176, 4, 7, 5, -1, -3 },
  { 180, 6, 3, 8, 1, -8 },
  { 183, 4, 3, 6, 0, -3 },
  { 185, 9, 17, 7, -1, -16 },
  { 205, 9, 16, 11, 1, -16 },
  { 223, 7, 16, 11, 2, -16 },
  { 237, 10, 16, 11, 0, -16 },
  { 257, 10, 16, 11, 0, -16 },
  { 277, 10, 16, 11, 0, -16 },
  { 297, 10, 16, 11, 1, -16 },
  { 317, 9, 16, 11, 1, -16 },
  { 335, 10, 16, 11, 1, -16 },
  { 355, 9, 16, 11, 1, -16 },
  { 373, 9, 16, 11, 1, -16 },
  { 391, 5, 12, 6, 0, -12 },
  { 399, 6, 16, 6, -1, -12 },
  { 411, 9, 10, 10, 0, -12 },
  { 423, 9, 8, 11, 1, -11 },
  { 432, 9, 11, 10, 0, -12 },
  { 445, 9, 16, 10, 1, -16 },
  { 463, 16, 20, 16, 0, -15 },
  { 503, 12, 16, 13, -1, -16 },
  { 527, 12, 16, 12, 0, -16 },
  { 551, 11, 16, 12, 1, -16 },
  { 573, 12, 16, 12, 0, -16 },
  { 597, 12, 16, 10, 0, -16 },
  { 621, 11, 16, 10, 0, -16 },
  { 643, 11, 16, 13, 1, -16 },
  { 665, 13, 16, 13, 0, -16 },
  { 691, 6, 16, 6, 0, -16 },
  { 703, 11, 16, 10, 0, -16 },
  { 725, 14, 16, 12, 0, -16 },
  { 753, 9, 16, 10, 0, -16 },
  { 771, 17, 16, 16, 0, -16 },
  { 805, 13, 16, 13, 0, -16 },
  { 831, 11, 16, 13, 1, -16 },
  { 853, 12, 16, 12, 0, -16 },
  { 877, 11, 19, 13, 1, -16 },
  { 904, 12, 16, 12, 0, -16 },
  { 928, 12, 16, 12, 0, -16 },
  { 952, 11, 16, 12, 2, -16 },
  { 974, 12, 16, 12, 1, -16 },
  { 998, 12, 16, 12, 2, -16 },
  { 1022, 15, 16, 16, 2, -16 },
  { 1052, 14, 16, 12, -1, -16 },
  { 1080, 11, 16, 12, 2, -16 },
  { 1102, 12, 16, 11, 0, -16 },
  { 1126, 7, 22, 6, 0, -18 },
  { 1146, 5, 17, 8, 2, -16 },
  { 1157, 7, 22, 6, -1, -18 },
  { 1177, 7, 8, 8, 1, -16 },
  { 1184, 8, 2, 9, -1, 0 },
  { 1186, 5, 3, 7, 2, -16 },
  { 1188, 9, 12, 10, 0, -12 },
  { 1202, 10, 17, 11, 0, -17 },
  { 1224, 9, 12, 10, 0, -12 },
  { 1238, 11, 17, 11, 0, -17 },
  { 1262, 9, 12, 10, 1, -12 },
  { 1276, 7, 17, 7, 1, -17 },
  { 1291, 11, 16, 11, 0, -12 },
  { 1313, 10, 17, 11, 0, -17 },
  { 1335, 6, 16, 5, 0, -16 },
  { 1347, 8, 20, 5, -2, -16 },
  { 1367, 11, 17, 10, 0, -17 },
  { 1391, 6, 17, 5, 0, -17 },
  { 1404, 15, 12, 16, 0, -12 },
  { 1427, 10, 12, 11, 0, -12 },
  { 1442, 10, 12, 11, 0, -12 },
  { 1457, 11, 16, 11, -1, -12 },
  { 1479, 10, 16, 11, 0, -12 },
  { 1499, 8, 12, 7, 0, -12 },
  { 1511, 9, 12, 10, 0, -12 },
  { 1525, 6, 14, 7, 1, -14 },
  { 1536, 9, 12, 11, 1, -12 },
  { 1550, 9, 12, 10, 1, -12 },
  { 1564, 13, 12, 14, 1, -12 },
  { 1584, 11, 12, 10, -1, -12 },
  { 1601, 11, 16, 10, -1, -12 },
  { 1623, 10, 12, 10, 0, -12 },
  { 1638, 7, 21, 6, 0, -17 },
  { 1657, 5, 19, 5, 0, -16 },
  { 1669, 7, 21, 6, -1, -17 },
  { 1688, 10, 5, 12, 1, -9 },
};

const GFXfont RobotoCondensed_BoldItalic22pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic22pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic22pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _ROBOTOCONDENSED_BOLDITALIC22PT7B_H_
