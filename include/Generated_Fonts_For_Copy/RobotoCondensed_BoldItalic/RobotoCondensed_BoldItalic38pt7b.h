#ifndef _ROBOTOCONDENSED_BOLDITALIC38PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0xC3, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x1C, 0x00, 0x38, 0xE7, 0x3D, 0xE7,
  0xBC, 0xF7, 0x9E, 0xE3, 0x9C, 0x73, 0x8E, 0xF3, 0x9C, 0x70, 0x00, 0x71,
  0xC0, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x78, 0x03, 0xCE,
  0x00, 0x71, 0xC0, 0x0E, 0x78, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFF,
  0x03, 0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x78, 0x01, 0xCE, 0x00, 0x71, 0xC0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x0E, 0x38, 0x01, 0xCE, 0x00,
  0x79, 0xC0, 0x0E, 0x38, 0x01, 0xCF, 0x00, 0x79, 0xC0, 0x0E, 0x38, 0x01,
  0xCF, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x0F, 0x80, 0x1F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x0F, 0xDF, 0x8F, 0x87,
  0xC7, 0xC3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7E, 0x1F, 0x1F, 0xBF,
  0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x01, 0xE7, 0x04, 0x71, 0xC3, 0x9C, 0x71, 0xEF, 0x1C, 0x73, 0xC7, 0x38,
  0xF1, 0xDE, 0x1C, 0xFF, 0x07, 0xFB, 0x80, 0xFD, 0xC0, 0x1E, 0xF0, 0x00,
  0x38, 0x00, 0x1D, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0xC1, 0xDE, 0xF0, 0xEF,
  0x1C, 0x7B, 0xC7, 0x1C, 0xF1, 0xCE, 0x38, 0x77, 0x8F, 0x3C, 0xC3, 0xCE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x80,
  0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xF9, 0xF0, 0x1E, 0x3E, 0x03, 0xC7, 0xC0,
  0x78, 0xF8, 0x0F, 0x1E, 0x01, 0xEF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0xC7, 0x8F, 0xF8, 0xF3, 0xFF, 0x9E, 0x7D, 0xF7, 0xDF,
  0x3F, 0xFB, 0xE3, 0xFE, 0x7C, 0x7F, 0xCF, 0x87, 0xF1, 0xF0, 0xFE, 0x3F,
  0x1F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFD, 0xF0, 0x7E, 0x3F, 0x00,
  0x3C, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0xF3, 0xC0, 0x00, 0x20, 0x1C, 0x07,
  0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x10,
  0x00, 0x02, 0x00, 0x30, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80,
  0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x07, 0x00, 0x40, 0x00,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x61, 0xC2, 0x79, 0xCF,
  0xFF, 0xFF, 0x7F, 0xFF, 0x0F, 0xF0, 0x07, 0xC0, 0x0F, 0xE0, 0x1E, 0xE0,
  0x3C, 0xF0, 0x78, 0x70, 0x30, 0x70, 0x00, 0x20, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x7C, 0xF8, 0xF0, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x33, 0xEF, 0xFF, 0xF9, 0xC0, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F,
  0xFE, 0x1F, 0xFE, 0x1F, 0x3E, 0x3E, 0x1F, 0x3E, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8,
  0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF0, 0x7C, 0xF0,
  0x7C, 0xF8, 0xF8, 0xF9, 0xF8, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0xE0, 0x1F,
  0x80, 0x00, 0x20, 0x1E, 0x0F, 0xE3, 0xFE, 0x7F, 0xE7, 0xFE, 0xFF, 0xCE,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x7F,
  0xF8, 0x1F, 0xFE, 0x0F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F,
  0x1F, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xFC,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0x01, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0xE1, 0xF9, 0xF9, 0xF8, 0x7C, 0xF8, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x9F,
  0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xF3, 0xF3, 0xF0, 0xFF, 0xF8, 0x7F, 0xF8,
  0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0xF7, 0xC0, 0x7D, 0xF0, 0x1E, 0x7C, 0x0F, 0x9F, 0x07, 0xCF,
  0xC1, 0xE3, 0xE0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0xFF, 0xE7, 0xFF, 0xF9,
  0xFF, 0xFE, 0x7F, 0xFF, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0xBC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x0F,
  0x8F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3F, 0x1F, 0x87, 0xEF, 0xC1, 0xFF, 0xF0,
  0x3F, 0xF8, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3C, 0x01, 0xF8, 0x0F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x03, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xFB, 0xE1, 0xFF, 0xE3, 0xFF, 0xEF, 0xFF, 0xDF, 0xCF, 0xFF, 0x0F, 0xFC,
  0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x87, 0xDF, 0x0F,
  0xBF, 0x7F, 0x3F, 0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0x3E, 0x00, 0x3F, 0xFF,
  0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF9, 0xF8, 0xF8, 0x7C,
  0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F, 0x8F, 0x8F, 0x87, 0xCF, 0xC1, 0xFF,
  0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0xFF, 0xF0, 0xFC, 0xFC, 0x7C, 0x3E, 0x7E,
  0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xE3, 0xF3, 0xF3, 0xF0,
  0xFF, 0xF8, 0x7F, 0xF8, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F,
  0xE0, 0x7F, 0xE1, 0xFF, 0xE7, 0xE7, 0xCF, 0x8F, 0xBE, 0x0F, 0x7C, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC3, 0xEF, 0x87, 0xDF, 0x9F, 0xBF,
  0xFF, 0x3F, 0xFE, 0x7F, 0xF8, 0x3D, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xC0, 0x00,
  0x0E, 0x1F, 0x3F, 0x3F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0xF8, 0xFC, 0xFC, 0xF8, 0x70, 0x01, 0x80, 0x7C,
  0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x1F, 0x00, 0xC0, 0x00, 0x00,
  0x02, 0x00, 0x1C, 0x00, 0xF0, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF, 0x9F, 0xF8,
  0x7F, 0xC0, 0xFE, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFC, 0x10, 0x00, 0x38,
  0x00, 0xF8, 0x01, 0xFC, 0x03, 0xFE, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x7E, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0xE7, 0xFE, 0x1F, 0xF0, 0x3F,
  0x80, 0x7C, 0x00, 0xE0, 0x01, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF,
  0x9F, 0xFE, 0xFC, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3F, 0x00, 0xF8, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x0F, 0x01,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x1E, 0x07, 0x81,
  0xC7, 0x07, 0xF8, 0x73, 0xC3, 0xFF, 0x1C, 0xE1, 0xF3, 0xC7, 0x78, 0xF8,
  0xE1, 0xDE, 0x3C, 0x38, 0x77, 0x0E, 0x1E, 0x1F, 0xC7, 0x87, 0x87, 0xF1,
  0xE1, 0xC3, 0xB8, 0x78, 0x70, 0xEE, 0x3C, 0x3C, 0x3B, 0x8F, 0x0F, 0x0E,
  0xE3, 0xC3, 0x87, 0x38, 0xF1, 0xE1, 0xCE, 0x3E, 0xF8, 0xE3, 0x87, 0xFF,
  0xF8, 0xE1, 0xFB, 0xFC, 0x38, 0x3C, 0x7C, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x7D, 0xE0, 0x01,
  0xF7, 0x80, 0x0F, 0x9E, 0x00, 0x3E, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7C, 0x03, 0xE1, 0xF0,
  0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x0F,
  0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xF8, 0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x1F, 0x83, 0xF1,
  0xF8, 0x3F, 0x1F, 0x07, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x3F, 0xFF, 0x83, 0xF0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07,
  0xC7, 0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x3F, 0x87, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xEF, 0xE1, 0xF8, 0x3F,
  0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C,
  0x0F, 0xC7, 0xC0, 0xF8, 0x7F, 0x3F, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x01,
  0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0xF8,
  0x1F, 0x1F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F,
  0x03, 0xF1, 0xF0, 0x3F, 0x3F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3,
  0xE0, 0x3E, 0x3E, 0x07, 0xE7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xC1, 0xF8,
  0x7C, 0x7F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF,
  0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xF1, 0xF8, 0x3F, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x01,
  0xF3, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC3,
  0xFE, 0x7C, 0x3F, 0xE7, 0xC3, 0xFE, 0x7C, 0x3F, 0xE7, 0xC0, 0x7E, 0x7C,
  0x07, 0xE7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xE0, 0x7C, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C,
  0x3F, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7C,
  0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x3F, 0x0F, 0x80,
  0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF8, 0x07,
  0xC3, 0xF0, 0x1F, 0x80, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC3, 0xE0,
  0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC,
  0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x7E,
  0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0xFC, 0x1F, 0xBF, 0x03, 0xFF, 0xE0, 0x3F,
  0xF8, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0xFE, 0x0F, 0x83,
  0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x1F, 0xC0, 0xF8, 0x7F, 0x01, 0xF0, 0xFC,
  0x03, 0xE3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00,
  0x7D, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7C, 0x00, 0xFC,
  0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x07,
  0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F,
  0x00, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7F,
  0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00,
  0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x07, 0xFC,
  0x1F, 0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFF, 0x07, 0xFE, 0x1E, 0xF8, 0x3E,
  0xF0, 0xF7, 0xC1, 0xF7, 0x8F, 0xFC, 0x0F, 0xBC, 0x7B, 0xE0, 0xF9, 0xE7,
  0xDF, 0x07, 0xCF, 0x3C, 0xF8, 0x3E, 0x79, 0xE7, 0xC1, 0xF3, 0xDE, 0x7E,
  0x0F, 0x9E, 0xF3, 0xE0, 0xFC, 0xFF, 0x1F, 0x07, 0xE3, 0xF8, 0xF8, 0x3E,
  0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x7E, 0x0F, 0x87, 0xE3, 0xE0, 0x7C, 0x3E,
  0x1F, 0x07, 0xE1, 0xF0, 0xF8, 0x3F, 0x0F, 0x07, 0xC0, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x7C, 0x3F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0xFE, 0x07, 0xC1,
  0xFE, 0x0F, 0x83, 0xFC, 0x1F, 0x07, 0xF8, 0x3E, 0x1F, 0xF0, 0xFC, 0x3F,
  0xF1, 0xF8, 0x7D, 0xE3, 0xE0, 0xFB, 0xC7, 0xC1, 0xF3, 0x8F, 0x83, 0xE7,
  0x9F, 0x0F, 0xCF, 0x7E, 0x1F, 0x9E, 0xFC, 0x3E, 0x1D, 0xF0, 0x7C, 0x3F,
  0xE0, 0xF8, 0x7F, 0xC3, 0xF0, 0xFF, 0x87, 0xE0, 0xFF, 0x0F, 0x81, 0xFC,
  0x1F, 0x03, 0xF8, 0x3E, 0x07, 0xF0, 0x7C, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xC1, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E,
  0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xE0,
  0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3,
  0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3F, 0x07,
  0xE1, 0xFE, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xE0, 0x01,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xC0, 0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xFC, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xC1, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x01,
  0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0xFC, 0x03, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xE0, 0x1F,
  0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3F, 0x07, 0xE1, 0xFE,
  0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF1,
  0xF8, 0x1F, 0x1F, 0x03, 0xF1, 0xF0, 0x7E, 0x1F, 0x9F, 0xE1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xE3, 0xF0, 0x3E, 0x3F,
  0x07, 0xE1, 0xF0, 0x7E, 0x1F, 0x07, 0xC1, 0xF8, 0x7C, 0x1F, 0x87, 0xC1,
  0xF8, 0x7C, 0x0F, 0x8F, 0xC0, 0xFC, 0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFE, 0xFC, 0x3F, 0x0F, 0xC7,
  0xC0, 0xF9, 0xF8, 0x1F, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF9, 0xF8,
  0x3E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0xFC, 0x0F,
  0xC7, 0xE0, 0x7E, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C,
  0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F,
  0xC0, 0xF8, 0x3E, 0x0F, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF7, 0xE0, 0x1F, 0xBF,
  0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x3E, 0x07, 0xE1, 0xF0, 0x3F,
  0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8,
  0x7C, 0x07, 0xE3, 0xE0, 0x1F, 0x3F, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x07, 0xFF, 0x07, 0xC1, 0xFF,
  0xC3, 0xF0, 0xFF, 0xF0, 0xFC, 0x3E, 0xF8, 0x3F, 0x0F, 0xBE, 0x1F, 0xC7,
  0xEF, 0x87, 0xF1, 0xF3, 0xE1, 0xFC, 0x7C, 0xF8, 0xFF, 0x1F, 0x1E, 0x3F,
  0xCF, 0x87, 0x9F, 0xF3, 0xE1, 0xE7, 0xBC, 0xF8, 0x79, 0xEF, 0x7C, 0x1E,
  0xFB, 0xDF, 0x07, 0xBC, 0xF7, 0xC1, 0xEF, 0x3F, 0xE0, 0x7F, 0xCF, 0xF8,
  0x1F, 0xE3, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x0F,
  0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x7E,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0x3E, 0x1F, 0x80,
  0x7C, 0x7E, 0x00, 0xFC, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x7E, 0x7C, 0x00, 0xFC, 0xF8, 0x03, 0xF1, 0xF8,
  0x07, 0xE3, 0xF0, 0x1F, 0x83, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0x7C, 0x0F, 0xC7, 0xC0,
  0xFC, 0x7C, 0x1F, 0x87, 0xE1, 0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xE0, 0x3E,
  0x7E, 0x03, 0xE7, 0xC0, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7E, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x00, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x87,
  0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF8, 0x3B,
  0xC3, 0xDE, 0x1C, 0x71, 0xE3, 0x8F, 0x1C, 0xF0, 0xFF, 0x87, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x7C, 0x7C, 0x3E, 0x1E, 0x0F,
  0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F, 0x3F, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x7E, 0x3E,
  0x7C, 0x3E, 0xFC, 0x3E, 0xFC, 0x7E, 0xFC, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x3F, 0xFC, 0x1F, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x9E, 0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF8, 0xFC, 0xFC, 0xFC, 0x3E,
  0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF7, 0xC0,
  0xFB, 0xE0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7E, 0x7F, 0x7F, 0xFF, 0x3F,
  0xFF, 0x1F, 0x7F, 0x8F, 0x9F, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1,
  0xFF, 0xF3, 0xE7, 0xEF, 0x87, 0xDF, 0x0F, 0xFE, 0x1F, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x0F, 0xBE, 0x1F, 0x7E, 0x7C,
  0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x81, 0xF3, 0xE1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFF, 0x1F, 0xDF, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xF8, 0x3F, 0x3E, 0x0F,
  0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xE3,
  0xE1, 0xF0, 0xFC, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x1E,
  0x7C, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0x3E,
  0x7C, 0x1E, 0x7C, 0x1F, 0x7C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x18, 0xFE, 0x78, 0x7F, 0xFC,
  0x7F, 0xFC, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x81,
  0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x81, 0xFF, 0xC7,
  0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x03, 0xE7, 0xC1,
  0xFD, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x3F, 0x9F, 0xCF, 0xC3, 0xE3, 0xE0,
  0xF9, 0xF8, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF1, 0xF0, 0x7C,
  0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF9, 0xFC, 0x7F, 0xFE, 0x0F,
  0xFF, 0x81, 0xFF, 0xE0, 0x3E, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC1, 0xC3, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x9E, 0x07, 0xFF, 0x83,
  0xFF, 0xE1, 0xFF, 0xF1, 0xFC, 0xF8, 0xF8, 0x7E, 0x7C, 0x3F, 0x3E, 0x1F,
  0x9F, 0x0F, 0x8F, 0x87, 0xCF, 0xC3, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0,
  0xFC, 0xF8, 0x7C, 0x7C, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF,
  0x87, 0xE0, 0x01, 0x01, 0xE0, 0xFC, 0x3F, 0x07, 0xC1, 0xE0, 0x00, 0x00,
  0x0F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3,
  0xE0, 0x00, 0x10, 0x01, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x2F, 0xE0, 0xFF, 0x03, 0xFC,
  0x0F, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE1, 0xF8, 0x7C, 0x7F, 0x0F, 0x8F, 0xC1, 0xF3, 0xF0, 0x3E,
  0xFC, 0x0F, 0xBF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x1F, 0xBE, 0x03, 0xE7,
  0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83,
  0xE0, 0x07, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC3, 0xF0,
  0xF8, 0x00, 0x1F, 0x3C, 0x1E, 0x07, 0xFF, 0xDF, 0xE1, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFE, 0x1F, 0x9F, 0xCF, 0xCF, 0xC7, 0xE1, 0xF3, 0xE1, 0xF8,
  0x7C, 0xF8, 0x7C, 0x1F, 0x3E, 0x1F, 0x0F, 0xCF, 0x87, 0xC3, 0xE3, 0xE1,
  0xF0, 0xF9, 0xF8, 0x7C, 0x3E, 0x7C, 0x3F, 0x0F, 0x9F, 0x0F, 0x83, 0xE7,
  0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x3E, 0x0F, 0x87,
  0xCF, 0x87, 0xE1, 0xF3, 0xE1, 0xF0, 0x7C, 0x1F, 0x3C, 0x0F, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xE3, 0xF9, 0xF9, 0xF0, 0xFC, 0xF8, 0x7E, 0x7C, 0x3F,
  0x3E, 0x1F, 0x1F, 0x0F, 0x9F, 0x87, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE1,
  0xF9, 0xF0, 0xF8, 0xF8, 0x7C, 0xFC, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0x3F,
  0x7E, 0x1F, 0x7C, 0x1F, 0xFC, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xFC, 0xFC, 0x7F, 0xFC,
  0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x0F, 0xBE, 0x03, 0xFF, 0xE0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x0F, 0xCF, 0xC7, 0xE1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F,
  0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xFC, 0x1F, 0x3E, 0x0F, 0x8F,
  0x83, 0xE3, 0xE0, 0xF8, 0xFC, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xDF,
  0xC1, 0xF3, 0xE0, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x07, 0xCF, 0x8F,
  0xF7, 0xCF, 0xFF, 0xE7, 0xFF, 0xE7, 0xF7, 0xF3, 0xE0, 0xF9, 0xF0, 0x7D,
  0xF0, 0x3E, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF, 0x83,
  0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xF9, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x03, 0xDF, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x78, 0xFF,
  0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFE, 0x3F, 0x1F, 0x3E, 0x1F, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFC, 0xF8, 0x7C, 0xF8, 0x3C,
  0xF8, 0x7C, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0xFF, 0xDF, 0xFB, 0xFF, 0xFF, 0xC7, 0xE0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x00, 0x3E, 0x0F, 0x9F,
  0x07, 0xCF, 0x87, 0xC7, 0xC3, 0xE3, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0x7C,
  0xF8, 0x7E, 0x7C, 0x3E, 0x3E, 0x1F, 0x3F, 0x0F, 0x9F, 0x07, 0xCF, 0x83,
  0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xF9, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x1F,
  0xFF, 0x07, 0xCF, 0x80, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xF8, 0x7C,
  0xF8, 0xFC, 0x78, 0xF8, 0x78, 0xF8, 0x79, 0xF0, 0x79, 0xF0, 0x7D, 0xE0,
  0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xF8, 0x78, 0x7F, 0xE1,
  0xE1, 0xFF, 0x8F, 0x8F, 0xBE, 0x3E, 0x3E, 0xF9, 0xF8, 0xFB, 0xE7, 0xE7,
  0xCF, 0x9F, 0x9F, 0x3E, 0xFE, 0x7C, 0xFB, 0xF9, 0xE3, 0xFE, 0xFF, 0x87,
  0xFB, 0xFC, 0x1F, 0xEF, 0xF0, 0x7F, 0x3F, 0xC1, 0xFC, 0xFE, 0x07, 0xE3,
  0xF8, 0x1F, 0x8F, 0xC0, 0x7C, 0x3F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xE0,
  0x1E, 0x07, 0x80, 0x1F, 0x87, 0xC1, 0xF1, 0xF8, 0x3E, 0x3E, 0x07, 0xCF,
  0x80, 0x7B, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xDF, 0x01, 0xFB, 0xE0, 0x3E, 0x7C, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8,
  0x7E, 0x1F, 0x00, 0x1F, 0x07, 0xE3, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0x87,
  0xC1, 0xF1, 0xF8, 0x1E, 0x3E, 0x03, 0xC7, 0xC0, 0x79, 0xF0, 0x0F, 0xBE,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF,
  0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0xFE,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x20, 0x1C, 0x07, 0x81,
  0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81,
  0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0xFC, 0x1F, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0E, 0x00, 0x40, 0x07, 0x0F,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C,
  0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70, 0x70,
  0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x06, 0x00, 0xE0, 0x1E, 0x03, 0xC0,
  0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78,
  0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x0F, 0x83, 0xF0, 0xF8, 0x1E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xC0, 0x70, 0x0C, 0x00, 0x0F, 0x00, 0x07,
  0xF0, 0xF3, 0xFE, 0x3D, 0xFF, 0xDF, 0x7D, 0xFF, 0x9E, 0x3F, 0xEF, 0x07,
  0xF0, 0x00, 0xF8,
};

const GFXglyph RobotoCondensed_BoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 27, 10, 1, -27 },
  { 32, 11, 10, 12, 2, -29 },
  { 46, 19, 27, 19, 1, -27 },
  { 111, 17, 35, 19, 1, -31 },
  { 186, 18, 27, 24, 3, -27 },
  { 247, 19, 27, 21, 1, -27 },
  { 312, 6, 10, 6, 2, -29 },
  { 320, 11, 38, 12, 2, -30 },
  { 373, 12, 39, 12, -2, -30 },
  { 432, 16, 16, 17, 2, -27 },
  { 464, 16, 20, 18, 1, -22 },
  { 504, 8, 11, 9, -2, -5 },
  { 515, 9, 4, 13, 2, -13 },
  { 520, 6, 6, 11, 1, -6 },
  { 525, 16, 29, 12, -2, -27 },
  { 583, 16, 27, 19, 2, -27 },
  { 637, 12, 27, 19, 4, -27 },
  { 678, 18, 27, 19, 0, -27 },
  { 739, 17, 27, 19, 1, -27 },
  { 797, 18, 27, 19, 0, -27 },
  { 858, 18, 27, 19, 1, -27 },
  { 919, 15, 27, 19, 2, -27 },
  { 970, 18, 27, 19, 2, -27 },
  { 1031, 17, 27, 19, 1, -27 },
  { 1089, 15, 27, 19, 3, -27 },
  { 1140, 8, 21, 10, 1, -21 },
  { 1161, 11, 27, 10, -2, -21 },
  { 1199, 15, 18, 16, 1, -21 },
  { 1233, 16, 12, 19, 1, -18 },
  { 1257, 15, 18, 17, 1, -20 },
  { 1291, 14, 27, 17, 3, -27 },
  { 1339, 26, 34, 28, 1, -26 },
  { 1450, 22, 27, 22, -2, -27 },
  { 1525, 20, 27, 21, 0, -27 },
  { 1593, 20, 27, 21, 1, -27 },
  { 1661, 20, 27, 21, 0, -27 },
  { 1729, 20, 27, 18, 0, -27 },
  { 1797, 19, 27, 18, 0, -27 },
  { 1862, 20, 27, 22, 1, -27 },
  { 1930, 23, 27, 23, 0, -27 },
  { 2008, 10, 27, 10, 0, -27 },
  { 2042, 19, 27, 18, 0, -27 },
  { 2107, 23, 27, 20, 0, -27 },
  { 2185, 16, 27, 18, 0, -27 },
  { 2239, 29, 27, 28, 0, -27 },
  { 2337, 23, 27, 23, 0, -27 },
  { 2415, 21, 27, 22, 1, -27 },
  { 2486, 21, 27, 21, 0, -27 },
  { 2557, 21, 32, 22, 1, -27 },
  { 2641, 20, 27, 20, 0, -27 },
  { 2709, 19, 27, 20, 1, -27 },
  { 2774, 19, 27, 20, 3, -27 },
  { 2839, 21, 27, 21, 1, -27 },
  { 2910, 21, 27, 21, 3, -27 },
  { 2981, 26, 27, 28, 3, -27 },
  { 3069, 23, 27, 21, -1, -27 },
  { 3147, 20, 27, 20, 3, -27 },
  { 3215, 22, 27, 20, -1, -27 },
  { 3290, 13, 37, 10, -1, -31 },
  { 3351, 9, 29, 14, 3, -27 },
  { 3384, 13, 37, 10, -2, -31 },
  { 3445, 13, 13, 14, 1, -27 },
  { 3467, 14, 4, 15, -2, 0 },
  { 3474, 8, 6, 12, 4, -29 },
  { 3480, 16, 20, 17, 0, -20 },
  { 3520, 17, 29, 18, 0, -29 },
  { 3582, 15, 20, 17, 1, -20 },
  { 3620, 18, 29, 18, 1, -29 },
  { 3686, 16, 20, 18, 1, -20 },
  { 3726, 14, 29, 12, 1, -29 },
  { 3777, 18, 28, 19, 0, -20 },
  { 3840, 17, 29, 18, 0, -29 },
  { 3902, 10, 28, 9, 0, -28 },
  { 3937, 14, 36, 9, -4, -28 },
  { 4000, 19, 29, 18, 0, -29 },
  { 4069, 10, 29, 9, 0, -29 },
  { 4106, 26, 20, 27, 0, -20 },
  { 4171, 17, 20, 18, 0, -20 },
  { 4214, 16, 20, 18, 1, -20 },
  { 4254, 18, 28, 18, -1, -20 },
  { 4317, 17, 28, 18, 1, -20 },
  { 4377, 13, 20, 12, 0, -20 },
  { 4410, 16, 20, 17, 0, -20 },
  { 4450, 11, 25, 11, 1, -25 },
  { 4485, 17, 20, 18, 1, -20 },
  { 4528, 16, 20, 17, 2, -20 },
  { 4568, 22, 20, 23, 2, -20 },
  { 4623, 19, 20, 17, -1, -20 },
  { 4671, 19, 28, 16, -1, -20 },
  { 4738, 18, 20, 17, -1, -20 },
  { 4783, 11, 37, 11, 1, -30 },
  { 4834, 8, 32, 9, 1, -27 },
  { 4866, 11, 37, 11, -1, -30 },
  { 4917, 18, 8, 21, 1, -15 },
};

const GFXfont RobotoCondensed_BoldItalic38pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic38pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic38pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOCONDENSED_BOLDITALIC38PT7B_H_
