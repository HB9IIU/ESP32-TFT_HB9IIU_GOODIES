#ifndef _ROBOTOCONDENSED_BOLDITALIC40PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xC0,
  0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0x8E, 0x78, 0xE7, 0x9E, 0x79, 0xE7, 0x1E,
  0x71, 0xC7, 0x1C, 0xF1, 0xC0, 0x00, 0x39, 0xE0, 0x07, 0x9C, 0x00, 0x71,
  0xC0, 0x07, 0x3C, 0x00, 0xF3, 0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x80, 0x1E,
  0x78, 0x1F, 0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x38, 0xE0, 0x03,
  0x8E, 0x00, 0x79, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x0F, 0x3C, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x1E, 0x70, 0x01, 0xC7, 0x00,
  0x3C, 0xF0, 0x03, 0xCE, 0x00, 0x38, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xC0,
  0x07, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0xC3,
  0xE3, 0xF1, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x3F,
  0x07, 0xC7, 0xC3, 0xF1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF,
  0x80, 0x1F, 0x80, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3E, 0xF0, 0x47, 0x8E, 0x1C,
  0xE1, 0xC7, 0x9C, 0x78, 0xE3, 0x8F, 0x38, 0x71, 0xEF, 0x0F, 0x7B, 0xC1,
  0xFF, 0x70, 0x1F, 0xDE, 0x01, 0xF7, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0x7C, 0x03, 0xDF, 0xC0, 0x77, 0xFC, 0x1F, 0xF7, 0x87, 0xBC, 0x71,
  0xE7, 0x0E, 0x38, 0xE1, 0xCF, 0x1C, 0x7B, 0xC3, 0x8F, 0x30, 0x7B, 0xE0,
  0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x80, 0xF8, 0xF8, 0x0F, 0x8F,
  0x80, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xFB, 0xF0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xE1, 0xE3, 0xFF, 0x1E, 0x7F,
  0xFB, 0xE7, 0xDF, 0xBE, 0xFC, 0xFF, 0xEF, 0x87, 0xFC, 0xF8, 0x7F, 0xCF,
  0x83, 0xF8, 0xFC, 0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0xC0, 0xFC, 0x7E, 0x3C, 0xF3, 0xDF, 0x79, 0xE7, 0x9E, 0x71,
  0xCF, 0x00, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07,
  0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E,
  0x00, 0xC0, 0x04, 0x00, 0x01, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x0E, 0x00, 0x40, 0x00, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x03, 0x8F, 0x39,
  0xFF, 0x7F, 0xFF, 0xFF, 0x1F, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xFC,
  0x01, 0xEF, 0x01, 0xE3, 0xC1, 0xE1, 0xE0, 0x70, 0x70, 0x10, 0x20, 0x00,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF0, 0x20, 0x7F, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xE1, 0xFF, 0xF1, 0xF8, 0xFC, 0xF8, 0x3E, 0x7C, 0x1F, 0x7C, 0x0F,
  0xBE, 0x07, 0xDF, 0x07, 0xEF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFB, 0xF0,
  0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x1F, 0xBE, 0x0F, 0x9F, 0x07, 0xCF,
  0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xFF, 0xF8, 0x7F, 0xF8, 0x3F, 0xF8,
  0x0F, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x30, 0x0F, 0x07, 0xF1, 0xFF, 0x7F,
  0xF7, 0xFE, 0x7F, 0xE7, 0x3E, 0x83, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0x0F, 0xC7, 0xE1, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF,
  0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x87, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0xCF, 0x83, 0xF3, 0xFF, 0xF8,
  0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3D, 0xF0, 0x0F, 0xBE, 0x03,
  0xEF, 0xC0, 0x79, 0xF8, 0x1F, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x3E,
  0x1F, 0x0F, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7E,
  0x7E, 0x01, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x8F, 0x81, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xFF,
  0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0xFE, 0x01, 0xFE, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFF, 0xFF, 0xFC, 0x3F, 0xFC, 0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xFF, 0xFC, 0x7F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xE7, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0xC7, 0xC3,
  0xF1, 0xF0, 0xF8, 0x3F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0xC0,
  0xFF, 0xF8, 0x7E, 0x3E, 0x1F, 0x07, 0xC7, 0xC1, 0xF3, 0xF0, 0x7C, 0xFC,
  0x1F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFF,
  0x01, 0xFF, 0x80, 0x3F, 0x80, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3F,
  0xFC, 0x3F, 0xFE, 0x7E, 0x3E, 0x7C, 0x3E, 0xFC, 0x3E, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x3F, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7E, 0xFC, 0xFE, 0xFF,
  0xFE, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x78,
  0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x7E, 0x3F, 0x1F, 0x8F,
  0xC3, 0xC0, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0x30, 0x00, 0x00, 0x01,
  0x00, 0x06, 0x00, 0x3E, 0x00, 0xFE, 0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0xF8,
  0x7F, 0xE0, 0xFF, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08,
  0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0x10, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0xFE,
  0x03, 0xFE, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xF8, 0x00,
  0xE0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xE3, 0xFF, 0xE7,
  0xFF, 0xDF, 0x8F, 0xFE, 0x1F, 0xFC, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0x00, 0x78, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x7C, 0x00, 0x0F,
  0x0F, 0x07, 0xC0, 0xE3, 0xC1, 0xFE, 0x1C, 0x78, 0x7F, 0xE3, 0x9E, 0x1F,
  0x7C, 0x73, 0xC7, 0xC7, 0x0E, 0xF0, 0xF1, 0xE1, 0xDE, 0x3C, 0x3C, 0x3B,
  0xC7, 0x87, 0x87, 0x70, 0xF0, 0xF0, 0xFE, 0x3C, 0x1C, 0x1F, 0xC7, 0x87,
  0x87, 0xF8, 0xF0, 0xF0, 0xEF, 0x1E, 0x1E, 0x1D, 0xC3, 0xC3, 0x83, 0xB8,
  0x78, 0xF0, 0xE7, 0x0F, 0x1E, 0x1C, 0xE1, 0xFF, 0xC7, 0x1C, 0x3F, 0xFF,
  0xE3, 0x83, 0xF7, 0xF8, 0x78, 0x3C, 0x3C, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x01, 0x00,
  0x07, 0xF9, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xE7,
  0x80, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7C,
  0x03, 0xE0, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x3E, 0x3F,
  0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xF8, 0x01, 0xF3, 0xF0, 0x03, 0xF0, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF8, 0xFC,
  0x0F, 0xC7, 0xE0, 0xFC, 0x3F, 0x0F, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x1F, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x8F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xE0, 0xFC, 0x7E, 0x07, 0xE3, 0xE0, 0x1F, 0x3F, 0x00,
  0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E, 0x3E, 0x03, 0xE1, 0xF8,
  0x3F, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xF0, 0x3F,
  0x0F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8,
  0x1F, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xE7, 0xE0, 0x3E, 0x3F, 0x01, 0xF1,
  0xF8, 0x1F, 0x8F, 0x80, 0xFC, 0x7C, 0x07, 0xC3, 0xE0, 0x7E, 0x3F, 0x03,
  0xF1, 0xF8, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F,
  0xFF, 0x83, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xF8, 0x3F, 0x3F, 0x01, 0xF3, 0xE0,
  0x1F, 0x7E, 0x01, 0xF7, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC3, 0xFE, 0xFC, 0x3F, 0xEF, 0xC3, 0xFE, 0xF8, 0x7F, 0xEF,
  0x80, 0x7E, 0xF8, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xCF, 0xC0, 0xFC,
  0xFC, 0x0F, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFE,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E,
  0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x3E, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8,
  0x7E, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xF0,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0x81, 0xF0, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x8F, 0xC1, 0xF0, 0xFC, 0x1F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3E, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x03, 0xE0, 0x7F, 0x01, 0xF0,
  0x3F, 0x80, 0xF8, 0x3F, 0x80, 0xFC, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0x3F,
  0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x0F, 0x9F, 0xC0, 0x0F, 0xDF, 0xC0, 0x07,
  0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xEF, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x00, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xFE, 0x07, 0xFE, 0x0F, 0xF8,
  0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0xC1, 0xF7, 0x83, 0xFF, 0x07, 0xDE, 0x0F,
  0x7C, 0x1F, 0x78, 0x7D, 0xF0, 0x7D, 0xE1, 0xEF, 0xC1, 0xF7, 0x8F, 0xBF,
  0x0F, 0xDF, 0x3C, 0xF8, 0x3F, 0x3C, 0xF3, 0xE0, 0xFC, 0xF7, 0xCF, 0x83,
  0xE3, 0xDE, 0x7E, 0x0F, 0x8F, 0xF9, 0xF8, 0x3E, 0x3F, 0xC7, 0xC1, 0xF8,
  0xFF, 0x1F, 0x07, 0xE3, 0xF8, 0x7C, 0x1F, 0x8F, 0xE3, 0xF0, 0x7C, 0x3F,
  0x0F, 0xC1, 0xF0, 0x7C, 0x3F, 0x0F, 0xC1, 0xE0, 0xF8, 0x3F, 0x07, 0x83,
  0xE0, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x3F, 0x07, 0xF0,
  0x3F, 0x0F, 0xF0, 0x3F, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF8,
  0x3E, 0x0F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xBC,
  0x7C, 0x1F, 0xBC, 0x7C, 0x1F, 0x3C, 0x7C, 0x1F, 0x3C, 0xFC, 0x3F, 0x1E,
  0xFC, 0x3F, 0x1E, 0xFC, 0x3F, 0x1E, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F,
  0xF8, 0x3E, 0x0F, 0xF8, 0x7E, 0x0F, 0xF8, 0x7E, 0x07, 0xF0, 0x7E, 0x07,
  0xF0, 0x7C, 0x07, 0xF0, 0x7C, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x0F, 0xC1, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x01,
  0xF3, 0xF0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7E,
  0x00, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F,
  0xBE, 0x00, 0xF9, 0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0x7E, 0x07, 0xE3, 0xF0,
  0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0,
  0x3F, 0x0F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E,
  0x1F, 0x83, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F,
  0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xC1, 0xF8,
  0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x7E, 0x01, 0xF3, 0xF0, 0x0F, 0xDF, 0x00,
  0x7E, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0xFB, 0xF0, 0x0F, 0xDF,
  0x80, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x0F,
  0xCF, 0x80, 0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x87, 0xE0, 0xFC, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xFC,
  0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x3F, 0x03, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F,
  0xC1, 0xF8, 0x7C, 0x0F, 0xC3, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE1, 0xFC, 0x3F, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x1F, 0x03, 0xF1,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0x87, 0xFF,
  0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFC,
  0x3E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7E,
  0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC7,
  0xE0, 0x3F, 0x1F, 0x80, 0xF8, 0x7E, 0x03, 0xE1, 0xF0, 0x1F, 0x87, 0xC0,
  0x7E, 0x1F, 0x01, 0xF8, 0xFC, 0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xEF, 0xC0, 0x3F, 0x9F, 0x00,
  0xFC, 0x7C, 0x03, 0xF1, 0xF0, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E,
  0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x80, 0x3E, 0x7C,
  0x00, 0xF9, 0xF0, 0x03, 0xEF, 0xC0, 0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x1E, 0x07, 0xFF, 0x07,
  0xE0, 0xFB, 0xE0, 0xFC, 0x1F, 0x7C, 0x1F, 0x87, 0xEF, 0x87, 0xF0, 0xF9,
  0xF0, 0xFE, 0x1F, 0x3E, 0x1F, 0xC7, 0xE7, 0xC7, 0xF8, 0xF8, 0xF8, 0xFF,
  0x1F, 0x1F, 0x1F, 0xE7, 0xE3, 0xE7, 0xFC, 0xF8, 0x7C, 0xFF, 0x9F, 0x0F,
  0x9F, 0xF3, 0xE1, 0xF7, 0xFE, 0xF8, 0x3E, 0xF3, 0xDF, 0x07, 0xFE, 0x7B,
  0xE0, 0xFF, 0xCF, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x3F, 0xE0, 0x7F,
  0xC7, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8,
  0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0,
  0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F,
  0x81, 0xF8, 0x1F, 0x80, 0x7C, 0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F,
  0xC0, 0x07, 0xC7, 0xE0, 0x03, 0xE7, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x3F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x03,
  0xFB, 0xE0, 0x1F, 0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFC, 0x1F,
  0x07, 0xE0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0, 0x3E, 0x3F, 0x00, 0xF9, 0xF0,
  0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFC, 0x3F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F,
  0x83, 0xF0, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xE1, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x0F, 0xF0, 0x7F, 0x83, 0xF8,
  0x1F, 0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0xF7, 0x03, 0xDE, 0x1E, 0x78, 0x79, 0xE3, 0xC7, 0x8F, 0x1E, 0x78,
  0x79, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xE1, 0xF9, 0xF8, 0xF8, 0xFC, 0xFC, 0x7E, 0x00, 0x3F, 0x03,
  0xFF, 0x07, 0xFF, 0x8F, 0xFF, 0xCF, 0xE3, 0xE7, 0xE3, 0xF3, 0xE1, 0xFB,
  0xF0, 0xF9, 0xF8, 0x7C, 0xFE, 0xFE, 0x3F, 0xFF, 0x1F, 0xFF, 0x87, 0xF7,
  0xC1, 0xF3, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xEF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xF0,
  0xFC, 0xFC, 0x1F, 0x3F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x3F,
  0x3E, 0x0F, 0xDF, 0x83, 0xE7, 0xE0, 0xF9, 0xF0, 0x3E, 0x7E, 0x1F, 0x9F,
  0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFB, 0xFC, 0x3E, 0x3E, 0x00, 0x03,
  0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x3F, 0xFF, 0x7E, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x3E, 0xF8, 0x3E, 0xF8, 0x7C, 0xFF, 0xFC, 0x7F, 0xF8, 0x7F,
  0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0xF9, 0xF8, 0x3F, 0xBF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0x87, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x9F, 0x83, 0xE3,
  0xF0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7,
  0xC1, 0xF0, 0xFC, 0x3E, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x03,
  0xFF, 0xC0, 0x3E, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83,
  0xFF, 0xE3, 0xFF, 0xF1, 0xF0, 0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7F, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x30, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF, 0x00,
  0xFE, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x81, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x7F,
  0xF0, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0xFF, 0x7C,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFC, 0x7E, 0x1F, 0x8F, 0x81, 0xF1,
  0xF0, 0x3E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC7,
  0xC0, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xE3, 0xF0, 0xFC, 0x7F, 0xFF, 0x07,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xFB, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x83, 0x03, 0xF0, 0x79, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F,
  0xF8, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xEF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xFF, 0xE3,
  0xF0, 0xF8, 0xFC, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF8,
  0x3E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F,
  0x1F, 0x07, 0xCF, 0xC3, 0xF3, 0xF0, 0xFC, 0xF8, 0x3E, 0x3E, 0x0F, 0x80,
  0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xC3, 0xF0,
  0xF8, 0x3E, 0x0F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0, 0xFC,
  0x3F, 0x00, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x83,
  0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x7E, 0x1F, 0x8F,
  0xE1, 0xF1, 0xFC, 0x1F, 0x3F, 0x81, 0xF3, 0xF0, 0x1F, 0x7E, 0x03, 0xFF,
  0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xE7, 0xC0, 0x7C, 0x7E, 0x07,
  0xC7, 0xE0, 0x7C, 0x3E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xF0,
  0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07,
  0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xBE, 0x0F, 0x83, 0xEF, 0xE7,
  0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3E,
  0x1F, 0x87, 0xCF, 0xC3, 0xE0, 0xF9, 0xF8, 0x7C, 0x1F, 0x3E, 0x0F, 0x83,
  0xE7, 0xC1, 0xF0, 0xFC, 0xF8, 0x7E, 0x1F, 0x9F, 0x0F, 0xC3, 0xE7, 0xE1,
  0xF0, 0x7C, 0xFC, 0x3E, 0x0F, 0x9F, 0x07, 0xC1, 0xF3, 0xE0, 0xF8, 0x7E,
  0x7C, 0x3F, 0x0F, 0xCF, 0x87, 0xE1, 0xF3, 0xF0, 0xF8, 0x3E, 0x7E, 0x1F,
  0x07, 0xCF, 0x83, 0xE1, 0xF8, 0x1F, 0x3E, 0x07, 0xDF, 0xC1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x1F, 0xFF, 0x8F, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x3E, 0x3E,
  0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x07,
  0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3,
  0xE0, 0xF8, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x83,
  0xFF, 0xE3, 0xFF, 0xF3, 0xF0, 0xFD, 0xF8, 0x7E, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0,
  0xFD, 0xF8, 0x7C, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00,
  0xFC, 0x00, 0x0F, 0x9F, 0x01, 0xF7, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x1F, 0x0F, 0xC7, 0xE0, 0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE3,
  0xE0, 0xFC, 0x7C, 0x1F, 0x8F, 0x83, 0xF3, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F,
  0x81, 0xF1, 0xF8, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x07, 0xC7, 0xC0, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC7, 0xC3, 0xF9, 0xF1, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x9F, 0x87,
  0xE7, 0xC1, 0xF9, 0xF0, 0x7E, 0xFC, 0x1F, 0x3F, 0x07, 0xCF, 0x81, 0xF3,
  0xE0, 0xFC, 0xF8, 0x3F, 0x3E, 0x0F, 0xCF, 0x83, 0xE3, 0xF0, 0xF8, 0xFF,
  0xFE, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xBC, 0x7D, 0xF1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x7F, 0xE3, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xE1, 0xF1, 0xF9, 0xF8, 0xFC, 0xF8, 0x7E, 0x7E, 0x00, 0x1F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF3,
  0xE0, 0xF9, 0xF0, 0x7C, 0xFC, 0x7E, 0x3F, 0xFE, 0x0F, 0xFF, 0x03, 0xFF,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x87, 0xFE,
  0x7F, 0xE7, 0xFE, 0xFF, 0xE1, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xF8,
  0x7F, 0x87, 0xF0, 0x3F, 0x01, 0xF0, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3, 0xE0,
  0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xE1, 0xF9, 0xF8, 0x7E,
  0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F,
  0x0F, 0xCF, 0x83, 0xE3, 0xF1, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x87, 0xFF,
  0xE1, 0xFF, 0xF0, 0x1F, 0x7C, 0x00, 0xFC, 0x1F, 0xFC, 0x3F, 0xFC, 0x3E,
  0xFC, 0x7E, 0x7C, 0x7E, 0x7C, 0x7C, 0x7C, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8,
  0x7D, 0xF0, 0x7D, 0xF0, 0x7D, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0xF8, 0x3C, 0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0x7C, 0x3E, 0xF8, 0xFC, 0x7C,
  0xF8, 0xFC, 0x7C, 0xF8, 0xFC, 0x7C, 0x79, 0xFC, 0xF8, 0x79, 0xFC, 0xF8,
  0x7B, 0xFC, 0xF0, 0x7B, 0xFD, 0xF0, 0x7B, 0xDD, 0xF0, 0x7F, 0x9D, 0xE0,
  0x7F, 0x9F, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x87, 0xE1, 0xF0, 0xFC, 0x3E, 0x3F, 0x07, 0xE7,
  0xC0, 0x7D, 0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0x3E, 0x07, 0xE7, 0xC1, 0xF8, 0xF8,
  0x3E, 0x1F, 0x8F, 0xC1, 0xF0, 0x1F, 0x83, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0xFC, 0x0F, 0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F, 0x80, 0xF9,
  0xF0, 0x0F, 0xBF, 0x00, 0xFB, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x30, 0x0F, 0x01,
  0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x0F, 0xE0, 0xF8,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x0E, 0x00, 0x40, 0x07, 0x07, 0x0F, 0x0F, 0x0F, 0x0E, 0x0E,
  0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C, 0x3C, 0x3C, 0x38, 0x38,
  0x38, 0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0xE0,
  0xE0, 0xE0, 0x02, 0x00, 0x70, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3C, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0xFC, 0x0F,
  0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0xE0, 0x0C, 0x00, 0x0F,
  0x80, 0x03, 0xF8, 0x3C, 0xFF, 0x87, 0x9F, 0xF9, 0xF7, 0xFF, 0xFC, 0xF1,
  0xFF, 0x9E, 0x1F, 0xE7, 0x81, 0xFC, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 28, 10, 1, -28 },
  { 36, 12, 11, 12, 2, -30 },
  { 53, 20, 28, 20, 1, -28 },
  { 123, 18, 36, 20, 1, -32 },
  { 204, 19, 28, 25, 3, -28 },
  { 271, 20, 28, 22, 1, -28 },
  { 341, 6, 11, 6, 2, -30 },
  { 350, 12, 41, 13, 2, -32 },
  { 412, 13, 41, 13, -2, -32 },
  { 479, 17, 17, 18, 2, -28 },
  { 516, 17, 21, 18, 1, -24 },
  { 561, 8, 12, 10, -2, -5 },
  { 573, 10, 5, 14, 2, -15 },
  { 580, 6, 6, 11, 1, -6 },
  { 585, 18, 30, 13, -3, -28 },
  { 653, 17, 28, 20, 2, -28 },
  { 713, 12, 28, 20, 4, -28 },
  { 755, 19, 28, 20, 0, -28 },
  { 822, 18, 28, 20, 1, -28 },
  { 885, 19, 28, 20, 0, -28 },
  { 952, 19, 28, 20, 1, -28 },
  { 1019, 16, 28, 20, 2, -28 },
  { 1075, 19, 28, 20, 2, -28 },
  { 1142, 18, 28, 20, 1, -28 },
  { 1205, 16, 28, 20, 3, -28 },
  { 1261, 9, 22, 11, 1, -22 },
  { 1286, 12, 29, 10, -2, -22 },
  { 1330, 16, 19, 17, 1, -22 },
  { 1368, 16, 14, 20, 2, -20 },
  { 1396, 16, 18, 18, 1, -21 },
  { 1432, 15, 28, 17, 3, -28 },
  { 1485, 27, 37, 30, 1, -28 },
  { 1610, 23, 28, 23, -2, -28 },
  { 1691, 21, 28, 22, 0, -28 },
  { 1765, 21, 28, 22, 1, -28 },
  { 1839, 21, 28, 22, 0, -28 },
  { 1913, 21, 28, 19, 0, -28 },
  { 1987, 20, 28, 18, 0, -28 },
  { 2057, 20, 28, 23, 2, -28 },
  { 2127, 24, 28, 24, 0, -28 },
  { 2211, 11, 28, 10, 0, -28 },
  { 2250, 20, 28, 19, 0, -28 },
  { 2320, 25, 28, 21, 0, -28 },
  { 2408, 16, 28, 19, 0, -28 },
  { 2464, 30, 28, 29, 0, -28 },
  { 2569, 24, 28, 24, 0, -28 },
  { 2653, 21, 28, 23, 2, -28 },
  { 2727, 22, 28, 22, 0, -28 },
  { 2804, 21, 33, 23, 2, -28 },
  { 2891, 21, 28, 21, 0, -28 },
  { 2965, 20, 28, 21, 1, -28 },
  { 3035, 20, 28, 21, 3, -28 },
  { 3105, 22, 28, 22, 1, -28 },
  { 3182, 22, 28, 22, 3, -28 },
  { 3259, 27, 28, 29, 4, -28 },
  { 3354, 25, 28, 22, -1, -28 },
  { 3442, 21, 28, 21, 3, -28 },
  { 3516, 23, 28, 21, -1, -28 },
  { 3597, 14, 40, 10, -1, -33 },
  { 3667, 10, 30, 15, 3, -28 },
  { 3705, 13, 40, 10, -2, -33 },
  { 3770, 14, 14, 15, 1, -28 },
  { 3795, 15, 4, 16, -2, 0 },
  { 3803, 9, 6, 13, 4, -30 },
  { 3810, 17, 21, 18, 0, -21 },
  { 3855, 18, 30, 19, 0, -30 },
  { 3923, 16, 21, 18, 1, -21 },
  { 3965, 19, 30, 19, 1, -30 },
  { 4037, 17, 21, 19, 1, -21 },
  { 4082, 14, 30, 13, 1, -30 },
  { 4135, 19, 29, 20, 0, -21 },
  { 4204, 18, 30, 19, 0, -30 },
  { 4272, 10, 30, 10, 0, -30 },
  { 4310, 14, 38, 10, -4, -30 },
  { 4377, 20, 30, 19, 0, -30 },
  { 4452, 11, 30, 10, 0, -30 },
  { 4494, 27, 21, 29, 0, -21 },
  { 4565, 18, 21, 19, 0, -21 },
  { 4613, 17, 21, 19, 1, -21 },
  { 4658, 19, 29, 19, -1, -21 },
  { 4727, 18, 29, 19, 1, -21 },
  { 4793, 14, 21, 13, 0, -21 },
  { 4830, 17, 21, 18, 0, -21 },
  { 4875, 12, 26, 12, 1, -26 },
  { 4914, 18, 21, 19, 1, -21 },
  { 4962, 16, 21, 17, 2, -21 },
  { 5004, 24, 21, 25, 2, -21 },
  { 5067, 19, 21, 18, -1, -21 },
  { 5117, 20, 29, 17, -1, -21 },
  { 5190, 19, 21, 18, -1, -21 },
  { 5240, 12, 38, 12, 1, -31 },
  { 5297, 8, 33, 10, 1, -28 },
  { 5330, 12, 38, 12, -1, -31 },
  { 5387, 19, 9, 22, 1, -16 },
};

const GFXfont RobotoCondensed_BoldItalic40pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic40pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic40pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _ROBOTOCONDENSED_BOLDITALIC40PT7B_H_
