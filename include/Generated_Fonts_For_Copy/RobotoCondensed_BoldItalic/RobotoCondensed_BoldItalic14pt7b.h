#ifndef _ROBOTOCONDENSED_BOLDITALIC14PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x66, 0x66, 0x60, 0xCC, 0xDF, 0xAA, 0x0A, 0x2C, 0x53, 0xF3,
  0xC5, 0x3F, 0x3C, 0x50, 0xA0, 0x08, 0x38, 0xFB, 0x36, 0x06, 0x07, 0x06,
  0xCC, 0xF9, 0xE1, 0x00, 0x61, 0xAB, 0x57, 0xC7, 0x83, 0x8E, 0xA9, 0xD6,
  0x18, 0x1C, 0x78, 0x91, 0x63, 0x8F, 0x77, 0xE6, 0xFC, 0xEC, 0xFA, 0x13,
  0x64, 0xCC, 0x88, 0x88, 0x88, 0xC4, 0x20, 0x84, 0x31, 0x8C, 0x63, 0x11,
  0x8C, 0x46, 0x20, 0x30, 0x8F, 0xD8, 0x52, 0x40, 0x18, 0x61, 0x1F, 0xFC,
  0xC3, 0x0C, 0x6D, 0x60, 0xFC, 0xF0, 0x04, 0x30, 0x86, 0x10, 0x42, 0x08,
  0x61, 0x0C, 0x00, 0x39, 0xEC, 0xF3, 0xCB, 0x69, 0xA6, 0xF3, 0xC0, 0x3E,
  0xE6, 0x66, 0x64, 0xCC, 0x3C, 0xF9, 0x98, 0x20, 0xC3, 0x0C, 0x30, 0xFD,
  0xF8, 0x3C, 0x79, 0x98, 0x21, 0xC7, 0x03, 0x66, 0xFC, 0xF0, 0x0E, 0x18,
  0x71, 0xE2, 0xCD, 0xBF, 0x7E, 0x18, 0x30, 0x3E, 0x7C, 0x83, 0xC6, 0xC1,
  0x83, 0x66, 0x7C, 0xF0, 0x1B, 0xD9, 0xFF, 0xEE, 0x73, 0xFB, 0x80, 0xFF,
  0xF1, 0x86, 0x30, 0xC6, 0x18, 0xC3, 0x00, 0x1C, 0x79, 0x9B, 0x33, 0xCF,
  0x1B, 0x66, 0x7C, 0xF0, 0x39, 0xEC, 0xB2, 0xCB, 0xE7, 0x84, 0xF3, 0x80,
  0x6C, 0x00, 0x36, 0x33, 0x00, 0x00, 0x26, 0x6C, 0x04, 0x77, 0xB0, 0x70,
  0xE0, 0x80, 0xFF, 0xC1, 0xFF, 0x80, 0x41, 0xC3, 0xC3, 0x7B, 0x88, 0x00,
  0x77, 0xF6, 0x33, 0x31, 0x80, 0xC6, 0x00, 0x0F, 0x06, 0x22, 0x0D, 0x99,
  0x4B, 0x56, 0x9D, 0x27, 0x4A, 0x96, 0xB6, 0xC4, 0x01, 0x80, 0x3C, 0x00,
  0x06, 0x0E, 0x0E, 0x1A, 0x1B, 0x13, 0x3F, 0x3F, 0x63, 0x63, 0x3C, 0x7D,
  0x9B, 0x36, 0xEF, 0x99, 0xE3, 0xFD, 0xF0, 0x3C, 0xFB, 0x1E, 0x3C, 0x18,
  0x30, 0x66, 0xFC, 0xF0, 0x3C, 0x7D, 0x9B, 0x36, 0x6C, 0xD9, 0xE3, 0xFD,
  0xF0, 0x3E, 0x7D, 0x83, 0x07, 0xCF, 0x98, 0x60, 0xFD, 0xF8, 0x3E, 0x7D,
  0x83, 0x07, 0xCF, 0x98, 0x60, 0xC1, 0x80, 0x3C, 0xFF, 0x1E, 0x0D, 0xFB,
  0xB3, 0x66, 0xFC, 0xF0, 0x31, 0x11, 0x98, 0xCC, 0x67, 0xF3, 0xF9, 0x89,
  0x8C, 0xC6, 0x63, 0x00, 0x33, 0x66, 0x66, 0x66, 0xCC, 0x06, 0x0C, 0x10,
  0x60, 0xC1, 0x83, 0x66, 0xF8, 0xE0, 0x33, 0x13, 0x1B, 0x8D, 0x87, 0x83,
  0xC1, 0xB1, 0x98, 0xCC, 0x67, 0x00, 0x30, 0x86, 0x18, 0x61, 0x86, 0x30,
  0xFF, 0xF0, 0x30, 0xC6, 0x39, 0xE7, 0x3D, 0xE7, 0xBC, 0xF5, 0x9F, 0xE6,
  0x6C, 0xCD, 0x99, 0x30, 0x31, 0x19, 0x9C, 0xCF, 0x67, 0xB3, 0x59, 0xB9,
  0x9C, 0xC6, 0x63, 0x00, 0x3C, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0x66, 0xFC,
  0xF0, 0x3E, 0x3E, 0x63, 0x63, 0x7E, 0x7C, 0x60, 0xC0, 0xC0, 0xC0, 0x3C,
  0xFB, 0x1E, 0x3C, 0x78, 0xF1, 0x66, 0xFC, 0xF0, 0x70, 0x40, 0x3E, 0x3E,
  0x62, 0x66, 0x7E, 0x7C, 0x6C, 0x4C, 0xCC, 0xCC, 0x1C, 0x7D, 0x9B, 0x03,
  0x83, 0x81, 0xE3, 0x7C, 0xF0, 0xFF, 0xFC, 0xC1, 0x83, 0x06, 0x0C, 0x30,
  0x60, 0xC0, 0x33, 0x63, 0x63, 0x62, 0x66, 0x66, 0x66, 0x66, 0x7C, 0x38,
  0xC6, 0xC6, 0xCE, 0x4C, 0x4C, 0x78, 0x78, 0x70, 0x70, 0x70, 0xCC, 0xF3,
  0x6D, 0xDB, 0x76, 0xDD, 0x3F, 0xCF, 0xF3, 0x98, 0xE6, 0x39, 0x80, 0x63,
  0x36, 0x36, 0x3C, 0x1C, 0x38, 0x3C, 0x6C, 0xEC, 0xCE, 0xC6, 0x99, 0xB3,
  0xC7, 0x8E, 0x0C, 0x30, 0x60, 0xC0, 0x7F, 0x7E, 0x06, 0x0C, 0x18, 0x30,
  0x30, 0x60, 0xFC, 0xFC, 0x33, 0x26, 0x66, 0x66, 0x4C, 0xCC, 0xEC, 0xDB,
  0x26, 0xDB, 0x6C, 0x80, 0x39, 0xC6, 0x23, 0x18, 0xC6, 0x31, 0x98, 0xCE,
  0x70, 0x11, 0xCE, 0xD4, 0x80, 0xFF, 0xE0, 0x64, 0x39, 0xF0, 0xDF, 0xEF,
  0x2F, 0x9E, 0x30, 0x86, 0x1F, 0x7D, 0xB6, 0xD3, 0xCF, 0xFF, 0x80, 0x39,
  0xF6, 0xF0, 0xC3, 0x27, 0x9C, 0x06, 0x0C, 0x19, 0xB7, 0xCD, 0xB3, 0x66,
  0xCD, 0xF9, 0xA0, 0x39, 0xF6, 0xF3, 0xFF, 0x07, 0x9E, 0x19, 0xCC, 0xF6,
  0x31, 0x8C, 0x63, 0x30, 0x36, 0xF9, 0xB6, 0x6C, 0xD9, 0x9F, 0x3E, 0x19,
  0xF3, 0xC0, 0x30, 0x86, 0x1F, 0x7D, 0xB6, 0xD3, 0xCF, 0x3C, 0x80, 0x32,
  0x06, 0x66, 0x64, 0xCC, 0xC0, 0x0C, 0x20, 0x06, 0x18, 0x61, 0x86, 0x30,
  0xC3, 0x0C, 0x71, 0x80, 0x30, 0x41, 0x83, 0x76, 0xCF, 0x1C, 0x3C, 0xD9,
  0xB3, 0x30, 0x33, 0x66, 0x66, 0x66, 0xCC, 0xC0, 0x7F, 0x9F, 0xE6, 0xC9,
  0xB6, 0x4D, 0xB3, 0x6C, 0x9B, 0x66, 0x7D, 0xF6, 0xDB, 0xCF, 0x3C, 0xF2,
  0x39, 0xF6, 0xF3, 0xCF, 0x37, 0x9E, 0x3E, 0x7C, 0xD9, 0xB2, 0x6C, 0xDF,
  0xBE, 0x60, 0xC1, 0x00, 0x36, 0xF9, 0xB6, 0x6C, 0xD9, 0xBF, 0x3C, 0x18,
  0x30, 0x60, 0x7B, 0xD8, 0xC4, 0x63, 0x18, 0x39, 0xB6, 0x1C, 0x38, 0x2D,
  0x9C, 0x37, 0x66, 0x66, 0x66, 0x60, 0x66, 0xD9, 0xB3, 0x64, 0xD9, 0xBF,
  0x34, 0xDE, 0xF5, 0xEF, 0x73, 0x9C, 0xDB, 0xDA, 0xFE, 0xFE, 0xFC, 0xFC,
  0xCC, 0xC8, 0x6D, 0xB3, 0x8C, 0x71, 0xED, 0xB6, 0x6C, 0xD9, 0xA3, 0xC7,
  0x8E, 0x1C, 0x30, 0x61, 0x83, 0x00, 0x7D, 0xF1, 0x8C, 0x31, 0x8F, 0xBE,
  0x11, 0x8C, 0x42, 0x33, 0x0C, 0x62, 0x10, 0x82, 0x00, 0x24, 0x96, 0x92,
  0x4B, 0x40, 0x30, 0x84, 0x23, 0x08, 0x66, 0x21, 0x18, 0xC4, 0x00, 0xE7,
  0xF9, 0x80,
};

const GFXglyph RobotoCondensed_BoldItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 4, 4, 4, 1, -11 },
  { 8, 7, 10, 7, 0, -10 },
  { 17, 7, 12, 7, 0, -11 },
  { 28, 7, 10, 9, 1, -10 },
  { 37, 7, 10, 8, 0, -10 },
  { 46, 2, 4, 2, 1, -11 },
  { 47, 4, 14, 4, 1, -11 },
  { 54, 5, 14, 4, -1, -11 },
  { 63, 6, 6, 6, 1, -10 },
  { 68, 6, 8, 6, 0, -9 },
  { 74, 3, 4, 3, -1, -2 },
  { 76, 3, 2, 5, 1, -5 },
  { 77, 2, 2, 4, 0, -2 },
  { 78, 6, 11, 5, -1, -10 },
  { 87, 6, 10, 7, 1, -10 },
  { 95, 4, 10, 7, 2, -10 },
  { 100, 7, 10, 7, 0, -10 },
  { 109, 7, 10, 7, 0, -10 },
  { 118, 7, 10, 7, 0, -10 },
  { 127, 7, 10, 7, 0, -10 },
  { 136, 5, 10, 7, 1, -10 },
  { 143, 6, 10, 7, 1, -10 },
  { 151, 7, 10, 7, 0, -10 },
  { 160, 6, 10, 7, 1, -10 },
  { 168, 3, 8, 4, 0, -8 },
  { 171, 4, 10, 4, -1, -8 },
  { 176, 6, 7, 6, 0, -8 },
  { 182, 5, 5, 7, 1, -7 },
  { 186, 6, 7, 6, 0, -8 },
  { 192, 5, 10, 6, 1, -10 },
  { 199, 10, 13, 10, 0, -10 },
  { 216, 8, 10, 8, -1, -10 },
  { 226, 7, 10, 8, 0, -10 },
  { 235, 7, 10, 8, 1, -10 },
  { 244, 7, 10, 8, 0, -10 },
  { 253, 7, 10, 7, 0, -10 },
  { 262, 7, 10, 6, 0, -10 },
  { 271, 7, 10, 8, 1, -10 },
  { 280, 9, 10, 8, 0, -10 },
  { 292, 4, 10, 4, 0, -10 },
  { 297, 7, 10, 7, 0, -10 },
  { 306, 9, 10, 8, 0, -10 },
  { 318, 6, 10, 7, 0, -10 },
  { 326, 11, 10, 10, 0, -10 },
  { 340, 9, 10, 8, 0, -10 },
  { 352, 7, 10, 8, 1, -10 },
  { 361, 8, 10, 8, 0, -10 },
  { 371, 7, 12, 8, 1, -10 },
  { 382, 8, 10, 8, 0, -10 },
  { 392, 7, 10, 7, 0, -10 },
  { 401, 7, 10, 7, 1, -10 },
  { 410, 8, 10, 8, 0, -10 },
  { 420, 8, 10, 8, 1, -10 },
  { 430, 10, 10, 10, 1, -10 },
  { 443, 8, 10, 8, 0, -10 },
  { 453, 7, 10, 7, 1, -10 },
  { 462, 8, 10, 7, 0, -10 },
  { 472, 4, 14, 4, 0, -12 },
  { 479, 3, 11, 5, 1, -10 },
  { 484, 5, 14, 4, -1, -12 },
  { 493, 5, 5, 5, 0, -10 },
  { 497, 6, 2, 5, -1, 0 },
  { 499, 3, 2, 5, 1, -10 },
  { 500, 6, 8, 6, 0, -8 },
  { 506, 6, 11, 7, 0, -11 },
  { 515, 6, 8, 6, 0, -8 },
  { 521, 7, 11, 7, 0, -11 },
  { 531, 6, 8, 7, 0, -8 },
  { 537, 5, 11, 4, 0, -11 },
  { 544, 7, 11, 7, 0, -8 },
  { 554, 6, 11, 7, 0, -11 },
  { 563, 4, 11, 3, 0, -11 },
  { 569, 6, 14, 3, -2, -11 },
  { 580, 7, 11, 7, 0, -11 },
  { 590, 4, 11, 3, 0, -11 },
  { 596, 10, 8, 10, 0, -8 },
  { 606, 6, 8, 7, 0, -8 },
  { 612, 6, 8, 7, 0, -8 },
  { 618, 7, 11, 7, -1, -8 },
  { 628, 7, 11, 7, 0, -8 },
  { 638, 5, 8, 4, 0, -8 },
  { 643, 6, 8, 6, 0, -8 },
  { 649, 4, 9, 4, 0, -9 },
  { 654, 7, 8, 7, 0, -8 },
  { 661, 5, 8, 6, 1, -8 },
  { 666, 8, 8, 9, 1, -8 },
  { 674, 6, 8, 6, 0, -8 },
  { 680, 7, 11, 6, 0, -8 },
  { 690, 6, 8, 6, 0, -8 },
  { 696, 5, 13, 4, 0, -11 },
  { 705, 3, 12, 3, 0, -10 },
  { 710, 5, 13, 4, -1, -11 },
  { 719, 6, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_BoldItalic14pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic14pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic14pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _ROBOTOCONDENSED_BOLDITALIC14PT7B_H_
