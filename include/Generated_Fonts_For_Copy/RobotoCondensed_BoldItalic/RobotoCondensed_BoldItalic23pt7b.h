#ifndef _ROBOTOCONDENSED_BOLDITALIC23PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x8E, 0x38, 0xC3, 0x1C, 0x00, 0x06,
  0x3C, 0x60, 0x66, 0xCD, 0xBB, 0x66, 0xD9, 0x80, 0x03, 0x60, 0x36, 0x06,
  0x60, 0x6C, 0x06, 0xC3, 0xFF, 0x3F, 0xF0, 0xD8, 0x0D, 0x81, 0x98, 0x7F,
  0xC7, 0xFC, 0x33, 0x03, 0x60, 0x36, 0x06, 0x60, 0x6C, 0x00, 0x03, 0x00,
  0x80, 0xF0, 0x7E, 0x3F, 0xCE, 0x77, 0x1D, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xEE, 0x3B, 0x9E, 0xFF, 0x1F, 0xC3, 0xC0, 0x40, 0x10,
  0x00, 0x38, 0x0F, 0x83, 0x33, 0x66, 0x6C, 0xD9, 0x9E, 0x3E, 0xC3, 0xB0,
  0x0C, 0x01, 0xF8, 0x7F, 0x1B, 0x33, 0x66, 0xCC, 0xF1, 0xB0, 0x3E, 0x03,
  0x80, 0x07, 0x80, 0xFC, 0x1F, 0xC1, 0xCC, 0x19, 0xC1, 0xDC, 0x1F, 0x81,
  0xF0, 0x1E, 0x03, 0xF7, 0x77, 0x77, 0x7E, 0xF3, 0xEF, 0x3C, 0x7F, 0xC7,
  0xFE, 0x3E, 0xE0, 0x76, 0x66, 0x6C, 0x02, 0x0C, 0x30, 0xE3, 0x86, 0x0C,
  0x38, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0xC1, 0xC3, 0x83, 0x06,
  0x06, 0x04, 0x00, 0x08, 0x30, 0x30, 0x60, 0xE0, 0xC1, 0x83, 0x06, 0x0C,
  0x38, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x30, 0xE1, 0x87, 0x1C, 0x20, 0x00,
  0x06, 0x01, 0x80, 0xC1, 0xB7, 0xFF, 0xC7, 0x83, 0xE0, 0xD8, 0x67, 0x00,
  0x80, 0x0E, 0x07, 0x03, 0x83, 0x8F, 0xFF, 0xFF, 0xFE, 0x38, 0x18, 0x1C,
  0x0E, 0x07, 0x00, 0x31, 0x9C, 0xE6, 0x73, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xF7, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x00,
  0x0F, 0x07, 0xE3, 0xF9, 0xC7, 0x71, 0xDC, 0x77, 0x1F, 0x87, 0xE3, 0xB8,
  0xEE, 0x3B, 0x8E, 0xE3, 0xB9, 0xCF, 0xF1, 0xF8, 0x3C, 0x00, 0x02, 0x3D,
  0xFB, 0xF6, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0x71, 0xE3, 0x87, 0x0E, 0x1C,
  0x38, 0x07, 0x83, 0xF8, 0xFF, 0x9C, 0x73, 0x8E, 0x01, 0xC0, 0x70, 0x0E,
  0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xF7, 0xFE, 0xFF,
  0x80, 0x0F, 0x83, 0xF8, 0xFF, 0x1C, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x7E,
  0x0F, 0x81, 0xF0, 0x07, 0x00, 0xEE, 0x1D, 0xE7, 0x9F, 0xE3, 0xF8, 0x1E,
  0x00, 0x01, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0x7C, 0x1F, 0x87, 0x70, 0xCE,
  0x3B, 0x8E, 0x71, 0xFF, 0x7F, 0xEF, 0xFC, 0x07, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x1F, 0xCF, 0xF3, 0xFC, 0xE0, 0x30, 0x1C, 0x07, 0xE1, 0xFC, 0x77,
  0x80, 0xE0, 0x38, 0x0E, 0xE3, 0xB9, 0xEF, 0xF1, 0xF8, 0x3C, 0x00, 0x03,
  0x87, 0xC7, 0xE7, 0x83, 0x83, 0x81, 0xFC, 0xFF, 0xFF, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3F, 0x1D, 0xFC, 0xFE, 0x3C, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x07, 0xE3, 0xFC, 0xE7,
  0x71, 0xDC, 0x77, 0x38, 0xFE, 0x3F, 0x1F, 0xCE, 0x3B, 0x8E, 0xE3, 0xB9,
  0xEF, 0xF3, 0xF8, 0x3C, 0x00, 0x1E, 0x3F, 0x9F, 0xDC, 0x6E, 0x3F, 0x1F,
  0x8F, 0xCF, 0xFF, 0x7F, 0x9F, 0xC0, 0xE0, 0xE0, 0xF3, 0xF1, 0xF0, 0xE0,
  0x00, 0x00, 0xF3, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x07, 0x1C, 0x70, 0x00,
  0x71, 0xC7, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8E, 0x31, 0xC7, 0x38, 0x40,
  0x00, 0xC0, 0xE0, 0xF8, 0xFC, 0x78, 0x1C, 0x07, 0xE0, 0x7C, 0x07, 0x00,
  0x40, 0x7F, 0x9F, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xEF, 0xF3, 0xFC, 0x20,
  0x0E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xE0, 0xF9, 0xFC, 0x7C, 0x1C, 0x08,
  0x00, 0x3C, 0x7E, 0xFF, 0xE7, 0xE7, 0x07, 0x0E, 0x1E, 0x3C, 0x38, 0x70,
  0x70, 0x00, 0x00, 0xE0, 0xE0, 0x60, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0x06,
  0x0C, 0x03, 0x18, 0x03, 0x38, 0xF3, 0x31, 0xFB, 0x73, 0x33, 0x67, 0x33,
  0x66, 0x33, 0x66, 0x73, 0x6E, 0x63, 0xCE, 0x62, 0xCE, 0xE6, 0xC7, 0xFC,
  0x67, 0x38, 0x60, 0x00, 0x60, 0x00, 0x30, 0x40, 0x3F, 0xC0, 0x0F, 0x80,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x03, 0xB0, 0x1D, 0xC1,
  0xCE, 0x0E, 0x70, 0xF3, 0x87, 0xFC, 0x3F, 0xE3, 0xFF, 0x1C, 0x39, 0xE1,
  0xEE, 0x0F, 0xF0, 0x38, 0x1F, 0xC1, 0xFE, 0x1F, 0xF3, 0xC7, 0x38, 0x73,
  0x87, 0x38, 0xF3, 0x9E, 0x3F, 0xC7, 0xFC, 0x70, 0xE7, 0x0E, 0x70, 0xE7,
  0x1E, 0x7F, 0xCF, 0xFC, 0xFF, 0x00, 0x0F, 0x81, 0xFE, 0x3F, 0xE3, 0x8E,
  0x70, 0x77, 0x07, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x1E,
  0xE1, 0xCE, 0x1C, 0x7F, 0x87, 0xF8, 0x3E, 0x00, 0x1F, 0x81, 0xFE, 0x1F,
  0xE3, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x73, 0x87, 0x38, 0x77, 0x87, 0x70,
  0xF7, 0x0E, 0x70, 0xE7, 0x1C, 0x7F, 0xCF, 0xF8, 0xFE, 0x00, 0x1F, 0xF1,
  0xFF, 0x1F, 0xF3, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFC, 0x3F, 0xC7,
  0xFC, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xCF, 0xF8, 0xFF, 0x80,
  0x1F, 0xF1, 0xFE, 0x1F, 0xE3, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFC,
  0x3F, 0xC7, 0xFC, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xE0, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xE3, 0x87, 0x70, 0x77, 0x00, 0x70,
  0x0F, 0x00, 0xF0, 0x0E, 0x3E, 0xE3, 0xEE, 0x0E, 0xE1, 0xEF, 0x1E, 0x7F,
  0xC7, 0xFC, 0x1F, 0x00, 0x1C, 0x1C, 0x70, 0x71, 0xC3, 0xCF, 0x0E, 0x38,
  0x38, 0xE0, 0xE3, 0x83, 0x8F, 0xFE, 0x3F, 0xF9, 0xFF, 0xC7, 0x07, 0x1C,
  0x1C, 0x70, 0x71, 0xC1, 0xC7, 0x0F, 0x3C, 0x38, 0xE0, 0xE0, 0x1C, 0x71,
  0xCF, 0x3C, 0xE3, 0x8E, 0x39, 0xE7, 0x9C, 0x71, 0xC7, 0x3C, 0xF0, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xCE, 0x39, 0xC7, 0x3F, 0xC3, 0xF8, 0x3C, 0x00, 0x1C,
  0x3C, 0x71, 0xE1, 0xCF, 0x0F, 0x38, 0x39, 0xE0, 0xEF, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xFE, 0x07, 0xF8, 0x1E, 0xE0, 0x73, 0xC1, 0xC7, 0x07,
  0x1C, 0x3C, 0x78, 0xE1, 0xE0, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xFF,
  0x80, 0x1E, 0x07, 0x8F, 0x07, 0xC7, 0x83, 0xE7, 0xC1, 0xF3, 0xE1, 0xF9,
  0xF0, 0xF8, 0xFC, 0xFC, 0x7E, 0x7E, 0x3F, 0x37, 0x3B, 0xBB, 0x9C, 0xDB,
  0xCE, 0x7D, 0xC7, 0x3C, 0xE3, 0x9E, 0x71, 0xCF, 0x39, 0xE7, 0x3C, 0xE3,
  0x9E, 0x00, 0x1C, 0x1C, 0x70, 0x71, 0xE3, 0xCF, 0x8E, 0x3E, 0x38, 0xF8,
  0xE3, 0xF3, 0x8E, 0xCE, 0x3B, 0x79, 0xEF, 0xC7, 0x3F, 0x1C, 0x7C, 0x71,
  0xF1, 0xC7, 0xC7, 0x1F, 0x3C, 0x38, 0xE0, 0xE0, 0x07, 0x81, 0xFE, 0x3F,
  0xE3, 0x8F, 0x70, 0x77, 0x07, 0x70, 0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEF, 0x1C, 0x7F, 0xC7, 0xF8, 0x1E, 0x00, 0x1F, 0xC0,
  0xFF, 0x07, 0xFC, 0x78, 0xE3, 0x87, 0x9C, 0x3C, 0xE1, 0xC7, 0x0E, 0x3F,
  0xF3, 0xFF, 0x1F, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x00, 0x07, 0x81, 0xFE, 0x3F, 0xE3, 0x8F, 0x70, 0x77, 0x07, 0x70,
  0x7F, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x0E, 0xE0, 0xEF, 0x1C, 0x7F,
  0xC7, 0xF8, 0x1F, 0x80, 0x3C, 0x01, 0xC0, 0x08, 0x1F, 0xC1, 0xFE, 0x1F,
  0xF3, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x73, 0x8F, 0x3F, 0xE7, 0xFC, 0x7F,
  0x87, 0x38, 0x73, 0xC7, 0x1C, 0x71, 0xCF, 0x1C, 0xE1, 0xE0, 0x07, 0xC0,
  0xFE, 0x1F, 0xF3, 0xC7, 0x38, 0x73, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x01, 0xE0, 0x0E, 0xF0, 0xE7, 0x1E, 0x7F, 0xC3, 0xF8, 0x1F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x00,
  0x38, 0x73, 0x87, 0x78, 0x77, 0x07, 0x70, 0xF7, 0x0E, 0x70, 0xE7, 0x0E,
  0xF0, 0xEE, 0x0E, 0xE1, 0xEE, 0x1C, 0xE1, 0xCE, 0x1C, 0xFF, 0x87, 0xF8,
  0x3E, 0x00, 0xE0, 0xFE, 0x0F, 0xE0, 0xEE, 0x1E, 0xF1, 0xCF, 0x1C, 0x73,
  0x87, 0x38, 0x77, 0x87, 0x70, 0x77, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C,
  0x03, 0xC0, 0x38, 0x00, 0xE3, 0x8F, 0xE3, 0x8E, 0xE3, 0x8E, 0xE7, 0x8E,
  0xE7, 0x9C, 0xE7, 0x9C, 0xEF, 0x9C, 0xEF, 0xB8, 0xED, 0xB8, 0xFD, 0xB8,
  0xFD, 0xB0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF9, 0xF0, 0xF1, 0xE0, 0xF1, 0xE0,
  0xF1, 0xE0, 0x1E, 0x1C, 0x3C, 0x78, 0x38, 0xE0, 0x73, 0xC0, 0xF7, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xDE, 0x07, 0x9C, 0x0E, 0x38, 0x3C, 0x78, 0x70, 0xF0, 0xE0, 0xEE,
  0x1E, 0xF1, 0xC7, 0x3C, 0x73, 0x87, 0x78, 0x77, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x00,
  0x3F, 0xF9, 0xFF, 0x8F, 0xFC, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xFF,
  0x1F, 0xF8, 0xFF, 0xC0, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x0E, 0x1C, 0x38,
  0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0F, 0x1E, 0x3C,
  0x00, 0xE7, 0x39, 0xCE, 0x39, 0xCE, 0x73, 0x9C, 0xE3, 0x9C, 0xE7, 0x39,
  0xC0, 0x1E, 0x1E, 0x1E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0xF0, 0xF0, 0xF0,
  0x0C, 0x38, 0x79, 0xB3, 0x6C, 0xD9, 0xE3, 0xFF, 0x7F, 0xBF, 0xC0, 0x71,
  0x8E, 0x0F, 0x0F, 0xE3, 0xBD, 0xE7, 0x03, 0xC7, 0xE7, 0xF9, 0xCE, 0xE3,
  0xBF, 0xE7, 0xF8, 0xEE, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03,
  0xF8, 0xFF, 0x3F, 0xDC, 0x77, 0x1D, 0xC7, 0x71, 0xDC, 0x77, 0x1F, 0xFE,
  0xFF, 0xBB, 0xC0, 0x0F, 0x0F, 0xE3, 0xFD, 0xC7, 0x71, 0xDC, 0x07, 0x01,
  0xC0, 0x73, 0x9F, 0xE7, 0xF0, 0xF8, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x1E, 0xE3, 0xFC, 0x7F, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xCF, 0x38, 0x73, 0x87, 0xF8, 0x7F, 0x83, 0xB8, 0x1E, 0x1F, 0x9F,
  0xFC, 0x7E, 0x3F, 0xFF, 0xFF, 0xC0, 0xE0, 0x7F, 0x9F, 0xC7, 0x80, 0x0F,
  0x1F, 0x3F, 0x38, 0x38, 0x38, 0xFE, 0xFC, 0x70, 0x70, 0x70, 0x70, 0x70,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1E, 0xE7, 0xFC, 0xFF, 0xB8, 0xE7, 0x1C,
  0xE3, 0x9C, 0x73, 0x8E, 0x71, 0xCF, 0xF1, 0xFE, 0x1F, 0xC0, 0x38, 0x0F,
  0x3F, 0xC7, 0xF8, 0x7C, 0x00, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0xF8, 0xFF, 0x7F, 0xDC, 0x77, 0x1D, 0xC7, 0x71, 0xDC, 0xEF, 0x3B,
  0x8E, 0xE3, 0xB8, 0xE0, 0x1C, 0x71, 0x80, 0x38, 0xE3, 0x8E, 0x79, 0xC7,
  0x1C, 0x71, 0xCE, 0x38, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x70, 0x38, 0x1C,
  0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x78, 0x38, 0x1C, 0x0E,
  0x1F, 0x0F, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x79, 0xDE, 0x3B, 0x8E, 0xE1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x1D,
  0xC7, 0x3C, 0xE3, 0x9C, 0x70, 0x1C, 0x71, 0xC7, 0x38, 0xE3, 0x8E, 0x38,
  0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0xE3, 0x80, 0x3B, 0x9E, 0x3F, 0xFE, 0x3F,
  0xFF, 0x79, 0xCF, 0x71, 0xCF, 0x71, 0xCE, 0x71, 0xCE, 0x73, 0x8E, 0x73,
  0x8E, 0xE3, 0x8E, 0xE3, 0x9C, 0xE3, 0x9C, 0x3F, 0x8F, 0xF3, 0xFD, 0xC7,
  0x71, 0xDC, 0x77, 0x1D, 0xCE, 0xF3, 0xB8, 0xEE, 0x3B, 0x8E, 0x0F, 0x07,
  0xE3, 0xFD, 0xC7, 0x71, 0xDC, 0x77, 0x1D, 0xC7, 0x73, 0xDF, 0xE7, 0xF0,
  0x78, 0x1F, 0xC3, 0xFC, 0x7F, 0x9E, 0x73, 0x8E, 0x71, 0xCE, 0x39, 0xC7,
  0x38, 0xEF, 0xF9, 0xFF, 0x3B, 0xC7, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x00, 0x1E, 0xE7, 0xFD, 0xFF, 0x38, 0xE7, 0x1C, 0xE3, 0x9C, 0x77, 0x9E,
  0x73, 0x8F, 0xF1, 0xFE, 0x1D, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x3F, 0x3F, 0x3F, 0x78, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0,
  0xE0, 0x1F, 0x0F, 0xE3, 0xB9, 0xC7, 0x78, 0x0F, 0x81, 0xF0, 0x1E, 0xE3,
  0xBD, 0xE7, 0xF0, 0xF8, 0x38, 0xE3, 0xBF, 0xFD, 0xC7, 0x1C, 0x73, 0xCE,
  0x38, 0xFB, 0xC7, 0x00, 0x71, 0xDC, 0xF7, 0x3B, 0x8E, 0xE3, 0xB8, 0xEE,
  0x3B, 0x9E, 0xE7, 0x3F, 0xCF, 0xF1, 0xDC, 0xE3, 0xB8, 0xEE, 0x79, 0x9C,
  0x67, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xE3, 0x1F,
  0x9C, 0xEE, 0x73, 0xBB, 0xCC, 0xEF, 0x71, 0xBD, 0xC7, 0xF6, 0x1E, 0xF8,
  0x7B, 0xC1, 0xCF, 0x07, 0x1C, 0x18, 0x60, 0x1C, 0xE1, 0xDE, 0x1D, 0xC1,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x3F, 0x83, 0xB8, 0x73, 0x87,
  0x3C, 0x38, 0xF3, 0x8E, 0x39, 0xE1, 0x9C, 0x1D, 0xC1, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x00, 0x3F, 0xCF, 0xF7, 0xF8, 0x1E, 0x0F, 0x03, 0x81, 0xC0,
  0xE0, 0x78, 0x3F, 0xCF, 0xF3, 0xFC, 0x02, 0x06, 0x0E, 0x1C, 0x1C, 0x1C,
  0x1C, 0x18, 0x38, 0x38, 0x70, 0x70, 0x70, 0x30, 0x30, 0x70, 0x70, 0x70,
  0x70, 0x30, 0x38, 0x10, 0x18, 0xC6, 0x31, 0x88, 0xC6, 0x31, 0x8C, 0x66,
  0x31, 0x8C, 0x63, 0x19, 0x80, 0x08, 0x38, 0x30, 0x60, 0xC1, 0x83, 0x0E,
  0x1C, 0x1C, 0x38, 0x71, 0xC7, 0x0E, 0x1C, 0x38, 0x70, 0xC3, 0x8E, 0x08,
  0x00, 0x38, 0xEF, 0x9B, 0xFF, 0x63, 0xEC, 0x38,
};

const GFXglyph RobotoCondensed_BoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 17, 6, 0, -17 },
  { 14, 7, 6, 7, 1, -17 },
  { 20, 12, 17, 12, 0, -17 },
  { 46, 10, 21, 11, 1, -19 },
  { 73, 11, 17, 14, 2, -17 },
  { 97, 12, 17, 13, 0, -17 },
  { 123, 4, 6, 4, 1, -17 },
  { 126, 7, 23, 7, 1, -18 },
  { 147, 7, 23, 7, -1, -18 },
  { 168, 10, 10, 10, 1, -17 },
  { 181, 9, 12, 11, 1, -13 },
  { 195, 5, 7, 5, -1, -3 },
  { 200, 6, 3, 8, 1, -9 },
  { 203, 4, 4, 6, 0, -4 },
  { 205, 10, 18, 7, -1, -17 },
  { 228, 10, 17, 11, 1, -17 },
  { 250, 7, 17, 11, 2, -17 },
  { 265, 11, 17, 11, 0, -17 },
  { 289, 11, 17, 11, 0, -17 },
  { 313, 11, 17, 11, 0, -17 },
  { 337, 10, 17, 11, 1, -17 },
  { 359, 9, 17, 11, 1, -17 },
  { 379, 11, 17, 11, 1, -17 },
  { 403, 10, 17, 11, 1, -17 },
  { 425, 9, 17, 11, 2, -17 },
  { 445, 6, 13, 6, 0, -13 },
  { 455, 6, 17, 6, -1, -13 },
  { 468, 10, 10, 10, 0, -12 },
  { 481, 10, 8, 11, 1, -11 },
  { 491, 10, 11, 10, 0, -12 },
  { 505, 8, 17, 10, 2, -17 },
  { 522, 16, 21, 17, 0, -16 },
  { 564, 13, 17, 13, -1, -17 },
  { 592, 12, 17, 13, 0, -17 },
  { 618, 12, 17, 13, 1, -17 },
  { 644, 12, 17, 13, 0, -17 },
  { 670, 12, 17, 11, 0, -17 },
  { 696, 12, 17, 11, 0, -17 },
  { 722, 12, 17, 13, 1, -17 },
  { 748, 14, 17, 14, 0, -17 },
  { 778, 6, 17, 6, 0, -17 },
  { 791, 11, 17, 11, 0, -17 },
  { 815, 14, 17, 12, 0, -17 },
  { 845, 9, 17, 11, 0, -17 },
  { 865, 17, 17, 17, 0, -17 },
  { 902, 14, 17, 14, 0, -17 },
  { 932, 12, 17, 13, 1, -17 },
  { 958, 13, 17, 13, 0, -17 },
  { 986, 12, 20, 13, 1, -17 },
  { 1016, 12, 17, 12, 0, -17 },
  { 1042, 12, 17, 12, 0, -17 },
  { 1068, 11, 17, 12, 2, -17 },
  { 1092, 12, 17, 13, 1, -17 },
  { 1118, 12, 17, 13, 2, -17 },
  { 1144, 16, 17, 17, 2, -17 },
  { 1178, 15, 17, 12, -1, -17 },
  { 1210, 12, 17, 12, 2, -17 },
  { 1236, 13, 17, 12, 0, -17 },
  { 1264, 7, 23, 6, 0, -19 },
  { 1285, 5, 18, 9, 2, -17 },
  { 1297, 8, 23, 6, -1, -19 },
  { 1320, 7, 8, 9, 1, -17 },
  { 1327, 9, 3, 9, -1, 0 },
  { 1331, 5, 3, 7, 2, -17 },
  { 1333, 10, 12, 11, 0, -12 },
  { 1348, 10, 18, 11, 0, -18 },
  { 1371, 10, 12, 10, 0, -12 },
  { 1386, 12, 18, 11, 0, -18 },
  { 1413, 9, 12, 11, 1, -12 },
  { 1427, 8, 18, 7, 1, -18 },
  { 1445, 11, 17, 11, 0, -12 },
  { 1469, 10, 18, 11, 0, -18 },
  { 1492, 6, 16, 6, 0, -16 },
  { 1504, 9, 21, 5, -3, -16 },
  { 1528, 11, 18, 11, 0, -18 },
  { 1553, 6, 18, 6, 0, -18 },
  { 1567, 16, 12, 17, 0, -12 },
  { 1591, 10, 12, 11, 0, -12 },
  { 1606, 10, 12, 11, 0, -12 },
  { 1621, 11, 17, 11, -1, -12 },
  { 1645, 11, 17, 11, 0, -12 },
  { 1669, 8, 12, 7, 0, -12 },
  { 1681, 10, 12, 10, 0, -12 },
  { 1696, 6, 15, 7, 1, -15 },
  { 1708, 10, 12, 11, 1, -12 },
  { 1723, 10, 12, 10, 1, -12 },
  { 1738, 14, 12, 14, 1, -12 },
  { 1759, 12, 12, 10, -1, -12 },
  { 1777, 12, 17, 10, -1, -12 },
  { 1803, 10, 12, 10, 0, -12 },
  { 1818, 8, 22, 7, 0, -18 },
  { 1840, 5, 20, 6, 0, -17 },
  { 1853, 7, 22, 7, -1, -18 },
  { 1873, 11, 5, 12, 1, -9 },
};

const GFXfont RobotoCondensed_BoldItalic23pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic23pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic23pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _ROBOTOCONDENSED_BOLDITALIC23PT7B_H_
