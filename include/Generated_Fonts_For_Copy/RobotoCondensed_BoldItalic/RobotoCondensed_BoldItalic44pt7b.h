#ifndef _ROBOTOCONDENSED_BOLDITALIC44PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3F,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1E, 0x00, 0x7C, 0xF7, 0xCF, 0x78,
  0xF7, 0x8F, 0x78, 0xF7, 0x9E, 0xF1, 0xEF, 0x1E, 0xF1, 0xEF, 0x1C, 0xE1,
  0xCE, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0xF1, 0xC0, 0x03, 0xCF, 0x00, 0x0E,
  0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x1E, 0x00, 0x3C, 0x78,
  0x00, 0xF3, 0xC0, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x0F, 0x1E, 0x00, 0x3C, 0x70, 0x00, 0xF3, 0xC0, 0x07, 0x8F,
  0x00, 0x1E, 0x38, 0x00, 0x79, 0xE0, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x07, 0x8E, 0x00, 0x1E, 0x78, 0x00, 0x71,
  0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x38, 0xF0, 0x01, 0xE3, 0xC0,
  0x07, 0x9E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xFC,
  0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xE7, 0xF0, 0xFC, 0x3F, 0x0F, 0x83,
  0xF0, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC0, 0xFC, 0xFC, 0x0F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x01, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0x9E, 0x0E, 0x78, 0x70, 0xF3,
  0xC3, 0x87, 0x9E, 0x1C, 0x78, 0xF1, 0xE7, 0x87, 0x8F, 0x3C, 0x3C, 0x7B,
  0xC1, 0xFF, 0xBC, 0x07, 0xFF, 0xC0, 0x1F, 0xDE, 0x00, 0x7D, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF7, 0xC0, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x7F,
  0xE0, 0x7F, 0xCF, 0x07, 0xBC, 0x38, 0x79, 0xE1, 0xC3, 0xCF, 0x1E, 0x3C,
  0x78, 0xF3, 0xC3, 0xC7, 0xBC, 0x1E, 0x3C, 0x60, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0x9F, 0x00, 0x7C,
  0x7E, 0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1F, 0x00, 0xFC, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x1F, 0x1F, 0xF8, 0xF8, 0xFF, 0xF3, 0xE7, 0xFF, 0xCF, 0x9F, 0xBF,
  0xFE, 0xFC, 0x7F, 0xF3, 0xF1, 0xFF, 0xCF, 0xC3, 0xFF, 0x3F, 0x0F, 0xF8,
  0xFC, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x7F, 0xEF, 0xC0, 0xFE, 0x3F, 0x80, 0x7D, 0xF7, 0xDE, 0x79,
  0xEF, 0xBC, 0xF3, 0xCF, 0x3C, 0x00, 0x08, 0x00, 0xE0, 0x07, 0x80, 0x3F,
  0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x02, 0x00,
  0x01, 0x00, 0x06, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0x80, 0x18, 0x00, 0x40, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x41, 0xE0, 0x9F, 0x3C, 0xF3,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE3, 0xFF, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0x1E, 0xF0, 0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x7C, 0x3E, 0x03,
  0x03, 0x80, 0x00, 0x40, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD,
  0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F,
  0x87, 0xC1, 0xE0, 0x10, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFC,
  0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x1F, 0x87, 0xC1,
  0xF1, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xC0, 0xFD, 0xF8, 0x1F, 0xBF, 0x03,
  0xF7, 0xE0, 0x7E, 0xFC, 0x1F, 0x9F, 0x83, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F,
  0xDF, 0x81, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F,
  0x3E, 0x07, 0xE7, 0xE0, 0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x18,
  0x07, 0xC0, 0xFE, 0x3F, 0xE7, 0xFF, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0xE3,
  0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xF1, 0xFC, 0x3F, 0x0F, 0xE3, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFC, 0x7E, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0xFC, 0x01, 0xFF,
  0x80, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC,
  0x1F, 0x8F, 0xE3, 0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07,
  0xCF, 0xC0, 0xF9, 0xF8, 0x0F, 0x9F, 0x81, 0xF1, 0xF8, 0x3F, 0x1F, 0x83,
  0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xDF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x01, 0xE1, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x03, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF7, 0xC0, 0xFF, 0xF8,
  0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFC, 0x7E, 0xFE, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC1,
  0xFB, 0xF0, 0x7E, 0xFC, 0x3F, 0x9F, 0x9F, 0xC7, 0xFF, 0xF1, 0xFF, 0xF8,
  0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFE, 0x7F, 0x0F, 0xC3, 0xF1, 0xF8,
  0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xFC, 0x7E, 0x0F,
  0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xF1, 0xF8, 0x7E, 0x0F, 0x87, 0xE0, 0xFC, 0x7C, 0x0F, 0xCF, 0xC0, 0xFC,
  0xFC, 0x0F, 0xCF, 0xC1, 0xF8, 0xFE, 0x1F, 0x87, 0xE3, 0xF8, 0x7F, 0xFF,
  0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xC7,
  0xE7, 0xE1, 0xF9, 0xF8, 0x3E, 0xFC, 0x0F, 0xBF, 0x03, 0xEF, 0xC0, 0xFB,
  0xF0, 0x3E, 0xFC, 0x1F, 0xBF, 0x07, 0xEF, 0xC1, 0xFB, 0xF8, 0xFE, 0x7F,
  0xFF, 0x9F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xBE, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x03, 0xFE, 0x07, 0xFF, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xC0, 0x07, 0x80, 0x00, 0x07, 0x03, 0xE1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xF0, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF0, 0x78, 0x00, 0x00, 0xC0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E,
  0x07, 0xC0, 0xFC, 0x0F, 0x80, 0x30, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x03, 0x80, 0x00, 0x40, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0,
  0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x7F, 0xF9, 0xFF, 0xF0, 0xFF, 0xC0, 0x7F, 0x80,
  0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF0, 0x0F,
  0xFC, 0x1F, 0xFE, 0x3F, 0xFF, 0x7F, 0xFF, 0x7E, 0x3F, 0xFE, 0x3F, 0xFC,
  0x3F, 0xFC, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00,
  0x07, 0x81, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x3E, 0x07, 0xC0,
  0xF0, 0xF0, 0x7F, 0xC3, 0xC7, 0x83, 0xFF, 0x87, 0x1E, 0x1F, 0xFE, 0x1C,
  0xF0, 0xF8, 0x78, 0x73, 0xC3, 0xC3, 0xC1, 0xDF, 0x1F, 0x0F, 0x07, 0x78,
  0x78, 0x3C, 0x3D, 0xE1, 0xE0, 0xF0, 0xF7, 0x8F, 0x87, 0x83, 0xFC, 0x3E,
  0x1E, 0x0F, 0xF0, 0xF0, 0x78, 0x3B, 0xC3, 0xC1, 0xE0, 0xEF, 0x1F, 0x0F,
  0x07, 0xBC, 0x7C, 0x3C, 0x1C, 0xF1, 0xF1, 0xF0, 0xF3, 0xC3, 0xC7, 0xC3,
  0x8F, 0x0F, 0xFF, 0xBE, 0x3C, 0x3F, 0xDF, 0xF0, 0xF0, 0x7E, 0x7F, 0x83,
  0xC0, 0xF0, 0xF8, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x30, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBE,
  0x00, 0x0F, 0xDF, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xE3,
  0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F,
  0xC0, 0x1F, 0x8F, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xF0, 0x03, 0xF3,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFC, 0x1F, 0xC3,
  0xF8, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F,
  0x03, 0xF8, 0x7E, 0x0F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0x07, 0xF0, 0xFE, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x1F, 0xE1, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x7F, 0x87, 0xF1, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00,
  0xFC, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF3, 0xF0, 0x0F,
  0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xE1, 0xFC, 0x7F, 0x87,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFC, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03,
  0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE3,
  0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x7F,
  0x07, 0xF0, 0xFC, 0x3F, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F, 0x87, 0xF0, 0x3F,
  0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xFF, 0x7F,
  0x0F, 0xFE, 0xFC, 0x1F, 0xF9, 0xF8, 0x3F, 0xF3, 0xF0, 0xFF, 0xE7, 0xE0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x9F, 0x80, 0x7F, 0x3F, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x1F, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0x7E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07,
  0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFE,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC1,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83,
  0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x07, 0xF0,
  0xFE, 0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0,
  0xFE, 0x07, 0xF8, 0x1F, 0x81, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x0F,
  0xE0, 0x0F, 0xC3, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0x7E, 0x1F, 0xC0, 0x0F,
  0xC7, 0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFD, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xC3,
  0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x01,
  0xF8, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x3F, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFE,
  0x0F, 0xFC, 0x07, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xEF, 0x03, 0xFF,
  0x81, 0xF7, 0x81, 0xFF, 0xC1, 0xFB, 0xE0, 0xFF, 0xE0, 0xFD, 0xF0, 0xFB,
  0xF0, 0x7E, 0xF8, 0x7D, 0xF8, 0x3F, 0x7C, 0x7C, 0xF8, 0x1F, 0xBE, 0x3E,
  0xFC, 0x0F, 0xDF, 0x3E, 0x7E, 0x0F, 0xC7, 0x9F, 0x3F, 0x07, 0xE3, 0xCF,
  0x1F, 0x83, 0xF1, 0xEF, 0x9F, 0xC1, 0xF8, 0xF7, 0x8F, 0xC0, 0xFC, 0x7F,
  0xC7, 0xE0, 0x7E, 0x3F, 0xE3, 0xF0, 0x7E, 0x1F, 0xE1, 0xF8, 0x3F, 0x0F,
  0xF1, 0xFC, 0x1F, 0x87, 0xF0, 0xFC, 0x0F, 0xC1, 0xF8, 0x7E, 0x07, 0xE0,
  0xF8, 0x3F, 0x07, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0x3C, 0x0F, 0xC0, 0x03,
  0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xFC, 0x07,
  0xE0, 0x7F, 0x80, 0xFC, 0x0F, 0xF0, 0x1F, 0x83, 0xFE, 0x03, 0xF0, 0x7F,
  0xE0, 0xFE, 0x0F, 0xFC, 0x1F, 0x81, 0xFF, 0x83, 0xF0, 0x3F, 0xF0, 0x7E,
  0x07, 0xFF, 0x0F, 0xC1, 0xFD, 0xE1, 0xF8, 0x3F, 0x3C, 0x7F, 0x07, 0xE7,
  0xCF, 0xC0, 0xFC, 0xF9, 0xF8, 0x1F, 0x8F, 0x3F, 0x03, 0xF1, 0xE7, 0xE0,
  0xFE, 0x3E, 0xFC, 0x1F, 0x87, 0xFF, 0x03, 0xF0, 0x7F, 0xE0, 0x7E, 0x0F,
  0xFC, 0x0F, 0xC1, 0xFF, 0x81, 0xF8, 0x3F, 0xF0, 0x7F, 0x03, 0xFE, 0x0F,
  0xC0, 0x7F, 0x81, 0xF8, 0x0F, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x1F,
  0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFC,
  0x3F, 0x87, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00, 0x7E, 0x7E, 0x00,
  0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x1F,
  0xDF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F,
  0x00, 0x7E, 0x7E, 0x01, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xFF,
  0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0xFE, 0x1F, 0x81, 0xFE, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x83, 0xFC, 0x3F, 0x87, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x00,
  0x7E, 0x7E, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07,
  0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFC, 0x00, 0xFD,
  0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x1F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0xFE, 0x7E, 0x01, 0xF8, 0xFE, 0x07, 0xF0, 0xFE,
  0x3F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0,
  0xFE, 0x1F, 0x80, 0xFC, 0x1F, 0x83, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x03,
  0xF0, 0xFE, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xC7, 0xE1,
  0xFC, 0x1F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7F, 0x3F, 0x01,
  0xF8, 0xFE, 0x07, 0xE1, 0xFC, 0x7F, 0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E,
  0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x7E,
  0x00, 0x7F, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x7E,
  0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x1F,
  0x3F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0xFF, 0xF0, 0x3E, 0x07,
  0xFF, 0xC1, 0xF8, 0x1F, 0xBF, 0x07, 0xF0, 0x7E, 0xFC, 0x1F, 0xC1, 0xFB,
  0xF0, 0xFF, 0x0F, 0xCF, 0xC3, 0xFC, 0x3F, 0x3F, 0x0F, 0xF0, 0xFC, 0xFC,
  0x7F, 0xC7, 0xE3, 0xF1, 0xFF, 0x1F, 0x8F, 0xC7, 0xFC, 0x7E, 0x3F, 0x3F,
  0xF3, 0xF0, 0xFC, 0xFF, 0xCF, 0xC3, 0xF3, 0xFF, 0x3F, 0x0F, 0xDF, 0x7D,
  0xF8, 0x3F, 0x7D, 0xF7, 0xE0, 0xFD, 0xF7, 0xDF, 0x83, 0xFF, 0x9F, 0x7C,
  0x0F, 0xFE, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xC7, 0xFE, 0x03,
  0xFF, 0x1F, 0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF,
  0x87, 0xFC, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC0,
  0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0xFF,
  0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7E,
  0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x07, 0xF0, 0x1F, 0x81, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x00, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xEF, 0xC0, 0x3F, 0xBF, 0x81, 0xFC, 0x7E, 0x07,
  0xF1, 0xF8, 0x3F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0x3E, 0x1F, 0x80,
  0xFC, 0xFE, 0x03, 0xF3, 0xF0, 0x0F, 0xDF, 0x80, 0x1F, 0x7E, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x00, 0x7C,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF0, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x0F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xEF, 0x03, 0xDE, 0x0F, 0xBC,
  0x1E, 0x78, 0x7C, 0xF0, 0xF1, 0xE3, 0xE3, 0xE7, 0x87, 0xDF, 0x07, 0xBC,
  0x0F, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7E, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x00, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x1F, 0x87,
  0xE1, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0xF8, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0xFE, 0x1F, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0xFC,
  0x1F, 0x9F, 0xC7, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F,
  0xBE, 0x03, 0xE7, 0xE0, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFC, 0x7F, 0x1F, 0x83, 0xF1, 0xF0,
  0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F,
  0x03, 0xE3, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x0F, 0xC7,
  0xF0, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xDF, 0xF0,
  0xFC, 0x7C, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE,
  0x3F, 0xFF, 0x8F, 0xC3, 0xF7, 0xE0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x7C, 0xFC, 0x3F, 0x3F, 0x0F, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8,
  0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0xFC,
  0x1F, 0xE7, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xE1,
  0xFC, 0x7E, 0x0F, 0xE3, 0xF0, 0x3E, 0x1F, 0x83, 0xF1, 0xF8, 0x1F, 0x8F,
  0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xFC, 0x7F, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFB, 0xE0, 0x1F, 0xBF, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0xCF, 0xE3, 0xF3,
  0xF0, 0x7D, 0xF8, 0x1F, 0x7E, 0x07, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x06,
  0x1F, 0x83, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x7F, 0xFC,
  0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0xF8, 0x1F,
  0xEF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xE3, 0xF8,
  0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF0, 0x1F, 0x9F, 0x81,
  0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x8F,
  0xC0, 0xF8, 0x7E, 0x0F, 0xC3, 0xF8, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xF7, 0xC0, 0x1F, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x81, 0x01, 0xFC, 0x1C, 0x1F, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x7C, 0x0F, 0xDF,
  0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFE, 0x3F, 0x1F, 0x87,
  0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F,
  0xCF, 0x81, 0xF3, 0xF0, 0x7E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8, 0x3F,
  0x3F, 0x07, 0xE7, 0xC0, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC,
  0xFC, 0x1F, 0x80, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0x00,
  0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x83, 0xF1, 0xFE, 0x1F, 0x87, 0xF0, 0x7E, 0x3F, 0x81,
  0xF9, 0xFC, 0x07, 0xEF, 0xE0, 0x1F, 0xFF, 0x00, 0x7D, 0xF8, 0x03, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFD, 0xF8, 0x07, 0xE3, 0xF0, 0x1F,
  0x8F, 0xC0, 0x7E, 0x3F, 0x81, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xF0, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x9F, 0x83, 0xE0, 0x3E, 0xFF,
  0x3F, 0xC0, 0xFF, 0xFD, 0xFF, 0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFC, 0x7F, 0x1F, 0xE7, 0xF1, 0xF8, 0x7F, 0x0F, 0xC7, 0xE1, 0xF8, 0x3F,
  0x3F, 0x07, 0xE0, 0xFC, 0xFC, 0x1F, 0x83, 0xF3, 0xF0, 0x7E, 0x1F, 0x8F,
  0xC1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC1, 0xF8, 0xF8, 0x3F, 0x07, 0xE7, 0xE0,
  0xFC, 0x1F, 0x9F, 0x83, 0xF0, 0x7E, 0x7E, 0x0F, 0xC3, 0xF1, 0xF8, 0x3E,
  0x0F, 0xC7, 0xE1, 0xF8, 0x3F, 0x1F, 0x07, 0xE0, 0xFC, 0xFC, 0x1F, 0x83,
  0xF3, 0xF0, 0x7E, 0x0F, 0xCF, 0xC1, 0xF8, 0x7E, 0x00, 0x0F, 0x9F, 0x81,
  0xF7, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0x8F, 0xC7,
  0xE1, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F,
  0x83, 0xF3, 0xF0, 0x7C, 0xFC, 0x1F, 0x9F, 0x83, 0xF3, 0xF0, 0x7E, 0x7E,
  0x0F, 0xCF, 0xC1, 0xF9, 0xF0, 0x3E, 0x7E, 0x0F, 0xCF, 0xC1, 0xF9, 0xF8,
  0x3F, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0x1F, 0x9F, 0xC1, 0xF3, 0xF0, 0x3F, 0x7E,
  0x07, 0xEF, 0x80, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7D, 0xF8,
  0x1F, 0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x1F, 0x9F, 0xC7, 0xF1, 0xFF,
  0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xF8, 0x00, 0x03,
  0xE7, 0xC0, 0x0F, 0xBF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x1F, 0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xC0, 0xFC,
  0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E,
  0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF0, 0x7F, 0x1F,
  0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFD, 0xFE, 0x03,
  0xF3, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE3, 0xF0, 0xFF, 0xBF, 0x1F, 0xFB, 0xE1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE3, 0xF0, 0xFE, 0x7E, 0x07, 0xE7, 0xE0, 0x7C, 0x7E,
  0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF,
  0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xE3, 0xF8,
  0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xBF,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F,
  0x9E, 0x1F, 0x7C, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x87, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x1F, 0x87, 0xC1, 0xF0,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x9F,
  0x83, 0xF1, 0xFD, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE1,
  0xFF, 0xEF, 0xFF, 0x7F, 0xF3, 0xFF, 0xBF, 0xFC, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0xC3, 0xFC, 0x0F, 0xE0, 0x7F, 0x00,
  0xF8, 0x00, 0x1F, 0x83, 0xF1, 0xF0, 0x3E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E,
  0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE3, 0xE0, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7E, 0x0F, 0xCF, 0xC1,
  0xF8, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0xE3, 0xF8, 0xFF,
  0xFF, 0x87, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0x3F, 0x00,
  0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xC1, 0xF9, 0xF0, 0x7E, 0x7C, 0x3F, 0x1F,
  0x0F, 0xC7, 0xE3, 0xE1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x07, 0xEF,
  0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x3C, 0x1F, 0xFC, 0x3E, 0x0F, 0xFE, 0x1F,
  0x07, 0xDF, 0x0F, 0xC7, 0xEF, 0x8F, 0xE3, 0xE7, 0xC7, 0xF1, 0xF3, 0xE7,
  0xF9, 0xF9, 0xF3, 0xFC, 0xF8, 0xF9, 0xFE, 0x7C, 0x7D, 0xFF, 0x7E, 0x3E,
  0xF7, 0xBE, 0x1F, 0xFB, 0xDF, 0x0F, 0xFD, 0xFF, 0x07, 0xFC, 0xFF, 0x83,
  0xFE, 0x7F, 0xC1, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xF0,
  0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0x83, 0xF1, 0xFC,
  0x0F, 0x8F, 0xC0, 0x7E, 0xFE, 0x03, 0xF7, 0xE0, 0x0F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0xFD, 0xF8, 0x0F, 0xE7, 0xC0, 0x7E, 0x3F, 0x07, 0xE1, 0xF8, 0x7F,
  0x0F, 0xC3, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xE0, 0xF8,
  0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0xFE,
  0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x7F,
  0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x00, 0x18, 0x03, 0xC0, 0x3E,
  0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC,
  0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x0E, 0x00, 0x10, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x00, 0x01, 0x00,
  0x07, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x03,
  0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x70, 0x01, 0x80, 0x00,
  0x0F, 0x00, 0x01, 0xFC, 0x0F, 0x3F, 0xE0, 0xF7, 0xFE, 0x1F, 0x7F, 0xF1,
  0xFF, 0x9F, 0xFE, 0xF8, 0xFF, 0xEF, 0x07, 0xFC, 0xF0, 0x3F, 0x80, 0x01,
  0xF0,
};

const GFXglyph RobotoCondensed_BoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 31, 11, 1, -31 },
  { 44, 12, 12, 14, 3, -33 },
  { 62, 22, 31, 23, 1, -31 },
  { 148, 20, 40, 22, 1, -36 },
  { 248, 21, 31, 27, 4, -31 },
  { 330, 22, 31, 25, 1, -31 },
  { 416, 6, 12, 7, 3, -33 },
  { 425, 14, 45, 14, 2, -35 },
  { 504, 14, 45, 14, -2, -35 },
  { 583, 19, 19, 19, 2, -31 },
  { 629, 19, 23, 20, 1, -26 },
  { 684, 10, 13, 10, -3, -5 },
  { 701, 11, 5, 15, 2, -16 },
  { 708, 7, 7, 12, 1, -7 },
  { 715, 20, 34, 14, -3, -31 },
  { 800, 19, 31, 22, 2, -31 },
  { 874, 13, 31, 22, 5, -31 },
  { 925, 21, 31, 22, 0, -31 },
  { 1007, 20, 31, 22, 1, -31 },
  { 1085, 20, 31, 22, 1, -31 },
  { 1163, 21, 31, 22, 1, -31 },
  { 1245, 18, 31, 22, 2, -31 },
  { 1315, 21, 31, 22, 2, -31 },
  { 1397, 20, 31, 22, 1, -31 },
  { 1475, 18, 31, 22, 3, -31 },
  { 1545, 10, 25, 12, 1, -25 },
  { 1577, 12, 33, 11, -2, -25 },
  { 1627, 17, 21, 19, 1, -24 },
  { 1672, 18, 14, 21, 2, -21 },
  { 1704, 17, 21, 19, 1, -24 },
  { 1749, 16, 31, 19, 3, -31 },
  { 1811, 30, 40, 33, 1, -30 },
  { 1961, 25, 31, 25, -2, -31 },
  { 2058, 23, 31, 24, 0, -31 },
  { 2148, 22, 31, 24, 2, -31 },
  { 2234, 23, 31, 24, 0, -31 },
  { 2324, 23, 31, 21, 0, -31 },
  { 2414, 22, 31, 20, 0, -31 },
  { 2500, 23, 31, 25, 2, -31 },
  { 2590, 27, 31, 26, 0, -31 },
  { 2695, 12, 31, 12, 0, -31 },
  { 2742, 22, 31, 21, 0, -31 },
  { 2828, 27, 31, 24, 0, -31 },
  { 2933, 18, 31, 20, 0, -31 },
  { 3003, 33, 31, 32, 0, -31 },
  { 3131, 27, 31, 26, 0, -31 },
  { 3236, 23, 31, 26, 2, -31 },
  { 3326, 24, 31, 24, 0, -31 },
  { 3419, 23, 37, 26, 2, -31 },
  { 3526, 24, 31, 24, 0, -31 },
  { 3619, 22, 31, 23, 1, -31 },
  { 3705, 22, 31, 23, 3, -31 },
  { 3791, 24, 31, 24, 1, -31 },
  { 3884, 24, 31, 25, 3, -31 },
  { 3977, 30, 31, 32, 4, -31 },
  { 4094, 27, 31, 24, -1, -31 },
  { 4199, 22, 31, 23, 4, -31 },
  { 4285, 25, 31, 23, -1, -31 },
  { 4382, 15, 43, 11, -1, -36 },
  { 4463, 11, 34, 16, 3, -31 },
  { 4510, 15, 43, 11, -2, -36 },
  { 4591, 15, 16, 17, 1, -31 },
  { 4621, 17, 5, 17, -3, 0 },
  { 4632, 10, 7, 14, 4, -33 },
  { 4641, 19, 23, 20, 0, -23 },
  { 4696, 20, 33, 21, 0, -33 },
  { 4779, 18, 23, 20, 1, -23 },
  { 4831, 21, 33, 21, 1, -33 },
  { 4918, 18, 23, 20, 1, -23 },
  { 4970, 16, 33, 14, 1, -33 },
  { 5036, 21, 32, 21, 0, -23 },
  { 5120, 19, 33, 21, 0, -33 },
  { 5199, 11, 32, 11, 0, -32 },
  { 5243, 16, 41, 10, -5, -32 },
  { 5325, 22, 33, 20, 0, -33 },
  { 5416, 12, 33, 11, 0, -33 },
  { 5466, 30, 23, 32, 0, -23 },
  { 5553, 19, 23, 21, 0, -23 },
  { 5608, 19, 23, 21, 1, -23 },
  { 5663, 22, 32, 21, -2, -23 },
  { 5751, 20, 32, 21, 1, -23 },
  { 5831, 15, 23, 14, 0, -23 },
  { 5875, 19, 23, 19, 0, -23 },
  { 5930, 13, 29, 13, 1, -29 },
  { 5978, 20, 23, 21, 1, -23 },
  { 6036, 18, 23, 19, 2, -23 },
  { 6088, 25, 23, 27, 3, -23 },
  { 6160, 21, 23, 19, -1, -23 },
  { 6221, 22, 32, 19, -1, -23 },
  { 6309, 20, 23, 19, -1, -23 },
  { 6367, 13, 42, 13, 1, -34 },
  { 6436, 9, 37, 11, 1, -31 },
  { 6478, 14, 42, 13, -2, -34 },
  { 6552, 20, 10, 24, 2, -18 },
};

const GFXfont RobotoCondensed_BoldItalic44pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic44pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic44pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _ROBOTOCONDENSED_BOLDITALIC44PT7B_H_
