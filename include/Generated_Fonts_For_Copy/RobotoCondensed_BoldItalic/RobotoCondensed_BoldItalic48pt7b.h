#ifndef _ROBOTOCONDENSED_BOLDITALIC48PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFC, 0x07, 0x80, 0x3C, 0x7C, 0xF1, 0xF7, 0xC7, 0xDF, 0x1E, 0x7C,
  0x79, 0xE3, 0xE7, 0x8F, 0x9E, 0x3C, 0x78, 0xF3, 0xE3, 0xCF, 0x0F, 0x3C,
  0x38, 0xF1, 0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x01, 0xE3, 0xC0,
  0x01, 0xE3, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0xC7, 0x80,
  0x03, 0xC7, 0x80, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x3E, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xF8, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0xFE, 0x07, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7E, 0x1F, 0x81,
  0xF8, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xCF, 0x83,
  0x0F, 0x0F, 0x0F, 0x9E, 0x1E, 0x1E, 0x7C, 0x3C, 0x78, 0xF8, 0x79, 0xF1,
  0xF1, 0xF3, 0xC3, 0xE3, 0xCF, 0x07, 0xCF, 0xBE, 0x07, 0xFF, 0x78, 0x0F,
  0xFD, 0xE0, 0x0F, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xEF, 0x80, 0x07, 0xBF, 0xC0, 0x1E, 0xFF, 0xC0, 0x7F,
  0xFF, 0x81, 0xF7, 0xCF, 0x03, 0xDF, 0x1F, 0x0F, 0x3E, 0x3E, 0x3E, 0x78,
  0x7C, 0x78, 0xF0, 0xF9, 0xE1, 0xE1, 0xE7, 0xC3, 0xC3, 0xC7, 0x07, 0xCF,
  0x84, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xE1, 0xF0, 0x07, 0xE1, 0xF0,
  0x07, 0xC1, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xF0, 0x07, 0xE7, 0xE0,
  0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x3F, 0x1F, 0xFC, 0x3E, 0x3F, 0xFE, 0x3E,
  0x7F, 0x7F, 0x7E, 0x7E, 0x7F, 0x7E, 0xFE, 0x3F, 0xFC, 0xFE, 0x3F, 0xFC,
  0xFE, 0x1F, 0xFC, 0xFE, 0x1F, 0xF8, 0xFE, 0x0F, 0xF8, 0xFE, 0x0F, 0xF0,
  0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFD, 0xFC, 0x07, 0xF0, 0xFE, 0x3E, 0x7D, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3C, 0x79, 0xF3, 0xE7, 0x8F, 0x00, 0x00, 0x04, 0x00, 0x18, 0x00, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x02, 0x00, 0x00, 0x80, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x30, 0x00, 0x40, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x10,
  0x3C, 0x00, 0xE1, 0xE1, 0xCF, 0xCF, 0x3E, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0xC3, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x03, 0xF7, 0xC0, 0x1F, 0x1E, 0x01, 0xF0, 0xF8, 0x0F, 0x03, 0xE0,
  0x38, 0x1C, 0x00, 0x80, 0x40, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7E, 0x1F, 0x0F, 0xC7, 0xE1, 0xF0,
  0x78, 0x04, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0, 0x7C,
  0xFF, 0xFF, 0xFF, 0xEF, 0xCF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xF3, 0xF8,
  0x7F, 0x0F, 0xC3, 0xF0, 0x7E, 0x3F, 0x83, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0,
  0xFE, 0x7E, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x81, 0xF9, 0xF8, 0x0F, 0xCF,
  0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0xBF, 0x81, 0xFD, 0xFC, 0x0F,
  0xEF, 0xE0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xFC, 0xFC,
  0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x07, 0xF1, 0xFC, 0x3F, 0x07, 0xF7, 0xF8,
  0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x78, 0x07, 0xF0, 0x3F, 0xE3, 0xFF, 0xCF,
  0xFF, 0x9F, 0xFF, 0x3F, 0xFC, 0x7D, 0xF9, 0xC3, 0xF2, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF, 0x7F, 0x83,
  0xF8, 0x3F, 0x07, 0xF0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xDF,
  0xE1, 0xFC, 0x1F, 0x87, 0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x83,
  0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xF7, 0xE0, 0x0F, 0x9F, 0x80, 0x7E, 0x7E, 0x01,
  0xF3, 0xF8, 0x0F, 0xCF, 0xE0, 0x7E, 0x3F, 0x81, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF9, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0x1F, 0xE0, 0x0C, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE1, 0xF8, 0x1F, 0x83, 0xF8, 0x7F,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFB, 0xE0,
  0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xDF,
  0xE7, 0xF0, 0xFE, 0xFE, 0x07, 0xEF, 0xE0, 0x7E, 0xFE, 0x07, 0xFF, 0xE0,
  0x7F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFE,
  0x0F, 0xC7, 0xE1, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0xEF, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xC1, 0xFC, 0x3F, 0x07,
  0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xF8, 0x1F, 0x9F, 0xC0,
  0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xE0, 0x7E,
  0x1F, 0x81, 0xF8, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0xFE, 0x1F,
  0xC3, 0xF8, 0x7F, 0xBF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0,
  0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xE3, 0xFB,
  0xF8, 0x3F, 0x7F, 0x07, 0xEF, 0xC0, 0xFD, 0xF8, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0x7E, 0x0F, 0xEF,
  0xE3, 0xFD, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0x81,
  0xF7, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0x80, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F,
  0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xE1, 0xFC, 0x3F, 0xC7,
  0xF0, 0x7E, 0x07, 0x80, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x80, 0xFC, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xFC,
  0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFC, 0x0F, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF,
  0xFF, 0x80, 0x08, 0x00, 0x01, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x81,
  0xFF, 0xF1, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x01, 0xF8, 0x01,
  0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xF1,
  0xFD, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF, 0x87, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x07,
  0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x3F, 0x01, 0xE1,
  0xF0, 0x3F, 0xE0, 0xF0, 0xF0, 0x7F, 0xF8, 0x78, 0xF8, 0x7F, 0xFC, 0x3C,
  0x78, 0x3F, 0x3E, 0x1E, 0x7C, 0x3E, 0x1F, 0x0F, 0x3C, 0x1F, 0x0F, 0x07,
  0x9E, 0x1F, 0x07, 0x83, 0xDF, 0x0F, 0x87, 0xC1, 0xEF, 0x0F, 0x83, 0xE0,
  0xF7, 0x87, 0xC1, 0xE0, 0x7F, 0xC3, 0xE0, 0xF0, 0x7B, 0xE1, 0xF0, 0x78,
  0x3D, 0xF1, 0xF0, 0x7C, 0x1E, 0xF0, 0xF8, 0x3E, 0x0F, 0x78, 0x7C, 0x1E,
  0x0F, 0x3C, 0x3E, 0x1F, 0x07, 0x9E, 0x1F, 0x0F, 0x87, 0x8F, 0x0F, 0xCF,
  0xC7, 0xC7, 0x83, 0xFF, 0xFF, 0xC3, 0xC1, 0xFF, 0xFF, 0xC1, 0xE0, 0x7F,
  0x3F, 0xC0, 0xF0, 0x1E, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x81, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFE,
  0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x81, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F,
  0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xE0, 0x03,
  0xF3, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFC, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F,
  0x07, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07,
  0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xF0,
  0x1F, 0xC1, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7F,
  0x00, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x3F, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0x7E, 0x1F,
  0x80, 0x3F, 0x1F, 0xC0, 0x1F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x07, 0xF7,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xF1, 0xFC, 0x01,
  0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x0F, 0xE0,
  0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xE0,
  0x3F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFE,
  0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F,
  0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1,
  0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFC,
  0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xC0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0,
  0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x0F, 0xFF, 0x3F,
  0x07, 0xFF, 0xBF, 0x83, 0xFF, 0x9F, 0xC1, 0xFF, 0xCF, 0xE0, 0xFF, 0xE7,
  0xF0, 0x07, 0xF3, 0xF8, 0x03, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0xFC,
  0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x7F, 0x87, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x1F,
  0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xE0,
  0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F,
  0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x3F, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x0F,
  0xE0, 0xFE, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x3F, 0x81,
  0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0,
  0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xE0, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0xFC, 0x07, 0xF8, 0x07, 0xE0,
  0x7F, 0xC0, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xC3, 0xFC,
  0x00, 0xFE, 0x3F, 0xC0, 0x07, 0xE1, 0xFE, 0x00, 0x7F, 0x1F, 0xE0, 0x03,
  0xF9, 0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xF7, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0x3F, 0xC0, 0x0F, 0xC0, 0xFE,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0x81, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0xC0, 0xFE, 0x01, 0xFE, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0,
  0x7F, 0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0x1F,
  0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0xFD, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF,
  0x03, 0xEF, 0xC0, 0xFD, 0xF0, 0x7E, 0xFC, 0x0F, 0xDF, 0x07, 0xFF, 0xC1,
  0xFD, 0xF0, 0x7D, 0xF8, 0x1F, 0xDF, 0x0F, 0xDF, 0x81, 0xF9, 0xF0, 0xF9,
  0xF8, 0x1F, 0x9F, 0x1F, 0xBF, 0x81, 0xF9, 0xF1, 0xF3, 0xF8, 0x1F, 0x8F,
  0x3F, 0x3F, 0x83, 0xF8, 0xFB, 0xE3, 0xF0, 0x3F, 0x8F, 0xBE, 0x3F, 0x03,
  0xF8, 0xFF, 0xC7, 0xF0, 0x3F, 0x8F, 0xFC, 0x7F, 0x03, 0xF0, 0xFF, 0x87,
  0xF0, 0x3F, 0x0F, 0xF8, 0x7E, 0x07, 0xF0, 0xFF, 0x87, 0xE0, 0x7F, 0x0F,
  0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0xFE, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFE, 0x07, 0xC0, 0xFC, 0x0F, 0xE0, 0x7C, 0x0F,
  0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE,
  0x07, 0xF8, 0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0x83, 0xFE, 0x01, 0xF8, 0x1F,
  0xF0, 0x0F, 0xC0, 0xFF, 0xC0, 0xFE, 0x07, 0xFE, 0x07, 0xF0, 0x7F, 0xF0,
  0x3F, 0x83, 0xFF, 0x81, 0xFC, 0x1F, 0xFE, 0x0F, 0xC0, 0xFF, 0xF0, 0xFE,
  0x07, 0xFF, 0x87, 0xF0, 0x3F, 0x3E, 0x3F, 0x83, 0xF9, 0xF1, 0xFC, 0x1F,
  0xCF, 0x8F, 0xC0, 0xFE, 0x7C, 0x7E, 0x07, 0xF1, 0xF7, 0xF0, 0x3F, 0x0F,
  0xBF, 0x81, 0xF8, 0x7D, 0xFC, 0x1F, 0xC1, 0xEF, 0xE0, 0xFE, 0x0F, 0xFE,
  0x07, 0xF0, 0x7F, 0xF0, 0x3F, 0x83, 0xFF, 0x81, 0xF8, 0x0F, 0xFC, 0x0F,
  0xC0, 0x7F, 0xE0, 0xFE, 0x03, 0xFF, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0x80,
  0x7F, 0x81, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0xFE, 0x00, 0xFF,
  0x07, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8,
  0x3F, 0x81, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F,
  0xCF, 0xE0, 0x0F, 0xE7, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01,
  0xFD, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xBF, 0x00,
  0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07, 0xF7, 0xF0,
  0x03, 0xFB, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0xFE, 0x7F,
  0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xE0, 0x1F, 0xC3, 0xF8, 0x03,
  0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x9F,
  0xC0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xFB,
  0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F,
  0xBF, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0xC0, 0x0F, 0xEF, 0xE0, 0x07,
  0xF7, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0xFE, 0x00,
  0xFE, 0x7F, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x01, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8,
  0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFC, 0x07,
  0xF8, 0x7F, 0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xC1, 0xFC,
  0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x03, 0xF8,
  0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x07, 0xE1, 0xFC, 0x01,
  0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1, 0xF8,
  0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F,
  0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x1F, 0xC0,
  0x3F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x3F,
  0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xF8,
  0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F,
  0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFF, 0x3F, 0x80,
  0x3F, 0x8F, 0xE0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F,
  0xC0, 0xFF, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF0,
  0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC7, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F,
  0x3F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x03, 0xE0,
  0x3F, 0xFF, 0x03, 0xF0, 0x1F, 0xFF, 0x81, 0xF8, 0x0F, 0xDF, 0xC0, 0xFC,
  0x0F, 0xEF, 0xE0, 0xFE, 0x07, 0xF7, 0xF0, 0x7F, 0x83, 0xF3, 0xF8, 0x3F,
  0xC3, 0xF9, 0xFC, 0x3F, 0xE1, 0xFC, 0xFE, 0x1F, 0xF0, 0xFC, 0x7F, 0x0F,
  0xF8, 0x7E, 0x3F, 0x8F, 0xFC, 0x7F, 0x1F, 0xC7, 0xFE, 0x3F, 0x0F, 0xE3,
  0xFF, 0x1F, 0x87, 0xF3, 0xFF, 0x9F, 0xC3, 0xF9, 0xF7, 0xCF, 0xC1, 0xFD,
  0xFB, 0xE7, 0xE0, 0x7E, 0xFD, 0xF7, 0xF0, 0x3F, 0x7C, 0xFB, 0xF0, 0x1F,
  0xFE, 0x7D, 0xF8, 0x0F, 0xFF, 0x3F, 0xFC, 0x07, 0xFF, 0x1F, 0xFC, 0x03,
  0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0xC7, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00,
  0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x0F, 0xF0,
  0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x01, 0xFC, 0x00, 0xFE, 0x0F,
  0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x8F, 0xF0,
  0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFD, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x7F, 0x00,
  0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x03,
  0xFC, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFC,
  0x07, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0x9F, 0x80, 0x3F, 0x8F,
  0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0,
  0x7E, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0x87, 0xF0, 0x0F, 0xE3, 0xF0,
  0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xF8,
  0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xE1, 0xFC, 0x3F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xF0, 0xFE, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x00,
  0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xBC, 0x0F, 0xBC, 0x1F,
  0x3C, 0x1F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0xF8,
  0x1E, 0xF8, 0x1F, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFC, 0xFE, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xE0, 0x7C,
  0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF,
  0xF1, 0xFE, 0x7F, 0x1F, 0xC3, 0xF1, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F,
  0x87, 0xE7, 0xF0, 0x7E, 0x7F, 0x0F, 0xE7, 0xE0, 0xFE, 0xFE, 0x0F, 0xEF,
  0xE0, 0xFC, 0x7F, 0x3F, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x1F, 0xEF, 0xC0, 0xF8, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFE, 0x1F, 0xC1, 0xF8, 0x7F, 0x07, 0xF1, 0xF8, 0x1F, 0xC7, 0xE0, 0x7F,
  0x1F, 0x81, 0xFC, 0xFE, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x9F, 0xC0, 0xFC, 0x7F, 0x03,
  0xF1, 0xFC, 0x1F, 0xC7, 0xFD, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFF, 0x0F, 0xCF, 0xF8, 0x3F, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFC, 0xFE, 0x3F,
  0x87, 0xE3, 0xF0, 0x7E, 0x7F, 0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xE1, 0xFC, 0x7F, 0xFF,
  0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xF1, 0xFC, 0x07, 0xFD,
  0xFC, 0x0F, 0xFD, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x3F, 0x87, 0xF8, 0x7F, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x7E, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xE0, 0xFE, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xEF, 0xC0, 0x0F, 0x8F,
  0x80, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE1, 0xFE, 0xFE, 0x3F, 0x83, 0xF3, 0xF0, 0x3F, 0x7F, 0x03, 0xF7,
  0xE0, 0x3F, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x01,
  0x07, 0xE0, 0x30, 0x7F, 0xDF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE1,
  0xFF, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x7E, 0x07, 0xFC, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFE, 0xFF, 0x87, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81,
  0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F,
  0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xF8, 0x7E, 0x03, 0xF0,
  0xFE, 0x07, 0xE1, 0xFC, 0x0F, 0xC3, 0xF8, 0x3F, 0x83, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xF7, 0xE0, 0x0F,
  0xDF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x06, 0x03,
  0xF8, 0x1F, 0x1F, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFB, 0xF0,
  0x1F, 0xBF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xF3,
  0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03,
  0xF1, 0xF8, 0x3F, 0x9F, 0xC1, 0xFC, 0xFE, 0x0F, 0xE7, 0xE0, 0x7E, 0x3F,
  0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0xFE, 0x0F, 0xE7, 0xF0, 0x7F,
  0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x80, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x7F,
  0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0xFE,
  0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0xC1, 0xF8,
  0x1F, 0x81, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xF0,
  0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0,
  0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x0F,
  0xE1, 0xFE, 0x0F, 0xC3, 0xFC, 0x0F, 0xC7, 0xF8, 0x0F, 0xCF, 0xF0, 0x1F,
  0xCF, 0xE0, 0x1F, 0xDF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x7F,
  0x3F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E,
  0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x81, 0xFC,
  0x00, 0x0F, 0xC7, 0xC0, 0xF8, 0x07, 0xEF, 0xF1, 0xFF, 0x03, 0xFF, 0xFD,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xBF,
  0xFF, 0xF8, 0x7F, 0x0F, 0xF0, 0xFC, 0x3F, 0x87, 0xF0, 0x7F, 0x1F, 0x83,
  0xF8, 0x3F, 0x8F, 0xC1, 0xFC, 0x1F, 0x87, 0xE0, 0xFE, 0x0F, 0xC7, 0xF0,
  0x7E, 0x07, 0xE3, 0xF8, 0x3F, 0x07, 0xF1, 0xF8, 0x1F, 0x83, 0xF8, 0xFC,
  0x0F, 0xC1, 0xFC, 0x7E, 0x0F, 0xE0, 0xFC, 0x3F, 0x07, 0xF0, 0x7E, 0x3F,
  0x83, 0xF0, 0x3F, 0x1F, 0xC1, 0xF8, 0x3F, 0x8F, 0xC0, 0xFC, 0x1F, 0xC7,
  0xE0, 0x7E, 0x0F, 0xE3, 0xF0, 0x7F, 0x07, 0xE1, 0xF8, 0x3F, 0x83, 0xF1,
  0xFC, 0x1F, 0x81, 0xF8, 0xFE, 0x0F, 0xC0, 0xFC, 0x7E, 0x07, 0xE0, 0xFE,
  0x00, 0x0F, 0xC7, 0xC0, 0x7E, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x81,
  0xF8, 0xFC, 0x1F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x0F, 0xCF, 0xE0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x3F,
  0x9F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x7F, 0x03, 0xF3, 0xF8,
  0x3F, 0x9F, 0xC1, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xF7, 0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0x7E, 0x7F, 0x03, 0xF3, 0xF0, 0x1F,
  0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xEF, 0xE0, 0x3F, 0x7F, 0x01, 0xFB, 0xF8,
  0x0F, 0xDF, 0xC0, 0x7E, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0x3F, 0x81, 0xF8,
  0xFC, 0x1F, 0xC7, 0xFB, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x03, 0xF7,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFD,
  0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0,
  0x7F, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0xFE, 0x1F, 0xC0,
  0xFC, 0x1F, 0xC0, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xF7, 0xF8, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xBF, 0xE0, 0x3F, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0xFC, 0x1F, 0xF7,
  0xE0, 0xFF, 0xDF, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x3F, 0xE3,
  0xF8, 0x7F, 0x9F, 0xC0, 0xFC, 0x7F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E,
  0x3F, 0x81, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x8F, 0xE0, 0xFE, 0x3F,
  0x83, 0xF0, 0xFF, 0xBF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x3E, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xCF,
  0x0F, 0xDF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF1, 0xFC, 0x7F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFC, 0x7E, 0x1F, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x83,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x7F, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFC, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x07,
  0xF0, 0x3F, 0xF1, 0xFF, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F,
  0xC1, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x83,
  0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F, 0x8F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x83, 0xF8, 0xFE, 0x0F, 0xE3, 0xF8, 0x3F,
  0x8F, 0xE0, 0xFC, 0x3F, 0x87, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0xFE,
  0x07, 0xF7, 0xE0, 0x7F, 0x7E, 0x0F, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F, 0xC7,
  0xE1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x87, 0xE3, 0xF0,
  0x3E, 0x3F, 0x03, 0xE7, 0xE0, 0x3E, 0x7E, 0x03, 0xF7, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0xFC, 0x1F, 0x07, 0xFF, 0xC1, 0xF0, 0x7E, 0xFC,
  0x3F, 0x07, 0xEF, 0xC3, 0xF0, 0xFC, 0xFC, 0x3F, 0x0F, 0xCF, 0xC7, 0xF0,
  0xFC, 0xFC, 0x7F, 0x1F, 0x8F, 0xCF, 0xF1, 0xF8, 0xFC, 0xFF, 0x1F, 0x8F,
  0xCF, 0xF3, 0xF0, 0xFD, 0xFF, 0xBF, 0x0F, 0xDF, 0xFB, 0xF0, 0xFF, 0xEF,
  0xFE, 0x0F, 0xFE, 0xFF, 0xE0, 0xFF, 0xEF, 0xFC, 0x0F, 0xFC, 0xFF, 0xC0,
  0xFF, 0xCF, 0xFC, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF8,
  0xFF, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xE0,
  0x0F, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x03, 0xF1, 0xFC, 0x03,
  0xF1, 0xF8, 0x03, 0xFB, 0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xEF, 0xC0, 0x0F,
  0xCF, 0xE0, 0x1F, 0xC7, 0xE0, 0x3F, 0x87, 0xE0, 0x3F, 0x87, 0xE0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F,
  0x07, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xF0,
  0xFE, 0x07, 0xE3, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F, 0xBF,
  0x80, 0x3F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x00, 0x00, 0x04, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x80, 0x03, 0x80, 0x07, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF8,
  0x03, 0xE0, 0x07, 0x00, 0x08, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x80,
  0xF3, 0xFF, 0x07, 0xCF, 0xFC, 0x1F, 0x7F, 0xF8, 0xFD, 0xFF, 0xFF, 0xEF,
  0xC7, 0xFF, 0xBE, 0x0F, 0xFC, 0xF8, 0x3F, 0xF3, 0xE0, 0x7F, 0x80, 0x00,
  0x78, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 34, 12, 1, -34 },
  { 52, 14, 13, 15, 3, -36 },
  { 75, 24, 34, 25, 1, -34 },
  { 177, 22, 44, 24, 1, -39 },
  { 298, 23, 34, 30, 4, -34 },
  { 396, 24, 34, 27, 1, -34 },
  { 498, 7, 13, 8, 3, -36 },
  { 510, 15, 49, 15, 2, -38 },
  { 602, 15, 49, 15, -2, -38 },
  { 694, 21, 21, 21, 2, -34 },
  { 750, 20, 25, 22, 1, -28 },
  { 813, 10, 14, 11, -3, -6 },
  { 831, 12, 5, 17, 2, -17 },
  { 839, 7, 7, 14, 1, -7 },
  { 846, 21, 37, 15, -3, -34 },
  { 944, 21, 34, 24, 2, -34 },
  { 1034, 15, 34, 24, 5, -34 },
  { 1098, 23, 34, 24, 0, -34 },
  { 1196, 22, 34, 24, 1, -34 },
  { 1290, 22, 34, 24, 1, -34 },
  { 1384, 23, 34, 24, 1, -34 },
  { 1482, 20, 34, 24, 2, -34 },
  { 1567, 23, 34, 24, 2, -34 },
  { 1665, 22, 34, 24, 1, -34 },
  { 1759, 19, 34, 24, 3, -34 },
  { 1840, 11, 26, 13, 1, -26 },
  { 1876, 13, 34, 12, -2, -26 },
  { 1932, 19, 23, 21, 1, -26 },
  { 1987, 20, 17, 23, 2, -24 },
  { 2030, 19, 23, 21, 1, -26 },
  { 2085, 18, 34, 21, 3, -34 },
  { 2162, 33, 44, 36, 1, -33 },
  { 2344, 27, 34, 28, -2, -34 },
  { 2459, 25, 34, 26, 0, -34 },
  { 2566, 25, 34, 27, 2, -34 },
  { 2673, 25, 34, 26, 0, -34 },
  { 2780, 25, 34, 23, 0, -34 },
  { 2887, 25, 34, 22, 0, -34 },
  { 2994, 25, 34, 27, 2, -34 },
  { 3101, 29, 34, 29, 0, -34 },
  { 3225, 13, 34, 13, 0, -34 },
  { 3281, 24, 34, 23, 0, -34 },
  { 3383, 29, 34, 26, 0, -34 },
  { 3507, 20, 34, 22, 0, -34 },
  { 3592, 36, 34, 35, 0, -34 },
  { 3745, 29, 34, 29, 0, -34 },
  { 3869, 25, 34, 28, 2, -34 },
  { 3976, 26, 34, 26, 0, -34 },
  { 4087, 25, 40, 28, 2, -34 },
  { 4212, 26, 34, 26, 0, -34 },
  { 4323, 24, 34, 25, 1, -34 },
  { 4425, 24, 34, 25, 4, -34 },
  { 4527, 26, 34, 27, 2, -34 },
  { 4638, 26, 34, 27, 4, -34 },
  { 4749, 33, 34, 35, 4, -34 },
  { 4890, 30, 34, 26, -2, -34 },
  { 5018, 25, 34, 25, 4, -34 },
  { 5125, 27, 34, 25, -1, -34 },
  { 5240, 16, 48, 12, -1, -40 },
  { 5336, 11, 37, 18, 4, -34 },
  { 5387, 17, 48, 12, -3, -40 },
  { 5489, 16, 17, 18, 2, -34 },
  { 5523, 19, 5, 19, -3, 0 },
  { 5535, 10, 7, 15, 5, -36 },
  { 5544, 20, 26, 22, 0, -26 },
  { 5609, 22, 36, 23, 0, -36 },
  { 5708, 20, 26, 21, 1, -26 },
  { 5773, 24, 36, 23, 1, -36 },
  { 5881, 20, 26, 22, 1, -26 },
  { 5946, 17, 36, 15, 1, -36 },
  { 6023, 23, 36, 23, 0, -26 },
  { 6127, 21, 36, 23, 0, -36 },
  { 6222, 12, 36, 12, 0, -36 },
  { 6276, 17, 46, 11, -5, -36 },
  { 6374, 24, 36, 22, 0, -36 },
  { 6482, 13, 36, 12, 0, -36 },
  { 6541, 33, 26, 35, 0, -26 },
  { 6649, 21, 26, 23, 0, -26 },
  { 6718, 21, 26, 23, 1, -26 },
  { 6787, 24, 36, 23, -2, -26 },
  { 6895, 22, 36, 23, 1, -26 },
  { 6994, 16, 26, 15, 0, -26 },
  { 7046, 20, 26, 21, 0, -26 },
  { 7111, 13, 32, 14, 2, -32 },
  { 7163, 22, 26, 23, 1, -26 },
  { 7235, 20, 26, 21, 2, -26 },
  { 7300, 28, 26, 29, 3, -26 },
  { 7391, 24, 26, 21, -2, -26 },
  { 7469, 23, 36, 21, -1, -26 },
  { 7573, 22, 26, 21, -1, -26 },
  { 7645, 15, 45, 14, 1, -37 },
  { 7730, 10, 40, 12, 1, -34 },
  { 7780, 15, 46, 14, -2, -37 },
  { 7867, 22, 11, 26, 2, -20 },
};

const GFXfont RobotoCondensed_BoldItalic48pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic48pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic48pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _ROBOTOCONDENSED_BOLDITALIC48PT7B_H_
