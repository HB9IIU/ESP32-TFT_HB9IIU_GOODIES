#ifndef _ROBOTOCONDENSED_BOLDITALIC24PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0x60, 0xC0, 0x00,
  0x0C, 0x3C, 0x78, 0x60, 0x76, 0xED, 0x9B, 0x36, 0xD9, 0x80, 0x03, 0x30,
  0x37, 0x03, 0x60, 0x66, 0x06, 0xE3, 0xFF, 0x3F, 0xF0, 0xCC, 0x0D, 0x81,
  0x98, 0x7F, 0xE7, 0xFE, 0x3B, 0x03, 0x30, 0x36, 0x07, 0x60, 0x66, 0x00,
  0x03, 0x00, 0x60, 0x3C, 0x0F, 0xC3, 0xFC, 0x73, 0x9E, 0x73, 0xCE, 0x38,
  0x07, 0x80, 0x7C, 0x07, 0xC0, 0x39, 0xC7, 0x38, 0xE7, 0x1C, 0xFF, 0x8F,
  0xE0, 0xF0, 0x0C, 0x01, 0x00, 0x38, 0x0F, 0x83, 0xB1, 0xE6, 0x6C, 0xCD,
  0x9B, 0x1F, 0xC3, 0xF8, 0x06, 0x01, 0xB8, 0x6F, 0x8F, 0xB3, 0x66, 0xCC,
  0xF9, 0x98, 0x3F, 0x03, 0xC0, 0x07, 0x80, 0xFC, 0x1F, 0xE1, 0xCE, 0x1C,
  0xE1, 0xDC, 0x1F, 0x81, 0xF0, 0x1E, 0x33, 0xF7, 0x77, 0x77, 0x3F, 0xF3,
  0xEF, 0x1C, 0x7F, 0xE7, 0xFE, 0x1E, 0xF0, 0x77, 0x66, 0x6E, 0x02, 0x0C,
  0x38, 0xE1, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x83, 0x06, 0x0E, 0x0C, 0x08, 0x08, 0x1C, 0x0C, 0x0E, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C,
  0x1C, 0x18, 0x38, 0x70, 0x70, 0xE0, 0x80, 0x06, 0x01, 0x80, 0x61, 0x97,
  0xFF, 0xC7, 0x81, 0xE0, 0xDC, 0x63, 0x08, 0x80, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x1E, 0x3F, 0xFF, 0xFB, 0xFE, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38,
  0x00, 0x39, 0x9C, 0xE6, 0x73, 0x00, 0x7F, 0xFF, 0xC0, 0x27, 0x77, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x00,
  0x0F, 0x07, 0xE3, 0xFC, 0xE7, 0x71, 0xDC, 0x77, 0x1F, 0xC7, 0xF1, 0xF8,
  0x7E, 0x3F, 0x8E, 0xE3, 0xB8, 0xEF, 0xF1, 0xF8, 0x3C, 0x00, 0x06, 0x3F,
  0xF7, 0xED, 0xC3, 0x87, 0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x8F, 0x1C, 0x38,
  0x70, 0x07, 0x81, 0xFC, 0x7F, 0x9E, 0x73, 0x8E, 0x71, 0xC0, 0x78, 0x0E,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xF7, 0xFE, 0xFF,
  0xC0, 0x07, 0x83, 0xF8, 0x7F, 0x9E, 0x73, 0x8E, 0x01, 0xC0, 0x78, 0x7E,
  0x0F, 0x81, 0xF0, 0x07, 0x00, 0xEF, 0x1D, 0xE3, 0x9F, 0xF3, 0xFC, 0x1E,
  0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x7E, 0x1F, 0x87, 0x70, 0xEE,
  0x39, 0xCE, 0x79, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x00, 0x1F, 0xE7, 0xFC, 0xFF, 0x1C, 0x03, 0x80, 0xE0, 0x1F, 0xC3, 0xFC,
  0x7F, 0x80, 0x70, 0x0F, 0x01, 0xEE, 0x39, 0xC7, 0x3F, 0xE3, 0xF8, 0x3C,
  0x00, 0x03, 0x83, 0xE1, 0xF8, 0xF0, 0x38, 0x1C, 0x07, 0x71, 0xFE, 0xFF,
  0xBC, 0xFE, 0x1F, 0x87, 0xE3, 0xF8, 0xE7, 0xF9, 0xFC, 0x3C, 0x00, 0x7F,
  0xEF, 0xFD, 0xFF, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0F, 0x01,
  0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x00, 0x0F,
  0x07, 0xF3, 0xFC, 0xE7, 0x79, 0xDE, 0x73, 0x9C, 0xFE, 0x3F, 0x1F, 0xCF,
  0x3B, 0x8E, 0xE3, 0xB8, 0xEF, 0xF9, 0xFC, 0x3C, 0x00, 0x1E, 0x1F, 0x9F,
  0xFE, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xFF, 0xFF, 0xDF, 0xC0, 0xE0, 0xF0,
  0xF3, 0xF1, 0xF0, 0xE0, 0x00, 0x33, 0xDE, 0x60, 0x00, 0x00, 0x00, 0x11,
  0xCE, 0x70, 0x0C, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xC3, 0x87, 0x1C, 0x38, 0xE0, 0x80, 0x00, 0x40, 0x70, 0x7C, 0xFE, 0x7E,
  0x1C, 0x07, 0xC0, 0xFC, 0x1F, 0x81, 0xC0, 0x10, 0x7F, 0xDF, 0xF7, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFB, 0xFE, 0xFF, 0x80, 0x20, 0x0E, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0xF0, 0xFD, 0xFC, 0x7C, 0x1C, 0x04, 0x00, 0x3E, 0x3F,
  0xBF, 0xDC, 0xEE, 0x78, 0x38, 0x3C, 0x3C, 0x3C, 0x1C, 0x0C, 0x0E, 0x00,
  0x03, 0x03, 0xC1, 0xE0, 0x60, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xC1,
  0xC1, 0xC0, 0x61, 0xC0, 0x18, 0xC7, 0x8C, 0xC7, 0xE6, 0x67, 0x33, 0x73,
  0x39, 0xB3, 0x98, 0xD9, 0xCC, 0x6C, 0xC6, 0x3E, 0x63, 0x37, 0x33, 0x9B,
  0x99, 0xD9, 0xCF, 0x7C, 0x63, 0xBC, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x08,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x0E, 0x70, 0x73, 0x87, 0xFE, 0x3F,
  0xF3, 0xFF, 0x9C, 0x1D, 0xE0, 0xEE, 0x07, 0xF0, 0x38, 0x1F, 0xC0, 0xFF,
  0x87, 0xFC, 0x78, 0xF3, 0xC7, 0x9C, 0x3C, 0xE1, 0xC7, 0x3E, 0x3F, 0xC3,
  0xFF, 0x1E, 0x38, 0xE1, 0xE7, 0x0F, 0x38, 0x71, 0xFF, 0x9F, 0xF8, 0xFF,
  0x80, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0x87, 0x78, 0x77, 0x07, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x0E, 0xE0, 0xEF, 0x1E, 0x7F, 0xC7,
  0xF8, 0x1F, 0x00, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x78, 0xE3, 0xC7, 0x1C,
  0x3C, 0xE1, 0xE7, 0x0F, 0x38, 0x73, 0xC3, 0x9E, 0x1C, 0xE1, 0xE7, 0x0E,
  0x38, 0xF1, 0xFF, 0x1F, 0xF0, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0x1F, 0xF8, 0xFF, 0xC0, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF3, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0xFC, 0x3F,
  0xC7, 0xFC, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0,
  0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF3, 0x87, 0x78, 0x77, 0x07, 0x70, 0x0F,
  0x00, 0xF3, 0xFF, 0x3F, 0xE3, 0xFE, 0x0E, 0xE0, 0xEF, 0x0E, 0x7F, 0xE7,
  0xFC, 0x1F, 0x00, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0x71, 0xE0, 0xE3, 0xC1,
  0xC7, 0x07, 0x8E, 0x0F, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF1, 0xE0, 0xE3,
  0x83, 0xC7, 0x07, 0x8E, 0x0E, 0x1C, 0x1C, 0x78, 0x38, 0xF0, 0xF0, 0x1C,
  0x38, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1C,
  0x38, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0xE3, 0xCF, 0x38, 0xFF,
  0x87, 0xF0, 0x3E, 0x00, 0x1C, 0x3C, 0x38, 0xF8, 0x71, 0xE1, 0xE7, 0x83,
  0xDE, 0x07, 0x78, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFF,
  0x03, 0xDE, 0x07, 0x1C, 0x0E, 0x3C, 0x1C, 0x78, 0x78, 0xF0, 0xF0, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E,
  0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x07,
  0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xFC, 0x3E, 0x3F, 0x0F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xFC, 0xEE, 0x3B, 0x3F, 0x9E, 0xCD, 0xC7, 0xB7, 0x71, 0xCD,
  0x9C, 0x73, 0xE7, 0x1C, 0xF3, 0xC7, 0x3C, 0xF3, 0xCE, 0x38, 0xF3, 0x8E,
  0x00, 0x1C, 0x1E, 0x3C, 0x38, 0x78, 0x71, 0xF0, 0xE3, 0xF1, 0xC7, 0xE7,
  0x8E, 0xCF, 0x1D, 0x9C, 0x3B, 0xB8, 0xF7, 0x71, 0xE7, 0xE3, 0x8F, 0xC7,
  0x1F, 0x0E, 0x1E, 0x1C, 0x3C, 0x78, 0x78, 0xF0, 0xF0, 0x07, 0xC0, 0xFF,
  0x0F, 0xFC, 0x70, 0xE7, 0x87, 0x38, 0x3D, 0xC1, 0xFE, 0x0E, 0xF0, 0x77,
  0x83, 0xB8, 0x1D, 0xC1, 0xEE, 0x0E, 0x78, 0xF1, 0xFF, 0x0F, 0xF0, 0x1F,
  0x00, 0x1F, 0xE0, 0xFF, 0x87, 0xFE, 0x78, 0xF3, 0xC3, 0x9C, 0x1C, 0xE1,
  0xE7, 0x0F, 0x3F, 0xF3, 0xFF, 0x1F, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0x70, 0xE7,
  0x87, 0x38, 0x39, 0xC1, 0xFE, 0x0E, 0xF0, 0x77, 0x03, 0xB8, 0x1D, 0xC1,
  0xEE, 0x0E, 0x78, 0xF1, 0xFF, 0x0F, 0xF0, 0x1F, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0x00, 0x1F, 0xC0, 0xFF, 0x87, 0xFC, 0x78, 0xF3, 0xC7, 0x9C, 0x3C,
  0xE1, 0xE7, 0x1E, 0x3F, 0xF3, 0xFF, 0x1F, 0xF0, 0xE7, 0x87, 0x1C, 0x38,
  0xE1, 0xC7, 0x9E, 0x3C, 0xF0, 0xE0, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x78,
  0xE3, 0xC7, 0x9E, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x79,
  0xE1, 0xC7, 0x0E, 0x38, 0xF1, 0xFF, 0x87, 0xF8, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x00,
  0x38, 0x79, 0xC3, 0xCE, 0x1C, 0xF0, 0xE7, 0x87, 0x38, 0x39, 0xC3, 0xCE,
  0x1E, 0xF0, 0xE7, 0x87, 0x3C, 0x39, 0xC1, 0xCE, 0x1E, 0x78, 0xE3, 0xFF,
  0x0F, 0xF0, 0x3E, 0x00, 0xF0, 0x7F, 0x87, 0xBC, 0x3D, 0xE1, 0xCF, 0x1E,
  0x38, 0xE1, 0xC7, 0x0E, 0x78, 0x73, 0x83, 0xBC, 0x1D, 0xC0, 0xEE, 0x07,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0xE1, 0xC7, 0x71, 0xE3,
  0xB8, 0xF3, 0xDC, 0x79, 0xCE, 0x7C, 0xE7, 0x3E, 0x73, 0x9F, 0x71, 0xDF,
  0xB8, 0xEF, 0xDC, 0x76, 0xFC, 0x3F, 0x7E, 0x1F, 0xBF, 0x0F, 0x9F, 0x07,
  0xCF, 0x83, 0xE3, 0xC1, 0xE1, 0xC0, 0xF0, 0xE0, 0x00, 0x1E, 0x1E, 0x1C,
  0x78, 0x38, 0xF0, 0x7B, 0xC0, 0xF7, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x77, 0x01, 0xEE, 0x07, 0x9C, 0x0F,
  0x3C, 0x3C, 0x78, 0x70, 0x70, 0xF0, 0xFF, 0x0E, 0x71, 0xE7, 0x1C, 0x73,
  0xC7, 0x38, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x00, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE,
  0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07,
  0x80, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xFF, 0x9F, 0xFC, 0xFF, 0xE0, 0x1F,
  0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0x78,
  0x70, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xF0, 0xF0, 0xF0, 0xE3,
  0x8E, 0x3C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xF0, 0x1F, 0x1F, 0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x78, 0xF0, 0xF0,
  0xF0, 0x0C, 0x1E, 0x1E, 0x3E, 0x36, 0x76, 0x66, 0xE7, 0xE7, 0xFF, 0xFF,
  0xFF, 0xC0, 0x71, 0xC3, 0x86, 0x0F, 0x07, 0xE3, 0xFC, 0xE7, 0x01, 0xC7,
  0xF7, 0xFD, 0xCF, 0xF3, 0xBC, 0xEF, 0xF9, 0xFE, 0x3B, 0x80, 0x1C, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0x77, 0x0F, 0xF1, 0xFF, 0x39, 0xEF, 0x1D,
  0xC3, 0xB8, 0xF7, 0x1E, 0xE3, 0x9C, 0x77, 0xFE, 0xFF, 0x9D, 0xE0, 0x0F,
  0x07, 0xE3, 0xFD, 0xE7, 0x71, 0xDC, 0x07, 0x01, 0xC0, 0x73, 0x9C, 0xE7,
  0xF9, 0xFC, 0x1E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE1,
  0xEE, 0x3F, 0xE3, 0xFE, 0x79, 0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0xF1, 0xCF,
  0x1C, 0x73, 0xC7, 0xFC, 0x7F, 0x83, 0xF8, 0x1E, 0x0F, 0xE7, 0xFB, 0xCE,
  0xE3, 0xB8, 0xEF, 0xFB, 0xFE, 0xE0, 0x38, 0x4F, 0xF1, 0xFC, 0x3E, 0x00,
  0x0F, 0x1F, 0x1F, 0x3C, 0x38, 0xFE, 0xFE, 0x38, 0x78, 0x70, 0x70, 0x70,
  0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x1E, 0xE3, 0xFE, 0x3F, 0xE7, 0x8E,
  0x70, 0xE7, 0x1E, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xC7, 0xFC,
  0x3F, 0x80, 0x38, 0x03, 0x8F, 0xF8, 0xFF, 0x07, 0xC0, 0x1C, 0x03, 0x80,
  0x70, 0x1E, 0x03, 0x80, 0x77, 0x0F, 0xF1, 0xFE, 0x39, 0xCF, 0x39, 0xC7,
  0x38, 0xE7, 0x1C, 0xE3, 0xBC, 0xF7, 0x9E, 0xE3, 0x9C, 0x70, 0x08, 0x71,
  0xC7, 0x00, 0x03, 0x8E, 0x38, 0xE3, 0x9E, 0x71, 0xC7, 0x1C, 0x73, 0xCE,
  0x00, 0x01, 0x01, 0xC0, 0xE0, 0x70, 0x00, 0x00, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81,
  0xC3, 0xE1, 0xE1, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03,
  0x8F, 0x39, 0xE3, 0xBC, 0x3F, 0x87, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x07,
  0x70, 0x77, 0x8F, 0x38, 0xE3, 0x8E, 0x3C, 0x1C, 0x71, 0xC7, 0x3C, 0xF3,
  0x8E, 0x38, 0xE7, 0x9C, 0x71, 0xC7, 0x1C, 0xF3, 0x80, 0x3B, 0x9E, 0x3F,
  0xFF, 0x3F, 0xFF, 0x39, 0xE7, 0x79, 0xC7, 0x71, 0xC7, 0x71, 0xC7, 0x71,
  0xC7, 0x71, 0xCF, 0x73, 0xCE, 0xF3, 0x8E, 0xE3, 0x8E, 0xE3, 0x8E, 0x3B,
  0x87, 0xF8, 0xFF, 0x3C, 0xE7, 0x9C, 0xE3, 0x9C, 0x73, 0x8E, 0x71, 0xDE,
  0x7B, 0xCF, 0x71, 0xCE, 0x38, 0x1F, 0x0F, 0xE7, 0xFB, 0xCF, 0xE1, 0xF8,
  0x7E, 0x3F, 0x8F, 0xE3, 0xB8, 0xEF, 0xF1, 0xFC, 0x3C, 0x00, 0x1D, 0xC1,
  0xFE, 0x1F, 0xF1, 0xCF, 0x3C, 0x73, 0x87, 0x38, 0xF3, 0x8F, 0x38, 0xE3,
  0x8E, 0x7F, 0xE7, 0xFC, 0x77, 0x87, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E,
  0x00, 0x1E, 0xE7, 0xFC, 0xFF, 0xBC, 0xF7, 0x1E, 0xE3, 0x9C, 0x73, 0x8E,
  0x71, 0xCE, 0x79, 0xFF, 0x3F, 0xC3, 0xF8, 0x07, 0x00, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x3B, 0x3F, 0x3F, 0x3C, 0x78, 0x70, 0x70, 0x70, 0x70, 0x70,
  0xF0, 0xE0, 0xE0, 0x0F, 0x0F, 0xE3, 0xFD, 0xC7, 0x78, 0x0F, 0x83, 0xF0,
  0x3E, 0x03, 0xB8, 0xEF, 0x79, 0xFC, 0x3E, 0x00, 0x38, 0x70, 0xE7, 0xEF,
  0xCF, 0x1C, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1F, 0x3E, 0x3C, 0x71, 0xDC,
  0x77, 0x1F, 0xCF, 0xF3, 0xF8, 0xEE, 0x3B, 0x8E, 0xE3, 0xB9, 0xEF, 0xFB,
  0xFC, 0x7F, 0x00, 0xF3, 0xFC, 0xEF, 0x39, 0xDE, 0x77, 0x1D, 0xC7, 0xE1,
  0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xE0, 0x38, 0x00, 0xE3, 0x1F, 0x8E, 0x7E,
  0x7B, 0xB9, 0xEE, 0x6F, 0xB9, 0xBF, 0xC6, 0xDF, 0x1F, 0x7C, 0x79, 0xE1,
  0xE7, 0x87, 0x1E, 0x1C, 0x70, 0x71, 0xC0, 0x1C, 0xF1, 0xCE, 0x1D, 0xE1,
  0xDC, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x83, 0xF8, 0x3B, 0x87,
  0xBC, 0xF1, 0xC0, 0x3C, 0xF3, 0xCF, 0x3C, 0xE1, 0xDE, 0x1D, 0xC1, 0xFC,
  0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x3F, 0xC7, 0xF8, 0xFF, 0x01, 0xC0,
  0x70, 0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xFE, 0x7F, 0xCF, 0xF0,
  0x06, 0x1C, 0x70, 0xE3, 0x87, 0x0E, 0x1C, 0x38, 0xE3, 0xC7, 0x0E, 0x1C,
  0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x06, 0x0E, 0x08, 0x00, 0x18, 0x61, 0x86,
  0x18, 0x63, 0x8C, 0x30, 0xC3, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x86, 0x30,
  0x08, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x0C, 0x0E, 0x06,
  0x0E, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0xE0, 0xC0, 0x38,
  0x6F, 0x9F, 0xFF, 0xF3, 0xEC, 0x38,
};

const GFXglyph RobotoCondensed_BoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 17, 6, 0, -17 },
  { 16, 7, 6, 7, 1, -18 },
  { 22, 12, 17, 12, 0, -17 },
  { 48, 11, 21, 12, 1, -19 },
  { 77, 11, 17, 15, 2, -17 },
  { 101, 12, 17, 13, 0, -17 },
  { 127, 4, 6, 4, 1, -18 },
  { 130, 7, 24, 8, 1, -19 },
  { 151, 8, 24, 8, -1, -19 },
  { 175, 10, 10, 11, 1, -17 },
  { 188, 10, 13, 11, 1, -15 },
  { 205, 5, 7, 6, -1, -3 },
  { 210, 6, 3, 8, 1, -9 },
  { 213, 4, 4, 7, 0, -4 },
  { 215, 11, 18, 8, -2, -17 },
  { 240, 10, 17, 12, 1, -17 },
  { 262, 7, 17, 12, 3, -17 },
  { 277, 11, 17, 12, 0, -17 },
  { 301, 11, 17, 12, 0, -17 },
  { 325, 11, 17, 12, 0, -17 },
  { 349, 11, 17, 12, 1, -17 },
  { 373, 10, 17, 12, 1, -17 },
  { 395, 11, 17, 12, 1, -17 },
  { 419, 10, 17, 12, 1, -17 },
  { 441, 9, 17, 12, 2, -17 },
  { 461, 5, 14, 6, 1, -14 },
  { 470, 7, 18, 6, -1, -14 },
  { 486, 10, 11, 10, 0, -13 },
  { 500, 10, 9, 12, 1, -12 },
  { 512, 10, 11, 11, 0, -13 },
  { 526, 9, 17, 10, 2, -17 },
  { 546, 17, 22, 18, 0, -17 },
  { 593, 13, 17, 14, -1, -17 },
  { 621, 13, 17, 13, 0, -17 },
  { 649, 12, 17, 13, 1, -17 },
  { 675, 13, 17, 13, 0, -17 },
  { 703, 13, 17, 11, 0, -17 },
  { 731, 12, 17, 11, 0, -17 },
  { 757, 12, 17, 14, 1, -17 },
  { 783, 15, 17, 14, 0, -17 },
  { 815, 7, 17, 6, 0, -17 },
  { 830, 12, 17, 11, 0, -17 },
  { 856, 15, 17, 13, 0, -17 },
  { 888, 10, 17, 11, 0, -17 },
  { 910, 18, 17, 18, 0, -17 },
  { 949, 15, 17, 14, 0, -17 },
  { 981, 13, 17, 14, 1, -17 },
  { 1009, 13, 17, 13, 0, -17 },
  { 1037, 13, 20, 14, 1, -17 },
  { 1070, 13, 17, 13, 0, -17 },
  { 1098, 13, 17, 13, 0, -17 },
  { 1126, 12, 17, 13, 2, -17 },
  { 1152, 13, 17, 13, 1, -17 },
  { 1180, 13, 17, 13, 2, -17 },
  { 1208, 17, 17, 17, 2, -17 },
  { 1245, 15, 17, 13, -1, -17 },
  { 1277, 12, 17, 13, 2, -17 },
  { 1303, 13, 17, 12, 0, -17 },
  { 1331, 8, 24, 6, 0, -20 },
  { 1355, 6, 18, 9, 2, -17 },
  { 1369, 8, 24, 6, -1, -20 },
  { 1393, 8, 9, 9, 1, -17 },
  { 1402, 9, 3, 9, -1, 0 },
  { 1406, 6, 4, 8, 2, -18 },
  { 1409, 10, 13, 11, 0, -13 },
  { 1426, 11, 18, 12, 0, -18 },
  { 1451, 10, 13, 11, 0, -13 },
  { 1468, 12, 18, 12, 0, -18 },
  { 1495, 10, 13, 11, 1, -13 },
  { 1512, 8, 18, 8, 1, -18 },
  { 1530, 12, 18, 12, 0, -13 },
  { 1557, 11, 18, 11, 0, -18 },
  { 1582, 6, 19, 6, 0, -19 },
  { 1597, 9, 24, 6, -3, -19 },
  { 1624, 12, 18, 11, 0, -18 },
  { 1651, 6, 18, 6, 0, -18 },
  { 1665, 16, 13, 17, 0, -13 },
  { 1691, 11, 13, 11, 0, -13 },
  { 1709, 10, 13, 12, 1, -13 },
  { 1726, 12, 18, 12, -1, -13 },
  { 1753, 11, 18, 12, 0, -13 },
  { 1778, 8, 13, 8, 0, -13 },
  { 1791, 10, 13, 11, 0, -13 },
  { 1808, 7, 16, 7, 1, -16 },
  { 1822, 10, 13, 11, 1, -13 },
  { 1839, 10, 13, 10, 1, -13 },
  { 1856, 14, 13, 15, 1, -13 },
  { 1879, 12, 13, 11, -1, -13 },
  { 1899, 12, 18, 10, -1, -13 },
  { 1926, 11, 13, 11, 0, -13 },
  { 1944, 7, 23, 7, 1, -19 },
  { 1965, 6, 20, 6, 0, -17 },
  { 1980, 8, 23, 7, -1, -19 },
  { 2003, 11, 5, 13, 1, -9 },
};

const GFXfont RobotoCondensed_BoldItalic24pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic24pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic24pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _ROBOTOCONDENSED_BOLDITALIC24PT7B_H_
