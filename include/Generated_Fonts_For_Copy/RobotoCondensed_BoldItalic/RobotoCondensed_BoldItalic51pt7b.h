#ifndef _ROBOTOCONDENSED_BOLDITALIC51PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x70, 0x00,
  0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF1, 0xE7, 0xC7, 0xCF, 0x8F, 0x9F,
  0x1F, 0x3E, 0x3C, 0x78, 0x78, 0xF0, 0xF1, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F,
  0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7,
  0xC0, 0x03, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x1F,
  0x1E, 0x01, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFE, 0x01, 0xE3, 0xE0, 0x01, 0xF1, 0xE0, 0x00, 0xF1, 0xF0, 0x00,
  0x78, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3E, 0x01,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x03, 0xE3, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1, 0xE0, 0x00, 0xF8, 0xF0,
  0x00, 0x78, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x3E,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F,
  0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x1F, 0x80, 0xFE, 0x3F, 0x01,
  0xFC, 0x7E, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xC3, 0xFC, 0x7F,
  0x83, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0x7C, 0x08,
  0x7C, 0x7C, 0x1E, 0x7C, 0x7C, 0x3E, 0x78, 0x7C, 0x3C, 0x78, 0x7C, 0x7C,
  0x78, 0x7C, 0xF8, 0x78, 0x7C, 0xF0, 0x78, 0x79, 0xE0, 0x7C, 0xFB, 0xE0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xF7, 0x80, 0x1F, 0xEF, 0x80, 0x0F, 0x9F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xFC,
  0x00, 0xF7, 0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xEF, 0x9F, 0x03, 0xDF, 0x0F,
  0x07, 0x9F, 0x0F, 0x0F, 0x9F, 0x0F, 0x1F, 0x1F, 0x0F, 0x1E, 0x1E, 0x0F,
  0x3E, 0x1E, 0x1F, 0x7C, 0x1F, 0x1F, 0x38, 0x1F, 0x3E, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xE0,
  0xFC, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x87, 0xE1, 0xFF, 0xC3, 0xF1,
  0xFF, 0xF1, 0xF9, 0xFF, 0xF8, 0xFD, 0xFC, 0xFE, 0xFC, 0xFE, 0x7F, 0x7E,
  0xFE, 0x1F, 0xFF, 0x7F, 0x0F, 0xFF, 0x3F, 0x83, 0xFF, 0x9F, 0xC1, 0xFF,
  0x8F, 0xE0, 0x7F, 0xC7, 0xF0, 0x3F, 0xC3, 0xFC, 0x3F, 0xE0, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xBF, 0x81, 0xFF,
  0x8F, 0xE0, 0x0C, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xF7, 0xEF, 0x9F, 0x3E,
  0x7C, 0xF9, 0xE7, 0xCF, 0x9F, 0x00, 0x00, 0x02, 0x00, 0x06, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0x00, 0x01, 0x00,
  0x00, 0x80, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x01, 0xC1, 0xE0,
  0xCF, 0x8F, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x0F,
  0xFF, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0x80,
  0x1F, 0x3E, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0xF8, 0x1F, 0x01, 0x80,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xC0, 0xF0, 0x04,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x18, 0x7E,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFE,
  0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0x81, 0xFC, 0x7E, 0x07, 0xF3, 0xF8, 0x1F,
  0xCF, 0xE0, 0x7F, 0x3F, 0x01, 0xFC, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF,
  0xC0, 0x7F, 0x7F, 0x01, 0xFD, 0xFC, 0x07, 0xE7, 0xF0, 0x3F, 0x9F, 0x80,
  0xFE, 0xFE, 0x03, 0xFB, 0xF8, 0x0F, 0xEF, 0xE0, 0x3F, 0xBF, 0x80, 0xFC,
  0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7E, 0x3F, 0x81, 0xF8, 0xFE,
  0x0F, 0xE1, 0xF8, 0x7F, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x06, 0x00,
  0x7C, 0x03, 0xF0, 0x3F, 0xE3, 0xFF, 0xCF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE,
  0xFF, 0xF9, 0xE3, 0xF3, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07,
  0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xF8,
  0x7F, 0x8F, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x3F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0,
  0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xE1, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x1F, 0xBF, 0x80, 0x3E, 0x7F, 0x00, 0xFC, 0xFE, 0x03, 0xF1, 0xF8, 0x07,
  0xE7, 0xF0, 0x1F, 0x8F, 0xE0, 0x7E, 0x1F, 0xC0, 0xFC, 0x3F, 0x83, 0xF0,
  0x7E, 0x0F, 0xE1, 0xFC, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xEF, 0xF8, 0x07, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x07, 0xF0,
  0x7F, 0x0F, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF9, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xE1, 0xFE, 0xFE,
  0x07, 0xF7, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFD, 0xFC, 0x0F, 0xE7, 0xE0,
  0xFF, 0x3F, 0x87, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0xFC, 0x3F,
  0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xFC, 0x7F, 0x07, 0xF0, 0x7E, 0x1F,
  0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xF3, 0xF8,
  0x0F, 0xE7, 0xF0, 0x3F, 0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0x1F, 0xC7, 0xF0,
  0x7E, 0x7F, 0x03, 0xF3, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x07, 0xF7,
  0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xEF, 0xC0, 0x7E, 0x7F, 0x07,
  0xF3, 0xF8, 0x7F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFD, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0x80, 0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xE0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x03, 0xC0, 0x00, 0x70, 0x07,
  0xE0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x1E, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0x10, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0x08,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x7F, 0x8F, 0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xEF, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x0F, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00,
  0x78, 0x1F, 0x00, 0x00, 0x0F, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0xF8, 0x0F,
  0xF8, 0x1E, 0x1E, 0x07, 0xFF, 0xC3, 0xC7, 0xC0, 0xFF, 0xF8, 0x78, 0xF0,
  0x3F, 0x9F, 0x0F, 0x3E, 0x0F, 0xC3, 0xC1, 0xE7, 0xC1, 0xF0, 0xF8, 0x3C,
  0xF0, 0x7C, 0x1F, 0x07, 0xBE, 0x0F, 0x83, 0xE0, 0xF7, 0xC3, 0xE0, 0x78,
  0x1E, 0xF0, 0x7C, 0x1F, 0x03, 0xDE, 0x0F, 0x83, 0xE0, 0xFF, 0xC3, 0xF0,
  0x7C, 0x1E, 0xF8, 0x7C, 0x0F, 0x03, 0xDF, 0x0F, 0x83, 0xE0, 0x7B, 0xE1,
  0xF0, 0x7C, 0x1E, 0x7C, 0x3E, 0x0F, 0x83, 0xCF, 0x07, 0xC3, 0xF0, 0x79,
  0xE0, 0xF8, 0x7C, 0x1E, 0x3C, 0x1F, 0x9F, 0x87, 0xC7, 0x83, 0xFF, 0xFD,
  0xF0, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0x07, 0xF9, 0xFF, 0x03, 0xE0, 0x7E,
  0x1F, 0xC0, 0x7C, 0x00, 0x00, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x18, 0x00, 0x03, 0xFE, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xDF,
  0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF1, 0xFC, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0,
  0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE1, 0xFC, 0x00, 0x7E,
  0x3F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF8,
  0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x0F, 0xF8, 0x3F, 0x80, 0xFF,
  0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8,
  0x0F, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x3F, 0xE0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x07,
  0xF0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07,
  0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0, 0xFF,
  0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0x87, 0xF8, 0x3F, 0x80,
  0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x8F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFE, 0x1F, 0xF0, 0x3F, 0x80, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0,
  0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x0F, 0xF0,
  0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x1F, 0xE0, 0xFF, 0x0F,
  0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0xFE,
  0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x1F, 0xC0,
  0x07, 0xF3, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x07, 0xFF, 0x8F, 0xE0, 0xFF, 0xF1, 0xFC, 0x1F,
  0xFE, 0x3F, 0x83, 0xFF, 0xCF, 0xF0, 0x7F, 0xF9, 0xFC, 0x1F, 0xFF, 0x3F,
  0x80, 0x1F, 0xE7, 0xF0, 0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xF0, 0xFF,
  0x87, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F,
  0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0,
  0x07, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x01, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0,
  0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x03,
  0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xFC,
  0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x3F, 0x81, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F,
  0x03, 0xF8, 0x7F, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xE0, 0x3F, 0xE0, 0x1F,
  0xC0, 0x7F, 0x80, 0x3F, 0x81, 0xFF, 0x00, 0x7F, 0x07, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0xFF, 0x00, 0x0F, 0xE3,
  0xFE, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0xFE, 0x7F,
  0x80, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFD, 0xFC, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00,
  0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x03,
  0xF8, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0x3F,
  0x80, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x01, 0xFC,
  0x03, 0xFC, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x7F,
  0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x81, 0xFF,
  0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0xFB, 0xF0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xF3, 0xE0, 0xFD, 0xFC, 0x0F, 0xCF,
  0x83, 0xF7, 0xE0, 0x7F, 0x3E, 0x1F, 0x9F, 0x81, 0xFC, 0xF8, 0x7E, 0xFE,
  0x07, 0xF3, 0xE1, 0xF3, 0xF8, 0x1F, 0xCF, 0x8F, 0xCF, 0xE0, 0x7F, 0x3E,
  0x3E, 0x3F, 0x81, 0xFC, 0xFD, 0xF9, 0xFC, 0x0F, 0xE3, 0xF7, 0xC7, 0xF0,
  0x3F, 0x87, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F, 0xFC, 0x7F, 0x03, 0xF8, 0x7F,
  0xE1, 0xFC, 0x0F, 0xE1, 0xFF, 0x8F, 0xF0, 0x3F, 0x87, 0xFC, 0x3F, 0x81,
  0xFE, 0x1F, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC1, 0xFE,
  0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC1, 0xFC, 0x07,
  0xF0, 0x3E, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0xFE, 0x07, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0x3F, 0x81, 0xFF, 0x80, 0x7F,
  0x03, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x01, 0xFC, 0x0F, 0xFE, 0x07, 0xF8,
  0x1F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x1F, 0xC0, 0xFE, 0xF8, 0x3F, 0x81,
  0xFD, 0xF0, 0x7F, 0x03, 0xFB, 0xE0, 0xFE, 0x07, 0xF7, 0xE3, 0xF8, 0x0F,
  0xE7, 0xC7, 0xF0, 0x3F, 0xCF, 0x8F, 0xE0, 0x7F, 0x1F, 0x1F, 0xC0, 0xFE,
  0x1F, 0x3F, 0x81, 0xFC, 0x3E, 0xFF, 0x03, 0xF8, 0x7D, 0xFC, 0x07, 0xF0,
  0xFB, 0xF8, 0x1F, 0xE0, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0xE0, 0x7F, 0x03,
  0xFF, 0xC0, 0xFE, 0x07, 0xFF, 0x81, 0xFC, 0x07, 0xFE, 0x03, 0xF8, 0x0F,
  0xFC, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xC0, 0x3F, 0xF0, 0x3F, 0x80, 0x3F,
  0xE0, 0x7F, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x03, 0xFE, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3,
  0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x7F,
  0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F,
  0xEF, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xE7, 0xF0,
  0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xF3, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x00, 0xFF, 0x07,
  0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFE, 0x0F,
  0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F,
  0xDF, 0xC0, 0x03, 0xFB, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xCF, 0xE0,
  0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xE0, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00,
  0x3F, 0x9F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x87,
  0xF0, 0x1F, 0xE0, 0xFF, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xFE, 0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x1F,
  0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x01, 0xFE, 0x0F, 0xE0, 0x7F,
  0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x3F, 0xC0,
  0x3F, 0x83, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1,
  0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x83,
  0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03,
  0xFC, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8,
  0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF8,
  0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF1, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01,
  0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x3F,
  0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x3F,
  0xC7, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x03, 0xF8, 0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xF8,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF,
  0x00, 0x3F, 0xC7, 0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x83,
  0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xF9,
  0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0xBF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x0F, 0xEF, 0xC0, 0x7F, 0x01, 0xFD,
  0xF8, 0x0F, 0xE0, 0x3F, 0xBF, 0x01, 0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0x81,
  0xFC, 0xFC, 0x0F, 0xF0, 0x3F, 0x9F, 0x81, 0xFE, 0x0F, 0xE3, 0xF0, 0x7F,
  0xC1, 0xFC, 0x7E, 0x0F, 0xF8, 0x3F, 0x8F, 0xC1, 0xFF, 0x0F, 0xE1, 0xF8,
  0x7F, 0xE1, 0xFC, 0x3F, 0x0F, 0xFC, 0x3F, 0x87, 0xE1, 0xFF, 0x87, 0xE0,
  0xFC, 0x7F, 0xF1, 0xFC, 0x1F, 0x8F, 0xFE, 0x3F, 0x83, 0xF1, 0xF7, 0xC7,
  0xE0, 0x7E, 0x7E, 0xF9, 0xFC, 0x0F, 0xCF, 0xDF, 0x3F, 0x81, 0xF9, 0xF3,
  0xE7, 0xE0, 0x3F, 0x7E, 0x7D, 0xFC, 0x07, 0xEF, 0xCF, 0xBF, 0x80, 0xFD,
  0xF1, 0xF7, 0xE0, 0x1F, 0xFE, 0x3F, 0xFC, 0x03, 0xFF, 0xC7, 0xFF, 0x80,
  0x7F, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0xC3, 0xFF,
  0x80, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x01, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0xBF,
  0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0x7F,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F,
  0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F,
  0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xDF, 0xC0, 0x0F, 0xE7,
  0xF0, 0x07, 0xF9, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x3F,
  0x83, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1,
  0xFE, 0x01, 0xF8, 0x7F, 0x00, 0x7E, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x07,
  0xF7, 0xF0, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8,
  0x3F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC,
  0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x07, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xDE, 0x07,
  0xCF, 0x07, 0xE7, 0x83, 0xE3, 0xE3, 0xF1, 0xF1, 0xF0, 0xF9, 0xF8, 0x7C,
  0xF8, 0x3E, 0xFC, 0x1F, 0x7C, 0x07, 0xC0, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xFE, 0x3F, 0x87, 0xF0, 0x7E, 0x1F, 0xC1, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFF, 0x0F, 0xF1, 0xFC, 0x7F, 0x87, 0xF1, 0xFC, 0x1F, 0xC7, 0xF0,
  0x7F, 0x1F, 0x81, 0xFC, 0x7F, 0x0F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xBF, 0x80, 0x7C, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x3F, 0xC3, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F,
  0xE3, 0xF8, 0x1F, 0xC7, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE,
  0x7F, 0x01, 0xFC, 0xFE, 0x03, 0xF1, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0xCF,
  0xE0, 0x3F, 0x9F, 0xC0, 0xFE, 0x3F, 0xC1, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xF7, 0xFF, 0x0F, 0xE7, 0xFC, 0x1F, 0x87,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFE, 0x0F, 0xC7, 0xF0, 0x7F, 0x7F,
  0x03, 0xFB, 0xF8, 0x1F, 0xDF, 0xC0, 0xFE, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x3F, 0x3F, 0x81, 0xF9, 0xFC, 0x1F, 0xC7, 0xF1, 0xFC, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x3F, 0x1F, 0xC0, 0x7F, 0xCF, 0xE0, 0x7F, 0xF7, 0xF0, 0x3F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC1, 0xF8, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80,
  0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8,
  0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x01, 0xFE, 0xFE, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x0F, 0xE7, 0xF0, 0x3F, 0x3F, 0x01, 0xFB,
  0xF8, 0x0F, 0xDF, 0xC0, 0x7E, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x01, 0x07, 0xF0, 0x3C, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x7F,
  0xF0, 0x3F, 0xF4, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0xFF, 0x9F, 0x80, 0xFF, 0xEF,
  0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0x87,
  0xF8, 0x3F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFC, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8,
  0x00, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0x00, 0x7F,
  0x00, 0xC0, 0x7F, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF9, 0xF8, 0x0F, 0xEF, 0xF0, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0x87,
  0xF1, 0xFC, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7E, 0x07, 0xF3,
  0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xE3, 0xF8,
  0x3F, 0x8F, 0xC0, 0xFE, 0x7F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F,
  0x9F, 0xC0, 0xFC, 0x7F, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F,
  0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0,
  0x3F, 0x8F, 0xF0, 0x1F, 0xCF, 0xF0, 0x0F, 0xC7, 0xF8, 0x0F, 0xE7, 0xF8,
  0x07, 0xF7, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFD, 0xFC, 0x03, 0xFC,
  0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F,
  0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x07,
  0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xE7,
  0xE0, 0x3E, 0x01, 0xFD, 0xFE, 0x1F, 0xF0, 0x3F, 0xFF, 0xE7, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF,
  0x87, 0xF8, 0x7F, 0xC7, 0xF0, 0xFE, 0x0F, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE3, 0xF8, 0x3F, 0x81, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0x0F, 0xC0,
  0xFE, 0x0F, 0xE3, 0xF8, 0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xF0, 0x3F, 0x8F,
  0xE0, 0xFE, 0x07, 0xF1, 0xFC, 0x1F, 0xC0, 0xFE, 0x3F, 0x83, 0xF8, 0x3F,
  0x87, 0xE0, 0x7F, 0x07, 0xF1, 0xFC, 0x0F, 0xE0, 0xFE, 0x3F, 0x81, 0xF8,
  0x1F, 0xC7, 0xF0, 0x7F, 0x03, 0xF8, 0xFE, 0x0F, 0xE0, 0x7F, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x83, 0xF8, 0xFE, 0x07, 0xF0, 0x7F, 0x1F,
  0xC0, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE7, 0xE0,
  0x3F, 0xBF, 0xC0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF1, 0xFE, 0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x07,
  0xF1, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3,
  0xF8, 0x1F, 0x8F, 0xE0, 0xFE, 0x3F, 0x03, 0xF9, 0xFC, 0x0F, 0xE7, 0xF0,
  0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x03, 0xF1, 0xFC, 0x1F, 0xCF, 0xE0, 0x7F,
  0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFC, 0x3F, 0x8F, 0xE0, 0x7F, 0x3F, 0x01,
  0xFD, 0xFC, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0x7E, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7E, 0xFE, 0x03, 0xFB, 0xF8,
  0x0F, 0xEF, 0xE0, 0x3F, 0x9F, 0x81, 0xFC, 0x7F, 0x0F, 0xF1, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF9, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xE1,
  0xFE, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC,
  0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x87,
  0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xBF, 0xF8, 0x1F, 0xCF, 0xF8,
  0x0F, 0xE3, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x7E, 0x0F, 0xF8, 0xFC, 0x3F, 0xFB, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xF0, 0xFF, 0x1F, 0xC0, 0xFE, 0x7F, 0x01,
  0xFC, 0xFE, 0x03, 0xF1, 0xFC, 0x0F, 0xE3, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F,
  0x9F, 0xC0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xF8, 0xFE, 0x07, 0xF1,
  0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xF0, 0xFF, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x3F, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE7,
  0x87, 0xF7, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x7F,
  0xFE, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xF1, 0xFC,
  0x7F, 0x0F, 0xE3, 0xF0, 0x3F, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x3F, 0x81, 0xF9, 0xFC, 0x0F,
  0xCF, 0xE0, 0xFE, 0x3F, 0x8F, 0xF1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFE, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0xFE, 0x3F, 0x81,
  0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xE1, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x07, 0xF0,
  0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x1F,
  0xC0, 0xFC, 0x3F, 0x83, 0xF8, 0x7E, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8,
  0x1F, 0xC7, 0xF0, 0x3F, 0x8F, 0xF0, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xDF, 0x80, 0x3F, 0x00,
  0x00, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xEF, 0xE0, 0xFE, 0xFE,
  0x0F, 0xEF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF, 0xE1, 0xF8, 0xFE, 0x3F, 0x87,
  0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xEF, 0xE0,
  0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0x81,
  0xFB, 0xF0, 0x3E, 0x0F, 0xEF, 0xC1, 0xF8, 0x3F, 0xBF, 0x07, 0xE0, 0xFC,
  0xFC, 0x3F, 0x87, 0xF3, 0xF0, 0xFE, 0x1F, 0xCF, 0xC3, 0xF8, 0x7E, 0x3F,
  0x1F, 0xF3, 0xF8, 0xFC, 0x7F, 0xCF, 0xC3, 0xF3, 0xFF, 0x3F, 0x0F, 0xCF,
  0xFD, 0xFC, 0x3F, 0x3F, 0xF7, 0xE0, 0xFD, 0xF7, 0xDF, 0x83, 0xF7, 0xDF,
  0x7E, 0x0F, 0xFF, 0x7F, 0xF0, 0x3F, 0xF9, 0xFF, 0xC0, 0xFF, 0xE7, 0xFE,
  0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x7F, 0xE0, 0x1F, 0xF1, 0xFF, 0x00,
  0x7F, 0x87, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x1F,
  0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0x3F, 0x87,
  0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0x1F,
  0x9F, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF, 0x80, 0x0F, 0xE7, 0xE0, 0x03,
  0xF9, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFF, 0x0F, 0xC0, 0x3F, 0x83, 0xF8,
  0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x87, 0xF0,
  0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC7, 0xF0, 0x07, 0xE3, 0xF8, 0x03,
  0xF3, 0xF8, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x3F, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x01, 0x00, 0x03,
  0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x00,
  0x80, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x1F, 0x3F, 0xF8, 0x3F, 0x3F, 0xF8,
  0x3E, 0x7F, 0xFC, 0x7E, 0x7F, 0xFF, 0xFE, 0xFC, 0x7F, 0xFC, 0xFC, 0x3F,
  0xFC, 0xF8, 0x1F, 0xF8, 0xF8, 0x0F, 0xF0, 0x00, 0x03, 0xE0,
};

const GFXglyph RobotoCondensed_BoldItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 36, 13, 1, -36 },
  { 60, 15, 14, 16, 3, -38 },
  { 87, 25, 36, 26, 1, -36 },
  { 200, 23, 46, 25, 2, -41 },
  { 333, 24, 36, 32, 4, -36 },
  { 441, 25, 37, 29, 1, -36 },
  { 557, 7, 14, 8, 3, -38 },
  { 570, 16, 51, 16, 2, -40 },
  { 672, 16, 51, 16, -2, -40 },
  { 774, 21, 22, 22, 3, -36 },
  { 832, 22, 26, 24, 1, -30 },
  { 904, 11, 15, 12, -3, -6 },
  { 925, 12, 6, 18, 3, -19 },
  { 934, 8, 8, 14, 1, -8 },
  { 942, 22, 39, 16, -3, -36 },
  { 1050, 22, 36, 25, 2, -36 },
  { 1149, 15, 36, 25, 6, -36 },
  { 1217, 24, 36, 25, 0, -36 },
  { 1325, 23, 36, 25, 1, -36 },
  { 1429, 23, 36, 25, 1, -36 },
  { 1533, 24, 36, 25, 1, -36 },
  { 1641, 21, 36, 25, 2, -36 },
  { 1736, 24, 36, 25, 2, -36 },
  { 1844, 23, 36, 25, 1, -36 },
  { 1948, 21, 36, 25, 3, -36 },
  { 2043, 12, 28, 14, 1, -28 },
  { 2085, 14, 37, 13, -2, -28 },
  { 2150, 20, 24, 22, 1, -28 },
  { 2210, 21, 17, 25, 2, -25 },
  { 2255, 20, 24, 22, 1, -27 },
  { 2315, 20, 36, 22, 3, -36 },
  { 2405, 35, 46, 38, 1, -35 },
  { 2607, 28, 36, 30, -2, -36 },
  { 2733, 27, 36, 28, 0, -36 },
  { 2855, 26, 36, 28, 2, -36 },
  { 2972, 27, 36, 28, 0, -36 },
  { 3094, 27, 36, 24, 0, -36 },
  { 3216, 26, 36, 24, 0, -36 },
  { 3333, 27, 36, 29, 2, -36 },
  { 3455, 31, 36, 30, 0, -36 },
  { 3595, 13, 36, 13, 1, -36 },
  { 3654, 25, 36, 24, 0, -36 },
  { 3767, 31, 36, 27, 0, -36 },
  { 3907, 21, 36, 24, 0, -36 },
  { 4002, 38, 36, 38, 0, -36 },
  { 4173, 31, 36, 30, 0, -36 },
  { 4313, 27, 36, 30, 2, -36 },
  { 4435, 28, 36, 28, 0, -36 },
  { 4561, 27, 43, 30, 2, -36 },
  { 4707, 27, 36, 27, 0, -36 },
  { 4829, 26, 36, 27, 1, -36 },
  { 4946, 25, 36, 27, 4, -36 },
  { 5059, 27, 36, 28, 2, -36 },
  { 5181, 28, 36, 29, 4, -36 },
  { 5307, 35, 36, 37, 4, -36 },
  { 5465, 32, 36, 28, -2, -36 },
  { 5609, 26, 36, 27, 4, -36 },
  { 5726, 29, 36, 26, -1, -36 },
  { 5857, 17, 50, 13, -1, -42 },
  { 5964, 12, 39, 19, 4, -36 },
  { 6023, 18, 50, 13, -3, -42 },
  { 6136, 17, 18, 19, 2, -36 },
  { 6175, 20, 6, 20, -3, 0 },
  { 6190, 11, 8, 16, 5, -39 },
  { 6201, 22, 27, 23, 0, -27 },
  { 6276, 23, 38, 25, 0, -38 },
  { 6386, 21, 27, 23, 1, -27 },
  { 6457, 25, 38, 25, 1, -38 },
  { 6576, 21, 27, 24, 1, -27 },
  { 6647, 18, 39, 16, 1, -39 },
  { 6735, 25, 37, 25, 0, -27 },
  { 6851, 22, 38, 24, 0, -38 },
  { 6956, 13, 38, 12, 0, -38 },
  { 7018, 19, 48, 12, -6, -38 },
  { 7132, 25, 38, 24, 0, -38 },
  { 7251, 14, 38, 12, 0, -38 },
  { 7318, 35, 27, 37, 0, -27 },
  { 7437, 22, 27, 24, 0, -27 },
  { 7512, 22, 27, 25, 1, -27 },
  { 7587, 25, 37, 25, -2, -27 },
  { 7703, 23, 37, 25, 1, -27 },
  { 7810, 17, 27, 16, 0, -27 },
  { 7868, 21, 27, 22, 0, -27 },
  { 7939, 14, 34, 15, 2, -34 },
  { 7999, 23, 27, 24, 1, -27 },
  { 8077, 20, 27, 22, 3, -27 },
  { 8145, 30, 27, 31, 3, -27 },
  { 8247, 26, 27, 22, -2, -27 },
  { 8335, 25, 37, 22, -1, -27 },
  { 8451, 23, 27, 22, -1, -27 },
  { 8529, 16, 49, 15, 1, -40 },
  { 8627, 11, 43, 13, 1, -36 },
  { 8687, 16, 49, 15, -2, -40 },
  { 8785, 24, 11, 28, 2, -20 },
};

const GFXfont RobotoCondensed_BoldItalic51pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic51pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic51pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _ROBOTOCONDENSED_BOLDITALIC51PT7B_H_
