#ifndef _ROBOTOCONDENSED_BOLDITALIC33PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x78, 0x78, 0x78, 0x00, 0x00, 0x00, 0x60, 0xF0, 0xF0, 0xF0, 0xE0,
  0x73, 0xDC, 0xE7, 0x39, 0xCE, 0x73, 0xB8, 0xEE, 0x73, 0x9C, 0xE7, 0x00,
  0x00, 0xCE, 0x01, 0xCE, 0x01, 0xCE, 0x01, 0xDC, 0x03, 0x9C, 0x03, 0x9C,
  0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x07, 0x30, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x60, 0x1C, 0xE0, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x39, 0xC0,
  0x39, 0xC0, 0x33, 0x80, 0x73, 0x80, 0x73, 0x80, 0x67, 0x00, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x1F, 0x80, 0x7F, 0x81, 0xFF, 0x87, 0xFF, 0x0F,
  0x1E, 0x3E, 0x3E, 0x7C, 0x7C, 0xF8, 0xF9, 0xF0, 0x01, 0xF0, 0x03, 0xF8,
  0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF3, 0xC1, 0xE7, 0x83, 0xCF,
  0x87, 0x9F, 0x1F, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x1F, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0x1C,
  0x6E, 0x39, 0xDC, 0x73, 0xB9, 0xCE, 0x73, 0xB8, 0xFF, 0xE0, 0xFD, 0xC0,
  0xF7, 0x00, 0x1C, 0x00, 0x77, 0x80, 0xFF, 0x83, 0xFF, 0x8E, 0xE7, 0x1D,
  0xCE, 0x73, 0x9D, 0xC7, 0x3F, 0x0E, 0x72, 0x1F, 0xE0, 0x3F, 0x80, 0x1E,
  0x00, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xF1, 0xE0,
  0x78, 0xF0, 0x3C, 0x70, 0x1E, 0x78, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xF8,
  0x01, 0xF8, 0xF1, 0xFE, 0x79, 0xFF, 0x3D, 0xF7, 0xFC, 0xF1, 0xFE, 0x78,
  0xFE, 0x3C, 0x3F, 0x1F, 0x1F, 0x0F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x3E, 0x7C, 0x7B, 0x9C, 0xE7, 0x7B, 0x9C, 0xE0, 0x00, 0x80, 0x60, 0x3C,
  0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x70,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0,
  0x10, 0x00, 0x04, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0,
  0xF0, 0x78, 0x1E, 0x0F, 0x03, 0x80, 0x80, 0x00, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x63, 0x1B, 0xEF, 0xEF, 0xFF, 0xC3, 0xF0, 0x0F, 0x00,
  0x7E, 0x03, 0x9C, 0x1C, 0x70, 0x70, 0xE0, 0x82, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFB, 0xFF, 0xE0, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x1E, 0x3C, 0x78, 0xE3, 0xC7, 0x9E, 0x3C, 0xF0, 0x40,
  0xFF, 0xFF, 0xFF, 0xFE, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0xF0, 0x3F,
  0xF0, 0xFF, 0xE1, 0xE3, 0xC7, 0x87, 0x8F, 0x0F, 0x9E, 0x1F, 0x7C, 0x3C,
  0xF8, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0xCF, 0x0F, 0xBE, 0x1F, 0x7C,
  0x3C, 0xF8, 0x79, 0xF1, 0xF1, 0xE3, 0xC3, 0xFF, 0x87, 0xFE, 0x07, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x81, 0xE3, 0xFB, 0xFE, 0xFF, 0xBF, 0xE8, 0xF0,
  0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3E,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0xFC,
  0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0x1E, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFC,
  0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x01, 0xF0, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xFE, 0x1F, 0x1E, 0x1E, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0xF8, 0x3C, 0x78, 0x7C, 0x78, 0x7C, 0x7F, 0xF8, 0x3F, 0xF0,
  0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xBC, 0x07, 0xBC, 0x0F, 0x7C,
  0x0F, 0x7C, 0x1E, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF, 0xF1, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3D, 0xE0, 0x7F, 0xE0, 0xFF, 0xE3, 0xFF,
  0xC0, 0x87, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3C, 0xF0, 0x79, 0xE0, 0xF3,
  0xE3, 0xE3, 0xFF, 0x87, 0xFE, 0x07, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x78,
  0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00,
  0x3D, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFE, 0x7C, 0x7D, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF8, 0x7D, 0xE1, 0xE7, 0x8F, 0x9F, 0xFC, 0x3F, 0xF0, 0xFF,
  0x80, 0xF8, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFE, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xE3, 0xE7, 0xC7,
  0xCF, 0x8F, 0x9F, 0x1E, 0x3E, 0x7C, 0x3F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFF, 0x0F, 0x9F, 0x3E, 0x1E, 0x7C, 0x3C, 0xF0, 0x79, 0xE1, 0xF3, 0xE3,
  0xE7, 0xFF, 0x87, 0xFF, 0x07, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x7F,
  0x07, 0xFC, 0x7F, 0xF7, 0xC7, 0xBC, 0x3D, 0xE1, 0xFF, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x1F, 0xF1, 0xF7, 0xFF, 0xBF, 0xF8, 0xFF, 0xC3, 0xFE, 0x01,
  0xE0, 0x1F, 0x01, 0xF0, 0xFF, 0x07, 0xF0, 0x3F, 0x01, 0xE0, 0x00, 0x1C,
  0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x3E,
  0x7C, 0xF8, 0xE0, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x00, 0x80, 0x00, 0x08, 0x01,
  0xC0, 0x3C, 0x07, 0xE1, 0xFF, 0x3F, 0xE3, 0xFC, 0x1F, 0x80, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFE, 0x01, 0xE0, 0x07, 0x00, 0x08, 0x3F,
  0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x7F, 0xFB, 0xFF, 0xCF, 0xFF, 0x00, 0x20, 0x01, 0xC0, 0x0F, 0x80,
  0x7E, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x01, 0xF0, 0x7F, 0x8F,
  0xF9, 0xFF, 0x0F, 0xE0, 0x7C, 0x03, 0x80, 0x10, 0x00, 0x0F, 0xC0, 0xFF,
  0x0F, 0xFC, 0xFF, 0xE7, 0x8F, 0x7C, 0x7B, 0xE3, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF0, 0x1E, 0x07, 0x00,
  0x38, 0x38, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x07, 0x87, 0x38, 0x7F, 0x8C,
  0xE3, 0xFE, 0x37, 0x0E, 0x38, 0xDC, 0x71, 0xE3, 0x71, 0xC7, 0x0F, 0x8F,
  0x1C, 0x7E, 0x38, 0x71, 0xF8, 0xE3, 0xC7, 0xE7, 0x8E, 0x1F, 0x9E, 0x38,
  0x6E, 0x79, 0xE3, 0xB9, 0xE7, 0x8C, 0xE3, 0xFF, 0xF3, 0x8F, 0xFF, 0x8E,
  0x1C, 0x78, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1F,
  0x3E, 0x07, 0x8F, 0x83, 0xE1, 0xE0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0xFF,
  0x8F, 0xFF, 0xE3, 0xE0, 0x79, 0xF0, 0x1F, 0x7C, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x7C, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F,
  0x0F, 0x87, 0xC1, 0xE1, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x87, 0x8F,
  0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0F, 0x07, 0xC3, 0xC1, 0xF1,
  0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC3, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xFF, 0xE1, 0xF0, 0xF9, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x3E, 0xF8, 0x1E, 0x3C, 0x1F, 0x1F, 0x0F, 0x8F, 0xFF,
  0x83, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xE1, 0xF0, 0xF8, 0xF8, 0x3C, 0x7C, 0x1E, 0x3E, 0x0F,
  0x1E, 0x07, 0x8F, 0x03, 0xCF, 0x81, 0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xE0,
  0x7C, 0xF0, 0x3C, 0xF8, 0x1E, 0x7C, 0x1F, 0x3E, 0x0F, 0x1F, 0x1F, 0x8F,
  0xFF, 0x87, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFF, 0x87, 0xFF,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0, 0x0F, 0xFF, 0x87,
  0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x01, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xF1, 0xF0, 0xF9, 0xF0, 0x3C, 0xF8,
  0x1E, 0x78, 0x0F, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x1F, 0xEF, 0x0F, 0xF7,
  0x87, 0xF3, 0xC7, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x3C, 0x0F,
  0x9F, 0x0F, 0xCF, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x1F, 0x80, 0x0F,
  0x80, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x1F, 0x01, 0xE1,
  0xF0, 0x1E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1E, 0x03, 0xE1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xC0, 0x7C, 0x3C, 0x07,
  0xC7, 0xC0, 0x78, 0x7C, 0x07, 0x87, 0xC0, 0x78, 0x7C, 0x0F, 0x87, 0x80,
  0xF8, 0x78, 0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x0F, 0x00, 0x0F, 0x87, 0xC3,
  0xE1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xE1,
  0xF0, 0xF0, 0x78, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC3, 0xE0, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0xF8, 0x78, 0xF8, 0xF8, 0xF8,
  0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0x80, 0x0F, 0x83, 0xF0,
  0xF8, 0x7E, 0x0F, 0x07, 0xC0, 0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF3, 0xF0,
  0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1E, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xE7,
  0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0x83, 0xE0, 0x78,
  0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xFE, 0x7F, 0xFB, 0xFF, 0xEF, 0xFF, 0x80,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F,
  0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xC3,
  0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xF0, 0xEF, 0x0F, 0xB8, 0xF7, 0x87, 0xDC,
  0x77, 0xC3, 0xCE, 0x7B, 0xE1, 0xE7, 0x3D, 0xE0, 0xF3, 0xBC, 0xF0, 0xF9,
  0xDE, 0x78, 0x7C, 0xFE, 0x7C, 0x3E, 0x7F, 0x3E, 0x1F, 0x3F, 0x1F, 0x0F,
  0x0F, 0x8F, 0x07, 0x87, 0x87, 0x87, 0xC3, 0xC7, 0xC3, 0xE1, 0xC3, 0xE0,
  0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xFC, 0x1F, 0x1F, 0xC1,
  0xE1, 0xFC, 0x1E, 0x1F, 0xC3, 0xE1, 0xFE, 0x3E, 0x1E, 0xE3, 0xE1, 0xEE,
  0x3C, 0x3E, 0xF3, 0xC3, 0xE7, 0x3C, 0x3E, 0x77, 0xC3, 0xC7, 0x7C, 0x3C,
  0x7F, 0xC7, 0xC3, 0xF8, 0x7C, 0x3F, 0x87, 0xC3, 0xF8, 0x7C, 0x3F, 0x87,
  0x81, 0xF8, 0x78, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x00, 0x01, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xFE, 0x1F, 0x0F, 0x8F, 0x81, 0xE3,
  0xE0, 0x78, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x79, 0xE0,
  0x1E, 0x78, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0xF8, 0x1F,
  0x1E, 0x07, 0xC7, 0xC3, 0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xFC, 0x00,
  0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F,
  0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0xC7, 0x81,
  0xF3, 0xE0, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x81,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0xF0, 0x3F, 0xFE, 0x1F, 0x0F, 0x8F, 0x81, 0xE3, 0xE0, 0x78, 0xF0, 0x1F,
  0x7C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0xBE,
  0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x3C, 0xF8, 0x1F, 0x1E, 0x07, 0xC7, 0xC3,
  0xE1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x00, 0x01, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C,
  0x1E, 0x1E, 0x07, 0x87, 0x83, 0xE3, 0xE1, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE,
  0x0F, 0xFF, 0x03, 0xFF, 0x81, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07,
  0xC3, 0xC1, 0xE0, 0xF8, 0x78, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE0, 0x01,
  0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x3F, 0x1F, 0x3E, 0x0F, 0x3E,
  0x0F, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x3C, 0xF8,
  0x7C, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x1F, 0x07, 0xC7, 0x81, 0xF1,
  0xE0, 0x7C, 0xF8, 0x1E, 0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF0,
  0x3E, 0x3C, 0x0F, 0x9F, 0x03, 0xC7, 0xC0, 0xF1, 0xF0, 0x7C, 0x78, 0x1F,
  0x1E, 0x07, 0xC7, 0x81, 0xF3, 0xE0, 0x78, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F,
  0x87, 0xC1, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x0F, 0xFC, 0x07, 0xFE, 0x07, 0xDF, 0x03, 0xEF, 0x83, 0xE7, 0xC1, 0xF3,
  0xE0, 0xF9, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E,
  0x07, 0x9F, 0x03, 0xCF, 0x01, 0xF7, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x78, 0x3D, 0xE0, 0xF0, 0xFB, 0xC3, 0xE1, 0xF7, 0x87, 0xC3, 0xCF,
  0x0F, 0x87, 0x9E, 0x3F, 0x1F, 0x3C, 0x7E, 0x3C, 0x78, 0xFC, 0x78, 0xF3,
  0xF9, 0xF1, 0xE7, 0xF3, 0xC3, 0xCE, 0xE7, 0x87, 0xBD, 0xDF, 0x0F, 0x7B,
  0xBC, 0x1E, 0xE7, 0x78, 0x3F, 0xCF, 0xF0, 0x7F, 0x9F, 0xC0, 0xFE, 0x3F,
  0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x7C, 0x1F,
  0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x01, 0xE7, 0xC0, 0x0F,
  0x3C, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xBE, 0x00, 0xF9, 0xF0, 0x07, 0xC7, 0x80, 0x7C, 0x3E, 0x07,
  0xE1, 0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x7C, 0x0F,
  0xBE, 0x0F, 0x8F, 0x07, 0xC7, 0x87, 0xC3, 0xC3, 0xC1, 0xF3, 0xE0, 0x79,
  0xE0, 0x3D, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF,
  0xC0, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x80, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x7E, 0x07, 0xE0, 0x7E, 0x0F,
  0xE0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF8, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E,
  0x1E, 0x1E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x07, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0x03, 0x80,
  0xF0, 0x1F, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0x71, 0xEE, 0x39, 0xEF, 0x1D,
  0xC3, 0xF8, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0x78, 0xF8,
  0xF0, 0xF1, 0xE0, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0xFF, 0x3E, 0x7C,
  0xF1, 0xF0, 0x07, 0xC3, 0xFE, 0x3F, 0xF9, 0xFF, 0xE7, 0xC7, 0xBE, 0x3E,
  0xF8, 0xFB, 0xFF, 0xC7, 0xFF, 0x1F, 0xFC, 0x1E, 0xF8, 0x0F, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0xF8, 0x3F, 0xF8, 0xFF, 0xF1, 0xFF, 0xF3, 0xE3, 0xE7, 0x87, 0xCF,
  0x0F, 0x9E, 0x1F, 0x7C, 0x3E, 0xF8, 0x7D, 0xE0, 0xF3, 0xC1, 0xE7, 0xC7,
  0xCF, 0xFF, 0x3F, 0xFE, 0x7B, 0xF8, 0xF3, 0xE0, 0x07, 0xC0, 0xFF, 0x8F,
  0xFC, 0xFF, 0xF7, 0x87, 0xBC, 0x3F, 0xE1, 0xFE, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE1, 0xEF, 0x1F, 0x7F, 0xF1, 0xFF, 0x8F, 0xF8, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x0F, 0x3C, 0x1F, 0xBC, 0x3F, 0xFC, 0x7F, 0xFC,
  0x7C, 0x7C, 0xF8, 0x7C, 0xF8, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF8,
  0xF0, 0xF8, 0xF0, 0xF0, 0xF8, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0,
  0x3C, 0xF0, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x8F, 0xFE, 0x7C, 0x79, 0xE1,
  0xEF, 0x87, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEF, 0x00, 0x3C, 0x00, 0xF8,
  0x63, 0xFF, 0x87, 0xFF, 0x0F, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x7F, 0xC7, 0xFC, 0x7F,
  0xC3, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xCF,
  0x0F, 0xFF, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E,
  0x78, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x7C, 0x7C, 0x7C,
  0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xF8, 0x1F, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x41, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0x3F, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0xF0, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x3E, 0x3C, 0xF0, 0xF3, 0xC3,
  0xDF, 0x0F, 0x7C, 0x3D, 0xF1, 0xF7, 0x87, 0xDE, 0x1E, 0x78, 0x7B, 0xE1,
  0xEF, 0x87, 0xBC, 0x3E, 0xF0, 0xF8, 0x06, 0x07, 0x83, 0xE1, 0xE0, 0x70,
  0x00, 0x00, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78,
  0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE1, 0xF0, 0x00, 0x60, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0,
  0x1F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x1E, 0x3F, 0x1E, 0x3E, 0x3E, 0x7C, 0x3E, 0xF8, 0x3D, 0xF0, 0x3D, 0xF0,
  0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x7D, 0xF0,
  0x79, 0xF0, 0x78, 0xF0, 0xF8, 0xF8, 0xF8, 0xF8, 0xF0, 0x78, 0x0F, 0x87,
  0xC3, 0xC1, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x87, 0xC3,
  0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE1,
  0xF0, 0xF8, 0x00, 0x1E, 0xF8, 0xF0, 0x7F, 0xF7, 0xF1, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3E, 0x3E, 0x3C, 0xF0, 0xF0, 0xF3, 0xC3, 0xC3, 0xCF, 0x0F,
  0x0F, 0x7C, 0x7C, 0x7D, 0xF1, 0xF1, 0xF7, 0xC7, 0xC7, 0xDE, 0x1E, 0x1E,
  0x78, 0x78, 0x79, 0xE1, 0xE1, 0xEF, 0x8F, 0x8F, 0xBE, 0x3E, 0x3E, 0xF0,
  0xF0, 0xF8, 0x1E, 0xF8, 0x7F, 0xF3, 0xFF, 0xCF, 0xFF, 0x3E, 0x3C, 0xF0,
  0xF3, 0xC3, 0xCF, 0x0F, 0x7C, 0x3D, 0xF1, 0xF7, 0x87, 0xDE, 0x1E, 0x78,
  0x7B, 0xE1, 0xEF, 0x87, 0xBE, 0x3E, 0xF0, 0xF8, 0x07, 0xE0, 0x7F, 0xC3,
  0xFF, 0x8F, 0xFE, 0x7C, 0x7D, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x07, 0xBC, 0x1E, 0xF8, 0xFB, 0xFF, 0xC7, 0xFE, 0x0F, 0xF0,
  0x1F, 0x80, 0x0F, 0x7C, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F, 0xFF, 0x1F, 0x1F,
  0x1E, 0x1F, 0x1E, 0x1F, 0x1E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1E,
  0x3C, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x7D, 0xF0,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x0F, 0x3C, 0x3F, 0x78, 0xFF, 0xF3, 0xFF, 0xE7, 0xC7, 0xDF,
  0x0F, 0xBE, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE1, 0xF3, 0xC3, 0xE7, 0x87,
  0xCF, 0x0F, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0x3D, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x1E,
  0xE3, 0xFC, 0x7F, 0x9F, 0xF3, 0xFE, 0x7C, 0x0F, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9F, 0x3C, 0x7C, 0xF0, 0x03, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x3C, 0x3E, 0xF0, 0xFB, 0xF7, 0xC7,
  0xFF, 0x0F, 0xF8, 0x1F, 0x80, 0x1F, 0x0F, 0x87, 0x83, 0xC1, 0xE3, 0xFF,
  0xFF, 0xFF, 0x3C, 0x1E, 0x0F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0x3C, 0x3C, 0x78, 0x79, 0xF0, 0xF3,
  0xE3, 0xE7, 0x87, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C, 0x3C, 0xF8, 0x79, 0xF1,
  0xF3, 0xC3, 0xE7, 0x87, 0xCF, 0x9F, 0x1F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8,
  0x3D, 0xF0, 0xF0, 0xFF, 0x87, 0xFC, 0x3D, 0xE3, 0xEF, 0x1E, 0x79, 0xF3,
  0xCF, 0x0E, 0x78, 0x7F, 0xC3, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0xE1, 0xFE, 0x3C, 0x7F, 0xC7,
  0x8F, 0x79, 0xF1, 0xEF, 0x3E, 0x79, 0xE7, 0xCF, 0x3D, 0xF9, 0xE7, 0xBF,
  0x78, 0xFF, 0xFF, 0x1F, 0xDF, 0xC3, 0xFB, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7,
  0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xC0, 0xF0, 0x78, 0x00, 0x1F,
  0x1F, 0x1F, 0x1E, 0x0F, 0x3E, 0x0F, 0x7C, 0x0F, 0x78, 0x07, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1E,
  0xF0, 0x3E, 0xF0, 0x7C, 0xF8, 0x7C, 0x78, 0xF8, 0x78, 0x1E, 0x1F, 0x1E,
  0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x1E, 0x3C, 0x1E, 0x7C, 0x1F, 0x78, 0x1F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x1F, 0xFC, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xCF, 0xFF, 0x3F,
  0xFC, 0xFF, 0xF0, 0x00, 0x80, 0xF0, 0x7C, 0x1E, 0x0F, 0x03, 0xC0, 0xF0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x07, 0xC3, 0xE0, 0xE0,
  0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x0F, 0x03, 0x80, 0x20, 0x0E, 0x18, 0x70, 0xE1, 0xC3,
  0x87, 0x0C, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0xC3,
  0x06, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x00, 0x04, 0x03, 0x80, 0xF0, 0x1C,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x01,
  0xC0, 0x78, 0x0F, 0x03, 0xC3, 0xF0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x3C, 0x0E, 0x03, 0x00, 0x1E,
  0x00, 0x3F, 0x0F, 0x7F, 0x8E, 0x7F, 0xFE, 0xF1, 0xFE, 0xF1, 0xFC, 0x00,
  0x78,
};

const GFXglyph RobotoCondensed_BoldItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 23, 8, 1, -23 },
  { 24, 10, 9, 10, 2, -25 },
  { 36, 16, 23, 17, 1, -23 },
  { 82, 15, 29, 16, 1, -26 },
  { 137, 15, 23, 20, 3, -23 },
  { 181, 17, 23, 19, 0, -23 },
  { 230, 5, 9, 5, 2, -25 },
  { 236, 10, 33, 10, 2, -26 },
  { 278, 10, 33, 10, -1, -26 },
  { 320, 14, 14, 15, 2, -23 },
  { 345, 14, 17, 15, 1, -19 },
  { 375, 7, 10, 8, -2, -4 },
  { 384, 8, 4, 12, 2, -12 },
  { 388, 5, 5, 9, 1, -5 },
  { 392, 15, 25, 11, -2, -23 },
  { 439, 15, 23, 16, 1, -23 },
  { 483, 10, 23, 16, 4, -23 },
  { 512, 16, 23, 16, 0, -23 },
  { 558, 16, 23, 16, 0, -23 },
  { 604, 16, 23, 16, 0, -23 },
  { 650, 15, 23, 16, 1, -23 },
  { 694, 14, 23, 16, 1, -23 },
  { 735, 16, 23, 16, 1, -23 },
  { 781, 15, 23, 16, 1, -23 },
  { 825, 13, 23, 16, 2, -23 },
  { 863, 7, 18, 9, 1, -18 },
  { 879, 10, 24, 8, -2, -18 },
  { 909, 13, 16, 14, 1, -18 },
  { 935, 14, 11, 16, 1, -16 },
  { 955, 13, 16, 15, 1, -18 },
  { 981, 13, 23, 14, 2, -23 },
  { 1019, 22, 30, 25, 1, -23 },
  { 1102, 18, 23, 19, -1, -23 },
  { 1154, 18, 23, 18, 0, -23 },
  { 1206, 17, 23, 18, 1, -23 },
  { 1255, 17, 23, 18, 0, -23 },
  { 1304, 17, 23, 16, 0, -23 },
  { 1353, 17, 23, 15, 0, -23 },
  { 1402, 17, 23, 19, 1, -23 },
  { 1451, 20, 23, 20, 0, -23 },
  { 1509, 9, 23, 9, 0, -23 },
  { 1535, 16, 23, 16, 0, -23 },
  { 1581, 20, 23, 18, 0, -23 },
  { 1639, 14, 23, 15, 0, -23 },
  { 1680, 25, 23, 24, 0, -23 },
  { 1752, 20, 23, 20, 0, -23 },
  { 1810, 18, 23, 19, 1, -23 },
  { 1862, 18, 23, 18, 0, -23 },
  { 1914, 18, 27, 19, 1, -23 },
  { 1975, 18, 23, 18, 0, -23 },
  { 2027, 16, 23, 17, 1, -23 },
  { 2073, 16, 23, 17, 3, -23 },
  { 2119, 18, 23, 18, 1, -23 },
  { 2171, 17, 23, 19, 3, -23 },
  { 2220, 23, 23, 24, 3, -23 },
  { 2287, 21, 23, 18, -1, -23 },
  { 2348, 17, 23, 17, 3, -23 },
  { 2397, 18, 23, 17, 0, -23 },
  { 2449, 12, 32, 8, -1, -27 },
  { 2497, 8, 25, 12, 3, -23 },
  { 2522, 11, 32, 8, -2, -27 },
  { 2566, 11, 12, 13, 1, -23 },
  { 2583, 13, 4, 13, -2, 0 },
  { 2590, 7, 5, 11, 3, -25 },
  { 2595, 14, 17, 15, 0, -17 },
  { 2625, 15, 25, 16, 0, -25 },
  { 2672, 13, 17, 15, 1, -17 },
  { 2700, 16, 25, 16, 1, -25 },
  { 2750, 14, 17, 15, 1, -17 },
  { 2780, 12, 25, 10, 1, -25 },
  { 2818, 16, 24, 16, 0, -17 },
  { 2866, 14, 25, 16, 0, -25 },
  { 2910, 9, 24, 8, 0, -24 },
  { 2937, 12, 31, 8, -4, -24 },
  { 2984, 16, 25, 15, 0, -25 },
  { 3034, 9, 25, 8, 0, -25 },
  { 3063, 22, 17, 24, 0, -17 },
  { 3110, 14, 17, 16, 0, -17 },
  { 3140, 14, 17, 16, 1, -17 },
  { 3170, 16, 24, 16, -1, -17 },
  { 3218, 15, 24, 16, 1, -17 },
  { 3263, 11, 17, 11, 0, -17 },
  { 3287, 14, 17, 15, 0, -17 },
  { 3317, 9, 22, 10, 1, -22 },
  { 3342, 15, 17, 16, 1, -17 },
  { 3374, 13, 17, 14, 2, -17 },
  { 3402, 19, 17, 20, 2, -17 },
  { 3443, 16, 17, 14, -1, -17 },
  { 3477, 16, 24, 14, -1, -17 },
  { 3525, 14, 17, 14, 0, -17 },
  { 3555, 10, 32, 10, 1, -26 },
  { 3595, 7, 27, 8, 1, -23 },
  { 3619, 10, 32, 10, -1, -26 },
  { 3659, 16, 7, 18, 1, -13 },
};

const GFXfont RobotoCondensed_BoldItalic33pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic33pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic33pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _ROBOTOCONDENSED_BOLDITALIC33PT7B_H_
