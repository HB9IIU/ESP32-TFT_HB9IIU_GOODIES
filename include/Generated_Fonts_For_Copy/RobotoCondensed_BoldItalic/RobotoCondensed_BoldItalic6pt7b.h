#ifndef _ROBOTOCONDENSED_BOLDITALIC6PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0x30, 0x6B, 0xE0, 0x0D, 0x1C, 0x00, 0xED, 0x6B, 0xF0, 0x40,
  0x1A, 0xA0, 0x15, 0xA0, 0xE8, 0x49, 0x20, 0xC0, 0xC0, 0x80, 0x5A, 0x76,
  0xE0, 0xF0, 0xE5, 0x70, 0x6C, 0xE0, 0x6F, 0xA0, 0x48, 0xE0, 0x5A, 0xE0,
  0x69, 0x40, 0x6E, 0xE0, 0x75, 0xA0, 0x20, 0x30, 0x58, 0x00, 0x78, 0xEA,
  0x00, 0xE9, 0x00, 0x7B, 0xFF, 0xC0, 0x6F, 0xD0, 0x7E, 0xF0, 0x72, 0x70,
  0x76, 0xE0, 0x7E, 0x60, 0x7A, 0x40, 0x72, 0xF0, 0x5E, 0xAA, 0x6A, 0x24,
  0xE0, 0x6C, 0xCA, 0x6B, 0x56, 0xBD, 0xA0, 0x5E, 0xAA, 0x76, 0xF0, 0x77,
  0x40, 0x76, 0xF2, 0x77, 0x50, 0x68, 0xF0, 0x69, 0x20, 0x76, 0xF0, 0xA6,
  0x64, 0xEE, 0xEC, 0x64, 0x4A, 0x66, 0x44, 0x69, 0x70, 0x6A, 0xA0, 0x95,
  0x5A, 0xA0, 0x60, 0xC0, 0x00, 0xFB, 0x00, 0x53, 0xDC, 0xF3, 0x00, 0x27,
  0xDC, 0xFF, 0x00, 0x5A, 0x80, 0xF7, 0x60, 0x53, 0xDC, 0x2A, 0x09, 0x24,
  0x53, 0x6C, 0x5A, 0x80, 0xFB, 0xD0, 0xF7, 0x00, 0xF7, 0x00, 0xF7, 0x40,
  0xF7, 0x20, 0xE8, 0xCB, 0x00, 0x6A, 0xB7, 0x00, 0xB9, 0x00, 0xDE, 0xA0,
  0xCB, 0x00, 0xB9, 0x40, 0xEB, 0x00, 0x56, 0xA0, 0xF8, 0x18, 0xA0, 0xE0,
};

const GFXglyph RobotoCondensed_BoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 2, 4, 2, 0, -4 },
  { 2, 2, 2, 2, 0, -5 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 6, 3, 0, -5 },
  { 8, 2, 4, 4, 1, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 2, 1, 0, -5 },
  { 12, 2, 6, 2, 0, -5 },
  { 14, 2, 6, 2, 0, -5 },
  { 16, 3, 2, 3, 0, -4 },
  { 17, 3, 4, 3, 0, -4 },
  { 19, 1, 2, 1, 0, -1 },
  { 20, 2, 1, 2, 0, -2 },
  { 21, 1, 1, 2, 0, -1 },
  { 22, 2, 4, 2, 0, -4 },
  { 23, 3, 4, 3, 0, -4 },
  { 25, 1, 4, 3, 1, -4 },
  { 26, 3, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 1, 3, 2, 0, -3 },
  { 43, 1, 4, 2, 0, -3 },
  { 44, 3, 3, 3, 0, -3 },
  { 46, 3, 2, 3, 0, -3 },
  { 47, 3, 3, 3, 0, -3 },
  { 49, 3, 4, 3, 0, -4 },
  { 51, 4, 5, 4, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 3, 4, 3, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 3, 4, 3, 0, -4 },
  { 62, 3, 4, 3, 0, -4 },
  { 64, 3, 4, 3, 0, -4 },
  { 66, 3, 4, 3, 0, -4 },
  { 68, 4, 4, 4, 0, -4 },
  { 70, 2, 4, 2, 0, -4 },
  { 71, 3, 4, 3, 0, -4 },
  { 73, 4, 4, 3, 0, -4 },
  { 75, 2, 4, 3, 0, -4 },
  { 76, 5, 4, 4, 0, -4 },
  { 79, 4, 4, 4, 0, -4 },
  { 81, 3, 4, 4, 0, -4 },
  { 83, 3, 4, 3, 0, -4 },
  { 85, 3, 5, 4, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 3, 4, 3, 0, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 4, 4, 3, 0, -4 },
  { 97, 4, 4, 4, 1, -4 },
  { 99, 4, 4, 3, 0, -4 },
  { 101, 4, 4, 3, 0, -4 },
  { 103, 3, 4, 3, 0, -4 },
  { 105, 2, 6, 2, 0, -5 },
  { 107, 2, 4, 2, 0, -4 },
  { 108, 2, 6, 2, 0, -5 },
  { 110, 2, 2, 2, 0, -4 },
  { 111, 2, 1, 2, 0, 0 },
  { 112, 1, 1, 2, 1, -5 },
  { 113, 3, 3, 3, 0, -3 },
  { 115, 3, 5, 3, 0, -5 },
  { 117, 3, 3, 3, 0, -3 },
  { 119, 3, 5, 3, 0, -5 },
  { 121, 3, 3, 3, 0, -3 },
  { 123, 2, 5, 2, 0, -5 },
  { 125, 3, 4, 3, 0, -3 },
  { 127, 3, 5, 3, 0, -5 },
  { 129, 2, 4, 1, 0, -4 },
  { 130, 3, 5, 1, -1, -4 },
  { 132, 3, 5, 3, 0, -5 },
  { 134, 2, 5, 1, 0, -5 },
  { 136, 4, 3, 4, 0, -3 },
  { 138, 3, 3, 3, 0, -3 },
  { 140, 3, 3, 3, 0, -3 },
  { 142, 3, 4, 3, 0, -3 },
  { 144, 3, 4, 3, 0, -3 },
  { 146, 2, 3, 2, 0, -3 },
  { 147, 3, 3, 3, 0, -3 },
  { 149, 2, 4, 2, 0, -4 },
  { 150, 3, 3, 3, 0, -3 },
  { 152, 3, 3, 3, 0, -3 },
  { 154, 4, 3, 4, 0, -3 },
  { 156, 3, 3, 3, 0, -3 },
  { 158, 3, 4, 3, 0, -3 },
  { 160, 3, 3, 3, 0, -3 },
  { 162, 2, 6, 2, 0, -5 },
  { 164, 1, 5, 1, 0, -4 },
  { 165, 2, 6, 2, 0, -5 },
  { 167, 3, 1, 3, 0, -2 },
};

const GFXfont RobotoCondensed_BoldItalic6pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic6pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _ROBOTOCONDENSED_BOLDITALIC6PT7B_H_
