#ifndef _ROBOTOCONDENSED_BOLDITALIC31PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic31pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xE7, 0x8F, 0x1E, 0x3C, 0x78, 0xE3, 0xC7,
  0x8F, 0x1C, 0x00, 0x01, 0xC3, 0xC7, 0x8F, 0x1C, 0x00, 0x73, 0xB9, 0xDC,
  0xCC, 0xEE, 0x77, 0x3B, 0x99, 0x8C, 0x01, 0xCC, 0x03, 0x38, 0x0E, 0x70,
  0x1C, 0xC0, 0x3B, 0x80, 0x67, 0x0F, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x1C,
  0xC0, 0x3B, 0x80, 0x67, 0x01, 0xCE, 0x1F, 0xFF, 0x3F, 0xFE, 0x7F, 0xF8,
  0x39, 0x80, 0x67, 0x01, 0xCE, 0x03, 0x98, 0x06, 0x70, 0x1C, 0xE0, 0x00,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0xF8, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF,
  0x8F, 0x9F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x03, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0,
  0xF3, 0xFF, 0xC7, 0xFE, 0x0F, 0xF0, 0x1F, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xF0, 0x39, 0xC7, 0xE7, 0x3B, 0x9C, 0xCE,
  0x77, 0x3F, 0xB8, 0xFF, 0xC1, 0xE7, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x70,
  0x3F, 0xF1, 0xDF, 0xCE, 0xE7, 0x3B, 0x9D, 0xCE, 0x7E, 0x39, 0xD0, 0xFF,
  0x01, 0xF8, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xFC,
  0x0F, 0x3C, 0x0E, 0x3C, 0x0E, 0x38, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0xCF, 0x3F, 0xCF, 0x7F, 0xEE, 0x79, 0xFE, 0x79, 0xFE,
  0x78, 0xFC, 0x78, 0x7C, 0x7D, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F, 0x9E,
  0x77, 0x77, 0xEE, 0xEE, 0x00, 0x80, 0x70, 0x3C, 0x1E, 0x07, 0x03, 0xC1,
  0xE0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0x80, 0x20, 0x04, 0x07, 0x03, 0x80,
  0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1C,
  0x1E, 0x0E, 0x0F, 0x0F, 0x07, 0x02, 0x00, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0E, 0x0F, 0x77, 0x7F, 0xF8, 0xFF, 0x81, 0xE0, 0x1F, 0x01, 0xDC, 0x1C,
  0xE0, 0xC3, 0x82, 0x10, 0x00, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0x83, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x38, 0x71, 0xE3, 0xC7,
  0x1E, 0x78, 0x60, 0xFF, 0xFF, 0xFF, 0xF0, 0x6F, 0xFF, 0xF0, 0x00, 0x3C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x87, 0xFE, 0x3C,
  0x78, 0xF0, 0xF3, 0xC3, 0xDE, 0x1F, 0x78, 0x7D, 0xE1, 0xE7, 0x87, 0x9E,
  0x1E, 0xF8, 0x7B, 0xE1, 0xEF, 0x0F, 0xBC, 0x3C, 0xF0, 0xF3, 0xC7, 0xC7,
  0xFE, 0x1F, 0xF0, 0x3F, 0xC0, 0x7C, 0x00, 0x00, 0xC1, 0xE1, 0xF9, 0xFE,
  0x7F, 0x9D, 0xE8, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x00, 0x01,
  0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE1, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xE7, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFF, 0x00, 0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xE1, 0xE3, 0xE7, 0xC7, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x3F, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0xF8,
  0x78, 0xF1, 0xF1, 0xFF, 0xC3, 0xFF, 0x83, 0xFE, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x03, 0xFC, 0x0F, 0x78, 0x1C, 0xF0, 0x79, 0xE1, 0xE7, 0xC3, 0xCF, 0x0F,
  0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0xFF, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0xFF,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0xDF,
  0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0xF0, 0xF3, 0xC3,
  0xCF, 0xFE, 0x1F, 0xF8, 0x3F, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x81,
  0xFC, 0x1F, 0xE1, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0xFC, 0x7F, 0xF3, 0xFF,
  0x9F, 0xFE, 0xF1, 0xF7, 0x87, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0xF3,
  0xC7, 0x9F, 0xFC, 0xFF, 0xC3, 0xFC, 0x0F, 0x80, 0x3F, 0xFE, 0x7F, 0xFC,
  0xFF, 0xFB, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xFF, 0x87, 0xFE, 0x3E, 0x7C, 0xF1,
  0xF3, 0xC7, 0xCF, 0x1E, 0x1E, 0xF8, 0x7F, 0xC1, 0xFC, 0x0F, 0xF8, 0x78,
  0xF3, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC7, 0xCF, 0xFE, 0x1F,
  0xF8, 0x7F, 0xC0, 0x7C, 0x00, 0x07, 0x81, 0xFE, 0x3F, 0xE3, 0xFF, 0x78,
  0xF7, 0x8F, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0xDF, 0x7F,
  0xF7, 0xFE, 0x1F, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x7F, 0x87, 0xF0, 0x7E,
  0x07, 0x00, 0x18, 0x78, 0xF9, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x1E, 0x3C, 0x78, 0x70, 0x06, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78,
  0xF0, 0xE0, 0x40, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7E, 0x1F, 0xE7, 0xF8,
  0xFE, 0x0F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xC0, 0x1C,
  0x00, 0x40, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x7F, 0xF7, 0xFF, 0xBF, 0xF8, 0x20, 0x03, 0x80, 0x3C,
  0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF0, 0x1F, 0x07, 0xF1, 0xFE, 0xFF,
  0x8F, 0xE0, 0xF8, 0x0E, 0x00, 0x80, 0x00, 0x0F, 0x83, 0xFC, 0x7F, 0xE7,
  0xFE, 0xF9, 0xFF, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81,
  0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00, 0x03, 0x00, 0x78, 0x07,
  0x80, 0x78, 0x03, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFD, 0xF8,
  0x0F, 0x01, 0xC0, 0xF0, 0x07, 0x0F, 0x00, 0x18, 0x70, 0xF0, 0xE7, 0x1F,
  0xE7, 0x38, 0xFF, 0x3B, 0x8E, 0x39, 0xDC, 0xF3, 0x8F, 0xC7, 0x1C, 0x7E,
  0x38, 0xE3, 0xF3, 0xC7, 0x1F, 0x9C, 0x70, 0xD8, 0xE3, 0x86, 0xC7, 0x1C,
  0x76, 0x39, 0xE3, 0x31, 0xFF, 0x79, 0x87, 0xDF, 0x8C, 0x3C, 0xF8, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03,
  0xDE, 0x01, 0xE7, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x7F, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x1E, 0x07, 0x9F, 0x03, 0xEF, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x3C, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF, 0x1F,
  0xFF, 0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0x3E, 0x3E, 0x3F,
  0xFC, 0x3F, 0xF8, 0x3F, 0xFC, 0x3C, 0x3E, 0x3C, 0x1E, 0x7C, 0x1E, 0x7C,
  0x1E, 0x78, 0x3E, 0x78, 0x3E, 0x7F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF,
  0xE0, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x3E, 0x1F, 0x3C,
  0x0F, 0x3C, 0x0F, 0x7C, 0x0F, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x3E, 0xF8, 0x3C, 0xF8, 0x3C, 0x78,
  0x7C, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x1F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x3E, 0x0F, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x3C,
  0x1F, 0x7C, 0x1E, 0x7C, 0x1E, 0x78, 0x3E, 0x78, 0x7C, 0x7F, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F,
  0xFF, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0xFF,
  0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F,
  0xF8, 0x3F, 0xF8, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07,
  0xFC, 0x0F, 0xFE, 0x1F, 0xFF, 0x3E, 0x0F, 0x3C, 0x0F, 0x3C, 0x0F, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0xFF, 0xF8, 0xFE, 0xF8,
  0xFE, 0xF8, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0x78, 0x3E, 0x7F, 0xFC, 0x3F,
  0xFC, 0x1F, 0xF8, 0x0F, 0xC0, 0x0F, 0x01, 0xE1, 0xE0, 0x7C, 0x3C, 0x0F,
  0x8F, 0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x3E,
  0x3E, 0x07, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8,
  0x78, 0x1F, 0x1F, 0x03, 0xC3, 0xE0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x7C, 0x3C, 0x0F, 0x8F, 0x81, 0xE1, 0xF0, 0x3C, 0x00, 0x0F, 0x0F,
  0x0F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x7C, 0x7C, 0xF8, 0xF1, 0xF1, 0xE1, 0xFF, 0xC3, 0xFF, 0x03, 0xFC, 0x03,
  0xE0, 0x00, 0x0F, 0x07, 0xE1, 0xE1, 0xF8, 0x3C, 0x3E, 0x0F, 0x8F, 0x81,
  0xF3, 0xE0, 0x3C, 0x7C, 0x07, 0x9F, 0x00, 0xF7, 0xC0, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F,
  0xBE, 0x03, 0xE7, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x81, 0xE1, 0xF0, 0x3C,
  0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x00, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x1F, 0xFE, 0xFF, 0xEF, 0xFF, 0x7F, 0xF8, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x3F,
  0x87, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F, 0xC3, 0xFC, 0x7B, 0x87, 0x78,
  0xF7, 0x1F, 0xE1, 0xEE, 0x3B, 0xC3, 0xDE, 0xF7, 0x87, 0xBD, 0xCF, 0x1F,
  0x3F, 0x9E, 0x3E, 0x7E, 0x7C, 0x78, 0xFC, 0xF0, 0xF1, 0xF1, 0xE1, 0xE3,
  0xE3, 0xC3, 0xC7, 0xC7, 0x8F, 0x8F, 0x1F, 0x1F, 0x1E, 0x3E, 0x00, 0x0F,
  0x01, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x8F, 0xC1, 0xE1, 0xF8, 0x3C, 0x3F,
  0x87, 0x87, 0xF1, 0xF0, 0xFE, 0x3E, 0x3F, 0xC7, 0x87, 0xDC, 0xF0, 0xF3,
  0x9E, 0x1E, 0x73, 0xC3, 0xCF, 0xF8, 0x78, 0xFF, 0x1F, 0x1F, 0xC3, 0xE3,
  0xF8, 0x78, 0x7F, 0x0F, 0x07, 0xE1, 0xE0, 0xFC, 0x3C, 0x1F, 0x8F, 0x81,
  0xE1, 0xF0, 0x3C, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF,
  0xE1, 0xE1, 0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C,
  0x07, 0x9E, 0x03, 0xCF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0x79,
  0xF0, 0x3C, 0xF8, 0x3E, 0x3C, 0x1E, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF,
  0x00, 0x7E, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1,
  0xF0, 0xF8, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x1F, 0x3E, 0x0F, 0x9F, 0x0F,
  0x8F, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x81, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xE1,
  0xF1, 0xE0, 0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0x9E,
  0x03, 0xCF, 0x01, 0xEF, 0x80, 0xF7, 0xC0, 0xFB, 0xE0, 0x79, 0xF0, 0x3C,
  0xF8, 0x3E, 0x3C, 0x1E, 0x1F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08, 0x00, 0x0F, 0xF8,
  0x07, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE1, 0xF0, 0xF0, 0xF0, 0x78, 0x78,
  0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x1F, 0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0x83,
  0xFF, 0x81, 0xFF, 0x81, 0xF3, 0xE0, 0xF9, 0xF0, 0x78, 0x78, 0x3C, 0x3C,
  0x1E, 0x1F, 0x0F, 0x0F, 0x8F, 0x83, 0xC7, 0xC1, 0xF0, 0x03, 0xF0, 0x1F,
  0xF0, 0x7F, 0xF0, 0xFF, 0xF3, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x1E, 0x78, 0x3E, 0xF0, 0x79, 0xE0, 0xF3, 0xFF, 0xE3, 0xFF, 0x83, 0xFE,
  0x03, 0xF0, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x1E,
  0x0F, 0x8F, 0x07, 0xCF, 0x83, 0xC7, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x78,
  0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x03,
  0xC7, 0x83, 0xE7, 0xC1, 0xF3, 0xE0, 0xF1, 0xF0, 0x78, 0xF8, 0x3C, 0x7C,
  0x3E, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0xF8, 0x0F,
  0xBC, 0x07, 0xDE, 0x07, 0xCF, 0x03, 0xE7, 0x81, 0xE3, 0xC1, 0xF1, 0xF0,
  0xF0, 0xF8, 0xF8, 0x7C, 0x78, 0x1E, 0x3C, 0x0F, 0x3E, 0x07, 0x9E, 0x03,
  0xDF, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0xF0, 0xFF,
  0x87, 0x87, 0xBC, 0x3C, 0x3D, 0xE3, 0xE1, 0xEF, 0x1F, 0x1F, 0x78, 0xF8,
  0xF3, 0xCF, 0xC7, 0x9E, 0x7E, 0x7C, 0xF3, 0xF3, 0xC7, 0xBF, 0x9E, 0x3D,
  0xDD, 0xF1, 0xEE, 0xEF, 0x0F, 0xF7, 0x78, 0x7F, 0x3B, 0xC3, 0xF9, 0xFC,
  0x1F, 0xCF, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF0,
  0xFC, 0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x00, 0x0F, 0x83, 0xE1, 0xF0, 0xF8,
  0x3E, 0x1F, 0x03, 0xC7, 0xC0, 0x7C, 0xF8, 0x0F, 0xBE, 0x00, 0xF7, 0x80,
  0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7D, 0xE0, 0x1F, 0x3C, 0x03,
  0xE7, 0x80, 0xF8, 0xF8, 0x1E, 0x1F, 0x07, 0xC1, 0xE1, 0xF0, 0x3E, 0x00,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC1, 0xF7, 0xC3, 0xC7, 0x8F, 0x8F, 0x1E, 0x1E,
  0x7C, 0x3C, 0xF0, 0x3B, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF,
  0xE3, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0x1F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xC0, 0x78,
  0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xE0, 0xF8, 0x3F, 0x00,
  0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1F, 0x0F, 0x0F,
  0x07, 0xE0, 0xFC, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1F, 0x07, 0xC0, 0xF8, 0x3F, 0x00, 0x07, 0x81, 0xE0, 0xF8, 0x3E,
  0x1D, 0x87, 0x63, 0x9C, 0xE7, 0x79, 0xDC, 0x7F, 0x1C, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0xF0, 0xF1, 0xE1, 0xC0, 0x07, 0xE0, 0x7F, 0x87, 0xFE,
  0x7D, 0xF3, 0xC7, 0x80, 0x3C, 0x01, 0xE1, 0xFF, 0x3F, 0xFB, 0xFF, 0x9E,
  0x3D, 0xF1, 0xEF, 0x8F, 0x7D, 0xF9, 0xFF, 0xCF, 0xFE, 0x3C, 0xF0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xEF, 0x07,
  0xFE, 0x3F, 0xF8, 0xFF, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF7,
  0xC3, 0xDE, 0x1F, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9F, 0xFE, 0xFF, 0xF3,
  0xDF, 0x8F, 0x3C, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF7, 0xFF, 0x78, 0xFF,
  0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x1E, 0xF1, 0xEF,
  0xFE, 0x7F, 0xC7, 0xF8, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0xCF, 0x1F, 0xFE, 0x3F, 0xF8, 0xFF,
  0xF1, 0xE3, 0xE7, 0xC3, 0xCF, 0x0F, 0x9E, 0x1E, 0x3C, 0x3C, 0x78, 0x78,
  0xF0, 0xF1, 0xE1, 0xE3, 0xC7, 0xC7, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F,
  0x78, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0xFC, 0xFF, 0xE7, 0x8F, 0x3C, 0x3B,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xBC, 0x01, 0xE0, 0x0F, 0x04, 0x7F,
  0xF1, 0xFF, 0x87, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x3F, 0x8F, 0xF1,
  0xF0, 0x3C, 0x1F, 0xE3, 0xFC, 0xFF, 0x87, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0,
  0x3C, 0x00, 0x07, 0x9E, 0x3F, 0xBC, 0x7F, 0xF1, 0xFF, 0xE3, 0xC3, 0xCF,
  0x87, 0x9E, 0x0F, 0x3C, 0x3E, 0x78, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3,
  0xC7, 0x87, 0x8F, 0xFF, 0x1F, 0xFC, 0x1F, 0xF8, 0x1E, 0xF0, 0x01, 0xE1,
  0x07, 0xC3, 0x9F, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x00,
  0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xEF, 0x07, 0xFE,
  0x3F, 0xF8, 0xFF, 0xE3, 0xC7, 0xCF, 0x1F, 0x3C, 0x79, 0xF1, 0xE7, 0x87,
  0x9E, 0x1E, 0x78, 0x79, 0xE3, 0xE7, 0x8F, 0xBE, 0x3C, 0xF0, 0xF3, 0xC3,
  0xCF, 0x0F, 0x00, 0x04, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x1E, 0x1E,
  0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78, 0x78,
  0x78, 0xF8, 0xF0, 0x00, 0x80, 0x3C, 0x0F, 0x80, 0xF0, 0x1C, 0x00, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0,
  0x1E, 0x03, 0xC3, 0xF8, 0x7E, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x8F, 0x8F, 0x3E,
  0x3E, 0xF8, 0x79, 0xF0, 0xF7, 0xC1, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF, 0x8F, 0x8F,
  0x1E, 0x1E, 0x3C, 0x3E, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E,
  0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x78,
  0x78, 0x78, 0xF8, 0xF0, 0x1E, 0xF1, 0xE0, 0xFF, 0xDF, 0x8F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xF3, 0xC7, 0xC7, 0x9E, 0x3C, 0x3C, 0xF1, 0xE1, 0xE7, 0x8F,
  0x0F, 0x7C, 0x78, 0xFB, 0xC3, 0xC7, 0x9E, 0x1E, 0x3C, 0xF1, 0xF1, 0xE7,
  0x8F, 0x0F, 0x3C, 0x78, 0x7B, 0xE3, 0xC7, 0xDE, 0x1E, 0x3C, 0xF0, 0xF1,
  0xE0, 0x1E, 0xF0, 0xFF, 0xE3, 0xFF, 0x8F, 0xFE, 0x3C, 0x7C, 0xF1, 0xF3,
  0xC7, 0x9F, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x3E, 0x78, 0xFB,
  0xE3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF0, 0x07, 0xC0, 0xFF, 0x0F, 0xFC,
  0xFF, 0xE7, 0x8F, 0xFC, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xFC,
  0x3D, 0xE1, 0xEF, 0x0F, 0x7F, 0xF1, 0xFF, 0x8F, 0xF8, 0x1F, 0x00, 0x0F,
  0x78, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87,
  0x9F, 0x0F, 0x3C, 0x1E, 0x78, 0x7C, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF,
  0xFF, 0x9F, 0xFE, 0x3D, 0xF8, 0x79, 0xE0, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0xFF, 0xE3, 0xFF,
  0x9F, 0xFE, 0x78, 0xFB, 0xE1, 0xEF, 0x0F, 0xBC, 0x3C, 0xF0, 0xF3, 0xC3,
  0xCF, 0x0F, 0x3C, 0x7C, 0xF1, 0xF3, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3D,
  0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x1E, 0xE3, 0xF8, 0xFF, 0x1F, 0xE3, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x00,
  0x07, 0xC0, 0xFF, 0x87, 0xFC, 0x7D, 0xF3, 0xC7, 0x9E, 0x00, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xEF, 0x0F, 0x7C, 0xF9, 0xFF,
  0x87, 0xF8, 0x1F, 0x00, 0x1E, 0x0F, 0x07, 0x8F, 0xFF, 0xF7, 0xF8, 0xF0,
  0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xF0, 0xFC, 0x3E,
  0x1F, 0x07, 0x80, 0x3C, 0x7D, 0xF1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x79,
  0xE1, 0xE7, 0x8F, 0xBE, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C,
  0xF1, 0xF3, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x3D, 0xE0, 0xF0, 0xFF, 0x1F,
  0xF1, 0xEF, 0x1E, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x78, 0xF7, 0x87, 0x70,
  0x7F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x00, 0xF1,
  0xC3, 0xFC, 0x71, 0xEF, 0x3C, 0x7B, 0xCF, 0x1E, 0xF7, 0xCF, 0x3D, 0xFB,
  0xCF, 0x7E, 0xE3, 0xFF, 0xF8, 0xFE, 0xFE, 0x3F, 0xBF, 0x0F, 0xCF, 0xC3,
  0xF3, 0xF0, 0xFC, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xC3, 0xC0, 0xF0,
  0xF0, 0x00, 0x1E, 0x3E, 0x3C, 0x78, 0x3D, 0xF0, 0x7B, 0xC0, 0xFF, 0x81,
  0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF,
  0x01, 0xEE, 0x07, 0x9E, 0x1F, 0x3C, 0x3C, 0x78, 0xF8, 0xF8, 0x1E, 0x1E,
  0x3C, 0x7C, 0x78, 0xF0, 0xF1, 0xE1, 0xE7, 0x83, 0xCF, 0x07, 0xBE, 0x0F,
  0x78, 0x1E, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF, 0x8F,
  0xFE, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0xFF, 0xE0,
  0x01, 0x81, 0xC1, 0xE1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F,
  0x07, 0x87, 0xC7, 0xC3, 0x81, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x01, 0x80, 0x0E, 0x1C, 0x38,
  0x70, 0xC1, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0xC1, 0x87, 0x0E, 0x1C, 0x38,
  0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC0, 0x0C, 0x07, 0x03, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38,
  0x1E, 0x07, 0x0F, 0x8F, 0x87, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1C, 0x1E, 0x1E, 0x0E, 0x06, 0x00, 0x1E, 0x00, 0x7E, 0x1D, 0xFE, 0x73,
  0xFF, 0xEF, 0x3F, 0xDC, 0x3F, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 22, 8, 1, -22 },
  { 21, 9, 8, 10, 2, -23 },
  { 30, 15, 22, 16, 1, -22 },
  { 72, 14, 28, 15, 1, -25 },
  { 121, 14, 22, 19, 3, -22 },
  { 160, 16, 22, 17, 0, -22 },
  { 204, 4, 8, 5, 2, -23 },
  { 208, 10, 32, 10, 1, -25 },
  { 248, 9, 31, 10, -1, -24 },
  { 283, 13, 13, 14, 2, -22 },
  { 305, 13, 16, 14, 1, -18 },
  { 331, 7, 9, 7, -2, -4 },
  { 339, 7, 4, 11, 2, -12 },
  { 343, 4, 5, 9, 1, -5 },
  { 346, 14, 24, 10, -2, -22 },
  { 388, 14, 22, 15, 1, -22 },
  { 427, 10, 22, 15, 3, -22 },
  { 455, 15, 22, 15, 0, -22 },
  { 497, 15, 22, 15, 0, -22 },
  { 539, 15, 22, 15, 0, -22 },
  { 581, 14, 22, 15, 1, -22 },
  { 620, 13, 22, 15, 1, -22 },
  { 656, 15, 22, 15, 1, -22 },
  { 698, 14, 22, 15, 1, -22 },
  { 737, 12, 22, 15, 2, -22 },
  { 770, 7, 17, 8, 1, -17 },
  { 785, 8, 22, 8, -1, -17 },
  { 807, 12, 15, 13, 1, -17 },
  { 830, 13, 11, 15, 1, -15 },
  { 848, 12, 15, 14, 1, -17 },
  { 871, 12, 22, 13, 2, -22 },
  { 904, 21, 28, 23, 1, -21 },
  { 978, 17, 22, 18, -1, -22 },
  { 1025, 16, 22, 17, 0, -22 },
  { 1069, 16, 22, 17, 1, -22 },
  { 1113, 16, 22, 17, 0, -22 },
  { 1157, 16, 22, 15, 0, -22 },
  { 1201, 16, 22, 14, 0, -22 },
  { 1245, 16, 22, 18, 1, -22 },
  { 1289, 19, 22, 18, 0, -22 },
  { 1342, 8, 22, 8, 0, -22 },
  { 1364, 15, 22, 15, 0, -22 },
  { 1406, 19, 22, 17, 0, -22 },
  { 1459, 13, 22, 14, 0, -22 },
  { 1495, 23, 22, 23, 0, -22 },
  { 1559, 19, 22, 18, 0, -22 },
  { 1612, 17, 22, 18, 1, -22 },
  { 1659, 17, 22, 17, 0, -22 },
  { 1706, 17, 26, 18, 1, -22 },
  { 1762, 17, 22, 17, 0, -22 },
  { 1809, 15, 22, 16, 1, -22 },
  { 1851, 16, 22, 16, 2, -22 },
  { 1895, 17, 22, 17, 1, -22 },
  { 1942, 17, 22, 17, 2, -22 },
  { 1989, 21, 22, 23, 3, -22 },
  { 2047, 19, 22, 17, -1, -22 },
  { 2100, 15, 22, 16, 3, -22 },
  { 2142, 17, 22, 16, 0, -22 },
  { 2189, 11, 31, 8, -1, -26 },
  { 2232, 8, 24, 11, 2, -22 },
  { 2256, 11, 31, 8, -2, -26 },
  { 2299, 10, 11, 12, 1, -22 },
  { 2313, 12, 3, 12, -2, 0 },
  { 2318, 7, 5, 10, 3, -24 },
  { 2323, 13, 17, 14, 0, -17 },
  { 2351, 14, 23, 15, 0, -23 },
  { 2392, 12, 17, 14, 1, -17 },
  { 2418, 15, 23, 15, 1, -23 },
  { 2462, 13, 17, 14, 1, -17 },
  { 2490, 11, 23, 10, 1, -23 },
  { 2522, 15, 23, 15, 0, -17 },
  { 2566, 14, 23, 15, 0, -23 },
  { 2607, 8, 24, 8, 0, -24 },
  { 2631, 11, 30, 7, -3, -24 },
  { 2673, 15, 23, 14, 0, -23 },
  { 2717, 8, 23, 8, 0, -23 },
  { 2740, 21, 17, 22, 0, -17 },
  { 2785, 14, 17, 15, 0, -17 },
  { 2815, 13, 17, 15, 1, -17 },
  { 2843, 15, 23, 15, -1, -17 },
  { 2887, 14, 23, 15, 1, -17 },
  { 2928, 11, 17, 10, 0, -17 },
  { 2952, 13, 17, 14, 0, -17 },
  { 2980, 9, 20, 9, 1, -20 },
  { 3003, 14, 17, 15, 1, -17 },
  { 3033, 12, 17, 13, 2, -17 },
  { 3059, 18, 17, 19, 2, -17 },
  { 3098, 15, 17, 14, -1, -17 },
  { 3130, 15, 23, 13, -1, -17 },
  { 3174, 14, 17, 14, 0, -17 },
  { 3204, 9, 29, 9, 1, -24 },
  { 3237, 7, 26, 8, 0, -22 },
  { 3260, 9, 30, 9, -1, -24 },
  { 3294, 15, 7, 17, 1, -13 },
};

const GFXfont RobotoCondensed_BoldItalic31pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic31pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic31pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _ROBOTOCONDENSED_BOLDITALIC31PT7B_H_
