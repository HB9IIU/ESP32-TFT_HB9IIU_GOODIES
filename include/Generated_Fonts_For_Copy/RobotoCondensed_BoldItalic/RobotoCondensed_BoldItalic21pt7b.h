#ifndef _ROBOTOCONDENSED_BOLDITALIC21PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC21PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x63, 0x8E, 0x38, 0xE3, 0x0C, 0x31, 0xC0, 0x00, 0x63, 0x86,
  0x00, 0x6D, 0xB6, 0xD3, 0xCB, 0x20, 0x06, 0x40, 0xD8, 0x1B, 0x02, 0x43,
  0xFE, 0x7F, 0xC2, 0x40, 0xD8, 0x1B, 0x0F, 0xF3, 0xFE, 0x1B, 0x02, 0x60,
  0xD8, 0x1B, 0x00, 0x06, 0x03, 0x07, 0x87, 0xE3, 0xBB, 0x9D, 0xCE, 0xE0,
  0x38, 0x1F, 0x03, 0xC0, 0xEC, 0x77, 0x3B, 0xBD, 0xFC, 0x3C, 0x18, 0x0C,
  0x00, 0x70, 0x3E, 0x0C, 0x9B, 0x26, 0xDB, 0x3F, 0x87, 0x40, 0x30, 0x1B,
  0x8D, 0xE3, 0xCD, 0xB3, 0xCC, 0x93, 0xE0, 0x70, 0x0F, 0x03, 0xF0, 0x76,
  0x0C, 0xC1, 0x98, 0x3E, 0x07, 0x80, 0xE7, 0x7E, 0xEF, 0xDB, 0x9F, 0x71,
  0xC7, 0x78, 0xFF, 0x8F, 0x70, 0x6D, 0xBD, 0x80, 0x04, 0x31, 0xC6, 0x30,
  0xC7, 0x18, 0x63, 0x8E, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x06, 0x18, 0x70,
  0x80, 0x10, 0x30, 0x30, 0x60, 0xC1, 0x83, 0x87, 0x0E, 0x1C, 0x38, 0x60,
  0xC1, 0x87, 0x0C, 0x18, 0x70, 0xC3, 0x0E, 0x10, 0x00, 0x0C, 0x06, 0x03,
  0x3F, 0x77, 0xF0, 0xE0, 0xF0, 0xCC, 0x44, 0x00, 0x0C, 0x1C, 0x1C, 0x1C,
  0xFF, 0xFF, 0xFF, 0x38, 0x38, 0x38, 0x30, 0x37, 0x76, 0xEC, 0xFF, 0xC0,
  0x6F, 0x60, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x38, 0x18,
  0x0C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x80, 0x1E, 0x1F, 0x8E, 0xEE,
  0x76, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0x73, 0xB9, 0xDC, 0xEE, 0xE3, 0xF1,
  0xE0, 0x06, 0x79, 0xF7, 0xE9, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xE1, 0xC3,
  0x06, 0x1C, 0x00, 0x0F, 0x07, 0xE3, 0x9C, 0xE7, 0x71, 0xC0, 0x70, 0x38,
  0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xEF, 0xF8, 0x0F, 0x07,
  0xE3, 0x9C, 0xE7, 0x01, 0xC0, 0xE0, 0xF0, 0x3C, 0x03, 0x80, 0xE0, 0x3B,
  0x8E, 0x77, 0x1F, 0xC3, 0xC0, 0x01, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x87,
  0xE1, 0xB8, 0xEE, 0x73, 0x19, 0xCF, 0xFB, 0xFE, 0x07, 0x01, 0xC0, 0x60,
  0x3F, 0x9F, 0xCC, 0x0E, 0x07, 0x03, 0xF1, 0xFC, 0xCE, 0x07, 0x03, 0x81,
  0xD8, 0xEE, 0xE7, 0xF1, 0xF0, 0x07, 0x1F, 0x3E, 0x38, 0x70, 0x6E, 0xFF,
  0xF7, 0xE3, 0xE3, 0xE7, 0xE7, 0xEF, 0x7E, 0x3C, 0x7F, 0xDF, 0xF0, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0x0E, 0x00, 0x1E, 0x1F, 0x9E, 0xEE, 0x77, 0x3B, 0xB8, 0xF8, 0xFC,
  0xE7, 0x73, 0xB1, 0xDC, 0xEE, 0xE7, 0xF1, 0xF0, 0x1E, 0x1F, 0x9D, 0xCE,
  0x76, 0x3F, 0x1F, 0x8E, 0xEE, 0x7F, 0x1F, 0x81, 0xC1, 0xC3, 0xC3, 0xC1,
  0xC0, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x67, 0x98, 0x1C, 0x71, 0xC0, 0x00,
  0x00, 0x00, 0x30, 0xC3, 0x1C, 0xE1, 0x00, 0x00, 0x81, 0xC3, 0xCF, 0xC7,
  0x83, 0x83, 0xF0, 0x3C, 0x0E, 0x01, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x0F,
  0xF7, 0xF8, 0x20, 0x1C, 0x0F, 0x83, 0xE0, 0x78, 0x7C, 0xFC, 0xF8, 0x70,
  0x40, 0x00, 0x1E, 0x7F, 0x77, 0xE7, 0x07, 0x0F, 0x1E, 0x1C, 0x38, 0x30,
  0x00, 0x00, 0x70, 0x70, 0x70, 0x01, 0xF0, 0x0F, 0xF0, 0x38, 0x30, 0xC0,
  0x21, 0x9E, 0x66, 0x7E, 0xCD, 0xD9, 0xB3, 0x33, 0x66, 0x66, 0xD8, 0xCD,
  0x33, 0x16, 0x66, 0x6C, 0xCC, 0xD9, 0xFF, 0x31, 0xDC, 0x30, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x3C, 0x07, 0xC0, 0x6E, 0x0E, 0xE0, 0xCE, 0x1C, 0xE1, 0xCE, 0x3F, 0xE3,
  0xFE, 0x70, 0x77, 0x07, 0xE0, 0x70, 0x1F, 0x87, 0xFC, 0xFF, 0x9C, 0x73,
  0x8E, 0x73, 0xCF, 0xF3, 0xFC, 0x71, 0xCE, 0x39, 0xC7, 0x38, 0xE6, 0x7D,
  0xFF, 0x3F, 0xC0, 0x0F, 0x87, 0xF8, 0xFF, 0x38, 0x77, 0x0F, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x87, 0x71, 0xCF, 0x78, 0xFE, 0x0F, 0x80,
  0x1F, 0x87, 0xF8, 0xFF, 0x1C, 0x73, 0x8E, 0x71, 0xCE, 0x3B, 0x87, 0x70,
  0xEE, 0x19, 0xC7, 0x38, 0xE6, 0x79, 0xFE, 0x3F, 0x80, 0x1F, 0xE7, 0xFC,
  0xFF, 0x9C, 0x03, 0x80, 0x70, 0x0F, 0xE3, 0xFC, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x06, 0x01, 0xFF, 0x3F, 0xE0, 0x1F, 0xE7, 0xF8, 0xFF, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0xFC, 0x7F, 0x8E, 0x01, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x38, 0x00, 0x0F, 0x87, 0xF8, 0xF7, 0x38, 0x77, 0x0E, 0xC0, 0x38,
  0x07, 0x3E, 0xE7, 0xDC, 0x3B, 0x87, 0x70, 0xEF, 0x78, 0xFF, 0x0F, 0x80,
  0x1C, 0x39, 0xC1, 0xCE, 0x0C, 0x70, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xCF,
  0xFE, 0x7F, 0xE3, 0x87, 0x1C, 0x38, 0xE1, 0xC6, 0x0E, 0x70, 0x73, 0x87,
  0x00, 0x1C, 0x63, 0x8E, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x1C, 0x73, 0x8E,
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0xEE, 0x3B, 0x9C, 0xFF, 0x1F, 0x83, 0xC0, 0x1C, 0x71, 0xC7, 0x8E,
  0x78, 0x73, 0x83, 0xB8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1C, 0xE0, 0xE7, 0x06, 0x38, 0x71, 0xE3, 0x87, 0x00, 0x1C, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x07,
  0xFB, 0xFC, 0x1C, 0x0F, 0x3E, 0x1F, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x36, 0x3E, 0x36, 0x7E, 0x76, 0x6E, 0x76, 0xEC, 0x76, 0xDC, 0x77, 0xDC,
  0x77, 0x9C, 0x67, 0x9C, 0xE3, 0x18, 0xE3, 0x38, 0x1C, 0x39, 0xE1, 0xCF,
  0x1C, 0x78, 0xE3, 0xE7, 0x1F, 0x38, 0xF9, 0xCE, 0xEE, 0x73, 0xE3, 0x9F,
  0x1C, 0xF8, 0xE7, 0xC6, 0x1E, 0x70, 0xE3, 0x87, 0x00, 0x0F, 0x83, 0xF8,
  0xFF, 0x38, 0x77, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xDC, 0x3B, 0x87,
  0x70, 0xEF, 0x78, 0xFE, 0x0F, 0x80, 0x1F, 0x83, 0xFE, 0x3F, 0xE3, 0x8E,
  0x38, 0x63, 0x8E, 0x30, 0xE7, 0x1E, 0x7F, 0xC7, 0xF8, 0x70, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x83, 0xF8, 0xFF, 0x38, 0x77, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xDC, 0x3B, 0x87, 0x70, 0xEF, 0x78, 0xFE,
  0x0F, 0xC0, 0x3C, 0x03, 0x80, 0x20, 0x1F, 0x87, 0xFC, 0xFF, 0x9C, 0x73,
  0x8E, 0x71, 0xCE, 0xF3, 0xFE, 0x7F, 0x0E, 0x71, 0xCE, 0x39, 0xC6, 0x39,
  0xC7, 0xB8, 0x70, 0x07, 0x83, 0xF8, 0xF7, 0x9C, 0x73, 0x8E, 0x70, 0x07,
  0x80, 0xFC, 0x07, 0x80, 0x3B, 0x87, 0x38, 0xE7, 0xB8, 0xFF, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x70, 0xEE, 0x1D, 0xC3, 0xB8,
  0x77, 0x1C, 0xE3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x33, 0x8E, 0x71, 0xCF,
  0xF8, 0xFE, 0x0F, 0x00, 0xE1, 0xFC, 0x3B, 0x87, 0x71, 0xCE, 0x39, 0xC7,
  0x39, 0xC3, 0x38, 0x6E, 0x0D, 0xC1, 0xB0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E,
  0x00, 0xE3, 0x1F, 0x9C, 0x7E, 0x71, 0xB9, 0xCE, 0xEF, 0x3B, 0xBC, 0xCE,
  0xF7, 0x3F, 0xDC, 0xFB, 0x63, 0xEF, 0x8F, 0xBE, 0x3C, 0xF0, 0xF3, 0xC3,
  0xCF, 0x0E, 0x3C, 0x00, 0x1C, 0x38, 0xE3, 0xC3, 0x9C, 0x1D, 0xC0, 0xEE,
  0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0x70, 0x7B, 0x83,
  0x9C, 0x3C, 0xF1, 0xC3, 0x80, 0xE1, 0xF8, 0xFE, 0x39, 0x9C, 0x67, 0x1F,
  0x87, 0xE0, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x00,
  0x3F, 0xF3, 0xFE, 0x3F, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0x1E,
  0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x87, 0x0C, 0x38,
  0x70, 0xE1, 0xC3, 0xC7, 0x80, 0xE7, 0x39, 0xCE, 0x71, 0x8E, 0x73, 0x9C,
  0xE7, 0x18, 0xE7, 0x1E, 0x3C, 0x38, 0x61, 0xC3, 0x87, 0x0E, 0x1C, 0x30,
  0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE3, 0xC7, 0x80, 0x1C, 0x38, 0xF1,
  0xE6, 0xDD, 0xB1, 0x80, 0xFF, 0xFF, 0xE3, 0x8C, 0x1E, 0x1F, 0x9E, 0xEE,
  0x73, 0xFB, 0xFB, 0x8D, 0xCE, 0xE7, 0x3F, 0x9F, 0xC0, 0x18, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xF8, 0xFE, 0xF7, 0x71, 0xB8, 0xDC, 0x6E, 0x76, 0x3F,
  0xBF, 0xFD, 0xDC, 0x1F, 0x1F, 0x9E, 0xEE, 0x77, 0x03, 0x03, 0x80, 0xC6,
  0x77, 0x3F, 0x0F, 0x00, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x3B,
  0x8F, 0xF3, 0xDC, 0x73, 0x8E, 0x71, 0x8E, 0x71, 0xCE, 0x38, 0xEE, 0x1F,
  0xC1, 0xF8, 0x1F, 0x1F, 0xCE, 0xEE, 0x37, 0xFB, 0xFD, 0x80, 0xC0, 0x73,
  0x3F, 0x8F, 0x80, 0x0E, 0x3C, 0xF1, 0xC3, 0x1F, 0xBF, 0x38, 0x70, 0xE1,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0x1D, 0xCF, 0xF7, 0xBD, 0xC6, 0x73, 0x98,
  0xE6, 0x39, 0x8E, 0x77, 0x9F, 0xC3, 0xF0, 0x1C, 0x4F, 0x3F, 0x87, 0xC0,
  0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xB8, 0xFE, 0xF7, 0x73, 0xB9, 0xDC,
  0xEC, 0x7E, 0x3F, 0x1B, 0x9D, 0xCE, 0x19, 0xC6, 0x03, 0x9C, 0xCE, 0x73,
  0x9C, 0xE6, 0x73, 0x80, 0x06, 0x1C, 0x18, 0x00, 0xE1, 0xC3, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0x87, 0x0E, 0x1C, 0x79, 0xE3, 0x80, 0x18, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x73, 0x39, 0xDC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x76, 0x39, 0xCE, 0x73, 0x9C, 0x1C, 0x63, 0x8E, 0x38, 0xE3, 0x8C, 0x71,
  0xC7, 0x1C, 0x71, 0x8E, 0x38, 0x37, 0x38, 0xFF, 0xF7, 0xBD, 0xDC, 0xE7,
  0x73, 0x9D, 0xCE, 0x77, 0x39, 0xD8, 0xC7, 0xE3, 0x1B, 0x9C, 0xEE, 0x73,
  0x80, 0x37, 0x1F, 0xDE, 0xEE, 0x77, 0x3B, 0x9D, 0x8E, 0xC7, 0xE3, 0x73,
  0xB9, 0xC0, 0x1F, 0x1F, 0xDE, 0xEE, 0x37, 0x1B, 0x0D, 0x8E, 0xC7, 0x77,
  0x3F, 0x8F, 0x00, 0x1B, 0x87, 0xF3, 0xDC, 0xE3, 0x38, 0xCE, 0x73, 0x9C,
  0xC7, 0x7B, 0xDF, 0xE7, 0x71, 0xC0, 0x60, 0x38, 0x0E, 0x00, 0x1D, 0xCF,
  0xF7, 0xB9, 0xCE, 0x73, 0x98, 0xEE, 0x3B, 0x8E, 0x77, 0x1F, 0xC3, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0x60, 0x36, 0x7D, 0xFB, 0x87, 0x0E, 0x1C, 0x30,
  0xE1, 0xC3, 0x80, 0x1E, 0x1F, 0x9C, 0xEE, 0x07, 0x81, 0xF0, 0x3D, 0xCE,
  0xE7, 0x3F, 0x0F, 0x00, 0x38, 0xC7, 0x3F, 0xF9, 0xC7, 0x18, 0xE3, 0x8E,
  0x38, 0xF1, 0xC0, 0x73, 0xB1, 0xF8, 0xDC, 0xEE, 0x77, 0x3B, 0x9D, 0x8E,
  0xEE, 0x7F, 0x1F, 0x80, 0xE7, 0x73, 0xB9, 0xDD, 0xC6, 0xE3, 0x61, 0xF0,
  0xF0, 0x78, 0x3C, 0x1C, 0x00, 0xE6, 0x3E, 0x67, 0xEE, 0x6E, 0xE6, 0xFF,
  0xEF, 0xBC, 0xFB, 0xCF, 0x3C, 0xF3, 0x87, 0x38, 0x63, 0x00, 0x39, 0xC3,
  0x38, 0x7E, 0x0F, 0xC0, 0xF0, 0x1C, 0x07, 0xC1, 0xF8, 0x3F, 0x0E, 0x61,
  0xCE, 0x00, 0x38, 0xE7, 0x38, 0xE7, 0x1D, 0xC1, 0xB8, 0x3E, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x3F,
  0xBF, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0x7F, 0xBF, 0x80,
  0x06, 0x1C, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x30, 0xE3, 0x83, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE0, 0xC0, 0x80, 0x18, 0xC4, 0x23, 0x18, 0xC6, 0x31,
  0x18, 0xC6, 0x31, 0x88, 0x46, 0x00, 0x10, 0x30, 0x70, 0x61, 0xC3, 0x87,
  0x0E, 0x1C, 0x1C, 0x70, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0xE3, 0x82, 0x00,
  0x30, 0xDE, 0x6F, 0xDB, 0x3E, 0xC7, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 15, 5, 0, -15 },
  { 13, 6, 6, 7, 1, -16 },
  { 18, 11, 15, 11, 0, -15 },
  { 39, 9, 19, 10, 1, -17 },
  { 61, 10, 15, 13, 2, -15 },
  { 80, 11, 15, 12, 0, -15 },
  { 101, 3, 6, 3, 1, -16 },
  { 104, 6, 22, 7, 1, -17 },
  { 121, 7, 22, 7, -1, -17 },
  { 141, 9, 9, 9, 1, -15 },
  { 152, 8, 11, 10, 1, -13 },
  { 163, 4, 6, 5, -1, -3 },
  { 166, 5, 2, 7, 1, -7 },
  { 168, 4, 3, 6, 0, -3 },
  { 170, 9, 16, 7, -1, -15 },
  { 188, 9, 15, 10, 1, -15 },
  { 205, 7, 15, 10, 2, -15 },
  { 219, 10, 15, 10, 0, -15 },
  { 238, 10, 15, 10, 0, -15 },
  { 257, 10, 15, 10, 0, -15 },
  { 276, 9, 15, 10, 1, -15 },
  { 293, 8, 15, 10, 1, -15 },
  { 308, 10, 15, 10, 1, -15 },
  { 327, 9, 15, 10, 1, -15 },
  { 344, 9, 15, 10, 1, -15 },
  { 361, 5, 11, 6, 0, -11 },
  { 368, 6, 14, 5, -1, -11 },
  { 379, 9, 10, 9, 0, -11 },
  { 391, 9, 6, 10, 1, -10 },
  { 398, 9, 10, 9, 0, -11 },
  { 410, 8, 15, 9, 1, -15 },
  { 425, 15, 20, 16, 0, -15 },
  { 463, 12, 15, 12, -1, -15 },
  { 486, 11, 15, 11, 0, -15 },
  { 507, 11, 15, 12, 1, -15 },
  { 528, 11, 15, 12, 0, -15 },
  { 549, 11, 15, 10, 0, -15 },
  { 570, 11, 15, 10, 0, -15 },
  { 591, 11, 15, 12, 1, -15 },
  { 612, 13, 15, 13, 0, -15 },
  { 637, 6, 15, 6, 0, -15 },
  { 649, 10, 15, 10, 0, -15 },
  { 668, 13, 15, 11, 0, -15 },
  { 693, 9, 15, 10, 0, -15 },
  { 710, 16, 15, 15, 0, -15 },
  { 740, 13, 15, 12, 0, -15 },
  { 765, 11, 15, 12, 1, -15 },
  { 786, 12, 15, 12, 0, -15 },
  { 809, 11, 18, 12, 1, -15 },
  { 834, 11, 15, 11, 0, -15 },
  { 855, 11, 15, 11, 0, -15 },
  { 876, 10, 15, 11, 2, -15 },
  { 895, 11, 15, 12, 1, -15 },
  { 916, 11, 15, 12, 2, -15 },
  { 937, 14, 15, 15, 2, -15 },
  { 964, 13, 15, 11, -1, -15 },
  { 989, 10, 15, 11, 2, -15 },
  { 1008, 12, 15, 11, 0, -15 },
  { 1031, 7, 20, 5, 0, -17 },
  { 1049, 5, 16, 8, 2, -15 },
  { 1059, 7, 20, 5, -1, -17 },
  { 1077, 7, 7, 8, 1, -15 },
  { 1084, 8, 2, 8, -1, 0 },
  { 1086, 5, 3, 7, 2, -16 },
  { 1088, 9, 11, 10, 0, -11 },
  { 1101, 9, 16, 10, 0, -16 },
  { 1119, 9, 11, 9, 0, -11 },
  { 1132, 11, 16, 10, 0, -16 },
  { 1154, 9, 11, 10, 0, -11 },
  { 1167, 7, 16, 7, 1, -16 },
  { 1181, 10, 15, 10, 0, -11 },
  { 1200, 9, 16, 10, 0, -16 },
  { 1218, 5, 15, 5, 0, -15 },
  { 1228, 7, 19, 5, -2, -15 },
  { 1245, 10, 16, 10, 0, -16 },
  { 1265, 6, 16, 5, 0, -16 },
  { 1277, 14, 11, 15, 0, -11 },
  { 1297, 9, 11, 10, 0, -11 },
  { 1310, 9, 11, 10, 0, -11 },
  { 1323, 10, 15, 10, -1, -11 },
  { 1342, 10, 15, 10, 0, -11 },
  { 1361, 7, 11, 7, 0, -11 },
  { 1371, 9, 11, 9, 0, -11 },
  { 1384, 6, 14, 6, 1, -14 },
  { 1395, 9, 11, 10, 1, -11 },
  { 1408, 9, 11, 9, 1, -11 },
  { 1421, 12, 11, 13, 1, -11 },
  { 1438, 11, 11, 9, -1, -11 },
  { 1454, 11, 15, 9, -1, -11 },
  { 1475, 9, 11, 9, 0, -11 },
  { 1488, 7, 20, 6, 0, -16 },
  { 1506, 5, 18, 5, 0, -15 },
  { 1518, 7, 20, 6, -1, -16 },
  { 1536, 10, 5, 11, 1, -9 },
};

const GFXfont RobotoCondensed_BoldItalic21pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic21pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _ROBOTOCONDENSED_BOLDITALIC21PT7B_H_
