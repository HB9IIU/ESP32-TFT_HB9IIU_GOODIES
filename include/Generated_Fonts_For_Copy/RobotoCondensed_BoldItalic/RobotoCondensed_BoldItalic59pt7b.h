#ifndef _ROBOTOCONDENSED_BOLDITALIC59PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x8F,
  0xC7, 0xC3, 0xF1, 0xF0, 0xF8, 0xFC, 0x3E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xE1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x87, 0xC7, 0xE3, 0xF1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0xF0, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8,
  0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x7C,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0x1F, 0xE0, 0x7F, 0x83,
  0xFC, 0x3F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF,
  0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0xFE,
  0x3F, 0xC0, 0x3F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01,
  0xFE, 0x3F, 0xE0, 0xFF, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF3, 0xE0, 0x10, 0x7E,
  0x3F, 0x03, 0x87, 0xC1, 0xF0, 0x7E, 0x7C, 0x1F, 0x07, 0xCF, 0xC1, 0xF0,
  0xF8, 0xFC, 0x3F, 0x1F, 0x8F, 0xC3, 0xF1, 0xF0, 0xF8, 0x3E, 0x3E, 0x0F,
  0xC3, 0xE7, 0xE0, 0xFC, 0x7E, 0x7C, 0x07, 0xEF, 0xEF, 0x80, 0x7F, 0xFD,
  0xF8, 0x03, 0xFF, 0xBF, 0x00, 0x3F, 0xFB, 0xE0, 0x00, 0xFE, 0x7C, 0x00,
  0x01, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x7F, 0x80, 0x07, 0xCF, 0xFC, 0x00, 0xFD, 0xFF,
  0xC0, 0x0F, 0xBF, 0xFE, 0x01, 0xF7, 0xF3, 0xE0, 0x3F, 0x7E, 0x3F, 0x03,
  0xE7, 0xC1, 0xF0, 0x7C, 0x7C, 0x1F, 0x0F, 0xCF, 0xC1, 0xF0, 0xF8, 0xFC,
  0x3F, 0x1F, 0x0F, 0x83, 0xF3, 0xE0, 0xF8, 0x3E, 0x7E, 0x0F, 0xC3, 0xE7,
  0xC0, 0xFC, 0x7E, 0x18, 0x07, 0xEF, 0xE0, 0x80, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xCF, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xE1, 0xFC,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x07, 0xE1,
  0xFF, 0xF8, 0x7F, 0x1F, 0xFF, 0xC3, 0xF8, 0xFF, 0xFF, 0x1F, 0xCF, 0xF7,
  0xF8, 0xFE, 0xFF, 0x1F, 0xEF, 0xE7, 0xF8, 0xFF, 0x7F, 0x7F, 0xC3, 0xFF,
  0xFB, 0xFC, 0x1F, 0xFF, 0x9F, 0xE0, 0x7F, 0xFC, 0xFF, 0x03, 0xFF, 0xC7,
  0xF8, 0x0F, 0xFE, 0x3F, 0xC0, 0x7F, 0xE1, 0xFF, 0x01, 0xFE, 0x07, 0xFC,
  0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFE, 0xFF, 0x00, 0xFF, 0xC7, 0xFC,
  0x00, 0x40, 0x00, 0x00, 0x1F, 0x8F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF8, 0xFC,
  0x7E, 0x3E, 0x3F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x04,
  0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x60, 0x3E,
  0x06, 0x3C, 0x1E, 0x1F, 0x3F, 0xCF, 0x3F, 0x9F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFB, 0xE0, 0x03,
  0xF9, 0xF8, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x0F, 0xC0,
  0x3C, 0x07, 0xC0, 0x0C, 0x01, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0xC3,
  0xF8, 0x3F, 0x87, 0xF0, 0xFE, 0x0F, 0xC0, 0x78, 0x01, 0x00, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x00,
  0x3F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7E, 0x08, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF1, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC,
  0x0F, 0xE0, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7,
  0xF0, 0x0F, 0xF1, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F,
  0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0x80,
  0x7F, 0x9F, 0xE0, 0x1F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE, 0x01, 0xFE, 0x7F,
  0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFC, 0x03, 0xFC,
  0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xE3, 0xFC, 0x03,
  0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0xC1, 0xFE,
  0x0F, 0xF0, 0x7F, 0xC7, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF,
  0x9F, 0xFF, 0xE7, 0xF7, 0xF1, 0xE3, 0xFC, 0x40, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xE3, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0x81, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xF0, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xE3,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87,
  0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00,
  0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0xC0, 0x07, 0xF7, 0xF8, 0x00, 0xFC, 0xFF,
  0x00, 0x3F, 0x9F, 0xE0, 0x0F, 0xE3, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x7F,
  0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFE, 0x0F, 0xF0,
  0x3F, 0x81, 0xFE, 0x07, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF0, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFE, 0x3F, 0xE0,
  0x0F, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0xC7, 0xF8, 0x0F,
  0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x7F, 0xC3, 0xFE, 0x0F, 0xF0, 0x3F,
  0xE7, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x9F, 0x80, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0x0F, 0xF9,
  0xFF, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x3F,
  0x9F, 0xE0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07,
  0xF9, 0xFC, 0x03, 0xFC, 0xFE, 0x01, 0xFE, 0x7F, 0x01, 0xFE, 0x3F, 0xC0,
  0xFF, 0x1F, 0xE0, 0xFF, 0x87, 0xF8, 0xFF, 0x83, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF1, 0xFE, 0x07,
  0xF8, 0x7F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F,
  0xC1, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0,
  0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F,
  0xF0, 0x3F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xF3, 0xFC, 0x3F, 0xC1, 0xFE, 0x3F,
  0xC1, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0x00, 0xFE, 0xFF,
  0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0xFF,
  0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFE, 0xFF,
  0x83, 0xFE, 0x7F, 0xCF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFB, 0xF8, 0x03, 0xE7, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xFE,
  0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x0F,
  0xC0, 0x08, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x0F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x80, 0x04, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x9F, 0xF1, 0xFF,
  0x7F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x1F, 0x00,
  0xFF, 0xC0, 0x78, 0x1F, 0x81, 0xFF, 0xF0, 0x3C, 0x1F, 0x81, 0xFF, 0xFC,
  0x1F, 0x0F, 0xC0, 0xFF, 0xFE, 0x0F, 0x87, 0xC0, 0xFE, 0x3F, 0x07, 0xC7,
  0xE0, 0xFE, 0x1F, 0x83, 0xE3, 0xE0, 0x7E, 0x0F, 0x81, 0xF3, 0xF0, 0x7E,
  0x07, 0xC0, 0xF9, 0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0xF8, 0x3F, 0x03, 0xF0,
  0x3E, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0x3E,
  0x0F, 0xC0, 0x7C, 0x0F, 0x9F, 0x07, 0xE0, 0x7E, 0x07, 0xCF, 0x83, 0xF0,
  0x3F, 0x03, 0xEF, 0xC1, 0xF8, 0x1F, 0x01, 0xF7, 0xE0, 0xFC, 0x0F, 0x80,
  0xF3, 0xF0, 0xFE, 0x0F, 0xC0, 0xF9, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0xF8,
  0x3F, 0x03, 0xE0, 0x3C, 0x7C, 0x1F, 0x83, 0xF0, 0x3E, 0x3E, 0x0F, 0xE1,
  0xF8, 0x1E, 0x1F, 0x03, 0xF1, 0xFC, 0x1F, 0x0F, 0x81, 0xFF, 0xFF, 0x1F,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xE0, 0x7F, 0xF7, 0xFF, 0x81, 0xF8,
  0x1F, 0xF3, 0xFF, 0x80, 0xFC, 0x07, 0xF0, 0xFF, 0x00, 0x3E, 0x00, 0x40,
  0x0C, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x02, 0x00, 0x00, 0x0F, 0xF0, 0x0F,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F,
  0xEF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0x7F,
  0x83, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x00, 0x07,
  0xF8, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0xC0, 0x00,
  0xFF, 0x7F, 0xC0, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0x03, 0xFF, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xE0, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x83, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x3F,
  0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xE0, 0xFF, 0x01,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xDF, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x1F, 0xE0, 0x01,
  0xFE, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F,
  0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x03, 0xFE,
  0x03, 0xFF, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01,
  0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8,
  0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x00,
  0xFF, 0x0F, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F,
  0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x7F,
  0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xCF, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F,
  0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF1, 0xFE,
  0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x9F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x1F,
  0xFF, 0x9F, 0xE0, 0x7F, 0xFE, 0x3F, 0xC0, 0xFF, 0xFC, 0x7F, 0x81, 0xFF,
  0xF8, 0xFF, 0x03, 0xFF, 0xF1, 0xFE, 0x07, 0xFF, 0xE3, 0xFC, 0x00, 0x7F,
  0xC7, 0xF8, 0x00, 0xFF, 0x8F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC,
  0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xF0, 0xFF, 0x00, 0x3F, 0xE1,
  0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F,
  0xC0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01,
  0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0x83, 0xFE, 0x03, 0xFC, 0x1F,
  0xF0, 0x3F, 0xE0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x80, 0xFF, 0xDF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x03, 0xFE,
  0x07, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xC0, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0x3F, 0xC1, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xC7, 0xFE,
  0x00, 0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x07, 0xF9,
  0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF0,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0x7E, 0x01,
  0xFF, 0xFC, 0x07, 0xF7, 0xE0, 0x3F, 0xBF, 0xC0, 0x7F, 0x7F, 0x03, 0xFB,
  0xF8, 0x0F, 0xF7, 0xF0, 0x3F, 0x7F, 0x80, 0xFF, 0x3F, 0x07, 0xF7, 0xF8,
  0x0F, 0xF3, 0xF0, 0x7E, 0x7F, 0x80, 0xFF, 0x3F, 0x0F, 0xE7, 0xF8, 0x0F,
  0xF3, 0xF0, 0xFC, 0x7F, 0x01, 0xFE, 0x3F, 0x1F, 0xCF, 0xF0, 0x1F, 0xE3,
  0xF1, 0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0x1F, 0x8F, 0xF0, 0x1F, 0xE3, 0xF3,
  0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0x3F, 0x1F, 0xF0, 0x1F, 0xE3, 0xF7, 0xF1,
  0xFE, 0x03, 0xFE, 0x1F, 0xFE, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0xE1, 0xFE,
  0x03, 0xFC, 0x1F, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0xC1, 0xFE, 0x03,
  0xFC, 0x1F, 0xF8, 0x3F, 0xE0, 0x3F, 0xC1, 0xFF, 0x83, 0xFC, 0x07, 0xFC,
  0x1F, 0xF8, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x07, 0xF8, 0x1F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xE0,
  0x7F, 0xC0, 0x7F, 0x80, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xC0, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xE0,
  0x1F, 0xF8, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x3F, 0xFC, 0x01,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xFC, 0x03, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0xC0, 0x3F, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xC0,
  0x7F, 0xFE, 0x03, 0xFC, 0x07, 0xFB, 0xE0, 0x7F, 0xC0, 0x7F, 0xBF, 0x07,
  0xF8, 0x07, 0xFB, 0xF0, 0x7F, 0x80, 0x7F, 0xBF, 0x07, 0xF8, 0x0F, 0xF9,
  0xF8, 0x7F, 0x80, 0xFF, 0x1F, 0x8F, 0xF8, 0x0F, 0xF1, 0xF8, 0xFF, 0x00,
  0xFF, 0x1F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFC, 0xFF, 0x01, 0xFF, 0x0F, 0xCF,
  0xF0, 0x1F, 0xF0, 0xFC, 0xFF, 0x01, 0xFE, 0x0F, 0xDF, 0xF0, 0x1F, 0xE0,
  0x7F, 0xFE, 0x01, 0xFE, 0x07, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0xFE, 0x03,
  0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xE0, 0x3F, 0xFE, 0x03, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0xC0, 0x3F, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xC0,
  0x1F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x07,
  0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0xFF,
  0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF,
  0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF,
  0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0,
  0x07, 0xFC, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00,
  0xFF, 0x83, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFC,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F,
  0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x01,
  0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0xFF,
  0x3F, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0x9F,
  0xF0, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0xC0, 0x07, 0xF8, 0x7F,
  0x80, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x83, 0xFE,
  0x03, 0xFF, 0x03, 0xFF, 0x9F, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x6F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01,
  0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x01,
  0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x03,
  0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F,
  0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x3F,
  0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xE7, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x1F,
  0xF0, 0x1F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0xF8,
  0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F,
  0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xFC,
  0x1F, 0xF0, 0x1F, 0xF0, 0x7F, 0xF3, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFF,
  0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFE,
  0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xFE,
  0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x03, 0xFC,
  0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xFC,
  0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8,
  0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF0,
  0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0,
  0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0,
  0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0x80, 0x3F, 0xC0,
  0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0x80, 0x03, 0xFE,
  0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x0F, 0xFC,
  0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x1F, 0xF0,
  0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xE0,
  0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x1F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0x7F, 0x80, 0x7F,
  0x80, 0x7F, 0xBF, 0xC0, 0x3F, 0xC0, 0x3F, 0xDF, 0xE0, 0x1F, 0xE0, 0x3F,
  0xCF, 0xF0, 0x1F, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF8, 0x0F, 0xF3, 0xFC,
  0x07, 0xFC, 0x0F, 0xF9, 0xFE, 0x07, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFF,
  0x03, 0xFC, 0x7F, 0x81, 0xFF, 0x81, 0xFE, 0x3F, 0xC1, 0xFF, 0xC1, 0xFE,
  0x1F, 0xE0, 0xFF, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0xF0, 0x7F, 0x87, 0xF8,
  0x7F, 0xF8, 0x7F, 0x83, 0xFC, 0x3F, 0xFC, 0x3F, 0xC1, 0xFE, 0x1F, 0xFE,
  0x1F, 0xE0, 0xFF, 0x1F, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xFF, 0x8F, 0xF0,
  0x1F, 0xC7, 0xEF, 0xC7, 0xF8, 0x0F, 0xE7, 0xF7, 0xE7, 0xF8, 0x07, 0xF3,
  0xFB, 0xF3, 0xFC, 0x03, 0xF9, 0xF9, 0xF9, 0xFE, 0x01, 0xFD, 0xFC, 0xFC,
  0xFE, 0x00, 0xFE, 0xFE, 0x7E, 0xFF, 0x00, 0x7F, 0x7E, 0x3F, 0x7F, 0x80,
  0x3F, 0xFF, 0x1F, 0xBF, 0x80, 0x1F, 0xFF, 0x8F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x87, 0xFF, 0xE0, 0x07, 0xFF, 0xC3, 0xFF, 0xE0, 0x03, 0xFF, 0xC1, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x1F, 0xFC,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x01, 0xFE,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x07,
  0xFC, 0xFF, 0x80, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0x03, 0xFE, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x1F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x07,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0x9F, 0xE0, 0x07, 0xFC, 0x7F, 0x80,
  0x1F, 0xE1, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x0F, 0xF0,
  0x07, 0xF0, 0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x01,
  0xFE, 0x3F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x07,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x07, 0xF0,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE,
  0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xE7, 0xC0, 0x7E, 0x7C, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C,
  0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0x3E, 0xFE, 0x03, 0xF0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFC, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0x87, 0xF8, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x8F, 0xFC, 0x3F, 0x8F, 0xF8, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC,
  0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x83, 0xFC, 0x3F,
  0xC3, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xE3, 0xF8, 0x00, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x82, 0x00, 0x0F, 0xF7, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFE, 0x3F, 0xE0, 0xFF, 0x03, 0xFC,
  0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x07, 0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xE0,
  0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1,
  0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x01,
  0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x3F,
  0xE0, 0x3F, 0xC7, 0xFC, 0x0F, 0xF0, 0xFF, 0xC3, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xEF, 0xFF, 0x83, 0xFC,
  0xFF, 0xE0, 0x7F, 0x0F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xE0, 0xFF,
  0x3F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x83, 0xFC,
  0x7F, 0xC7, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0x8F, 0xF0, 0x0F, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xE3, 0xFF,
  0x83, 0xFE, 0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F,
  0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0,
  0x1F, 0xC0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F,
  0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x07,
  0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x0F, 0xF8,
  0x3F, 0xE0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F, 0xE1, 0xFE, 0x1F, 0xE0, 0x7F,
  0x0F, 0xE0, 0x3F, 0xCF, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xF8, 0x07,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x20, 0x7F,
  0x80, 0x70, 0x3F, 0xF0, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xF2, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0xFF,
  0xE7, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xC7, 0xFE, 0x1F, 0xF0, 0x3F, 0xE1, 0xFE,
  0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x3F, 0xC0, 0x3F,
  0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F,
  0xC0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07,
  0xF8, 0x7F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x83,
  0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFF, 0x3F, 0xF0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x41, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x03, 0x00, 0x3F, 0xC0, 0x38, 0x07, 0xFC,
  0x07, 0xFB, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xE3, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x0F,
  0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8,
  0x0F, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F,
  0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0xFF,
  0x0F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80,
  0xFF, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF,
  0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF0,
  0x00, 0x30, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0x7E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0xE0, 0xFF, 0xC0, 0xFF, 0x07, 0xFC,
  0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0x87, 0xFC, 0x03, 0xFC, 0x7F, 0xE0, 0x1F,
  0xE7, 0xFE, 0x00, 0xFF, 0x3F, 0xE0, 0x07, 0xFB, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x01, 0xFF, 0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0xFF, 0x0F, 0xF0,
  0x07, 0xF8, 0x7F, 0xC0, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x0F,
  0xF0, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0,
  0x7F, 0xC1, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x1F,
  0xFC, 0x07, 0xFF, 0xFF, 0xBF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0xFF,
  0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0,
  0x3F, 0x80, 0xFF, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x7F, 0x80,
  0xFE, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x3F,
  0xC0, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x3F, 0xC0, 0xFF,
  0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x7F, 0x80,
  0xFE, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x03,
  0xF8, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0xFF,
  0x01, 0xFE, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFC,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x7F, 0x7F, 0xF0,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x3F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0xC3, 0xFC, 0x0F, 0xF1, 0xFE,
  0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xE1,
  0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F,
  0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0,
  0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F,
  0xE0, 0x3F, 0x87, 0xF8, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE,
  0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xC3, 0xFE,
  0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x00,
  0xFE, 0x7F, 0x80, 0x3F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF8, 0x07, 0xF9, 0xFE,
  0x01, 0xFE, 0x7F, 0x80, 0x7F, 0x9F, 0xE0, 0x1F, 0xEF, 0xF0, 0x07, 0xFB,
  0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0xC0, 0x3F, 0xC7, 0xF0, 0x0F,
  0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x1F, 0xF1, 0xFF, 0x83, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x7F, 0x7F, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xE3, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x03, 0xFC, 0x03,
  0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0,
  0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0x83, 0xFC, 0x03,
  0xFC, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0xC3, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xEF, 0xFF, 0x80, 0xFF,
  0x3F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x3F, 0xC0, 0x80, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x0F, 0xFE, 0x7F,
  0x83, 0xFF, 0xEF, 0xE0, 0xFF, 0xFD, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF0, 0xFF, 0x87, 0xFE, 0x3F, 0xE0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF0,
  0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x00,
  0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x1F,
  0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0, 0x0F,
  0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF,
  0x81, 0xFE, 0x0F, 0xF8, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x87, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xBF,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE3,
  0xFC, 0x07, 0xF1, 0xFE, 0x03, 0xF8, 0xFF, 0x01, 0xFC, 0x3F, 0x81, 0xFE,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F,
  0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x02, 0x00,
  0x1F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0x01,
  0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3, 0xFC, 0x07, 0xF8, 0xFF,
  0x01, 0xFE, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF1,
  0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xE0, 0x3F, 0x87, 0xF8, 0x1F,
  0xE3, 0xFC, 0x07, 0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0,
  0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x1F, 0xF0, 0xFF, 0x8F, 0xFC, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x01, 0xFE, 0x7F, 0x80, 0x0C, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFE, 0xFF, 0x03, 0xFC, 0x7F,
  0x03, 0xFC, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x7F,
  0x0F, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0x8F, 0xE0, 0x7F, 0x9F, 0xE0, 0x7F,
  0x9F, 0xC0, 0x3F, 0x9F, 0xC0, 0x3F, 0xBF, 0xC0, 0x3F, 0xBF, 0x80, 0x3F,
  0xBF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x03, 0xF0, 0x1F, 0xFF, 0xE0, 0x7E,
  0x03, 0xFB, 0xFC, 0x0F, 0xC0, 0xFF, 0x3F, 0x83, 0xF8, 0x1F, 0xC7, 0xF0,
  0x7F, 0x83, 0xF8, 0xFE, 0x1F, 0xF0, 0xFF, 0x1F, 0xC3, 0xFE, 0x1F, 0xC3,
  0xF8, 0x7F, 0xC3, 0xF8, 0x7F, 0x1F, 0xF8, 0xFF, 0x0F, 0xE3, 0xFF, 0x1F,
  0xC1, 0xFC, 0xFF, 0xE3, 0xF8, 0x3F, 0x9F, 0xFC, 0xFE, 0x07, 0xF7, 0xFF,
  0x9F, 0xC0, 0xFE, 0xFF, 0xF3, 0xF8, 0x1F, 0xDF, 0xFE, 0xFE, 0x03, 0xFF,
  0xEF, 0xDF, 0xC0, 0x7F, 0xFC, 0xFB, 0xF8, 0x0F, 0xFF, 0x9F, 0xFE, 0x01,
  0xFF, 0xE3, 0xFF, 0xC0, 0x3F, 0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0x0F, 0xFE,
  0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x0F,
  0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xFC, 0x03, 0xF8, 0x3F, 0xC0,
  0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x07, 0xF9, 0xFE, 0x00, 0x1F,
  0xDF, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0xFF, 0x3F, 0x80,
  0x0F, 0xF1, 0xFC, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F,
  0xC3, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x83, 0xFE, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x7F,
  0x80, 0x3F, 0x83, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0,
  0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x03,
  0xFC, 0xFF, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x7F,
  0x7F, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x40, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x00,
  0x01, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x0F, 0xFC,
  0x03, 0xF1, 0xFF, 0xE0, 0x7E, 0x3F, 0xFF, 0x07, 0xE3, 0xFF, 0xF8, 0xFE,
  0x7F, 0xFF, 0xFF, 0xE7, 0xF1, 0xFF, 0xFC, 0x7E, 0x0F, 0xFF, 0xCF, 0xC0,
  0x7F, 0xF8, 0xFC, 0x07, 0xFF, 0x0F, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xFC,
  0x00,
};

const GFXglyph RobotoCondensed_BoldItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 15, 43, 15, 1, -42 },
  { 82, 18, 16, 18, 3, -44 },
  { 118, 30, 42, 30, 1, -42 },
  { 276, 26, 56, 29, 2, -49 },
  { 458, 28, 44, 37, 5, -43 },
  { 612, 29, 44, 33, 1, -43 },
  { 772, 9, 16, 9, 3, -44 },
  { 790, 18, 60, 18, 3, -47 },
  { 925, 19, 60, 19, -3, -47 },
  { 1068, 25, 26, 26, 3, -42 },
  { 1150, 24, 31, 27, 2, -35 },
  { 1243, 12, 18, 14, -3, -7 },
  { 1270, 15, 7, 21, 3, -22 },
  { 1284, 9, 9, 17, 1, -8 },
  { 1295, 26, 46, 19, -4, -42 },
  { 1445, 26, 44, 29, 2, -43 },
  { 1588, 18, 42, 29, 6, -42 },
  { 1683, 28, 43, 29, 0, -43 },
  { 1834, 27, 44, 29, 1, -43 },
  { 1983, 27, 42, 29, 1, -42 },
  { 2125, 27, 43, 29, 2, -42 },
  { 2271, 25, 43, 29, 2, -42 },
  { 2406, 28, 42, 29, 2, -42 },
  { 2553, 26, 44, 29, 2, -43 },
  { 2696, 24, 43, 29, 4, -43 },
  { 2825, 14, 33, 16, 1, -32 },
  { 2883, 17, 43, 15, -3, -32 },
  { 2975, 24, 28, 26, 1, -32 },
  { 3059, 25, 20, 29, 2, -29 },
  { 3122, 24, 28, 26, 1, -32 },
  { 3206, 22, 44, 26, 4, -43 },
  { 3327, 41, 54, 44, 1, -41 },
  { 3604, 33, 42, 34, -3, -42 },
  { 3778, 31, 42, 32, 0, -42 },
  { 3941, 31, 44, 33, 2, -43 },
  { 4112, 31, 42, 32, 0, -42 },
  { 4275, 31, 42, 28, 0, -42 },
  { 4438, 30, 42, 27, 0, -42 },
  { 4596, 31, 44, 34, 2, -43 },
  { 4767, 36, 42, 35, 0, -42 },
  { 4956, 15, 42, 15, 1, -42 },
  { 5035, 29, 43, 28, 0, -42 },
  { 5191, 36, 42, 32, 0, -42 },
  { 5380, 24, 42, 27, 0, -42 },
  { 5506, 44, 42, 43, 0, -42 },
  { 5737, 36, 42, 35, 0, -42 },
  { 5926, 31, 44, 35, 2, -43 },
  { 6097, 33, 42, 33, 0, -42 },
  { 6271, 31, 51, 35, 2, -43 },
  { 6469, 32, 42, 32, 0, -42 },
  { 6637, 30, 44, 31, 1, -43 },
  { 6802, 30, 42, 31, 4, -42 },
  { 6960, 32, 43, 33, 2, -42 },
  { 7132, 32, 42, 33, 5, -42 },
  { 7300, 41, 42, 43, 5, -42 },
  { 7516, 37, 42, 32, -2, -42 },
  { 7711, 30, 42, 31, 5, -42 },
  { 7869, 34, 42, 30, -1, -42 },
  { 8048, 20, 59, 15, -1, -49 },
  { 8196, 14, 46, 22, 5, -42 },
  { 8277, 20, 59, 15, -3, -49 },
  { 8425, 20, 21, 22, 2, -42 },
  { 8478, 23, 7, 23, -4, 0 },
  { 8499, 12, 9, 19, 6, -44 },
  { 8513, 25, 33, 27, 0, -32 },
  { 8617, 27, 45, 28, 0, -44 },
  { 8769, 24, 33, 26, 1, -32 },
  { 8868, 29, 45, 28, 1, -44 },
  { 9032, 25, 33, 27, 1, -32 },
  { 9136, 21, 45, 19, 2, -45 },
  { 9255, 28, 44, 29, 0, -32 },
  { 9409, 26, 44, 28, 0, -44 },
  { 9552, 15, 44, 14, 0, -44 },
  { 9635, 21, 56, 14, -6, -44 },
  { 9782, 29, 44, 27, 0, -44 },
  { 9942, 16, 44, 14, 0, -44 },
  { 10030, 40, 32, 42, 0, -32 },
  { 10190, 26, 32, 28, 0, -32 },
  { 10294, 26, 33, 28, 1, -32 },
  { 10402, 29, 44, 28, -2, -32 },
  { 10562, 27, 44, 28, 1, -32 },
  { 10711, 20, 32, 19, 0, -32 },
  { 10791, 25, 33, 26, 0, -32 },
  { 10895, 17, 40, 18, 2, -39 },
  { 10980, 26, 32, 28, 2, -31 },
  { 11084, 24, 31, 26, 3, -31 },
  { 11177, 35, 31, 36, 3, -31 },
  { 11313, 29, 31, 26, -2, -31 },
  { 11426, 30, 43, 26, -2, -31 },
  { 11588, 27, 31, 26, -1, -31 },
  { 11693, 18, 56, 17, 1, -46 },
  { 11819, 13, 50, 14, 1, -42 },
  { 11901, 18, 56, 17, -2, -46 },
  { 12027, 28, 13, 32, 2, -24 },
};

const GFXfont RobotoCondensed_BoldItalic59pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic59pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic59pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _ROBOTOCONDENSED_BOLDITALIC59PT7B_H_
