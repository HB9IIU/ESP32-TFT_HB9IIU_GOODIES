#ifndef _ROBOTOCONDENSED_BOLDITALIC17PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x63, 0x31, 0x8C, 0x02, 0x38, 0x80, 0x5A, 0xF7, 0xA9,
  0x00, 0x0D, 0x06, 0x82, 0xC3, 0x43, 0xF8, 0xB0, 0xD1, 0xFE, 0x2C, 0x14,
  0x1A, 0x0B, 0x00, 0x04, 0x04, 0x1E, 0x3F, 0x33, 0x33, 0x30, 0x3C, 0x1E,
  0x06, 0x66, 0x66, 0x7E, 0x3C, 0x10, 0x10, 0x30, 0x78, 0x4B, 0x5A, 0x5C,
  0x7C, 0x1F, 0x1D, 0x2D, 0x69, 0x4F, 0x06, 0x1E, 0x0F, 0x0C, 0xC6, 0xC3,
  0xE0, 0xE1, 0xE6, 0xDE, 0xEF, 0x73, 0x9F, 0xC7, 0x60, 0x5F, 0xC0, 0x08,
  0xCC, 0xC6, 0x33, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x08, 0x40, 0x10, 0x61,
  0x82, 0x08, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x30, 0xC6, 0x38, 0x80, 0x18,
  0x33, 0x5B, 0xE3, 0x8D, 0x12, 0x00, 0x0C, 0x1C, 0x18, 0x7E, 0x7E, 0x18,
  0x38, 0x30, 0x36, 0x66, 0xC0, 0xFF, 0x5D, 0x80, 0x02, 0x0C, 0x10, 0x60,
  0x83, 0x06, 0x18, 0x30, 0xC1, 0x82, 0x0C, 0x00, 0x3C, 0xFD, 0x9F, 0x3C,
  0x78, 0xF3, 0xE7, 0xCD, 0x9B, 0xE3, 0x80, 0x1B, 0xFF, 0x63, 0x18, 0xCE,
  0x73, 0x18, 0xC0, 0x1E, 0x3F, 0x33, 0x63, 0x07, 0x06, 0x0C, 0x18, 0x38,
  0x70, 0xFE, 0xFE, 0x1E, 0x3F, 0x73, 0x03, 0x07, 0x1E, 0x1E, 0x06, 0x06,
  0xE6, 0x7E, 0x78, 0x07, 0x07, 0x0F, 0x1E, 0x36, 0x36, 0x66, 0xFF, 0xFE,
  0x0C, 0x0C, 0x0C, 0x1F, 0x3F, 0x30, 0x30, 0x3C, 0x7E, 0x06, 0x06, 0x66,
  0x66, 0x7E, 0x38, 0x0C, 0x79, 0xC3, 0x0F, 0xDF, 0xB3, 0xE7, 0xCF, 0x9B,
  0xF3, 0xC0, 0x7F, 0xFF, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60,
  0x60, 0xC0, 0x1E, 0x3F, 0x33, 0x33, 0x37, 0x3E, 0x3E, 0x66, 0x66, 0x66,
  0x7E, 0x3C, 0x3C, 0xF9, 0x9F, 0x3C, 0x7D, 0xFF, 0xBE, 0x0C, 0x31, 0xE3,
  0x00, 0x23, 0x30, 0x00, 0x04, 0xE6, 0x11, 0xC6, 0x00, 0x00, 0x00, 0x31,
  0x98, 0xC4, 0x00, 0x02, 0x1C, 0xF3, 0x8E, 0x0F, 0x87, 0x02, 0x7F, 0xF8,
  0x07, 0xEF, 0xC0, 0x20, 0xE0, 0xF0, 0x71, 0xEF, 0x9C, 0x40, 0x38, 0xFB,
  0xB0, 0x61, 0xC7, 0x0C, 0x30, 0x00, 0x81, 0x83, 0x00, 0x07, 0xC0, 0xC6,
  0x18, 0x23, 0x03, 0x23, 0x96, 0x69, 0x4D, 0x94, 0x9B, 0xD9, 0x3D, 0x92,
  0xDB, 0x6C, 0xDC, 0x40, 0x06, 0x00, 0x76, 0x01, 0xE0, 0x03, 0x01, 0xC0,
  0x78, 0x3E, 0x0D, 0x87, 0x61, 0x98, 0xE6, 0x3F, 0x9F, 0xE6, 0x1D, 0x87,
  0x3F, 0x1F, 0xCC, 0xE6, 0x37, 0x3B, 0xF9, 0xFC, 0xC6, 0x63, 0x33, 0xBF,
  0xDF, 0x80, 0x1E, 0x3F, 0x63, 0xE3, 0xE0, 0xC0, 0xC0, 0xC0, 0xC7, 0xC6,
  0xFE, 0x78, 0x3E, 0x1F, 0x8C, 0xE6, 0x37, 0x1B, 0x9D, 0x8E, 0xC6, 0x63,
  0x33, 0xBF, 0x9F, 0x80, 0x3F, 0x9F, 0xCC, 0x06, 0x07, 0x03, 0xF1, 0xF8,
  0xC0, 0x60, 0x30, 0x3F, 0x9F, 0xC0, 0x3F, 0x9F, 0x8C, 0x06, 0x07, 0x03,
  0xF1, 0xF8, 0xC0, 0x60, 0x30, 0x38, 0x1C, 0x00, 0x1E, 0x1F, 0x98, 0xDC,
  0x6E, 0x06, 0x7B, 0x3D, 0x8E, 0xC7, 0x63, 0xBF, 0x8F, 0x80, 0x30, 0xCC,
  0x33, 0x0C, 0xC7, 0x71, 0xDF, 0xE7, 0xF9, 0x86, 0x61, 0x98, 0xEE, 0x3B,
  0x8C, 0x39, 0x8C, 0x67, 0x39, 0xCC, 0x63, 0x39, 0xC0, 0x03, 0x03, 0x03,
  0x07, 0x07, 0x06, 0x06, 0x06, 0xC6, 0xEE, 0x7C, 0x78, 0x31, 0xCC, 0xE3,
  0x30, 0xDC, 0x7E, 0x1F, 0x07, 0xC1, 0xF8, 0x66, 0x19, 0x8E, 0x73, 0x9C,
  0x30, 0x60, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0xFF, 0xF0, 0x38,
  0x79, 0xC3, 0xCE, 0x1C, 0x79, 0xE7, 0xCF, 0x36, 0xD9, 0xB7, 0xCD, 0xEC,
  0x6F, 0x63, 0x73, 0x3B, 0x99, 0xC9, 0xC0, 0x38, 0xCE, 0x33, 0x8C, 0xE7,
  0x7D, 0xDF, 0x66, 0x59, 0x96, 0x67, 0x99, 0xEE, 0x3B, 0x8C, 0x1E, 0x1F,
  0x98, 0xDC, 0x7E, 0x3E, 0x1B, 0x0D, 0x86, 0xC7, 0x63, 0x3F, 0x8F, 0x80,
  0x3F, 0x1F, 0xCC, 0x66, 0x37, 0x1B, 0x9D, 0xFC, 0xFC, 0x60, 0x30, 0x38,
  0x1C, 0x00, 0x1E, 0x1F, 0x98, 0xDC, 0x7E, 0x3E, 0x1B, 0x0D, 0x86, 0xC7,
  0x63, 0x3F, 0x8F, 0x80, 0xE0, 0x20, 0x3F, 0x1F, 0xCC, 0xE6, 0x37, 0x1B,
  0x9D, 0xFC, 0xFC, 0x66, 0x33, 0x39, 0xDC, 0xE0, 0x1E, 0x1F, 0x8C, 0xE6,
  0x33, 0x01, 0xE0, 0x38, 0x0E, 0xE3, 0x33, 0x9F, 0x87, 0x80, 0x7F, 0xFF,
  0xC6, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x00,
  0x63, 0xB1, 0xD8, 0xDC, 0x6E, 0x37, 0x3B, 0x1D, 0x8E, 0xC6, 0x63, 0x3F,
  0x0F, 0x00, 0xE1, 0xB8, 0xE6, 0x31, 0x9C, 0x67, 0x19, 0x86, 0xE1, 0xB0,
  0x6C, 0x1E, 0x03, 0x80, 0xC0, 0x66, 0x36, 0x67, 0x6E, 0x66, 0xE6, 0x6E,
  0xE7, 0xAC, 0x7A, 0xC7, 0xBC, 0x73, 0x87, 0x38, 0x73, 0x86, 0x30, 0x18,
  0xE3, 0x38, 0x77, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xF8, 0x1B, 0x07,
  0x61, 0xCE, 0x39, 0xC0, 0x63, 0xB1, 0x99, 0xCC, 0xC7, 0xC1, 0xE0, 0xE0,
  0x70, 0x30, 0x18, 0x0C, 0x0E, 0x00, 0x3F, 0x9F, 0xC0, 0xC0, 0xE0, 0xE0,
  0x60, 0x60, 0x70, 0x70, 0x30, 0x3F, 0xDF, 0xC0, 0x39, 0xCC, 0x63, 0x39,
  0xCC, 0x63, 0x18, 0xCE, 0x63, 0x1C, 0xE0, 0xE6, 0x66, 0x66, 0x77, 0x33,
  0x33, 0x30, 0x1C, 0xF1, 0x86, 0x18, 0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x31,
  0xC7, 0x38, 0xE0, 0x31, 0x9E, 0xFD, 0xEC, 0xFD, 0xF8, 0xCD, 0x80, 0x1C,
  0xFD, 0x98, 0x33, 0xED, 0xF3, 0xFE, 0x7C, 0x30, 0x30, 0x30, 0x30, 0x7E,
  0x7E, 0x67, 0x67, 0x67, 0x66, 0xE6, 0xFE, 0xDC, 0x1C, 0xFD, 0x9B, 0x0E,
  0x1C, 0x3B, 0xBE, 0x38, 0x03, 0x81, 0x80, 0xC0, 0x63, 0xB3, 0xF9, 0x9C,
  0xCC, 0xE6, 0x73, 0x39, 0x8F, 0xC7, 0xE0, 0x1C, 0x7D, 0x9B, 0xF7, 0xFC,
  0x18, 0x3F, 0x3C, 0x0C, 0x73, 0x8C, 0x7D, 0xE3, 0x1C, 0x71, 0x86, 0x18,
  0x60, 0x3B, 0x7F, 0x67, 0x67, 0xE6, 0xE6, 0xE6, 0x7E, 0x7E, 0x0C, 0xFC,
  0x78, 0x30, 0x60, 0xC1, 0x87, 0xEF, 0xD9, 0xB3, 0x66, 0xCF, 0x9E, 0x7C,
  0xE0, 0x03, 0x30, 0x37, 0x66, 0x66, 0x6E, 0xC0, 0x00, 0x30, 0xC0, 0x0C,
  0x71, 0x86, 0x18, 0x63, 0x8E, 0x30, 0xCF, 0x38, 0x30, 0x30, 0x30, 0x30,
  0x77, 0x7E, 0x6C, 0x78, 0x78, 0x7C, 0xEC, 0xCC, 0xCE, 0x31, 0x8C, 0x63,
  0x39, 0x8C, 0x63, 0x19, 0xCC, 0x00, 0x7E, 0xE7, 0xFE, 0x67, 0x76, 0x66,
  0x66, 0x66, 0x66, 0xE6, 0x6E, 0xE6, 0xCC, 0xE0, 0x7E, 0xFD, 0x9B, 0x36,
  0x6C, 0xF9, 0xE7, 0xCE, 0x1C, 0x3E, 0x67, 0x67, 0xE7, 0xE6, 0x66, 0x7C,
  0x38, 0x3F, 0x1F, 0x8C, 0xE6, 0x73, 0x39, 0x99, 0xCC, 0xFE, 0x6E, 0x30,
  0x18, 0x1C, 0x00, 0x3B, 0x7F, 0x67, 0x66, 0xE6, 0xE6, 0xE6, 0x7E, 0x7E,
  0x0C, 0x0C, 0x0C, 0x7D, 0xF7, 0x18, 0x61, 0x8E, 0x30, 0xC0, 0x3C, 0xFD,
  0x9B, 0x83, 0xC3, 0xB3, 0x7E, 0x78, 0x66, 0xFF, 0x6E, 0xCC, 0xCE, 0xE0,
  0x73, 0x67, 0x67, 0x66, 0x66, 0x66, 0xE6, 0x7E, 0x7E, 0xCF, 0x9B, 0x36,
  0xCD, 0x9F, 0x1C, 0x38, 0x60, 0xCD, 0xF7, 0x6D, 0xDB, 0x76, 0xFF, 0x3F,
  0xCE, 0xE3, 0x98, 0xC6, 0x00, 0x33, 0x9D, 0x87, 0x83, 0xC1, 0xC0, 0xE0,
  0xD8, 0xEC, 0x66, 0x00, 0x67, 0x66, 0x6E, 0x6C, 0x6C, 0x78, 0x38, 0x30,
  0x30, 0x60, 0xE0, 0xC0, 0x7E, 0xFC, 0x30, 0xE3, 0x86, 0x18, 0x7E, 0xFC,
  0x08, 0x61, 0x8C, 0x30, 0xC3, 0x18, 0xE1, 0x86, 0x18, 0x61, 0x86, 0x08,
  0x33, 0x32, 0x22, 0x66, 0x64, 0x44, 0x4C, 0x10, 0x61, 0x86, 0x18, 0x61,
  0x87, 0x1C, 0xC3, 0x0C, 0x31, 0x86, 0x10, 0x63, 0xF2, 0xDE, 0x8C,
};

const GFXglyph RobotoCondensed_BoldItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 12, 4, 0, -12 },
  { 9, 5, 5, 5, 1, -13 },
  { 13, 9, 12, 9, 0, -12 },
  { 27, 8, 16, 8, 0, -14 },
  { 43, 8, 12, 11, 1, -12 },
  { 55, 9, 12, 10, 0, -12 },
  { 69, 2, 5, 3, 1, -13 },
  { 71, 5, 17, 5, 1, -13 },
  { 82, 6, 17, 5, -1, -13 },
  { 95, 7, 7, 7, 1, -12 },
  { 102, 8, 8, 8, 0, -10 },
  { 110, 4, 5, 4, -1, -2 },
  { 113, 4, 2, 6, 1, -6 },
  { 114, 3, 3, 5, 0, -3 },
  { 116, 7, 13, 5, -1, -12 },
  { 128, 7, 12, 8, 1, -12 },
  { 139, 5, 12, 8, 2, -12 },
  { 147, 8, 12, 8, 0, -12 },
  { 159, 8, 12, 8, 0, -12 },
  { 171, 8, 12, 8, 0, -12 },
  { 183, 8, 12, 8, 0, -12 },
  { 195, 7, 12, 8, 1, -12 },
  { 206, 8, 12, 8, 1, -12 },
  { 218, 8, 12, 8, 0, -12 },
  { 230, 7, 12, 8, 1, -12 },
  { 241, 4, 10, 5, 0, -10 },
  { 246, 5, 13, 4, -1, -10 },
  { 255, 7, 8, 7, 0, -9 },
  { 262, 7, 5, 8, 1, -8 },
  { 267, 7, 8, 7, 0, -9 },
  { 274, 7, 12, 7, 1, -12 },
  { 285, 12, 16, 13, 0, -12 },
  { 309, 10, 12, 10, -1, -12 },
  { 324, 9, 12, 9, 0, -12 },
  { 338, 8, 12, 9, 1, -12 },
  { 350, 9, 12, 9, 0, -12 },
  { 364, 9, 12, 8, 0, -12 },
  { 378, 9, 12, 8, 0, -12 },
  { 392, 9, 12, 10, 1, -12 },
  { 406, 10, 12, 10, 0, -12 },
  { 421, 5, 12, 4, 0, -12 },
  { 429, 8, 12, 8, 0, -12 },
  { 441, 10, 12, 9, 0, -12 },
  { 456, 7, 12, 8, 0, -12 },
  { 467, 13, 12, 13, 0, -12 },
  { 487, 10, 12, 10, 0, -12 },
  { 502, 9, 12, 10, 1, -12 },
  { 516, 9, 12, 9, 0, -12 },
  { 530, 9, 14, 10, 1, -12 },
  { 546, 9, 12, 9, 0, -12 },
  { 560, 9, 12, 9, 0, -12 },
  { 574, 9, 12, 9, 1, -12 },
  { 588, 9, 12, 9, 1, -12 },
  { 602, 10, 12, 10, 1, -12 },
  { 617, 12, 12, 12, 1, -12 },
  { 635, 11, 12, 9, -1, -12 },
  { 652, 9, 12, 9, 1, -12 },
  { 666, 9, 12, 9, 0, -12 },
  { 680, 5, 17, 4, 0, -14 },
  { 691, 4, 13, 6, 1, -12 },
  { 698, 6, 17, 4, -1, -14 },
  { 711, 5, 6, 6, 1, -12 },
  { 715, 7, 2, 7, -1, 0 },
  { 717, 3, 3, 5, 2, -13 },
  { 719, 7, 9, 8, 0, -9 },
  { 727, 8, 13, 8, 0, -13 },
  { 740, 7, 9, 8, 0, -9 },
  { 748, 9, 13, 8, 0, -13 },
  { 763, 7, 9, 8, 0, -9 },
  { 771, 6, 13, 5, 0, -13 },
  { 781, 8, 12, 8, 0, -9 },
  { 793, 7, 13, 8, 0, -13 },
  { 805, 4, 13, 4, 0, -13 },
  { 812, 6, 16, 4, -2, -13 },
  { 824, 8, 13, 8, 0, -13 },
  { 837, 5, 13, 4, 0, -13 },
  { 846, 12, 9, 12, 0, -9 },
  { 860, 7, 9, 8, 0, -9 },
  { 868, 8, 9, 8, 0, -9 },
  { 877, 9, 12, 8, -1, -9 },
  { 891, 8, 12, 8, 0, -9 },
  { 903, 6, 9, 5, 0, -9 },
  { 910, 7, 9, 7, 0, -9 },
  { 918, 4, 11, 5, 1, -11 },
  { 924, 8, 9, 8, 0, -9 },
  { 933, 7, 9, 7, 1, -9 },
  { 941, 10, 9, 10, 1, -9 },
  { 953, 9, 9, 7, -1, -9 },
  { 964, 8, 12, 7, 0, -9 },
  { 976, 7, 9, 7, 0, -9 },
  { 984, 6, 16, 5, 0, -13 },
  { 996, 4, 14, 4, 0, -12 },
  { 1003, 6, 16, 5, -1, -13 },
  { 1015, 8, 4, 9, 1, -7 },
};

const GFXfont RobotoCondensed_BoldItalic17pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic17pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic17pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _ROBOTOCONDENSED_BOLDITALIC17PT7B_H_
