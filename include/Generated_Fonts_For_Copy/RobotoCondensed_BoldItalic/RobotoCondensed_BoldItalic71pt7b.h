#ifndef _ROBOTOCONDENSED_BOLDITALIC71PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0xFE,
  0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x87, 0xE3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8,
  0xFE, 0x1F, 0xC7, 0xF0, 0xFE, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1,
  0xF8, 0xFE, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC1, 0xF8, 0x7C, 0x0F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF8, 0x7F,
  0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xCF, 0xFE, 0x03,
  0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x07,
  0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x07,
  0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F, 0xC0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x7F, 0xF9, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x01,
  0x81, 0xFC, 0x3F, 0x80, 0xF8, 0x7F, 0x07, 0xE0, 0x3F, 0x1F, 0x81, 0xF8,
  0x1F, 0xC7, 0xE0, 0x7E, 0x0F, 0xE1, 0xF8, 0x1F, 0x83, 0xF0, 0xFE, 0x07,
  0xE1, 0xFC, 0x3F, 0x83, 0xF8, 0xFE, 0x0F, 0xE0, 0xFE, 0x3F, 0x03, 0xF8,
  0x3F, 0x1F, 0x80, 0xFE, 0x0F, 0xCF, 0xE0, 0x1F, 0x87, 0xF3, 0xF0, 0x07,
  0xFF, 0xF9, 0xF8, 0x01, 0xFF, 0xFE, 0xFE, 0x00, 0x3F, 0xFF, 0x3F, 0x00,
  0x07, 0xFF, 0x9F, 0x80, 0x00, 0xFF, 0xCF, 0xE0, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x07,
  0xF7, 0xFF, 0x00, 0x01, 0xFB, 0xFF, 0xE0, 0x00, 0xFD, 0xFF, 0xFC, 0x00,
  0x7F, 0x7F, 0xFF, 0x00, 0x1F, 0xBF, 0xFF, 0xE0, 0x0F, 0xCF, 0xE1, 0xF8,
  0x07, 0xF3, 0xF0, 0x7E, 0x03, 0xF9, 0xFC, 0x1F, 0x80, 0xFC, 0x7E, 0x07,
  0xE0, 0x7F, 0x1F, 0x81, 0xF8, 0x3F, 0x87, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8,
  0x1F, 0x87, 0xE0, 0x7E, 0x07, 0xE3, 0xF8, 0x1F, 0x81, 0xF8, 0xFC, 0x07,
  0xE0, 0xFE, 0x7E, 0x01, 0xF8, 0x3F, 0x07, 0x80, 0x7F, 0x1F, 0xC0, 0x40,
  0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xE7, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x1F, 0xE3, 0xFF, 0x00, 0x03, 0xFE, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0x81, 0xFF,
  0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xC1, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xC7,
  0xFF, 0xFF, 0x8F, 0xF9, 0xFF, 0x9F, 0xF9, 0xFF, 0x3F, 0xF3, 0xFF, 0x3F,
  0xCF, 0xFC, 0x3F, 0xFF, 0xF9, 0xFF, 0x87, 0xFF, 0xFF, 0x3F, 0xE0, 0x7F,
  0xFF, 0xCF, 0xFC, 0x0F, 0xFF, 0xF9, 0xFF, 0x80, 0xFF, 0xFF, 0x3F, 0xF0,
  0x1F, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0xF0, 0xFF, 0xC0, 0x3F, 0xFE, 0x1F,
  0xFC, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFC, 0x7F, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE3, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x8F, 0xE0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x08, 0x00, 0x00, 0x08, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x18, 0x03, 0xF0, 0x08, 0x78, 0x0F,
  0x80, 0xF3, 0xF8, 0x3E, 0x1F, 0xCF, 0xF9, 0xFB, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x7F,
  0x9F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x7F, 0x81,
  0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x0C, 0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F,
  0xE0, 0x7F, 0x81, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x81,
  0xFF, 0x03, 0xFC, 0x01, 0xF0, 0x00, 0xC0, 0x00, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xE7, 0xFF, 0xF9,
  0xFF, 0xFE, 0x0F, 0x83, 0xFC, 0x7F, 0xE7, 0xFE, 0x7F, 0xEF, 0xFF, 0x7F,
  0xE7, 0xFE, 0x7F, 0xE3, 0xFC, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xC3, 0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF1,
  0xFF, 0x00, 0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFC, 0xFF,
  0xC0, 0x1F, 0xF3, 0xFF, 0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0,
  0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF8, 0x03,
  0xFF, 0x7F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0xE7, 0xFC, 0x00, 0xFF,
  0x9F, 0xF0, 0x03, 0xFE, 0x7F, 0xC0, 0x0F, 0xFB, 0xFF, 0x00, 0x7F, 0xEF,
  0xFC, 0x01, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0xFF, 0xC0, 0x1F, 0xF3, 0xFE,
  0x00, 0x7F, 0xCF, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF, 0x80,
  0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x1F,
  0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0xF8,
  0x1F, 0xF8, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xF3, 0xFE, 0x7E, 0x3F, 0xF3, 0x81,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE7, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xE0,
  0x0F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xCF, 0xFF,
  0x03, 0xFF, 0x81, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0xC3,
  0xFF, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x3F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xFC, 0x0F, 0xFF, 0x3F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xEF, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0x7F, 0x8F, 0xF8, 0x00, 0x7F, 0x9F, 0xF8, 0x00, 0xFF,
  0x1F, 0xF8, 0x01, 0xFE, 0x1F, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x03, 0xFC,
  0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xF8, 0x3F, 0xF0, 0x0F, 0xF0,
  0x3F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF,
  0xF0, 0x07, 0xF8, 0x1F, 0xFC, 0x00, 0x38, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x0F, 0xF8,
  0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xC1, 0xFF,
  0x80, 0x7F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F,
  0xFE, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0xCF, 0xE0, 0x07, 0xFD, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xC3, 0xFF, 0x9F,
  0xFC, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xEF,
  0xF8, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xFB, 0xFF, 0x00, 0xFF, 0xCF, 0xF8,
  0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xE3, 0xFF, 0x07, 0xFE, 0x1F, 0xFC, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xCF, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x07,
  0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0x07,
  0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x0F, 0xFC, 0x03,
  0xFF, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F,
  0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xE0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xF1, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFC, 0xFF, 0xE3, 0xFF, 0x03, 0xFE, 0x3F, 0xF0, 0x3F, 0xE7, 0xFE, 0x03,
  0xFE, 0x7F, 0xE0, 0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0x7F, 0xC0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFE, 0xFF, 0xC0, 0x7F, 0xEF, 0xFE,
  0x0F, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x07,
  0xFE, 0xFF, 0x80, 0x1F, 0x8F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0xF8, 0x1F, 0xF8,
  0x3F, 0xF0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07,
  0xF0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x0F, 0xF0, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xC3, 0xFF, 0x07,
  0xFE, 0x0F, 0xFC, 0x0F, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01,
  0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x02,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFE, 0x7F, 0xF9, 0xFF, 0xDF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0x81, 0xFC,
  0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0xFC, 0x01, 0xFF, 0xFF, 0x07, 0xE0, 0xFE,
  0x01, 0xFF, 0xFF, 0x83, 0xF0, 0x7E, 0x01, 0xFF, 0xFF, 0xC0, 0xF8, 0x7F,
  0x01, 0xFF, 0x0F, 0xC0, 0x7C, 0x3F, 0x81, 0xFE, 0x07, 0xE0, 0x3E, 0x1F,
  0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0x8F,
  0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC7, 0xE0, 0x7F, 0x80, 0xFC, 0x07, 0xE7,
  0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF3, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xF9,
  0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFD, 0xFC, 0x0F, 0xE0, 0x1F, 0x80, 0x7E,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x3E, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0x3F, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0x9F, 0x81, 0xFC, 0x03, 0xF0, 0x0F,
  0xCF, 0xC0, 0xFE, 0x03, 0xF8, 0x07, 0xEF, 0xE0, 0x7F, 0x01, 0xFC, 0x03,
  0xE7, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF3, 0xF8, 0x1F, 0xC0, 0x7E, 0x01,
  0xF9, 0xFC, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0xFE, 0x07, 0xF0, 0x3F, 0x80,
  0xFC, 0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0xE0,
  0x7E, 0x1F, 0xC0, 0xFF, 0xBF, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xFF, 0x3F,
  0xFF, 0x00, 0xFC, 0x03, 0xFF, 0x1F, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0x07,
  0xFE, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0xDF,
  0xE0, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00,
  0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x80, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0x8F,
  0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF0,
  0x1F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC7,
  0xFF, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0x0F, 0xF8, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07,
  0xFE, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF,
  0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF8,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xC1,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x7F,
  0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x1F,
  0xF9, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x3F,
  0xFF, 0xE3, 0xFF, 0x01, 0xFF, 0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0xF8, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC7, 0xFE, 0x03, 0xFF, 0xFE, 0x7F, 0xE0, 0x3F, 0xFF,
  0xE3, 0xFF, 0x01, 0xFF, 0xFF, 0x1F, 0xF8, 0x0F, 0xFF, 0xF8, 0xFF, 0xC0,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF1,
  0xFF, 0x80, 0x03, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x00,
  0xFF, 0xC3, 0xFF, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F,
  0xE0, 0x03, 0xFF, 0x83, 0xFF, 0x80, 0x1F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x7F, 0xF0, 0x0F, 0xFC, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x81, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x83, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF3, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF7,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xE1, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x03, 0xFE, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xF7, 0xF0, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0xF0, 0x07, 0xFD, 0xFC, 0x01,
  0xFE, 0xFF, 0x80, 0x7F, 0xEF, 0xF0, 0x0F, 0xF7, 0xFC, 0x03, 0xFF, 0x7F,
  0x80, 0xFF, 0x7F, 0xE0, 0x1F, 0xF3, 0xFC, 0x07, 0xFB, 0xFE, 0x00, 0xFF,
  0x9F, 0xE0, 0x7F, 0x9F, 0xF0, 0x07, 0xFC, 0xFF, 0x03, 0xFC, 0xFF, 0x80,
  0x3F, 0xE3, 0xF8, 0x3F, 0xCF, 0xFC, 0x03, 0xFF, 0x1F, 0xC1, 0xFE, 0x7F,
  0xE0, 0x1F, 0xF8, 0xFE, 0x1F, 0xE3, 0xFF, 0x00, 0xFF, 0xC7, 0xF0, 0xFF,
  0x1F, 0xF0, 0x07, 0xFE, 0x3F, 0x87, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFC,
  0x7F, 0x8F, 0xFC, 0x01, 0xFF, 0x0F, 0xE3, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8,
  0x7F, 0x3F, 0xC3, 0xFF, 0x00, 0xFF, 0xC3, 0xFD, 0xFE, 0x1F, 0xF8, 0x07,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xFF, 0x0F, 0xFC,
  0x01, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xE0, 0x0F, 0xF8, 0x1F, 0xFF, 0x83,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFF,
  0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x7F,
  0xE0, 0x0F, 0xFC, 0x03, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x00, 0x07,
  0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F,
  0xFD, 0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0xBF, 0x81, 0xFF, 0x80, 0x7F, 0xE7,
  0xF0, 0x3F, 0xF0, 0x0F, 0xFC, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x8F, 0xE0,
  0xFF, 0x80, 0x3F, 0xF1, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0x87, 0xFE,
  0x00, 0xFF, 0xC7, 0xF8, 0xFF, 0xC0, 0x3F, 0xF0, 0x7F, 0x1F, 0xF8, 0x07,
  0xFE, 0x0F, 0xE3, 0xFF, 0x00, 0xFF, 0xC1, 0xFC, 0x7F, 0xC0, 0x1F, 0xF8,
  0x3F, 0xDF, 0xF8, 0x03, 0xFF, 0x03, 0xFB, 0xFF, 0x00, 0x7F, 0xE0, 0x7F,
  0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xEF, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0x03,
  0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF,
  0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F,
  0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF9, 0xFF, 0x80,
  0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x3F, 0xF3,
  0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x00,
  0x7F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xF3, 0xFF,
  0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x00,
  0x00, 0xFF, 0xDF, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00,
  0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF,
  0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0xFC,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0xFF,
  0xC0, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x7F, 0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x03, 0xFF, 0x1F, 0xF0,
  0x00, 0x1F, 0xF9, 0xFF, 0x80, 0x00, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0xFE,
  0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00,
  0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0x7F,
  0xE0, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F,
  0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0x7F, 0xE0,
  0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC,
  0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00,
  0x1F, 0xF9, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xFC, 0x7F,
  0xE0, 0x00, 0x7F, 0xE3, 0xFF, 0x00, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFE, 0x00,
  0x3F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xE0,
  0x03, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xFC, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x07, 0xFE, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC1, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x3F,
  0xE0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0xFF, 0xC0, 0x00, 0x3F,
  0xF9, 0xFF, 0x80, 0x00, 0x7F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0xC7, 0xFE,
  0x00, 0x03, 0xFF, 0x8F, 0xFE, 0x00, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x07,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xE1,
  0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0xFF, 0x87, 0xFC, 0x00,
  0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0xFF, 0xC0, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x00, 0x0F, 0xF3, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xBF, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xDF, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xEF, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xE7, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x00, 0xFF, 0xE0,
  0x1F, 0xF9, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xF8, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFC, 0x7F, 0xE0, 0x3F, 0xFC, 0x07, 0xFE, 0x3F, 0xF0, 0x1F, 0xFE,
  0x03, 0xFE, 0x1F, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0x0F, 0xFC, 0x0F, 0xFF,
  0x81, 0xFF, 0x87, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x07, 0xFF,
  0xE0, 0x7F, 0xC0, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFF,
  0xF8, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0xFC, 0x1F, 0xF0, 0x1F, 0xF0, 0xFF,
  0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x7F, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x7F,
  0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x3F, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x1F,
  0xFF, 0xE3, 0xFE, 0x00, 0xFF, 0x9F, 0xEF, 0xF1, 0xFF, 0x00, 0x7F, 0xCF,
  0xF3, 0xF8, 0xFF, 0x80, 0x3F, 0xE7, 0xF9, 0xFC, 0xFF, 0x80, 0x1F, 0xF7,
  0xF8, 0xFE, 0x7F, 0xC0, 0x0F, 0xFB, 0xFC, 0x7F, 0x3F, 0xE0, 0x07, 0xFD,
  0xFE, 0x3F, 0xBF, 0xE0, 0x03, 0xFF, 0xFE, 0x1F, 0xDF, 0xF0, 0x01, 0xFF,
  0xFF, 0x0F, 0xEF, 0xF8, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC7, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF7,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE3, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0xFF, 0xE0,
  0x00, 0xFF, 0xE7, 0xFE, 0x00, 0x1F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0xC7,
  0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x7F,
  0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF8, 0x01,
  0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0x87, 0xFE,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x0F, 0xF8,
  0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xF8, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFD, 0xFC, 0x01, 0xFD, 0xFC,
  0x03, 0xF8, 0xFC, 0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xF0, 0xFE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFF, 0x81, 0xFF,
  0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF,
  0xC7, 0xFE, 0x07, 0xFE, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0x8F,
  0xFE, 0x07, 0xFC, 0x7F, 0xE0, 0x7F, 0xE7, 0xFE, 0x03, 0xFF, 0x3F, 0xF0,
  0x1F, 0xF9, 0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x07, 0xFC, 0x7F, 0xC0, 0x3F,
  0xE3, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x7F, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0x7F, 0xE0, 0x3F, 0xF1, 0xFF, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x0F,
  0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x9F, 0xFE, 0x07, 0xFE, 0x07,
  0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x07, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03,
  0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x03,
  0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x03,
  0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x03,
  0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x3F, 0xF0, 0x07,
  0xFE, 0x3F, 0xF0, 0x07, 0xFE, 0x3F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xF0, 0x1F,
  0xF8, 0x7F, 0xFE, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x9F, 0xFF,
  0xC0, 0xFF, 0x8F, 0xFF, 0x80, 0xFF, 0x87, 0xFE, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x3F, 0xF8, 0x3F,
  0xE0, 0x3F, 0xE1, 0xFF, 0x80, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x3F, 0xF0,
  0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0,
  0x3F, 0xE1, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x7F,
  0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xE0, 0x7F,
  0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0xF1, 0xFF, 0x00, 0x3F, 0xFF,
  0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x8F, 0xFF, 0x80,
  0xFF, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0x0F, 0xF8, 0x1F, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC, 0x01, 0xFF,
  0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0xFF, 0x00, 0x07, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xE3, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFE, 0x3F,
  0xF0, 0xFF, 0xC0, 0xFF, 0x87, 0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x1F, 0xF3,
  0xFE, 0x00, 0xFF, 0xBF, 0xF0, 0x07, 0xFD, 0xFF, 0x80, 0x3F, 0xEF, 0xF8,
  0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x20, 0x7F, 0xE0, 0x03, 0x01, 0xFF, 0x80, 0x7C, 0x0F, 0xFF, 0x1F, 0xE0,
  0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF9, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x1F, 0xF0, 0x07, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0xF9, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF,
  0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xFC, 0x1F, 0xF8, 0x01,
  0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xFC, 0x3F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0x83, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFE, 0x0F,
  0xF8, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xF0,
  0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0xC0, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x03,
  0xFE, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xFB, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xF0, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x01, 0x00, 0x07, 0xFE, 0x00, 0xE0, 0x03, 0xFF,
  0x00, 0x3E, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xC3, 0xC0, 0x01, 0xFF, 0xBF, 0xF0, 0x03, 0xFE, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xE7, 0xFF, 0x83, 0xFF, 0x03,
  0xFF, 0x07, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F,
  0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x00, 0xFF,
  0xC3, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC,
  0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE3,
  0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xFE, 0x1F,
  0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF1, 0xFF,
  0x80, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0x87, 0xFE, 0x01, 0xFF, 0x0F, 0xF8,
  0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0,
  0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0x87, 0xFC, 0x01,
  0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x04, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0xC0, 0x7F,
  0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0x00,
  0x3F, 0xE1, 0xFF, 0xE0, 0x0F, 0xFC, 0x7F, 0xF8, 0x01, 0xFF, 0x8F, 0xFE,
  0x00, 0x3F, 0xE3, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0xE0, 0x00, 0xFF, 0xBF,
  0xF8, 0x00, 0x3F, 0xF7, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xCF, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0xFF, 0x83, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xF0, 0x03, 0xFE, 0xFF, 0xF0, 0x7F, 0xF8,
  0x03, 0xFF, 0xFF, 0xF8, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF,
  0x07, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0x03, 0xFF,
  0x07, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF,
  0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE,
  0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x7F, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8,
  0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x07, 0xFC, 0xFF, 0xC0, 0x0F, 0xFB, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0x9F, 0xFE, 0x0F,
  0xFC, 0x0F, 0xFC, 0x3F, 0xF0, 0x1F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF,
  0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x01, 0xFF, 0x87, 0xFC,
  0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFE, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xE0,
  0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0xC3, 0xFE, 0x01,
  0xFF, 0x8F, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x0F,
  0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF, 0x00, 0xFF,
  0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC,
  0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xF0, 0xFF, 0x80, 0x7F, 0xE3,
  0xFF, 0x00, 0xFF, 0xC7, 0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x1F,
  0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x00,
  0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x3F, 0xE0, 0x0F, 0xFD, 0xFF, 0x80, 0x3F,
  0xF7, 0xFE, 0x00, 0xFF, 0xDF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFB, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0xFF, 0xBF, 0xE0,
  0x03, 0xFE, 0xFF, 0x80, 0x1F, 0xFB, 0xFE, 0x00, 0x7F, 0xEF, 0xF8, 0x01,
  0xFF, 0x3F, 0xE0, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xF3, 0xFF, 0x01, 0xFF,
  0x8F, 0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF9, 0xFF, 0x80, 0x01,
  0xFF, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x07, 0xFE, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFC, 0x01,
  0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x1F, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xFC, 0x7F, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xBF, 0xFF, 0x00, 0x3F, 0xF3, 0xFF, 0xC0,
  0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x81, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x7F, 0x80, 0x3F, 0xFE, 0x3F, 0xC0, 0x3F, 0xFF, 0x3F, 0xE0, 0x3F,
  0xFF, 0xDF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFE, 0x3F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x7F, 0xE1,
  0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF8,
  0x7F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF0, 0x07, 0xFE, 0x1F, 0xF8, 0x03, 0xFF,
  0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0xFF,
  0xC1, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x07,
  0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0x80, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x01,
  0xF1, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0E,
  0x03, 0xFE, 0x7F, 0x03, 0xFE, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xEF, 0xFE,
  0x07, 0xFE, 0x0F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0xFF, 0x80, 0xFF, 0xC3,
  0xFE, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x3F,
  0xE0, 0x0F, 0xF8, 0xFF, 0x80, 0x3F, 0xE3, 0xFE, 0x00, 0xFF, 0x87, 0xFC,
  0x07, 0xFE, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xFB, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x0F, 0x00,
  0x0F, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x1F, 0xF8,
  0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x00, 0xFF, 0xC7,
  0xFE, 0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x0F, 0xFC, 0x3F,
  0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF,
  0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x07, 0xFE, 0x1F, 0xF0,
  0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0x3F, 0xF1, 0xFF, 0x80,
  0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x03, 0xFF, 0x0F, 0xF8, 0x07,
  0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F,
  0xE1, 0xFF, 0x80, 0x7F, 0xC3, 0xFF, 0x01, 0xFF, 0x87, 0xFE, 0x03, 0xFF,
  0x0F, 0xFC, 0x07, 0xFE, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xFC, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0xF8, 0x01,
  0xFF, 0x9F, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xF7,
  0xFC, 0x01, 0xFF, 0xBF, 0xE0, 0x0F, 0xFD, 0xFF, 0x00, 0xFF, 0xCF, 0xF8,
  0x07, 0xFE, 0x7F, 0xE0, 0x3F, 0xE3, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x1F,
  0xF8, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x3F, 0xE1, 0xFF, 0x01, 0xFF,
  0x0F, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0x7F, 0xC7, 0xFC, 0x03, 0xFE, 0x7F,
  0xC0, 0x0F, 0xF3, 0xFE, 0x00, 0x7F, 0x9F, 0xF0, 0x03, 0xFD, 0xFF, 0x00,
  0x1F, 0xEF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x7F,
  0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F, 0xEF, 0xF8,
  0x1F, 0xF0, 0x1F, 0xF7, 0xFC, 0x0F, 0xF8, 0x1F, 0xF3, 0xFE, 0x07, 0xFC,
  0x0F, 0xF9, 0xFF, 0x07, 0xFE, 0x07, 0xFC, 0xFF, 0x83, 0xFF, 0x07, 0xFC,
  0x7F, 0xC3, 0xFF, 0xC3, 0xFE, 0x3F, 0xE1, 0xFF, 0xE1, 0xFF, 0x1F, 0xF0,
  0xFF, 0xF1, 0xFF, 0x0F, 0xF8, 0xFF, 0xF8, 0xFF, 0x83, 0xFC, 0x7F, 0xFC,
  0x7F, 0x81, 0xFE, 0x7F, 0xFE, 0x7F, 0xC0, 0xFF, 0x3F, 0xFF, 0x3F, 0xE0,
  0x7F, 0x9F, 0xFF, 0x9F, 0xE0, 0x3F, 0xDF, 0xDF, 0xDF, 0xF0, 0x1F, 0xEF,
  0xEF, 0xEF, 0xF8, 0x0F, 0xFF, 0xF7, 0xF7, 0xF8, 0x07, 0xFF, 0xF3, 0xFF,
  0xFC, 0x03, 0xFF, 0xF9, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0xFF, 0xFE, 0x00,
  0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF8, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F,
  0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x80,
  0x07, 0xFE, 0x7F, 0xE0, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x0F, 0xFB, 0xFF,
  0x00, 0x01, 0xFF, 0x7F, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07,
  0xFD, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xE7, 0xFC, 0x00,
  0x0F, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF,
  0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF0,
  0x1F, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F,
  0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0xC0,
  0x07, 0xFC, 0x3F, 0xF0, 0x00, 0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x0F, 0xF9,
  0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x03,
  0xFD, 0xFF, 0x80, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0x80, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x1F, 0xC3, 0xFF, 0xC0, 0x0F, 0xE3, 0xFF, 0xF0, 0x0F, 0xF1, 0xFF,
  0xFC, 0x07, 0xF1, 0xFF, 0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0x83, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFC, 0x7F, 0x8F, 0xFF, 0xFE, 0x3F, 0x83, 0xFF, 0xFF, 0x3F,
  0xC0, 0xFF, 0xFF, 0x1F, 0xC0, 0x3F, 0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0x87,
  0xF0, 0x07, 0xFF, 0x83, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 18, 51, 18, 1, -50 },
  { 116, 21, 19, 22, 4, -53 },
  { 166, 36, 50, 36, 1, -50 },
  { 391, 32, 66, 35, 2, -58 },
  { 655, 34, 52, 44, 6, -51 },
  { 876, 35, 52, 40, 1, -51 },
  { 1104, 10, 19, 11, 4, -53 },
  { 1128, 22, 72, 22, 3, -56 },
  { 1326, 22, 72, 22, -3, -56 },
  { 1524, 30, 31, 31, 3, -50 },
  { 1641, 30, 37, 33, 2, -42 },
  { 1780, 15, 21, 17, -4, -9 },
  { 1820, 18, 8, 25, 3, -26 },
  { 1838, 12, 11, 20, 1, -10 },
  { 1855, 32, 54, 23, -5, -50 },
  { 2071, 30, 52, 35, 3, -51 },
  { 2266, 21, 50, 35, 8, -50 },
  { 2398, 34, 51, 35, 0, -51 },
  { 2615, 33, 52, 35, 1, -51 },
  { 2830, 32, 50, 35, 1, -50 },
  { 3030, 33, 51, 35, 2, -50 },
  { 3241, 29, 51, 35, 3, -50 },
  { 3426, 34, 50, 35, 3, -50 },
  { 3639, 32, 52, 35, 2, -51 },
  { 3847, 28, 51, 35, 5, -51 },
  { 4026, 15, 39, 19, 2, -38 },
  { 4100, 20, 50, 18, -3, -38 },
  { 4225, 29, 33, 31, 1, -38 },
  { 4345, 29, 23, 35, 3, -34 },
  { 4429, 29, 33, 31, 1, -38 },
  { 4549, 26, 52, 31, 5, -51 },
  { 4718, 49, 65, 53, 1, -49 },
  { 5117, 40, 50, 41, -3, -50 },
  { 5367, 38, 50, 39, 0, -50 },
  { 5605, 36, 52, 39, 3, -51 },
  { 5839, 38, 50, 39, 0, -50 },
  { 6077, 37, 50, 34, 0, -50 },
  { 6309, 36, 50, 33, 0, -50 },
  { 6534, 37, 52, 40, 3, -51 },
  { 6775, 43, 50, 42, 0, -50 },
  { 7044, 18, 50, 19, 1, -50 },
  { 7157, 35, 51, 34, 0, -50 },
  { 7381, 44, 50, 38, 0, -50 },
  { 7656, 29, 50, 33, 0, -50 },
  { 7838, 53, 50, 52, 0, -50 },
  { 8170, 43, 50, 42, 0, -50 },
  { 8439, 37, 52, 42, 3, -51 },
  { 8680, 39, 50, 39, 0, -50 },
  { 8924, 37, 60, 42, 3, -51 },
  { 9202, 38, 50, 38, 0, -50 },
  { 9440, 37, 52, 37, 1, -51 },
  { 9681, 36, 50, 37, 5, -50 },
  { 9906, 39, 51, 39, 2, -50 },
  { 10155, 39, 50, 40, 5, -50 },
  { 10399, 49, 50, 52, 6, -50 },
  { 10706, 44, 50, 39, -2, -50 },
  { 10981, 36, 50, 37, 6, -50 },
  { 11206, 40, 50, 37, -1, -50 },
  { 11456, 24, 71, 18, -1, -59 },
  { 11669, 17, 54, 26, 6, -50 },
  { 11784, 24, 71, 18, -4, -59 },
  { 11997, 24, 25, 27, 2, -50 },
  { 12072, 27, 8, 28, -4, 0 },
  { 12099, 15, 11, 23, 7, -54 },
  { 12120, 29, 40, 32, 1, -39 },
  { 12265, 32, 54, 34, 0, -53 },
  { 12481, 30, 40, 32, 1, -39 },
  { 12631, 35, 54, 34, 1, -53 },
  { 12868, 29, 40, 33, 2, -39 },
  { 13013, 25, 54, 23, 2, -54 },
  { 13182, 34, 53, 35, 0, -39 },
  { 13408, 31, 53, 34, 0, -53 },
  { 13614, 18, 53, 17, 0, -53 },
  { 13734, 26, 67, 17, -8, -53 },
  { 13952, 35, 53, 33, 0, -53 },
  { 14184, 19, 53, 17, 0, -53 },
  { 14310, 48, 39, 51, 0, -39 },
  { 14544, 31, 39, 34, 0, -39 },
  { 14696, 30, 40, 34, 2, -39 },
  { 14846, 35, 53, 34, -3, -39 },
  { 15078, 33, 53, 34, 1, -39 },
  { 15297, 24, 39, 23, 0, -39 },
  { 15414, 30, 40, 31, 0, -39 },
  { 15564, 20, 48, 21, 2, -47 },
  { 15684, 31, 39, 34, 2, -38 },
  { 15836, 29, 38, 31, 4, -38 },
  { 15974, 41, 38, 44, 4, -38 },
  { 16169, 35, 38, 31, -2, -38 },
  { 16336, 35, 52, 31, -2, -38 },
  { 16564, 32, 38, 31, -1, -38 },
  { 16716, 21, 67, 21, 2, -55 },
  { 16892, 15, 59, 17, 1, -50 },
  { 17003, 22, 68, 21, -3, -55 },
  { 17190, 33, 16, 38, 3, -29 },
};

const GFXfont RobotoCondensed_BoldItalic71pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic71pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic71pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOCONDENSED_BOLDITALIC71PT7B_H_
