#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/RobotoCondensed_BoldItalic
// Headers: 67

#include "RobotoCondensed_BoldItalic6pt7b.h"
#include "RobotoCondensed_BoldItalic7pt7b.h"
#include "RobotoCondensed_BoldItalic8pt7b.h"
#include "RobotoCondensed_BoldItalic9pt7b.h"
#include "RobotoCondensed_BoldItalic10pt7b.h"
#include "RobotoCondensed_BoldItalic11pt7b.h"
#include "RobotoCondensed_BoldItalic12pt7b.h"
#include "RobotoCondensed_BoldItalic13pt7b.h"
#include "RobotoCondensed_BoldItalic14pt7b.h"
#include "RobotoCondensed_BoldItalic15pt7b.h"
#include "RobotoCondensed_BoldItalic16pt7b.h"
#include "RobotoCondensed_BoldItalic17pt7b.h"
#include "RobotoCondensed_BoldItalic18pt7b.h"
#include "RobotoCondensed_BoldItalic19pt7b.h"
#include "RobotoCondensed_BoldItalic20pt7b.h"
#include "RobotoCondensed_BoldItalic21pt7b.h"
#include "RobotoCondensed_BoldItalic22pt7b.h"
#include "RobotoCondensed_BoldItalic23pt7b.h"
#include "RobotoCondensed_BoldItalic24pt7b.h"
#include "RobotoCondensed_BoldItalic25pt7b.h"
#include "RobotoCondensed_BoldItalic26pt7b.h"
#include "RobotoCondensed_BoldItalic27pt7b.h"
#include "RobotoCondensed_BoldItalic28pt7b.h"
#include "RobotoCondensed_BoldItalic29pt7b.h"
#include "RobotoCondensed_BoldItalic30pt7b.h"
#include "RobotoCondensed_BoldItalic31pt7b.h"
#include "RobotoCondensed_BoldItalic32pt7b.h"
#include "RobotoCondensed_BoldItalic33pt7b.h"
#include "RobotoCondensed_BoldItalic34pt7b.h"
#include "RobotoCondensed_BoldItalic35pt7b.h"
#include "RobotoCondensed_BoldItalic36pt7b.h"
#include "RobotoCondensed_BoldItalic37pt7b.h"
#include "RobotoCondensed_BoldItalic38pt7b.h"
#include "RobotoCondensed_BoldItalic39pt7b.h"
#include "RobotoCondensed_BoldItalic40pt7b.h"
#include "RobotoCondensed_BoldItalic41pt7b.h"
#include "RobotoCondensed_BoldItalic42pt7b.h"
#include "RobotoCondensed_BoldItalic43pt7b.h"
#include "RobotoCondensed_BoldItalic44pt7b.h"
#include "RobotoCondensed_BoldItalic45pt7b.h"
#include "RobotoCondensed_BoldItalic46pt7b.h"
#include "RobotoCondensed_BoldItalic47pt7b.h"
#include "RobotoCondensed_BoldItalic48pt7b.h"
#include "RobotoCondensed_BoldItalic49pt7b.h"
#include "RobotoCondensed_BoldItalic50pt7b.h"
#include "RobotoCondensed_BoldItalic51pt7b.h"
#include "RobotoCondensed_BoldItalic52pt7b.h"
#include "RobotoCondensed_BoldItalic53pt7b.h"
#include "RobotoCondensed_BoldItalic54pt7b.h"
#include "RobotoCondensed_BoldItalic55pt7b.h"
#include "RobotoCondensed_BoldItalic56pt7b.h"
#include "RobotoCondensed_BoldItalic57pt7b.h"
#include "RobotoCondensed_BoldItalic58pt7b.h"
#include "RobotoCondensed_BoldItalic59pt7b.h"
#include "RobotoCondensed_BoldItalic60pt7b.h"
#include "RobotoCondensed_BoldItalic61pt7b.h"
#include "RobotoCondensed_BoldItalic62pt7b.h"
#include "RobotoCondensed_BoldItalic63pt7b.h"
#include "RobotoCondensed_BoldItalic64pt7b.h"
#include "RobotoCondensed_BoldItalic65pt7b.h"
#include "RobotoCondensed_BoldItalic66pt7b.h"
#include "RobotoCondensed_BoldItalic67pt7b.h"
#include "RobotoCondensed_BoldItalic68pt7b.h"
#include "RobotoCondensed_BoldItalic69pt7b.h"
#include "RobotoCondensed_BoldItalic70pt7b.h"
#include "RobotoCondensed_BoldItalic71pt7b.h"
#include "RobotoCondensed_BoldItalic72pt7b.h"
