#ifndef _ROBOTOCONDENSED_BOLDITALIC12PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x2D, 0xB4, 0x86, 0xC0, 0xB6, 0x80, 0x14, 0x52, 0x9F, 0x2B, 0xE5,
  0x14, 0x60, 0x08, 0xE6, 0xDB, 0x60, 0xC1, 0xB2, 0x59, 0xC2, 0x00, 0x62,
  0xAA, 0xBC, 0x20, 0xE5, 0x65, 0x18, 0x38, 0xA6, 0x8E, 0x71, 0xDD, 0xF6,
  0x7C, 0xE0, 0x2D, 0x69, 0x24, 0x92, 0x44, 0x21, 0x11, 0x11, 0x13, 0x32,
  0x44, 0x25, 0x7C, 0xCB, 0x00, 0x11, 0x9F, 0xF2, 0x10, 0x6D, 0x60, 0xC0,
  0xF0, 0x08, 0x21, 0x84, 0x30, 0x82, 0x10, 0x43, 0x00, 0x39, 0xB6, 0xD3,
  0x49, 0x24, 0x96, 0x70, 0x37, 0xB2, 0x26, 0x66, 0x60, 0x39, 0xB4, 0xC2,
  0x18, 0xC6, 0x30, 0xF8, 0x39, 0xB0, 0xC6, 0x30, 0x20, 0xB6, 0x70, 0x0C,
  0x63, 0x8E, 0x7B, 0x6F, 0x84, 0x10, 0x3C, 0x86, 0x1E, 0x58, 0x2C, 0x96,
  0x70, 0x19, 0x98, 0xF7, 0xA5, 0x2B, 0x70, 0xF8, 0xC4, 0x62, 0x31, 0x18,
  0x80, 0x39, 0xB6, 0xDA, 0x71, 0x6C, 0xB6, 0x70, 0x76, 0xB7, 0x3D, 0x78,
  0xCC, 0xC0, 0x6C, 0x01, 0xB0, 0x33, 0x00, 0x00, 0x66, 0x44, 0x09, 0xF9,
  0xC3, 0x08, 0x78, 0x1E, 0x43, 0x86, 0xE8, 0x00, 0x7F, 0x13, 0x64, 0x0C,
  0xC0, 0x1E, 0x18, 0x9B, 0x4A, 0x95, 0x55, 0xAA, 0xF5, 0x3C, 0x80, 0x20,
  0x0E, 0x00, 0x0C, 0x18, 0x70, 0xF1, 0x66, 0xCF, 0xB3, 0x66, 0x7D, 0xB6,
  0x5B, 0x79, 0x3C, 0xF7, 0xF8, 0x3C, 0x49, 0x9A, 0x04, 0x08, 0x13, 0x36,
  0x78, 0x79, 0xB6, 0x59, 0x45, 0x3C, 0xF6, 0xF0, 0x7D, 0x86, 0x18, 0x79,
  0x0C, 0x30, 0xF8, 0x7D, 0x86, 0x18, 0x79, 0x0C, 0x30, 0xC0, 0x3C, 0x69,
  0x9A, 0x04, 0x0B, 0x93, 0x36, 0x38, 0x62, 0xCD, 0x9B, 0x37, 0xE8, 0xB1,
  0x66, 0xCC, 0x2D, 0xB6, 0x96, 0xC0, 0x0C, 0x30, 0xC2, 0x08, 0x6D, 0xB6,
  0x70, 0x66, 0xD9, 0xA3, 0xC7, 0x0F, 0x36, 0x64, 0xCC, 0x63, 0x18, 0xC4,
  0x23, 0x18, 0xF8, 0x71, 0xB9, 0xDC, 0xEE, 0xE5, 0x52, 0xBB, 0x6D, 0xB6,
  0xDB, 0x00, 0x62, 0xED, 0xDB, 0xB5, 0x6B, 0xB3, 0x66, 0xCC, 0x1C, 0x79,
  0x9A, 0x34, 0x68, 0x91, 0x36, 0x78, 0x7C, 0xD9, 0x9B, 0x24, 0xCF, 0x30,
  0x60, 0xC0, 0x1C, 0x79, 0x9A, 0x34, 0x68, 0x91, 0x36, 0x78, 0x18, 0x20,
  0x7D, 0xB6, 0x59, 0x4D, 0xED, 0xB2, 0xCC, 0x39, 0xB6, 0x58, 0x38, 0x3C,
  0xD6, 0x78, 0xFC, 0xC2, 0x08, 0x61, 0x86, 0x18, 0x40, 0x66, 0xCD, 0x9B,
  0x24, 0x49, 0xB3, 0x34, 0x78, 0xCF, 0x3C, 0xB6, 0xD9, 0x47, 0x18, 0x60,
  0xDB, 0xDB, 0xDB, 0xFA, 0xEE, 0xEE, 0xEC, 0xCC, 0xCC, 0x66, 0xD8, 0xB1,
  0xC3, 0x07, 0x1E, 0x64, 0xCC, 0xCF, 0x25, 0x94, 0x71, 0x86, 0x18, 0x40,
  0x7E, 0x18, 0x20, 0xC3, 0x04, 0x18, 0x60, 0xF8, 0x36, 0x66, 0x64, 0x4C,
  0xCC, 0xCC, 0xDB, 0x64, 0x93, 0x6C, 0x31, 0x33, 0x33, 0x22, 0x66, 0x6E,
  0x33, 0x55, 0xF8, 0x4C, 0x33, 0xC6, 0xFD, 0xED, 0xC0, 0x63, 0x1E, 0xD4,
  0xA7, 0x3B, 0xF0, 0x3B, 0x51, 0x8C, 0x6D, 0xC0, 0x0C, 0x37, 0xDF, 0xCB,
  0x2D, 0xB6, 0x78, 0x3B, 0x53, 0xFC, 0x69, 0xC0, 0x39, 0x9C, 0xC6, 0x31,
  0x08, 0xC0, 0x7D, 0xBC, 0xB2, 0xDB, 0x67, 0xA4, 0xF0, 0x63, 0x1E, 0xF4,
  0xAF, 0x7B, 0xD8, 0x2C, 0x36, 0x96, 0xD8, 0x13, 0x03, 0x32, 0x26, 0x66,
  0x4C, 0x61, 0x86, 0xDE, 0x71, 0xCD, 0x34, 0xD8, 0x2D, 0xB4, 0xB6, 0xC0,
  0x7F, 0x7F, 0x49, 0x5B, 0xDB, 0xDB, 0xDB, 0x5B, 0xD3, 0xBD, 0xEF, 0x60,
  0x3B, 0x53, 0x9C, 0xED, 0xC0, 0x7B, 0x53, 0x9C, 0xEF, 0xD0, 0x80, 0x7D,
  0xEC, 0xB6, 0xDB, 0x67, 0x84, 0x10, 0x77, 0x44, 0xCC, 0xC0, 0x72, 0xD0,
  0xE1, 0xE9, 0xC0, 0x27, 0x66, 0x44, 0x46, 0x6D, 0x24, 0x96, 0xDB, 0x67,
  0x80, 0x95, 0xAD, 0x4E, 0x63, 0x00, 0xB7, 0x6A, 0xF7, 0xCD, 0x9B, 0x24,
  0x00, 0x49, 0xE7, 0x0C, 0x73, 0x4D, 0x00, 0x49, 0x65, 0x1C, 0x71, 0x86,
  0x10, 0xC0, 0x78, 0xCC, 0x46, 0x63, 0xC0, 0x12, 0x26, 0x6C, 0x44, 0x44,
  0x40, 0x25, 0x24, 0x92, 0x52, 0x00, 0x4D, 0xB6, 0x52, 0xDA, 0x00, 0x65,
  0x7D, 0x80,
};

const GFXglyph RobotoCondensed_BoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 4, 1, -9 },
  { 7, 6, 9, 6, 0, -9 },
  { 14, 6, 11, 6, 0, -10 },
  { 23, 6, 9, 7, 1, -9 },
  { 30, 6, 9, 7, 0, -9 },
  { 37, 1, 3, 2, 1, -9 },
  { 38, 3, 13, 4, 1, -10 },
  { 43, 4, 12, 4, -1, -9 },
  { 49, 5, 5, 5, 1, -9 },
  { 53, 5, 6, 6, 0, -7 },
  { 57, 3, 4, 3, -1, -1 },
  { 59, 3, 1, 4, 1, -4 },
  { 60, 2, 2, 3, 0, -2 },
  { 61, 6, 10, 4, -1, -9 },
  { 69, 6, 9, 6, 0, -9 },
  { 76, 4, 9, 6, 1, -9 },
  { 81, 6, 9, 6, 0, -9 },
  { 88, 6, 9, 6, 0, -9 },
  { 95, 6, 9, 6, 0, -9 },
  { 102, 6, 9, 6, 0, -9 },
  { 109, 5, 9, 6, 0, -9 },
  { 115, 5, 9, 6, 1, -9 },
  { 121, 6, 9, 6, 0, -9 },
  { 128, 5, 9, 6, 1, -9 },
  { 134, 3, 7, 3, 0, -7 },
  { 137, 4, 10, 3, -1, -7 },
  { 142, 5, 6, 5, 0, -7 },
  { 146, 5, 3, 6, 0, -5 },
  { 148, 5, 5, 5, 0, -6 },
  { 152, 4, 9, 5, 1, -9 },
  { 157, 9, 11, 9, 0, -8 },
  { 170, 7, 9, 7, -1, -9 },
  { 178, 6, 9, 7, 0, -9 },
  { 185, 7, 9, 7, 0, -9 },
  { 193, 6, 9, 7, 0, -9 },
  { 200, 6, 9, 6, 0, -9 },
  { 207, 6, 9, 6, 0, -9 },
  { 214, 7, 9, 7, 0, -9 },
  { 222, 7, 9, 7, 0, -9 },
  { 230, 3, 9, 3, 0, -9 },
  { 234, 6, 9, 6, 0, -9 },
  { 241, 7, 9, 6, 0, -9 },
  { 249, 5, 9, 6, 0, -9 },
  { 255, 9, 9, 9, 0, -9 },
  { 266, 7, 9, 7, 0, -9 },
  { 274, 7, 9, 7, 0, -9 },
  { 282, 7, 9, 7, 0, -9 },
  { 290, 7, 11, 7, 0, -9 },
  { 300, 6, 9, 6, 0, -9 },
  { 307, 6, 9, 6, 0, -9 },
  { 314, 6, 9, 6, 1, -9 },
  { 321, 7, 9, 7, 0, -9 },
  { 329, 6, 9, 7, 1, -9 },
  { 336, 8, 9, 9, 1, -9 },
  { 345, 7, 9, 7, 0, -9 },
  { 353, 6, 9, 6, 1, -9 },
  { 360, 7, 9, 6, 0, -9 },
  { 368, 4, 12, 3, 0, -10 },
  { 374, 3, 10, 4, 1, -9 },
  { 378, 4, 12, 3, -1, -10 },
  { 384, 4, 4, 5, 0, -9 },
  { 386, 5, 1, 5, -1, 0 },
  { 387, 3, 2, 4, 1, -9 },
  { 388, 5, 7, 5, 0, -7 },
  { 393, 5, 9, 6, 0, -9 },
  { 399, 5, 7, 5, 0, -7 },
  { 404, 6, 9, 6, 0, -9 },
  { 411, 5, 7, 6, 0, -7 },
  { 416, 5, 9, 4, 0, -9 },
  { 422, 6, 9, 6, 0, -7 },
  { 429, 5, 9, 6, 0, -9 },
  { 435, 3, 10, 3, 0, -10 },
  { 439, 4, 12, 3, -1, -10 },
  { 445, 6, 9, 6, 0, -9 },
  { 452, 3, 9, 3, 0, -9 },
  { 456, 8, 7, 9, 0, -7 },
  { 463, 5, 7, 6, 0, -7 },
  { 468, 5, 7, 6, 0, -7 },
  { 473, 5, 9, 6, 0, -7 },
  { 479, 6, 9, 6, 0, -7 },
  { 486, 4, 7, 4, 0, -7 },
  { 490, 5, 7, 5, 0, -7 },
  { 495, 4, 8, 4, 0, -8 },
  { 499, 6, 7, 6, 0, -7 },
  { 505, 5, 7, 5, 1, -7 },
  { 510, 7, 7, 7, 1, -7 },
  { 517, 6, 7, 5, 0, -7 },
  { 523, 6, 9, 5, 0, -7 },
  { 530, 5, 7, 5, 0, -7 },
  { 535, 4, 11, 3, 0, -9 },
  { 541, 3, 11, 3, 0, -9 },
  { 546, 3, 11, 3, 0, -9 },
  { 551, 6, 3, 7, 0, -5 },
};

const GFXfont RobotoCondensed_BoldItalic12pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic12pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _ROBOTOCONDENSED_BOLDITALIC12PT7B_H_
