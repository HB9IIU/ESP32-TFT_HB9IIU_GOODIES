#ifndef _ROBOTOCONDENSED_BOLDITALIC46PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic46pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC0, 0x78, 0x00, 0x3C, 0x7B, 0xE3, 0xDF, 0x3E, 0xF9, 0xF7, 0x8F, 0x3C,
  0x79, 0xE3, 0xDF, 0x1E, 0xF1, 0xE7, 0x8F, 0x3C, 0x79, 0xC3, 0xC0, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0x70, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03,
  0xC7, 0x80, 0x07, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x79,
  0xE0, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC0, 0x3C, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x07, 0x8E, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x0F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x0F, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F,
  0x00, 0x0F, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0x81, 0xFC, 0xFC, 0x1F, 0xC7, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F,
  0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF9, 0xFC, 0x0F, 0xCF,
  0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7F, 0x3F,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x78, 0xF0, 0x63, 0xE3, 0xC3, 0xEF, 0x0F, 0x0F, 0x3C, 0x3C, 0x78, 0xF0,
  0xF3, 0xE3, 0xC3, 0xCF, 0x0F, 0x1F, 0x78, 0x1F, 0xFB, 0xC0, 0x7F, 0xEF,
  0x00, 0xFF, 0x78, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x7B, 0xFC, 0x03, 0xDF, 0xF8, 0x1E,
  0xFF, 0xE0, 0x7B, 0xE7, 0x83, 0xCF, 0x0F, 0x1E, 0x3C, 0x3C, 0xF8, 0xF1,
  0xE3, 0xC7, 0xC7, 0x9E, 0x1F, 0x1E, 0x78, 0x3C, 0x78, 0x40, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFE,
  0xFC, 0x01, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x1F, 0x87,
  0xC0, 0x1F, 0x1F, 0x80, 0x3E, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF8, 0xFC,
  0xFF, 0xF1, 0xF1, 0xFF, 0xF3, 0xE7, 0xE7, 0xE7, 0xDF, 0xCF, 0xFF, 0xBF,
  0x0F, 0xFE, 0x7E, 0x1F, 0xFC, 0xFC, 0x1F, 0xF1, 0xF8, 0x3F, 0xE3, 0xF8,
  0x3F, 0x87, 0xF0, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFD, 0xFC, 0x07, 0xE1, 0xFC, 0x3D, 0xF7, 0xDF, 0x7D, 0xE7,
  0xBE, 0xFB, 0xCF, 0x3C, 0x00, 0x08, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x06, 0x00, 0x08,
  0x00, 0x01, 0x00, 0x07, 0x00, 0x1C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x60, 0x01, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x02, 0x07,
  0x82, 0x38, 0x70, 0xE7, 0xF7, 0x7E, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x07,
  0xFF, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xBC, 0x01,
  0xF3, 0xE0, 0x3E, 0x1E, 0x03, 0xC1, 0xF0, 0x18, 0x0E, 0x00, 0x80, 0x80,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F,
  0xC7, 0xE1, 0xF0, 0x78, 0x04, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xE7, 0xFE,
  0xFF, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0x8E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0xFF, 0xE1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x3E, 0x3F,
  0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x03, 0xF7, 0xE0, 0x3F, 0x7E, 0x07, 0xF7,
  0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xEF, 0xE0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0xFE, 0xFC, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F,
  0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0x8F, 0xC1, 0xF8, 0xFC, 0x3F, 0x8F, 0xE7,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x07,
  0xE0, 0x00, 0x00, 0x0C, 0x01, 0xF0, 0x1F, 0x83, 0xFE, 0x3F, 0xF9, 0xFF,
  0xE7, 0xFF, 0xBF, 0xFE, 0xFB, 0xF3, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0xCF, 0xE0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7F, 0x0F, 0xC1,
  0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xF3, 0xF8, 0x7F,
  0x0F, 0xE3, 0xF0, 0x7F, 0x1F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x0F,
  0xE7, 0xE0, 0x7E, 0x3F, 0x07, 0xF1, 0xFC, 0x7F, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x00, 0x7D, 0xF8, 0x03, 0xEF, 0xC0, 0x3E, 0xFE, 0x03, 0xF7, 0xE0, 0x1F,
  0x3F, 0x01, 0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xF8, 0x7E, 0x0F, 0xC7, 0xE0,
  0xFC, 0x3F, 0x07, 0xC1, 0xF8, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x01, 0xF8, 0xFE, 0x0F, 0xE1, 0xF8, 0x3F,
  0x07, 0xE0, 0xFC, 0x1F, 0xCF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xBF,
  0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0x9F,
  0xDF, 0xC1, 0xFB, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x83, 0xFB, 0xF8, 0x7E,
  0x3F, 0x1F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xC0,
  0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xF1, 0xF8, 0x3F, 0x8F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC3, 0xF8, 0x7E, 0x1F,
  0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF0, 0x1F,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0x1F, 0x87, 0xF0, 0xFC, 0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x9F, 0xC1,
  0xFC, 0xFE, 0x0F, 0xC7, 0xF0, 0x7E, 0x3F, 0x87, 0xF0, 0xFE, 0x7F, 0x87,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF,
  0x8F, 0xE7, 0xF3, 0xF0, 0xFD, 0xF8, 0x3F, 0x7E, 0x0F, 0xDF, 0x83, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF8,
  0x7F, 0x7E, 0x3F, 0xDF, 0xFF, 0xF7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF,
  0x83, 0xE7, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0x83, 0xF1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF0,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC1, 0xF8, 0xFE, 0x3F, 0x8F, 0xE1, 0xF8, 0x38, 0x00,
  0x00, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E,
  0x03, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F, 0xF8,
  0x7F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F,
  0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x18, 0x00, 0x07, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0xFF, 0xC1, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF8,
  0x07, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0xFF, 0xFB, 0xF9, 0xFD, 0xF8,
  0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x01, 0xF0, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1E, 0x0F, 0x80, 0xF8, 0x0E, 0x0F, 0x03, 0xFE, 0x0E, 0x1E, 0x07, 0xFF,
  0x0E, 0x1E, 0x0F, 0xFF, 0x0F, 0x3C, 0x1F, 0x0F, 0x0F, 0x3C, 0x3E, 0x1F,
  0x0F, 0x7C, 0x3E, 0x1E, 0x0E, 0x78, 0x3C, 0x1E, 0x0E, 0x78, 0x7C, 0x1E,
  0x0E, 0x78, 0x78, 0x3E, 0x1E, 0xF8, 0xF8, 0x3C, 0x1E, 0xF0, 0xF8, 0x3C,
  0x1E, 0xF0, 0xF8, 0x3C, 0x1E, 0xF0, 0xF8, 0x7C, 0x1C, 0xF0, 0xF8, 0x78,
  0x3C, 0xF0, 0xF8, 0x78, 0x3C, 0xF0, 0xF8, 0xF8, 0x78, 0xF0, 0xF9, 0xF8,
  0x78, 0xF0, 0xFF, 0xFF, 0xF0, 0xF0, 0x7F, 0xFF, 0xE0, 0xF0, 0x7F, 0x3F,
  0xC0, 0xF0, 0x3E, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFD, 0xF8,
  0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x03, 0xF0,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F,
  0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFC, 0x01,
  0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x07, 0xE7, 0xF0,
  0x01, 0xF9, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x07, 0xE1, 0xFF, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F,
  0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x81, 0xFC, 0x3F, 0x80, 0xFC,
  0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x01, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x0F, 0xF8, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x0F, 0xF3, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0x80, 0x7E,
  0x3F, 0x80, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x03, 0xF8, 0xFC, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x9F, 0xF0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xE3, 0xFE, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x7E, 0x3F, 0x80, 0x7E, 0x3F, 0x80, 0xFE, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x03, 0xF8, 0x7F, 0x07, 0xF8,
  0x7F, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F,
  0xFB, 0xFE, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0x7F, 0x3F,
  0x00, 0x7F, 0x3F, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xFE, 0xFE,
  0x0F, 0xFE, 0xFE, 0x1F, 0xFC, 0xFE, 0x1F, 0xFC, 0xFC, 0x1F, 0xFC, 0xFC,
  0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0xFE, 0x01, 0xF8, 0xFE,
  0x01, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0xDF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F,
  0x83, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07,
  0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0xFE, 0x0F,
  0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x7F, 0x03, 0xFD, 0xFC, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x0F, 0xF0, 0x3F, 0x01, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0x7F,
  0x03, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7E, 0x0F, 0xF0, 0x07, 0xE1, 0xFE,
  0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x80, 0x0F,
  0xE7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xEF,
  0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xF0, 0xFE, 0x00,
  0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x3F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xFC,
  0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F, 0xFF, 0xF7, 0xFF, 0xFE,
  0xFF, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xF8,
  0x1F, 0xF0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F,
  0xFC, 0x0F, 0xFC, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x1F, 0xFE, 0x07, 0xEF, 0x83, 0xEF, 0xC0, 0xFC, 0xF0, 0x7D,
  0xF8, 0x1F, 0x9E, 0x1F, 0x3F, 0x03, 0xF3, 0xE3, 0xEF, 0xE0, 0x7E, 0x7C,
  0xF9, 0xF8, 0x0F, 0xCF, 0x9F, 0x3F, 0x03, 0xF9, 0xF7, 0xE7, 0xE0, 0x7F,
  0x3E, 0xF8, 0xFC, 0x0F, 0xC7, 0xDF, 0x3F, 0x81, 0xF8, 0xFF, 0xC7, 0xF0,
  0x3F, 0x0F, 0xF8, 0xFC, 0x07, 0xE1, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0xC3,
  0xF0, 0x3F, 0x87, 0xF0, 0xFE, 0x07, 0xE0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F,
  0x83, 0xF8, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0xF0, 0x7E, 0x0F, 0xC0, 0xFE,
  0x0F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x7F, 0x07,
  0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7E, 0x07, 0xF8, 0x07, 0xE0, 0x7F, 0xC0,
  0x7E, 0x07, 0xFC, 0x07, 0xE0, 0x7F, 0xC0, 0xFE, 0x0F, 0xFC, 0x0F, 0xE0,
  0xFF, 0xE0, 0xFC, 0x0F, 0xFE, 0x0F, 0xC0, 0xFD, 0xE0, 0xFC, 0x0F, 0xDE,
  0x0F, 0xC0, 0xFD, 0xF1, 0xFC, 0x1F, 0xDF, 0x1F, 0xC1, 0xFC, 0xF1, 0xF8,
  0x1F, 0xCF, 0x9F, 0x81, 0xF8, 0xF9, 0xF8, 0x1F, 0x8F, 0x9F, 0x81, 0xF8,
  0x7B, 0xF8, 0x3F, 0x87, 0xFF, 0x83, 0xF8, 0x7F, 0xF0, 0x3F, 0x07, 0xFF,
  0x03, 0xF0, 0x3F, 0xF0, 0x3F, 0x03, 0xFF, 0x03, 0xF0, 0x3F, 0xF0, 0x7F,
  0x03, 0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0x7E, 0x01, 0xFE, 0x07, 0xE0, 0x1F,
  0xE0, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x0F, 0xFB, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0x7F,
  0x3F, 0x80, 0x7F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F,
  0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0x7E, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E,
  0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC,
  0xFC, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0x7E, 0x07, 0xF8, 0x7F, 0xDF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x1F, 0xFC, 0x1F, 0x80,
  0xFE, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF8,
  0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x7F,
  0x01, 0xFC, 0x3F, 0x87, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x0F, 0xFB, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0x80, 0x7E, 0x3F,
  0x80, 0x7F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7F,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC,
  0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x7F, 0xDF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0,
  0x3F, 0x07, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F,
  0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07,
  0xF0, 0x7E, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x3F, 0x87, 0xFC, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F,
  0x07, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x07,
  0xE0, 0x3F, 0x83, 0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0,
  0xFE, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0x3F, 0xC3, 0xF8, 0x3F,
  0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x7E, 0x01,
  0xFC, 0xFC, 0x03, 0xF1, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC3, 0xFC, 0xFF,
  0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x03,
  0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83,
  0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xC0, 0x3F,
  0x87, 0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x07, 0xE0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE,
  0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F,
  0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0xFC, 0x07, 0xC0,
  0x7E, 0xFC, 0x0F, 0xC0, 0xFE, 0xFC, 0x0F, 0xC0, 0xFC, 0xFC, 0x0F, 0xE0,
  0xFC, 0xFC, 0x1F, 0xE0, 0xFC, 0xFC, 0x1F, 0xE1, 0xF8, 0xFC, 0x3F, 0xE1,
  0xF8, 0xFC, 0x3F, 0xE1, 0xF8, 0xFC, 0x3F, 0xE3, 0xF8, 0xFC, 0x7F, 0xE3,
  0xF0, 0xFC, 0x7F, 0xE3, 0xF0, 0xFC, 0x7F, 0xE7, 0xF0, 0xFC, 0xFF, 0xE7,
  0xE0, 0xFC, 0xFB, 0xE7, 0xE0, 0xFC, 0xFB, 0xEF, 0xE0, 0xFD, 0xFB, 0xEF,
  0xC0, 0xFD, 0xF3, 0xEF, 0xC0, 0xFD, 0xF3, 0xEF, 0xC0, 0xFF, 0xF3, 0xFF,
  0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE3, 0xFF, 0x80, 0xFF, 0xE3, 0xFF,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0xFF, 0xC3, 0xFE,
  0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0x83, 0xFC,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC1, 0xFE, 0x00,
  0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7E,
  0x7F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x3F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x01, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFB, 0xF8,
  0x07, 0xF3, 0xF0, 0x1F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x1F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x3F, 0x80, 0xFC, 0x7E,
  0x01, 0xF9, 0xFC, 0x01, 0xF3, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F,
  0x83, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x78,
  0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC,
  0x07, 0xBC, 0x0F, 0xBE, 0x0F, 0x9E, 0x1F, 0x1E, 0x1F, 0x1E, 0x3E, 0x1E,
  0x3E, 0x1E, 0x7C, 0x1F, 0x7C, 0x1F, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF0,
  0xFC, 0x3E, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE1, 0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x00, 0x07,
  0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xF8,
  0xFC, 0x7F, 0x0F, 0xC7, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xE1, 0xFC, 0x7E,
  0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xDF, 0x80,
  0xF9, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xE7, 0xF0, 0xFC,
  0x1F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF3, 0xF8, 0x1F, 0x9F, 0x81, 0xFC,
  0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xF8, 0x1F, 0x9F, 0xC0,
  0xFC, 0xFC, 0x0F, 0xE7, 0xF0, 0x7E, 0x3F, 0xC7, 0xF1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF8, 0xFD, 0xFF, 0x87, 0xE7, 0xF8, 0x3F, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x1F,
  0x8F, 0xC1, 0xFB, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0xFC, 0x1F, 0x9F, 0x83, 0xF1, 0xF8, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xE0,
  0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0xFC, 0xFE, 0x07, 0xFB, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x3F, 0x8F, 0xF1, 0xFC, 0x1F, 0xC7, 0xE0, 0x7E, 0x1F,
  0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0xFC, 0x1F, 0xC3, 0xF8, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x80, 0xFF, 0x7E, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0x1F, 0xCF, 0xC1,
  0xFB, 0xF8, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x41, 0xFC, 0x7C, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE,
  0x03, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFF, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0xFC, 0x0F,
  0xFB, 0xF0, 0x7F, 0xEF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0x9F,
  0xE3, 0xF8, 0x3F, 0x8F, 0xE0, 0x7E, 0x3F, 0x03, 0xF8, 0xFC, 0x0F, 0xC7,
  0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x7F, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xFC, 0x1F, 0x87, 0xF9, 0xFE,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x01,
  0xF3, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x02, 0x01, 0xF8, 0x1E, 0x1F,
  0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0xF8, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xC7, 0xF1, 0xF8, 0x3F,
  0x1F, 0x83, 0xF3, 0xF8, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x3F, 0x07,
  0xF3, 0xF0, 0x7E, 0x3F, 0x07, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x0F, 0xE7, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xE0, 0xFC, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x1F, 0xC0, 0x01, 0xC0, 0x3E, 0x07, 0xF0,
  0x7F, 0x07, 0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x00, 0x0E,
  0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x0F, 0xE0, 0xFC, 0x3F, 0xC1, 0xF8, 0xFF, 0x07, 0xF3,
  0xFC, 0x0F, 0xC7, 0xF0, 0x1F, 0x9F, 0xC0, 0x3F, 0x7F, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFE, 0xFC, 0x03,
  0xF9, 0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F,
  0x0F, 0xE0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x80, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F,
  0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF8, 0x3F, 0x83, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xCF, 0x81, 0xF0, 0x1F, 0xFF, 0xCF, 0xF8,
  0x3F, 0xFF, 0xBF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFC, 0xFF, 0x9F, 0xC7, 0xE0, 0xFE, 0x1F, 0x8F, 0xC1, 0xF8, 0x3F, 0x1F,
  0x83, 0xF0, 0x7E, 0x7F, 0x07, 0xE0, 0xFC, 0xFC, 0x1F, 0xC1, 0xF9, 0xF8,
  0x3F, 0x07, 0xF3, 0xF0, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC, 0x1F, 0x8F, 0xC1,
  0xF8, 0x3F, 0x3F, 0x83, 0xF0, 0x7E, 0x7E, 0x0F, 0xE0, 0xFC, 0xFC, 0x1F,
  0x83, 0xF9, 0xF8, 0x3F, 0x07, 0xE3, 0xF0, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC,
  0x1F, 0x9F, 0xC1, 0xF8, 0x3F, 0x3F, 0x07, 0xF0, 0x7E, 0x7E, 0x0F, 0xC1,
  0xFC, 0x0F, 0xCF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF1, 0xFE, 0x7F, 0x1F, 0x83, 0xF1, 0xF8, 0x3F, 0x3F, 0x83, 0xF3,
  0xF0, 0x3F, 0x3F, 0x03, 0xF3, 0xF0, 0x7F, 0x3F, 0x07, 0xE3, 0xF0, 0x7E,
  0x7F, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0xFE, 0x7E, 0x0F,
  0xC7, 0xE0, 0xFC, 0xFE, 0x0F, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0xCF, 0xC1,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE3, 0xF8, 0xFE, 0x3F, 0x07, 0xE7, 0xF0, 0x7E, 0x7E, 0x07, 0xF7,
  0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xEF, 0xC0, 0x7E, 0xFC, 0x0F, 0xCF, 0xE0, 0xFC, 0x7F, 0x3F,
  0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x7F,
  0x00, 0x03, 0xF3, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0x3F, 0x81, 0xF8, 0x3F, 0x83, 0xF0, 0x7F,
  0x07, 0xE0, 0x7E, 0x1F, 0xC1, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F,
  0x81, 0xFC, 0x3F, 0x83, 0xF0, 0x7F, 0x1F, 0xE0, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x07, 0xEF, 0xFC, 0x0F, 0xCF, 0xF0, 0x1F, 0x8F, 0x80, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF1, 0xF8, 0x3F, 0xCF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF,
  0xFF, 0x1F, 0xC7, 0xF9, 0xFC, 0x1F, 0xCF, 0xC0, 0xFC, 0x7E, 0x07, 0xE3,
  0xF0, 0x3F, 0x3F, 0x81, 0xF9, 0xF8, 0x1F, 0xCF, 0xC0, 0xFE, 0x7E, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE, 0x3F,
  0x8F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x01, 0xF7, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x0F, 0xCF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xFE, 0x1F, 0xF2, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFF, 0xFE, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0xF8, 0x3F, 0x1F, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0xFC, 0xFC, 0x0F, 0xDF, 0x81, 0xF3, 0xF8, 0x7E,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFE, 0x0F, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x83, 0xF8,
  0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81,
  0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFC, 0x3F, 0x07, 0xE3, 0xF8, 0x3F, 0x1F,
  0x81, 0xF8, 0xFC, 0x1F, 0xC7, 0xE0, 0xFE, 0x3F, 0x07, 0xE3, 0xF8, 0x3F,
  0x1F, 0xC1, 0xF8, 0xFC, 0x0F, 0xC7, 0xF0, 0xFE, 0x3F, 0xCF, 0xE0, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0x7E, 0x03, 0xF3, 0xF0,
  0xFE, 0x0F, 0xFF, 0xC1, 0xFD, 0xF8, 0x3F, 0x3F, 0x0F, 0xE7, 0xE1, 0xF8,
  0xFC, 0x3F, 0x1F, 0x8F, 0xC3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F, 0xCF, 0xC1,
  0xF9, 0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0xC0, 0x7D, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x3E, 0x0F,
  0xFE, 0x0F, 0x83, 0xFF, 0x83, 0xE0, 0xFB, 0xE1, 0xF8, 0x7E, 0xF8, 0x7E,
  0x1F, 0xBE, 0x3F, 0x87, 0xCF, 0x8F, 0xF3, 0xF3, 0xE3, 0xFC, 0xFC, 0xF9,
  0xFF, 0x3E, 0x3E, 0x7F, 0xDF, 0x8F, 0xBF, 0xF7, 0xC3, 0xEF, 0xFD, 0xF0,
  0xFB, 0xDF, 0xFC, 0x3F, 0xF3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x3F,
  0xE0, 0xFF, 0x8F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xE0, 0xFE, 0x0F, 0xC1, 0xF8, 0x1F, 0xC7, 0xF0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0xFE, 0x00, 0x7D, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xDF, 0x00, 0x3F, 0x3F, 0x00, 0xFE, 0x7E,
  0x01, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0,
  0x1F, 0xC0, 0xFC, 0x3F, 0x07, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x0F,
  0xC3, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xCF,
  0xE0, 0x3F, 0x3F, 0x00, 0xFD, 0xFC, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x80,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x08,
  0x00, 0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x80, 0x03, 0xC0, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x00, 0x01, 0x80, 0x07, 0x00, 0x1E, 0x00, 0xFC, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0,
  0x1F, 0x80, 0xFE, 0x01, 0xF0, 0x07, 0x00, 0x10, 0x00, 0x0F, 0x80, 0x00,
  0xFE, 0x03, 0xCF, 0xF8, 0x3E, 0xFF, 0xE1, 0xF7, 0xFF, 0x9F, 0x7E, 0x7F,
  0xFB, 0xE1, 0xFF, 0xDF, 0x07, 0xFC, 0xF0, 0x1F, 0xC0, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 33, 12, 1, -33 },
  { 51, 13, 12, 14, 3, -35 },
  { 71, 23, 33, 24, 1, -33 },
  { 166, 21, 42, 23, 1, -38 },
  { 277, 22, 33, 29, 4, -33 },
  { 368, 23, 33, 26, 1, -33 },
  { 463, 6, 12, 7, 3, -35 },
  { 472, 14, 46, 14, 2, -36 },
  { 553, 14, 46, 14, -2, -36 },
  { 634, 20, 20, 20, 2, -33 },
  { 684, 20, 24, 21, 1, -27 },
  { 744, 10, 14, 11, -3, -6 },
  { 762, 12, 5, 16, 2, -16 },
  { 770, 7, 7, 13, 1, -7 },
  { 777, 20, 36, 15, -3, -33 },
  { 867, 20, 33, 23, 2, -33 },
  { 950, 14, 33, 23, 5, -33 },
  { 1008, 22, 33, 23, 0, -33 },
  { 1099, 21, 33, 23, 1, -33 },
  { 1186, 21, 33, 23, 1, -33 },
  { 1273, 22, 33, 23, 1, -33 },
  { 1364, 19, 33, 23, 2, -33 },
  { 1443, 22, 33, 23, 2, -33 },
  { 1534, 21, 33, 23, 1, -33 },
  { 1621, 18, 33, 23, 3, -33 },
  { 1696, 10, 25, 12, 1, -25 },
  { 1728, 13, 33, 12, -2, -25 },
  { 1782, 18, 22, 20, 1, -25 },
  { 1832, 19, 15, 22, 2, -22 },
  { 1868, 18, 22, 20, 1, -25 },
  { 1918, 17, 33, 20, 3, -33 },
  { 1989, 32, 42, 34, 1, -32 },
  { 2157, 26, 33, 27, -2, -33 },
  { 2265, 24, 33, 25, 0, -33 },
  { 2364, 24, 33, 25, 2, -33 },
  { 2463, 24, 33, 25, 0, -33 },
  { 2562, 24, 33, 22, 0, -33 },
  { 2661, 23, 33, 21, 0, -33 },
  { 2756, 24, 33, 26, 2, -33 },
  { 2855, 28, 33, 27, 0, -33 },
  { 2971, 13, 33, 12, 0, -33 },
  { 3025, 23, 33, 22, 0, -33 },
  { 3120, 28, 33, 25, 0, -33 },
  { 3236, 19, 33, 21, 0, -33 },
  { 3315, 35, 33, 34, 0, -33 },
  { 3460, 28, 33, 27, 0, -33 },
  { 3576, 24, 33, 27, 2, -33 },
  { 3675, 25, 33, 25, 0, -33 },
  { 3779, 24, 39, 27, 2, -33 },
  { 3896, 25, 33, 25, 0, -33 },
  { 4000, 23, 33, 24, 1, -33 },
  { 4095, 23, 33, 24, 3, -33 },
  { 4190, 26, 33, 26, 1, -33 },
  { 4298, 24, 33, 26, 4, -33 },
  { 4397, 32, 33, 33, 4, -33 },
  { 4529, 29, 33, 25, -2, -33 },
  { 4649, 23, 33, 24, 4, -33 },
  { 4744, 26, 33, 24, -1, -33 },
  { 4852, 16, 46, 12, -1, -38 },
  { 4944, 11, 36, 17, 4, -33 },
  { 4994, 16, 46, 12, -3, -38 },
  { 5086, 16, 16, 17, 1, -33 },
  { 5118, 18, 5, 18, -3, 0 },
  { 5130, 9, 7, 15, 5, -35 },
  { 5138, 20, 24, 21, 0, -24 },
  { 5198, 21, 35, 22, 0, -35 },
  { 5290, 19, 24, 21, 1, -24 },
  { 5347, 22, 35, 22, 1, -35 },
  { 5444, 19, 24, 21, 1, -24 },
  { 5501, 17, 35, 15, 1, -35 },
  { 5576, 22, 33, 22, 0, -24 },
  { 5667, 20, 35, 22, 0, -35 },
  { 5755, 12, 34, 11, 0, -34 },
  { 5806, 17, 43, 11, -5, -34 },
  { 5898, 23, 35, 21, 0, -35 },
  { 5999, 12, 35, 11, 0, -35 },
  { 6052, 31, 24, 33, 0, -24 },
  { 6145, 20, 24, 22, 0, -24 },
  { 6205, 20, 24, 22, 1, -24 },
  { 6265, 23, 33, 22, -2, -24 },
  { 6360, 21, 33, 22, 1, -24 },
  { 6447, 16, 24, 15, 0, -24 },
  { 6495, 19, 24, 20, 0, -24 },
  { 6552, 12, 30, 14, 2, -30 },
  { 6597, 21, 24, 22, 1, -24 },
  { 6660, 19, 24, 20, 2, -24 },
  { 6717, 26, 24, 28, 3, -24 },
  { 6795, 23, 24, 20, -2, -24 },
  { 6864, 22, 33, 20, -1, -24 },
  { 6955, 21, 24, 20, -1, -24 },
  { 7018, 14, 44, 13, 1, -36 },
  { 7095, 10, 39, 11, 1, -33 },
  { 7144, 14, 44, 13, -2, -36 },
  { 7221, 21, 10, 25, 2, -18 },
};

const GFXfont RobotoCondensed_BoldItalic46pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic46pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic46pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _ROBOTOCONDENSED_BOLDITALIC46PT7B_H_
