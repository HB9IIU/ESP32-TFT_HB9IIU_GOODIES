#ifndef _ROBOTOCONDENSED_BOLDITALIC10PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0xB0, 0xDB, 0x00, 0x29, 0x5E, 0xAF, 0x31, 0x80, 0x11,
  0x96, 0x83, 0x0B, 0x4E, 0x40, 0xC5, 0xB8, 0x47, 0x54, 0xC0, 0x32, 0x94,
  0xDF, 0xE9, 0xE0, 0xE0, 0x12, 0x44, 0x44, 0xC4, 0x44, 0x48, 0x96, 0xD2,
  0x90, 0x23, 0xC8, 0xA0, 0x22, 0xF2, 0x60, 0x4B, 0x00, 0x60, 0x30, 0x08,
  0x84, 0x42, 0x21, 0x08, 0x32, 0xD6, 0xBD, 0x69, 0x80, 0x3D, 0xA4, 0x90,
  0x72, 0xC6, 0x22, 0x23, 0xC0, 0x72, 0xC6, 0x61, 0x69, 0x80, 0x19, 0x9C,
  0xAF, 0x18, 0xC0, 0x7A, 0x1C, 0x21, 0x69, 0x80, 0x33, 0x1C, 0xAD, 0x29,
  0xC0, 0x78, 0xC4, 0x62, 0x31, 0x00, 0x32, 0xD6, 0xED, 0x69, 0xC0, 0x6B,
  0xBB, 0xE6, 0xC0, 0x10, 0x30, 0x10, 0x3A, 0x1E, 0xE2, 0x70, 0x1C, 0x43,
  0x78, 0xF4, 0xAC, 0x20, 0x1C, 0x45, 0x6B, 0x5A, 0xB5, 0x6F, 0x40, 0x70,
  0x11, 0x8E, 0xF4, 0xFE, 0x20, 0x7A, 0x52, 0xED, 0xEF, 0xC0, 0x39, 0xA4,
  0xD0, 0xC1, 0x67, 0x00, 0x72, 0x52, 0x9C, 0xEF, 0xC0, 0x7A, 0x10, 0xEC,
  0x63, 0xC0, 0x7A, 0x10, 0xEC, 0x63, 0x00, 0x39, 0xB4, 0x16, 0xC9, 0x27,
  0x00, 0x65, 0x34, 0xDF, 0xCB, 0x2C, 0x80, 0x69, 0x25, 0xB0, 0x18, 0xC6,
  0x21, 0x59, 0x80, 0x6D, 0x65, 0x1C, 0xD3, 0x4D, 0x80, 0x64, 0x44, 0xCC,
  0xF0, 0x66, 0x66, 0x66, 0x6A, 0xEE, 0xD6, 0xD4, 0x65, 0xB6, 0xD6, 0xDB,
  0x6D, 0x80, 0x39, 0xB4, 0xD3, 0xC9, 0x67, 0x00, 0x79, 0x24, 0x92, 0xF3,
  0x0C, 0x00, 0x39, 0xB4, 0xD3, 0xC9, 0x67, 0x06, 0x7A, 0x52, 0xED, 0x6B,
  0x60, 0x3A, 0x50, 0x61, 0xED, 0xC0, 0xFB, 0x18, 0x84, 0x23, 0x00, 0x6D,
  0x34, 0x92, 0xCB, 0x67, 0x00, 0x9C, 0xE5, 0xEE, 0x71, 0x00, 0x97, 0x6A,
  0xD7, 0xED, 0x9B, 0x36, 0x00, 0x6D, 0xE3, 0x0C, 0x71, 0x4D, 0x80, 0x9E,
  0xB8, 0xC4, 0x21, 0x00, 0x78, 0x61, 0x08, 0x63, 0x0F, 0x00, 0x69, 0x24,
  0xB6, 0x98, 0xAB, 0xD5, 0x33, 0x22, 0x22, 0x66, 0x64, 0x26, 0x65, 0x70,
  0xD0, 0x75, 0x79, 0xF0, 0x62, 0x10, 0xE5, 0x6B, 0x5E, 0x75, 0xCD, 0x60,
  0x08, 0x46, 0xFD, 0x6B, 0x4E, 0x75, 0xFD, 0x70, 0x36, 0x66, 0x44, 0x4C,
  0x7E, 0xF5, 0xA7, 0x5B, 0x80, 0x44, 0x47, 0x5D, 0xD9, 0x61, 0x25, 0xA0,
  0x30, 0x22, 0x26, 0x44, 0xC0, 0x62, 0x10, 0xB7, 0x73, 0xD6, 0x69, 0x25,
  0xB4, 0x7E, 0xAF, 0x5E, 0xA9, 0x40, 0x75, 0xDD, 0x90, 0x72, 0xB5, 0xA7,
  0x00, 0x72, 0xB5, 0xAF, 0x42, 0x00, 0x7E, 0xB5, 0xA7, 0x18, 0xC0, 0x6B,
  0x68, 0x75, 0x69, 0x60, 0x6B, 0xA5, 0x90, 0x5A, 0xB5, 0xA7, 0x00, 0x52,
  0x98, 0xC6, 0x00, 0xAF, 0x7D, 0x6B, 0x00, 0x53, 0x98, 0xCB, 0x00, 0x52,
  0x98, 0xC6, 0x22, 0x00, 0x73, 0x64, 0xF0, 0x25, 0xA5, 0x12, 0x48, 0x55,
  0x6A, 0x49, 0x22, 0x96, 0x90, 0x6D, 0xC0,
};

const GFXglyph RobotoCondensed_BoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 7, 3, 0, -7 },
  { 4, 3, 3, 3, 1, -8 },
  { 6, 5, 7, 5, 0, -7 },
  { 11, 5, 9, 5, 0, -8 },
  { 17, 5, 7, 6, 1, -7 },
  { 22, 5, 7, 6, 0, -7 },
  { 27, 1, 3, 2, 1, -8 },
  { 28, 4, 10, 3, 0, -8 },
  { 33, 3, 10, 3, 0, -8 },
  { 37, 5, 4, 4, 0, -7 },
  { 40, 4, 5, 5, 0, -6 },
  { 43, 3, 3, 2, -1, -1 },
  { 45, 3, 1, 4, 0, -3 },
  { 46, 2, 2, 3, 0, -2 },
  { 47, 5, 8, 3, -1, -7 },
  { 52, 5, 7, 5, 0, -7 },
  { 57, 3, 7, 5, 1, -7 },
  { 60, 5, 7, 5, 0, -7 },
  { 65, 5, 7, 5, 0, -7 },
  { 70, 5, 7, 5, 0, -7 },
  { 75, 5, 7, 5, 0, -7 },
  { 80, 5, 7, 5, 0, -7 },
  { 85, 5, 7, 5, 0, -7 },
  { 90, 5, 7, 5, 0, -7 },
  { 95, 4, 7, 5, 1, -7 },
  { 99, 2, 6, 3, 0, -6 },
  { 101, 2, 8, 3, 0, -6 },
  { 103, 4, 4, 4, 0, -5 },
  { 105, 5, 3, 5, 0, -5 },
  { 107, 4, 4, 4, 0, -5 },
  { 109, 3, 7, 4, 1, -7 },
  { 112, 7, 9, 7, 0, -7 },
  { 120, 5, 7, 6, 0, -7 },
  { 125, 5, 7, 5, 0, -7 },
  { 130, 6, 7, 6, 0, -7 },
  { 136, 5, 7, 5, 0, -7 },
  { 141, 5, 7, 5, 0, -7 },
  { 146, 5, 7, 5, 0, -7 },
  { 151, 6, 7, 6, 0, -7 },
  { 157, 6, 7, 6, 0, -7 },
  { 163, 3, 7, 3, 0, -7 },
  { 166, 5, 7, 5, 0, -7 },
  { 171, 6, 7, 5, 0, -7 },
  { 177, 4, 7, 5, 0, -7 },
  { 181, 8, 7, 7, 0, -7 },
  { 188, 6, 7, 6, 0, -7 },
  { 194, 6, 7, 6, 0, -7 },
  { 200, 6, 7, 6, 0, -7 },
  { 206, 6, 8, 6, 0, -7 },
  { 212, 5, 7, 5, 0, -7 },
  { 217, 5, 7, 5, 0, -7 },
  { 222, 5, 7, 5, 1, -7 },
  { 227, 6, 7, 6, 0, -7 },
  { 233, 5, 7, 6, 1, -7 },
  { 238, 7, 7, 7, 1, -7 },
  { 245, 6, 7, 5, 0, -7 },
  { 251, 5, 7, 5, 1, -7 },
  { 256, 6, 7, 5, 0, -7 },
  { 262, 3, 10, 3, 0, -8 },
  { 266, 2, 8, 4, 1, -7 },
  { 268, 4, 10, 3, -1, -8 },
  { 273, 4, 4, 4, 0, -7 },
  { 275, 4, 1, 4, -1, 0 },
  { 276, 2, 2, 3, 1, -8 },
  { 277, 4, 5, 5, 0, -5 },
  { 280, 5, 8, 5, 0, -8 },
  { 285, 4, 5, 4, 0, -5 },
  { 288, 5, 8, 5, 0, -8 },
  { 293, 4, 5, 5, 0, -5 },
  { 296, 4, 8, 3, 0, -8 },
  { 300, 5, 7, 5, 0, -5 },
  { 305, 4, 8, 5, 0, -8 },
  { 309, 3, 7, 2, 0, -7 },
  { 312, 4, 9, 2, -1, -7 },
  { 317, 5, 8, 5, 0, -8 },
  { 322, 3, 8, 2, 0, -8 },
  { 325, 7, 5, 7, 0, -5 },
  { 330, 4, 5, 5, 0, -5 },
  { 333, 5, 5, 5, 0, -5 },
  { 337, 5, 7, 5, 0, -5 },
  { 342, 5, 7, 5, 0, -5 },
  { 347, 3, 5, 3, 0, -5 },
  { 349, 4, 5, 4, 0, -5 },
  { 352, 3, 7, 3, 0, -7 },
  { 355, 5, 5, 5, 0, -5 },
  { 359, 5, 5, 4, 0, -5 },
  { 363, 5, 5, 6, 1, -5 },
  { 367, 5, 5, 4, 0, -5 },
  { 371, 5, 7, 4, 0, -5 },
  { 376, 4, 5, 4, 0, -5 },
  { 379, 3, 10, 3, 0, -8 },
  { 383, 2, 8, 2, 0, -7 },
  { 385, 3, 10, 3, 0, -8 },
  { 389, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoCondensed_BoldItalic10pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic10pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOCONDENSED_BOLDITALIC10PT7B_H_
