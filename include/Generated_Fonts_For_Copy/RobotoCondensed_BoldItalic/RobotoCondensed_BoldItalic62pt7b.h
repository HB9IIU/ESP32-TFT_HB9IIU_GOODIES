#ifndef _ROBOTOCONDENSED_BOLDITALIC62PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC62PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07,
  0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF,
  0x80, 0x7F, 0x00, 0x3E, 0x00, 0x08, 0x00, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3,
  0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF9, 0xF8,
  0x7C, 0x7E, 0x1F, 0x1F, 0x0F, 0xC7, 0xC3, 0xF3, 0xF0, 0xF8, 0xFC, 0x3E,
  0x3E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xF8, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03,
  0xF0, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F,
  0xF0, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x8F, 0xF0,
  0x0F, 0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF, 0x00, 0xFF,
  0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x81, 0xFF, 0x07, 0xF8, 0x3F, 0xF0, 0x7F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x02, 0x07, 0xF1,
  0xF8, 0x0C, 0x1F, 0x87, 0xE0, 0x7C, 0x7E, 0x1F, 0x83, 0xF1, 0xF0, 0x7E,
  0x0F, 0x87, 0xC1, 0xF8, 0x7E, 0x1F, 0x07, 0xE3, 0xF0, 0x7C, 0x1F, 0x9F,
  0x81, 0xF0, 0x7C, 0x7C, 0x07, 0xC1, 0xF3, 0xF0, 0x1F, 0x0F, 0xDF, 0x80,
  0x7F, 0xFE, 0x7C, 0x01, 0xFF, 0xFB, 0xF0, 0x03, 0xFF, 0xDF, 0x80, 0x07,
  0xFE, 0x7C, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x04, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0xFF, 0x00, 0x03, 0xE7, 0xFE, 0x00, 0x1F, 0xBF, 0xFC, 0x00, 0xFD, 0xFF,
  0xF8, 0x03, 0xEF, 0xFF, 0xE0, 0x1F, 0xBF, 0x0F, 0x80, 0xFC, 0xFC, 0x3E,
  0x03, 0xE7, 0xE0, 0xF8, 0x1F, 0x9F, 0x83, 0xE0, 0xFC, 0x7E, 0x0F, 0x83,
  0xE1, 0xF8, 0x3E, 0x1F, 0x87, 0xE0, 0xF8, 0xFC, 0x1F, 0x87, 0xE3, 0xE0,
  0x7E, 0x1F, 0x8F, 0x01, 0xF8, 0x7C, 0x0C, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0xFE, 0x1F, 0xFF, 0xC1, 0xFC, 0x7F, 0xFF,
  0xC7, 0xF1, 0xFF, 0xFF, 0x8F, 0xE3, 0xFC, 0xFF, 0x9F, 0xCF, 0xF8, 0xFF,
  0x7F, 0x9F, 0xE1, 0xFF, 0xFF, 0x7F, 0xC1, 0xFF, 0xFC, 0xFF, 0x83, 0xFF,
  0xF9, 0xFF, 0x03, 0xFF, 0xE3, 0xFE, 0x07, 0xFF, 0xC7, 0xFC, 0x07, 0xFF,
  0x0F, 0xF8, 0x0F, 0xFE, 0x1F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x7F, 0xC0, 0x7F, 0xF8, 0x7F, 0x80,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF3, 0xF9, 0xF8,
  0xFC, 0x7E, 0x3F, 0x1F, 0x9F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x00, 0x20, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0xC0, 0x3E, 0x02, 0x3C, 0x0F,
  0x07, 0xDF, 0xC7, 0xC7, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x9F,
  0x80, 0x0F, 0xC7, 0xE0, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x1E, 0x01, 0xF0, 0x03, 0x00, 0x70, 0x00, 0x40, 0x08, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F,
  0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x01,
  0xE0, 0x02, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1E, 0x0F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFD, 0xFE, 0x3F, 0x02, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xC3,
  0xFC, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0xFF, 0x1F, 0xC0, 0x3F,
  0xCF, 0xF0, 0x0F, 0xF3, 0xFC, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0,
  0x3F, 0xDF, 0xF0, 0x0F, 0xF7, 0xF8, 0x03, 0xFD, 0xFE, 0x00, 0xFF, 0x7F,
  0x80, 0x7F, 0xDF, 0xE0, 0x1F, 0xF7, 0xF8, 0x07, 0xFB, 0xFE, 0x01, 0xFE,
  0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xEF, 0xF0, 0x0F, 0xFB, 0xFC, 0x03,
  0xFE, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xF0, 0x0F, 0xF3, 0xFC,
  0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xE3,
  0xFC, 0x07, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xC1, 0xFF, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0xF0, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC7,
  0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xF3, 0xFC, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xF8,
  0x1F, 0xE0, 0x7F, 0xC1, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0xFF, 0x81, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x07, 0xF8, 0xFF, 0x00,
  0x7F, 0x8F, 0xF0, 0x0F, 0xF8, 0xFF, 0x80, 0xFF, 0x8F, 0xFC, 0x1F, 0xF0,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFB, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xF7, 0xFC,
  0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x3F,
  0x87, 0xF8, 0x03, 0xF8, 0xFF, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x7F,
  0x81, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0x03,
  0xFE, 0x00, 0x30, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFF, 0x03, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x8F, 0xC0,
  0x3F, 0xDF, 0xF8, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF, 0x87, 0xFD, 0xFF, 0x81,
  0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x01, 0xFE, 0xFF, 0x00, 0xFF, 0x7F, 0x80, 0xFF, 0xBF, 0xC0, 0x7F, 0xDF,
  0xE0, 0x7F, 0xC7, 0xF8, 0x3F, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x03, 0xFC, 0x3F, 0xE0, 0x7F,
  0x87, 0xFC, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC3, 0xFC,
  0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x1F, 0xE1, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0x87, 0xF8, 0x3F, 0xE0, 0x7F, 0x87, 0xF8, 0x0F,
  0xF0, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xF8, 0x07, 0xF8, 0xFF,
  0x00, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0xFF,
  0x8F, 0xF8, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x1F, 0xE0, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0xCF, 0xF8, 0x0F,
  0xF7, 0xF8, 0x07, 0xFB, 0xFC, 0x03, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xEF, 0xF8, 0x0F, 0xF7, 0xFC, 0x07, 0xF9, 0xFE, 0x07, 0xFC, 0xFF,
  0x87, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xCF, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x03, 0xF0,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF,
  0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x3C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x7F, 0xC3, 0xFE, 0xFF, 0x83, 0xFD, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x03,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xFF,
  0x01, 0xF0, 0x3F, 0x00, 0xFF, 0xF8, 0x1F, 0x07, 0xE0, 0x7F, 0xFF, 0x83,
  0xE1, 0xF8, 0x0F, 0xFF, 0xF0, 0x7C, 0x3F, 0x03, 0xFC, 0x7E, 0x0F, 0x8F,
  0xC0, 0xFE, 0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x3E, 0x07,
  0xE0, 0x7E, 0x07, 0xCF, 0xC0, 0xFC, 0x0F, 0xC0, 0xF9, 0xF8, 0x3F, 0x01,
  0xF0, 0x1F, 0x3E, 0x07, 0xE0, 0x7E, 0x03, 0xEF, 0xC1, 0xFC, 0x0F, 0xC0,
  0xFD, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x3F, 0x07, 0xE0, 0x3F, 0x03, 0xE7,
  0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0xBF, 0x07,
  0xF0, 0x3F, 0x01, 0xF7, 0xE0, 0xFE, 0x07, 0xE0, 0x7C, 0xFC, 0x1F, 0x80,
  0xF8, 0x0F, 0x9F, 0x83, 0xF0, 0x3F, 0x01, 0xF3, 0xF0, 0x7E, 0x07, 0xE0,
  0x7C, 0x7E, 0x0F, 0xC1, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8, 0x3F, 0x83, 0xE1,
  0xF8, 0x3F, 0x8F, 0xF0, 0x7C, 0x3F, 0x07, 0xFF, 0xFE, 0x3F, 0x07, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xFE, 0xFF, 0xF8, 0x1F, 0x80, 0xFF,
  0x9F, 0xFE, 0x03, 0xF0, 0x1F, 0xE1, 0xFF, 0x00, 0x3E, 0x00, 0x70, 0x0F,
  0x80, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x06, 0x00, 0x00, 0x07, 0xFF, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x03, 0xFD,
  0xFC, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x07,
  0xFC, 0xFE, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F,
  0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x3F, 0xF0, 0x00, 0x7F, 0x87, 0xFC,
  0x00, 0x0F, 0xF1, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x3F, 0xE7,
  0xFC, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x0F, 0xFE, 0x03, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x1F,
  0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x03,
  0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x07, 0xFC,
  0x07, 0xFC, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F,
  0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x03,
  0xFE, 0x07, 0xF8, 0x03, 0xFF, 0x03, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x0F, 0xF8, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0xFF, 0x1F,
  0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x0F, 0xF8, 0x7F,
  0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFC, 0x3F, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF8, 0x01,
  0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFE, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x83, 0xFE,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x1F,
  0xF0, 0x07, 0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xFE, 0x03,
  0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x7F,
  0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x01, 0xFF, 0xF8,
  0xFF, 0x81, 0xFF, 0xFC, 0x7F, 0xC0, 0xFF, 0xFE, 0x3F, 0xE0, 0x7F, 0xFF,
  0x1F, 0xF0, 0x3F, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0xC7, 0xF8, 0x0F, 0xFF,
  0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F,
  0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x03,
  0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x81,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xE0,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07,
  0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03,
  0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0,
  0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0xFF,
  0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xF8,
  0x00, 0x7F, 0x80, 0xFF, 0xC0, 0x03, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0x03, 0xFC, 0x3F, 0xF0, 0x00, 0x0F, 0xF1, 0xFF, 0x80, 0x00, 0x7F, 0xCF,
  0xFC, 0x00, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xBF, 0xE0, 0x00, 0x1F, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xE3, 0xFE,
  0x00, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFE,
  0x01, 0xFE, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFD, 0xF8, 0x03, 0xFF, 0xF8,
  0x07, 0xFB, 0xF0, 0x0F, 0xEF, 0xF0, 0x0F, 0xF7, 0xE0, 0x1F, 0xDF, 0xE0,
  0x1F, 0xEF, 0xE0, 0x7F, 0x7F, 0x80, 0x3F, 0xDF, 0xC0, 0xFE, 0xFF, 0x00,
  0xFF, 0xBF, 0x83, 0xF9, 0xFE, 0x01, 0xFE, 0x7F, 0x07, 0xF3, 0xFC, 0x03,
  0xFC, 0xFE, 0x0F, 0xEF, 0xF8, 0x07, 0xF8, 0xFC, 0x3F, 0x9F, 0xF0, 0x0F,
  0xF1, 0xF8, 0x7F, 0x3F, 0xC0, 0x1F, 0xE3, 0xF1, 0xFC, 0x7F, 0x80, 0x7F,
  0xC7, 0xE3, 0xF8, 0xFF, 0x00, 0xFF, 0x8F, 0xCF, 0xE3, 0xFE, 0x01, 0xFE,
  0x1F, 0x9F, 0xC7, 0xFC, 0x03, 0xFC, 0x3F, 0x3F, 0x0F, 0xF8, 0x07, 0xF8,
  0x7F, 0xFE, 0x1F, 0xE0, 0x1F, 0xF0, 0xFF, 0xF8, 0x3F, 0xC0, 0x3F, 0xE0,
  0xFF, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xE1, 0xFF, 0x00, 0xFF, 0x83,
  0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x07, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x0F,
  0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xF8,
  0x07, 0xF8, 0x07, 0xFC, 0x03, 0xF0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0x80,
  0x7F, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFF, 0x00,
  0x3F, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE, 0x03,
  0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xFE, 0x07,
  0xF8, 0x07, 0xFD, 0xF8, 0x3F, 0xE0, 0x1F, 0xF7, 0xE0, 0xFF, 0x80, 0x7F,
  0x9F, 0x83, 0xFE, 0x01, 0xFE, 0x7F, 0x0F, 0xF0, 0x0F, 0xF8, 0xFC, 0x3F,
  0xC0, 0x3F, 0xE3, 0xF0, 0xFF, 0x00, 0xFF, 0x8F, 0xC7, 0xFC, 0x03, 0xFE,
  0x3F, 0x9F, 0xF0, 0x0F, 0xF0, 0x7E, 0x7F, 0xC0, 0x3F, 0xC1, 0xF9, 0xFE,
  0x01, 0xFF, 0x07, 0xE7, 0xF8, 0x07, 0xFC, 0x1F, 0xFF, 0xE0, 0x1F, 0xF0,
  0x3F, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0xF8,
  0x0F, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFC, 0x00,
  0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC,
  0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x03,
  0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x3F, 0xE7, 0xF8, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x00,
  0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFE, 0x1F, 0xF0,
  0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0x81, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xF8, 0x0F, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F,
  0xF8, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0,
  0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F,
  0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF8, 0x1F, 0xE0, 0x0F,
  0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x03, 0xFE, 0x3F, 0xC0, 0x01,
  0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xF0, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x3F, 0xE7, 0xF8, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x0F, 0xF9, 0xFE, 0x00,
  0x07, 0xF9, 0xFF, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0,
  0x01, 0xFF, 0x3F, 0xE0, 0x00, 0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xCF, 0xF0,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x1F, 0xF1, 0xFE,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x01, 0xFF, 0x07,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x37, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFC, 0x03, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x03, 0xFE,
  0x0F, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0x81, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0,
  0x7F, 0xC0, 0x1F, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x3F,
  0xC0, 0x0F, 0xFC, 0x1F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x07, 0xFE,
  0x07, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x0F, 0xF0,
  0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x1F, 0xF0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x1F, 0xF0, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F,
  0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xE0, 0x7F,
  0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xFC,
  0x0F, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x1F,
  0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xFC, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xE0,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xC0, 0xFF,
  0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x7F, 0xEF,
  0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x3F, 0xF1, 0xFF, 0x00, 0x1F, 0xF8,
  0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0x07, 0xFC,
  0x1F, 0xF0, 0x07, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F,
  0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F,
  0xE0, 0x07, 0xF8, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x1F, 0xE3,
  0xFE, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F,
  0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xF0, 0x07, 0xFB, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xE7, 0xF8, 0x0F, 0xF8, 0x07, 0xF8,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE3, 0xFC,
  0x0F, 0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xFF, 0x80, 0xFF, 0x0F, 0xF0, 0x3F,
  0xF0, 0x3F, 0xE1, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x3F, 0xC1, 0xFF, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xFF, 0x87, 0xFC,
  0x1F, 0xE1, 0xFF, 0xF0, 0xFF, 0x03, 0xFC, 0x3F, 0xFE, 0x1F, 0xE0, 0x7F,
  0x8F, 0xFF, 0xC7, 0xFC, 0x0F, 0xF1, 0xFF, 0xF8, 0xFF, 0x01, 0xFE, 0x3F,
  0xFF, 0x1F, 0xE0, 0x3F, 0xCF, 0xEF, 0xE7, 0xFC, 0x07, 0xF9, 0xFD, 0xFC,
  0xFF, 0x00, 0xFF, 0x3F, 0xBF, 0x9F, 0xE0, 0x1F, 0xEF, 0xE7, 0xF7, 0xFC,
  0x03, 0xFD, 0xFC, 0xFE, 0xFF, 0x00, 0x7F, 0xBF, 0x9F, 0xDF, 0xE0, 0x0F,
  0xFF, 0xE3, 0xFB, 0xFC, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE0, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0xFC,
  0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0xFF, 0x80, 0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0xFF, 0x80, 0x00, 0x03, 0xFD, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x3F, 0xF7, 0xFC,
  0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x01, 0xFF, 0x9F, 0xF0, 0x00, 0x07,
  0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x07,
  0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x07,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x7F, 0xC0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F,
  0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F,
  0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xE1, 0xFF,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x80,
  0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x01, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x0F,
  0xEF, 0xC0, 0x7E, 0x7E, 0x07, 0xF1, 0xF0, 0x3F, 0x0F, 0x83, 0xF8, 0x7E,
  0x1F, 0x83, 0xF1, 0xFC, 0x1F, 0x8F, 0xC0, 0xFC, 0xFE, 0x07, 0xE7, 0xE0,
  0x3F, 0x7F, 0x01, 0xFC, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF8, 0x1F,
  0xC0, 0x7F, 0x01, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x3F, 0xF1, 0xFF, 0x1F, 0xF0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7,
  0xF8, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xCF, 0xFE, 0x3F, 0xE7, 0xFC, 0x1F, 0xF7, 0xFC, 0x0F,
  0xF3, 0xFE, 0x07, 0xF9, 0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x81,
  0xFF, 0x3F, 0xC0, 0xFF, 0x9F, 0xF1, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFB, 0xFC, 0x07,
  0xF9, 0xFF, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC1, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x81, 0xFF, 0x0F,
  0xF0, 0x1F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00,
  0xFF, 0x1F, 0xF0, 0x0F, 0xF1, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xF1,
  0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0x1F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xE0,
  0x1F, 0xE3, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xFC, 0x01, 0xFE,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0xC7, 0xFE,
  0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x0F, 0xF7, 0xFF, 0xE0, 0xFF, 0x3F, 0xFE, 0x0F, 0xF3, 0xFF, 0xC0, 0xFF,
  0x0F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xF7, 0xFE, 0x1F, 0xF0, 0x7F, 0x87,
  0xF8, 0x1F, 0xE3, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F,
  0xDF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFC,
  0x7F, 0x81, 0xFE, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xE1, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x01, 0x01, 0xFE, 0x00, 0x3F, 0xE3, 0xFC, 0x00, 0xFF,
  0xE7, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x0F,
  0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0x00, 0xFF, 0x03,
  0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xBF, 0xC0, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0xC7,
  0xF8, 0x0F, 0xF1, 0xFE, 0x03, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x3F,
  0xCF, 0xF0, 0x0F, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x08, 0x1F, 0xF0, 0x06, 0x07, 0xFC, 0x07, 0xC0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x7F, 0xF2, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0x3F, 0xC0,
  0x7F, 0xFC, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xF8, 0x1F, 0xF8, 0x7F, 0xC0,
  0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F,
  0xF0, 0xFF, 0x80, 0x7F, 0xC3, 0xFC, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFE, 0x0F,
  0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x3F, 0xE1, 0xFF, 0x00, 0xFF, 0x07, 0xFC,
  0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x01,
  0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x02, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x03, 0x00,
  0x3F, 0xE0, 0x0F, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x7F, 0x80,
  0x3F, 0xDF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3,
  0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE3, 0xFE, 0x03,
  0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFE, 0x3F,
  0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xC0, 0x3F,
  0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xC7, 0xFC,
  0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xE0, 0x1F, 0xE3, 0xFC, 0x07, 0xFC,
  0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0xC0,
  0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0xC0,
  0x00, 0x7C, 0x00, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0x80,
  0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x0F, 0xFE,
  0x07, 0xF8, 0x1F, 0xF8, 0x0F, 0xF0, 0x7F, 0xE0, 0x1F, 0xE1, 0xFF, 0x80,
  0x3F, 0xC7, 0xFE, 0x00, 0xFF, 0x8F, 0xF8, 0x01, 0xFF, 0x3F, 0xE0, 0x03,
  0xFC, 0xFF, 0xC0, 0x07, 0xFB, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xF8, 0x7F,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0xFF, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x07, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xBF, 0xF8, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF,
  0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xF8, 0x3F, 0xF8, 0x7F, 0xC3, 0xFC, 0x0F, 0xFC, 0x0F, 0xF0, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC7, 0xFC, 0x0F, 0xF8, 0x1F, 0xF1, 0xFF, 0x03, 0xFE, 0x07, 0xFC,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x87, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0xFF, 0x81, 0xFF,
  0x03, 0xFE, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x8F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC3, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC7, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x1F, 0xE3,
  0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x03, 0xFE, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x1F,
  0xEF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xE1, 0xFE,
  0x03, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE,
  0x3F, 0xE0, 0x3F, 0xC7, 0xF8, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xE0,
  0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF, 0x1F, 0xF0, 0x1F, 0xE3,
  0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF, 0x8F, 0xF0, 0x1F, 0xE3, 0xFE, 0x03,
  0xFC, 0x7F, 0xC0, 0x7F, 0x8F, 0xF0, 0x0F, 0xF1, 0xFE, 0x03, 0xFE, 0x3F,
  0xC0, 0x7F, 0xC7, 0xF8, 0x0F, 0xF1, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x3F,
  0xC7, 0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFC, 0x07, 0xF8, 0xFF, 0x80, 0xFF,
  0x9F, 0xE0, 0x1F, 0xF3, 0xFC, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xDF, 0xF0,
  0x0F, 0xFB, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0x3F, 0xEF, 0xF0, 0x07, 0xFD,
  0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xEF, 0xF8, 0x03, 0xFD, 0xFF, 0x00,
  0x7F, 0x9F, 0xE0, 0x1F, 0xF3, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F,
  0xF0, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x1F, 0xEF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x1F,
  0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xF8,
  0x07, 0xFC, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFE, 0x01,
  0xFE, 0x0F, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF,
  0x83, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC1,
  0xFF, 0x83, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xCF,
  0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x03, 0xFC, 0x04, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F,
  0xF8, 0x7F, 0x01, 0xFF, 0xCF, 0xF0, 0x3F, 0xFE, 0xFF, 0x07, 0xFF, 0xEF,
  0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F,
  0xF0, 0x7F, 0xE3, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x3F, 0xE3, 0xFC, 0x03,
  0xFE, 0x7F, 0xC0, 0x3F, 0xC7, 0xFC, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC7,
  0xF8, 0x07, 0xFC, 0x7F, 0x80, 0x7F, 0xC7, 0xF8, 0x07, 0xF8, 0x7F, 0x80,
  0x7F, 0x8F, 0xF8, 0x07, 0xF8, 0xFF, 0x80, 0x7F, 0x8F, 0xF8, 0x0F, 0xF8,
  0xFF, 0x80, 0xFF, 0x8F, 0xF8, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0x0F, 0xF8,
  0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFD, 0xFE, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x83, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xC1, 0xFE, 0xFE,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF,
  0x0F, 0xF0, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xFC, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF, 0xF0,
  0x1F, 0xE1, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x7F, 0xFF,
  0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xFF, 0x81, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0,
  0x00, 0x60, 0x00, 0x1F, 0xF0, 0x1F, 0xE3, 0xFC, 0x03, 0xFC, 0x7F, 0x80,
  0xFF, 0x8F, 0xF0, 0x1F, 0xF1, 0xFE, 0x03, 0xFC, 0x7F, 0xC0, 0x7F, 0x8F,
  0xF8, 0x0F, 0xF1, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x7F, 0xC7, 0xF8, 0x0F,
  0xF8, 0xFF, 0x01, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xFC, 0x07, 0xF8, 0xFF,
  0x00, 0xFF, 0x1F, 0xE0, 0x3F, 0xE3, 0xFC, 0x07, 0xFC, 0x7F, 0x80, 0xFF,
  0x1F, 0xF0, 0x1F, 0xE3, 0xFE, 0x03, 0xFC, 0x7F, 0x80, 0x7F, 0x8F, 0xF0,
  0x1F, 0xF1, 0xFE, 0x03, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0,
  0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x7F, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xDF, 0xE0, 0x1F, 0xF3, 0xFC, 0x00, 0x20, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xBF, 0xE0, 0x3F, 0xEF, 0xF8, 0x0F, 0xF9, 0xFE, 0x07, 0xFC, 0x7F,
  0x81, 0xFF, 0x1F, 0xE0, 0x7F, 0x87, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xE1, 0xFF, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F,
  0xE0, 0x7F, 0x8F, 0xF0, 0x0F, 0xE3, 0xFC, 0x03, 0xF8, 0xFE, 0x00, 0xFE,
  0x7F, 0x80, 0x3F, 0x9F, 0xE0, 0x0F, 0xE7, 0xF0, 0x03, 0xFB, 0xFC, 0x00,
  0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x03,
  0xF0, 0x1F, 0xEF, 0xE0, 0x3F, 0x81, 0xFE, 0xFE, 0x07, 0xF8, 0x1F, 0xEF,
  0xE0, 0x7F, 0x83, 0xFC, 0xFE, 0x07, 0xF8, 0x3F, 0xCF, 0xE0, 0xFF, 0x83,
  0xFC, 0xFE, 0x0F, 0xF8, 0x7F, 0x8F, 0xE1, 0xFF, 0x87, 0xF8, 0xFE, 0x1F,
  0xF8, 0x7F, 0x8F, 0xE1, 0xFF, 0x8F, 0xF0, 0xFE, 0x3F, 0xF8, 0xFF, 0x0F,
  0xE3, 0xFF, 0x8F, 0xE0, 0xFE, 0x7F, 0xF9, 0xFE, 0x0F, 0xE7, 0xFF, 0x9F,
  0xE0, 0xFE, 0x7F, 0xF9, 0xFC, 0x0F, 0xEF, 0xFF, 0xBF, 0xC0, 0xFE, 0xFD,
  0xFB, 0xFC, 0x0F, 0xFF, 0xDF, 0xBF, 0x80, 0xFF, 0xF8, 0xFB, 0xF8, 0x0F,
  0xFF, 0x8F, 0xFF, 0x00, 0xFF, 0xF8, 0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x0F,
  0xF8, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFF,
  0x7F, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x3F, 0xE3, 0xFC, 0x00,
  0xFF, 0x87, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x1F,
  0xF0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x80, 0x07,
  0xFC, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x7F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0xFF,
  0x07, 0xFC, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8,
  0x7F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x3F, 0x9F, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0x7F,
  0x80, 0x01, 0xFD, 0xFF, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x40, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00,
  0x01, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0,
  0x3E, 0x01, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xC3, 0xFF, 0x80, 0x7E,
  0x3F, 0xFE, 0x03, 0xF1, 0xFF, 0xF8, 0x3F, 0x9F, 0xFF, 0xC1, 0xF8, 0xFF,
  0xFF, 0x1F, 0xCF, 0xF3, 0xFF, 0xFE, 0x7F, 0x0F, 0xFF, 0xE3, 0xF0, 0x3F,
  0xFF, 0x1F, 0x80, 0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0x0F, 0xC0, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 45, 16, 1, -44 },
  { 91, 18, 17, 19, 4, -47 },
  { 130, 31, 44, 32, 1, -44 },
  { 301, 28, 58, 30, 2, -51 },
  { 504, 30, 46, 38, 5, -45 },
  { 677, 31, 46, 35, 1, -45 },
  { 856, 9, 17, 10, 4, -47 },
  { 876, 19, 63, 19, 3, -49 },
  { 1026, 20, 63, 19, -3, -49 },
  { 1184, 26, 27, 27, 3, -44 },
  { 1272, 26, 32, 29, 2, -37 },
  { 1376, 13, 19, 15, -4, -7 },
  { 1407, 16, 7, 22, 3, -22 },
  { 1421, 10, 10, 18, 1, -9 },
  { 1434, 28, 48, 20, -4, -44 },
  { 1602, 26, 46, 30, 3, -45 },
  { 1752, 18, 44, 30, 7, -44 },
  { 1851, 29, 45, 30, 0, -45 },
  { 2015, 28, 46, 30, 1, -45 },
  { 2176, 28, 44, 30, 1, -44 },
  { 2330, 29, 45, 30, 2, -44 },
  { 2494, 25, 45, 30, 3, -44 },
  { 2635, 29, 44, 30, 3, -44 },
  { 2795, 27, 46, 30, 2, -45 },
  { 2951, 25, 45, 30, 4, -45 },
  { 3092, 14, 35, 17, 1, -34 },
  { 3154, 18, 46, 16, -3, -34 },
  { 3258, 25, 30, 27, 1, -34 },
  { 3352, 26, 20, 30, 2, -30 },
  { 3417, 25, 29, 27, 1, -33 },
  { 3508, 23, 46, 27, 4, -45 },
  { 3641, 43, 57, 46, 1, -43 },
  { 3948, 35, 44, 36, -3, -44 },
  { 4141, 33, 44, 34, 0, -44 },
  { 4323, 32, 46, 34, 2, -45 },
  { 4507, 33, 44, 34, 0, -44 },
  { 4689, 32, 44, 30, 0, -44 },
  { 4865, 32, 44, 29, 0, -44 },
  { 5041, 33, 46, 35, 2, -45 },
  { 5231, 38, 44, 37, 0, -44 },
  { 5440, 16, 44, 16, 1, -44 },
  { 5528, 31, 45, 30, 0, -44 },
  { 5703, 38, 44, 33, 0, -44 },
  { 5912, 25, 44, 29, 0, -44 },
  { 6050, 47, 44, 46, 0, -44 },
  { 6309, 38, 44, 37, 0, -44 },
  { 6518, 33, 46, 36, 2, -45 },
  { 6708, 34, 44, 34, 0, -44 },
  { 6895, 33, 53, 36, 2, -45 },
  { 7114, 33, 44, 33, 0, -44 },
  { 7296, 32, 46, 32, 1, -45 },
  { 7480, 31, 44, 33, 5, -44 },
  { 7651, 34, 45, 34, 2, -44 },
  { 7843, 33, 44, 35, 5, -44 },
  { 8025, 43, 44, 45, 5, -44 },
  { 8262, 39, 44, 34, -2, -44 },
  { 8477, 32, 44, 33, 5, -44 },
  { 8653, 35, 44, 32, -1, -44 },
  { 8846, 21, 61, 16, -1, -51 },
  { 9007, 15, 48, 23, 5, -44 },
  { 9097, 21, 61, 16, -3, -51 },
  { 9258, 21, 22, 24, 2, -44 },
  { 9316, 24, 7, 24, -4, 0 },
  { 9337, 13, 9, 20, 6, -46 },
  { 9352, 25, 35, 28, 1, -34 },
  { 9462, 28, 48, 30, 0, -47 },
  { 9630, 26, 35, 28, 1, -34 },
  { 9744, 31, 48, 30, 1, -47 },
  { 9930, 26, 35, 29, 1, -34 },
  { 10044, 22, 48, 20, 2, -48 },
  { 10176, 30, 47, 30, 0, -34 },
  { 10353, 27, 47, 30, 0, -47 },
  { 10512, 16, 46, 15, 0, -46 },
  { 10604, 23, 59, 15, -7, -46 },
  { 10774, 31, 47, 29, 0, -47 },
  { 10957, 17, 47, 15, 0, -47 },
  { 11057, 42, 34, 45, 0, -34 },
  { 11236, 27, 34, 30, 0, -34 },
  { 11351, 27, 35, 30, 1, -34 },
  { 11470, 30, 47, 30, -2, -34 },
  { 11647, 28, 47, 30, 1, -34 },
  { 11812, 21, 34, 20, 0, -34 },
  { 11902, 26, 35, 27, 0, -34 },
  { 12016, 18, 42, 18, 2, -41 },
  { 12111, 27, 34, 30, 2, -33 },
  { 12226, 26, 33, 27, 3, -33 },
  { 12334, 36, 33, 38, 4, -33 },
  { 12483, 31, 33, 27, -2, -33 },
  { 12611, 31, 46, 27, -2, -33 },
  { 12790, 28, 33, 27, -1, -33 },
  { 12906, 19, 59, 18, 1, -48 },
  { 13047, 13, 52, 15, 1, -44 },
  { 13132, 19, 59, 18, -2, -48 },
  { 13273, 29, 14, 34, 2, -25 },
};

const GFXfont RobotoCondensed_BoldItalic62pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic62pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic62pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOCONDENSED_BOLDITALIC62PT7B_H_
