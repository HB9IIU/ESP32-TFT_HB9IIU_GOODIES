#ifndef _ROBOTOCONDENSED_BOLDITALIC9PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x48, 0xF0, 0x31, 0x9E, 0xAF, 0x32, 0x80, 0x13, 0x54, 0x61,
  0xD6, 0x40, 0xCD, 0xE4, 0x7B, 0x30, 0x32, 0x9C, 0xCF, 0xD9, 0xC0, 0xC0,
  0x2D, 0x25, 0x22, 0x40, 0x55, 0x56, 0x80, 0x27, 0x65, 0x22, 0xF6, 0x40,
  0x54, 0x60, 0xC0, 0x11, 0x22, 0x24, 0x44, 0x35, 0x55, 0xDD, 0x60, 0x79,
  0x24, 0xB0, 0x75, 0x13, 0x64, 0xF0, 0x75, 0x12, 0x19, 0x60, 0x13, 0x57,
  0xF2, 0x20, 0x74, 0x71, 0x1D, 0x60, 0x36, 0x75, 0xDD, 0x60, 0x78, 0x8C,
  0x42, 0x21, 0x00, 0x75, 0x56, 0xDD, 0x60, 0x76, 0xDE, 0xB0, 0x40, 0xC0,
  0x40, 0xA8, 0x1E, 0xC2, 0x70, 0xF0, 0x43, 0x78, 0xF5, 0xA8, 0x20, 0x3D,
  0x15, 0xEB, 0xB6, 0xF8, 0x1C, 0x31, 0x8C, 0xA5, 0x7A, 0x60, 0x72, 0xD6,
  0xED, 0x6B, 0xC0, 0x3A, 0x51, 0x8C, 0x69, 0xC0, 0x72, 0xD6, 0xBD, 0x6B,
  0x80, 0x7A, 0x10, 0xEC, 0x63, 0xC0, 0x7A, 0x10, 0xEC, 0x62, 0x00, 0x3A,
  0x50, 0xBD, 0xED, 0xC0, 0x49, 0x24, 0x9E, 0xCB, 0x69, 0x00, 0x55, 0xF8,
  0x11, 0x11, 0x3B, 0xE0, 0x49, 0x47, 0x18, 0xF3, 0x49, 0x00, 0x44, 0x44,
  0xCC, 0xF0, 0x66, 0xCD, 0xB3, 0x6F, 0x5E, 0xAF, 0x00, 0x49, 0xA6, 0x9A,
  0xDB, 0x69, 0x00, 0x32, 0x53, 0x9C, 0xE9, 0xC0, 0x72, 0x52, 0xBF, 0x62,
  0x00, 0x32, 0x53, 0x9C, 0xE9, 0xC2, 0x72, 0x56, 0xEF, 0x6A, 0x40, 0x32,
  0xD0, 0xE1, 0x49, 0xC0, 0xF4, 0x44, 0x44, 0xC0, 0x4A, 0x52, 0xBD, 0x69,
  0xC0, 0x94, 0xAD, 0x4A, 0x63, 0x00, 0xA6, 0xBA, 0xBA, 0xDB, 0x49, 0x00,
  0x4A, 0x9C, 0x47, 0x2A, 0x40, 0x9B, 0xAC, 0x44, 0xC0, 0x78, 0x8C, 0x44,
  0x63, 0xC0, 0x69, 0x2D, 0x26, 0xAA, 0xB5, 0x22, 0x22, 0x26, 0x44, 0x2D,
  0x80, 0x70, 0x90, 0x65, 0x7A, 0xE0, 0x44, 0x75, 0xD9, 0xE0, 0x6D, 0x8A,
  0x60, 0x18, 0x9D, 0xA9, 0x5B, 0xC0, 0x75, 0xF8, 0x60, 0x2B, 0xA4, 0xB0,
  0x7D, 0x99, 0x72, 0xE0, 0x44, 0x75, 0xDB, 0xA0, 0x45, 0xE8, 0x20, 0x96,
  0xD2, 0xC0, 0x44, 0x56, 0xEA, 0xB0, 0x55, 0xF8, 0x7D, 0x5D, 0x6D, 0xAC,
  0x75, 0xDB, 0xA0, 0x7D, 0x99, 0x60, 0x75, 0xD9, 0xE8, 0x80, 0x7D, 0x9B,
  0xF2, 0x20, 0x6B, 0x48, 0x64, 0x6A, 0xE0, 0x5D, 0x2C, 0x80, 0x55, 0xDB,
  0xF0, 0x57, 0x66, 0x40, 0xFF, 0xBD, 0x6A, 0x00, 0x56, 0x66, 0xA0, 0x57,
  0x66, 0x44, 0x80, 0x72, 0x64, 0xE0, 0x29, 0x28, 0x96, 0x40, 0x55, 0x6A,
  0x55, 0x5A, 0x80, 0x6D, 0x80,
};

const GFXglyph RobotoCondensed_BoldItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 4, 9, 4, 0, -8 },
  { 14, 4, 7, 6, 1, -7 },
  { 18, 5, 7, 5, 0, -7 },
  { 23, 1, 2, 1, 1, -7 },
  { 24, 3, 9, 3, 0, -7 },
  { 28, 2, 9, 3, 0, -7 },
  { 31, 4, 4, 4, 0, -7 },
  { 33, 4, 5, 4, 0, -5 },
  { 36, 2, 3, 2, -1, -1 },
  { 37, 3, 1, 3, 0, -3 },
  { 38, 2, 1, 3, 0, -1 },
  { 39, 4, 8, 3, -1, -7 },
  { 43, 4, 7, 4, 0, -7 },
  { 47, 3, 7, 4, 1, -7 },
  { 50, 4, 7, 4, 0, -7 },
  { 54, 4, 7, 4, 0, -7 },
  { 58, 4, 7, 4, 0, -7 },
  { 62, 4, 7, 4, 0, -7 },
  { 66, 4, 7, 4, 0, -7 },
  { 70, 5, 7, 4, 0, -7 },
  { 75, 4, 7, 4, 0, -7 },
  { 79, 3, 7, 4, 1, -7 },
  { 82, 2, 5, 2, 0, -5 },
  { 84, 2, 7, 2, 0, -5 },
  { 86, 4, 4, 4, 0, -5 },
  { 88, 4, 3, 4, 0, -4 },
  { 90, 4, 4, 4, 0, -5 },
  { 92, 3, 7, 4, 1, -7 },
  { 95, 6, 8, 7, 0, -6 },
  { 101, 5, 7, 5, 0, -7 },
  { 106, 5, 7, 5, 0, -7 },
  { 111, 5, 7, 5, 0, -7 },
  { 116, 5, 7, 5, 0, -7 },
  { 121, 5, 7, 4, 0, -7 },
  { 126, 5, 7, 4, 0, -7 },
  { 131, 5, 7, 5, 0, -7 },
  { 136, 6, 7, 5, 0, -7 },
  { 142, 2, 7, 2, 0, -7 },
  { 144, 4, 7, 4, 0, -7 },
  { 148, 6, 7, 5, 0, -7 },
  { 154, 4, 7, 4, 0, -7 },
  { 158, 7, 7, 7, 0, -7 },
  { 165, 6, 7, 5, 0, -7 },
  { 171, 5, 7, 5, 0, -7 },
  { 176, 5, 7, 5, 0, -7 },
  { 181, 5, 8, 5, 0, -7 },
  { 186, 5, 7, 5, 0, -7 },
  { 191, 5, 7, 5, 0, -7 },
  { 196, 4, 7, 5, 1, -7 },
  { 200, 5, 7, 5, 0, -7 },
  { 205, 5, 7, 5, 1, -7 },
  { 210, 6, 7, 7, 1, -7 },
  { 216, 5, 7, 5, 0, -7 },
  { 221, 4, 7, 5, 1, -7 },
  { 225, 5, 7, 5, 0, -7 },
  { 230, 3, 8, 2, 0, -7 },
  { 233, 2, 8, 3, 1, -7 },
  { 235, 4, 8, 2, -1, -7 },
  { 239, 3, 3, 3, 0, -7 },
  { 241, 4, 1, 3, -1, 0 },
  { 242, 2, 2, 3, 1, -7 },
  { 243, 4, 5, 4, 0, -5 },
  { 246, 4, 7, 4, 0, -7 },
  { 250, 4, 5, 4, 0, -5 },
  { 253, 5, 7, 4, 0, -7 },
  { 258, 4, 5, 4, 0, -5 },
  { 261, 3, 7, 3, 0, -7 },
  { 264, 4, 7, 4, 0, -5 },
  { 268, 4, 7, 4, 0, -7 },
  { 272, 2, 7, 2, 0, -7 },
  { 274, 3, 9, 2, -1, -7 },
  { 278, 4, 7, 4, 0, -7 },
  { 282, 2, 7, 2, 0, -7 },
  { 284, 6, 5, 6, 0, -5 },
  { 288, 4, 5, 4, 0, -5 },
  { 291, 4, 5, 4, 0, -5 },
  { 294, 4, 7, 4, 0, -5 },
  { 298, 4, 7, 4, 0, -5 },
  { 302, 3, 5, 3, 0, -5 },
  { 304, 4, 5, 4, 0, -5 },
  { 307, 3, 6, 3, 0, -6 },
  { 310, 4, 5, 4, 0, -5 },
  { 313, 4, 5, 4, 0, -5 },
  { 316, 5, 5, 6, 1, -5 },
  { 320, 4, 5, 4, 0, -5 },
  { 323, 4, 7, 4, 0, -5 },
  { 327, 4, 5, 4, 0, -5 },
  { 330, 3, 9, 3, 0, -7 },
  { 334, 2, 8, 2, 0, -7 },
  { 336, 2, 9, 3, 0, -7 },
  { 339, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoCondensed_BoldItalic9pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic9pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic9pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOCONDENSED_BOLDITALIC9PT7B_H_
