#ifndef _ROBOTOCONDENSED_BOLDITALIC53PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic53pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xFE, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF0, 0x01, 0x00, 0x00, 0x3E, 0x3F,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0x7C, 0x78, 0x78, 0x78, 0x78, 0xF8, 0x78,
  0xF0, 0xF8, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x00, 0x03,
  0xC3, 0xC0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x7C,
  0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x3C, 0x01, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x3C,
  0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0x0F, 0xE1, 0xFC, 0x1F, 0xC3, 0xF8,
  0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0,
  0x3F, 0x8F, 0xE0, 0x7F, 0x1F, 0xE1, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xE3, 0xC0,
  0x63, 0xE1, 0xF0, 0x79, 0xF0, 0xF8, 0x7C, 0xF8, 0x7C, 0x3C, 0x7C, 0x3E,
  0x3E, 0x3C, 0x1F, 0x3E, 0x1E, 0x0F, 0x3E, 0x0F, 0x8F, 0x9F, 0x07, 0xC7,
  0xDF, 0x03, 0xFF, 0xDF, 0x00, 0xFF, 0xEF, 0x80, 0x7F, 0xEF, 0x80, 0x0F,
  0xEF, 0x80, 0x01, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xEF, 0xF0, 0x03, 0xEF, 0xFC, 0x01, 0xEF, 0xFE,
  0x01, 0xF7, 0xFF, 0x81, 0xF7, 0xE7, 0xC0, 0xF3, 0xE1, 0xE0, 0xF9, 0xF0,
  0xF0, 0xF8, 0xF0, 0x78, 0x78, 0x78, 0x3C, 0x7C, 0x3C, 0x1E, 0x7C, 0x3E,
  0x1F, 0x3C, 0x0F, 0x0F, 0x9E, 0x07, 0xCF, 0xC2, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xE3,
  0xF0, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x7F, 0x80,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xC3, 0xFF, 0xC3, 0xF1, 0xFF,
  0xF0, 0xFC, 0xFF, 0xFE, 0x7F, 0x7F, 0xBF, 0xDF, 0x9F, 0xC7, 0xF7, 0xEF,
  0xF1, 0xFF, 0xFB, 0xF8, 0x3F, 0xFC, 0xFE, 0x0F, 0xFF, 0x3F, 0x81, 0xFF,
  0xCF, 0xE0, 0x7F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xF7,
  0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xDF, 0xC0, 0x7F, 0xC7, 0xF8, 0x03, 0x00, 0x00, 0x3F, 0x3F, 0x3E,
  0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0x00,
  0x01, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0xC0, 0x00, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x02, 0x03,
  0xC0, 0x9E, 0x1F, 0x1E, 0x7F, 0x79, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x80, 0x0F, 0x9E, 0x00, 0x7C, 0x7C, 0x03, 0xF1, 0xF8, 0x1F, 0x83,
  0xE0, 0x3C, 0x0F, 0x80, 0x60, 0x1C, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x87,
  0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x87,
  0xE1, 0xF8, 0x1E, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0x7F, 0xF8, 0x08, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x81, 0xFE, 0xFF, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7,
  0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x7F, 0x80, 0xFE, 0xFE,
  0x03, 0xFD, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0,
  0x3F, 0x9F, 0xC0, 0x7F, 0x7F, 0x80, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x07,
  0xF3, 0xF8, 0x0F, 0xE7, 0xF0, 0x1F, 0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFE,
  0x3F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0x7F, 0x0F, 0xE0, 0xFF, 0x7F, 0xC1,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0x00, 0x1E, 0x00, 0xFE, 0x03,
  0xFE, 0x1F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFD,
  0xFC, 0xE1, 0xFC, 0x81, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xF0, 0xFF, 0x07, 0xF0,
  0x7F, 0x87, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0x00,
  0x02, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F,
  0xE0, 0xFF, 0x1F, 0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFF,
  0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFD, 0xFC, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xF3, 0xF8, 0x03,
  0xF3, 0xF8, 0x07, 0xE3, 0xF8, 0x0F, 0xE3, 0xF8, 0x0F, 0xC3, 0xF8, 0x1F,
  0x87, 0xF0, 0x3F, 0x87, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3,
  0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x7E, 0x03, 0xFB, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F,
  0xF1, 0xFE, 0x7F, 0x83, 0xFD, 0xFC, 0x0F, 0xF7, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFE,
  0xFE, 0x03, 0xF9, 0xF8, 0x0F, 0xE7, 0xF0, 0x7F, 0x1F, 0xC3, 0xFC, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xF8, 0xFF, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0xFF,
  0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xF1, 0xFC, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x3F, 0xC7, 0xF8, 0x3F, 0x83, 0xF8, 0x7F, 0x83, 0xF8,
  0x7F, 0x01, 0xF8, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x03, 0xF8,
  0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xCF, 0xF0, 0xFE, 0x7F, 0x07, 0xF3, 0xF8, 0x1F, 0xBF, 0x80, 0xFD, 0xFC,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE,
  0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x83, 0xFD, 0xFE, 0x1F, 0xEF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3E, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x80, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0,
  0x7E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x3E, 0x07,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x20,
  0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF, 0xFC, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x0F, 0x80, 0x7E, 0x01, 0xE0, 0x7C, 0x07, 0xFC, 0x0F, 0x07, 0xC0,
  0xFF, 0xF8, 0x78, 0x3E, 0x0F, 0xFF, 0xC3, 0xC3, 0xE0, 0x7F, 0xFE, 0x1E,
  0x1F, 0x07, 0xE1, 0xF0, 0xF1, 0xF0, 0x7E, 0x1F, 0x07, 0x8F, 0x83, 0xE0,
  0xF8, 0x3C, 0x7C, 0x3F, 0x07, 0xC1, 0xE7, 0xC1, 0xF0, 0x3E, 0x0F, 0x3E,
  0x0F, 0x83, 0xE0, 0x79, 0xF0, 0xFC, 0x1F, 0x03, 0xCF, 0x87, 0xC0, 0xF8,
  0x1E, 0xF8, 0x3E, 0x07, 0xC1, 0xF7, 0xC1, 0xF0, 0x7C, 0x0F, 0xBE, 0x1F,
  0x83, 0xE0, 0x79, 0xF0, 0xFC, 0x1F, 0x03, 0xCF, 0x87, 0xE0, 0xF8, 0x3E,
  0x7C, 0x3F, 0x0F, 0xC1, 0xE3, 0xE1, 0xF8, 0x7C, 0x0F, 0x1F, 0x0F, 0xC7,
  0xE0, 0xF0, 0xF8, 0x7E, 0x3F, 0x8F, 0x87, 0xC1, 0xFF, 0xFF, 0xF8, 0x3E,
  0x0F, 0xFF, 0xFF, 0x81, 0xF0, 0x3F, 0xCF, 0xF8, 0x0F, 0x81, 0xFC, 0x3F,
  0x80, 0x7C, 0x01, 0x00, 0x60, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x18, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0,
  0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x7F, 0x80,
  0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F,
  0xDF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x03, 0xF8, 0x3F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F,
  0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F,
  0xF0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x0F, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x3F, 0x81,
  0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0xC0,
  0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xF8,
  0x3F, 0x80, 0xFF, 0x87, 0xF8, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF, 0x0F, 0xF0, 0x0F, 0xE3, 0xFC,
  0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF3, 0xFC, 0x00, 0xFE,
  0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x7F,
  0x00, 0x1F, 0xCF, 0xE0, 0x07, 0xF9, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F,
  0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xF8, 0x7F, 0xC0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0,
  0xFF, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFE,
  0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC3, 0xFC,
  0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFF, 0x07, 0xF8, 0x7F, 0xE0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0,
  0x0F, 0xE1, 0xFE, 0x00, 0xFE, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0xFF,
  0x3F, 0xC0, 0x0F, 0xF3, 0xF8, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x3F, 0xFC, 0x7F, 0x03, 0xFF, 0xC7, 0xF0, 0x3F, 0xFC, 0x7F,
  0x07, 0xFF, 0xCF, 0xF0, 0x7F, 0xFC, 0xFF, 0x07, 0xFF, 0xCF, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x3F, 0x87,
  0xF0, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xF8, 0x07, 0xF8, 0x7F, 0xC0,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFE, 0x07, 0xF0,
  0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0,
  0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xC0, 0x07, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0, 0x07, 0xF0, 0x3F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0x80,
  0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x7F, 0x80,
  0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xF8, 0x3F, 0xC0,
  0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x00,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0x80,
  0x3F, 0x80, 0xFF, 0x80, 0x1F, 0xC0, 0xFF, 0x80, 0x0F, 0xE0, 0xFF, 0x80,
  0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x7F, 0xC0,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x3F, 0xE0,
  0x00, 0x7F, 0xBF, 0xE0, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xF3,
  0xF8, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0x80,
  0x1F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xEF, 0x80, 0x7F, 0xFC, 0x0F, 0xEF,
  0x80, 0xFF, 0xFC, 0x0F, 0xEF, 0x80, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0xFF,
  0xF8, 0x0F, 0xEF, 0xC1, 0xFB, 0xF8, 0x0F, 0xEF, 0xC1, 0xFB, 0xF8, 0x0F,
  0xEF, 0xC3, 0xF3, 0xF8, 0x1F, 0xCF, 0xC3, 0xF7, 0xF8, 0x1F, 0xCF, 0xC7,
  0xE7, 0xF0, 0x1F, 0xC7, 0xC7, 0xE7, 0xF0, 0x1F, 0xC7, 0xC7, 0xC7, 0xF0,
  0x1F, 0xC7, 0xCF, 0xC7, 0xF0, 0x1F, 0xC7, 0xCF, 0xCF, 0xF0, 0x3F, 0xC7,
  0xDF, 0x8F, 0xE0, 0x3F, 0xC7, 0xDF, 0x8F, 0xE0, 0x3F, 0x87, 0xFF, 0x0F,
  0xE0, 0x3F, 0x87, 0xFF, 0x0F, 0xE0, 0x3F, 0x87, 0xFE, 0x1F, 0xE0, 0x3F,
  0x83, 0xFE, 0x1F, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7F, 0x83, 0xFC,
  0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x03, 0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x03,
  0xFE, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0xFE, 0x03, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x00, 0xFE, 0x07,
  0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x01, 0xFE, 0x07, 0xFF, 0x81, 0xFE, 0x07,
  0xFF, 0x81, 0xFC, 0x07, 0xFF, 0x81, 0xFC, 0x0F, 0xFF, 0xC1, 0xFC, 0x0F,
  0xFF, 0xC1, 0xFC, 0x0F, 0xF7, 0xC3, 0xFC, 0x0F, 0xE7, 0xC3, 0xFC, 0x0F,
  0xE7, 0xE3, 0xF8, 0x0F, 0xE3, 0xE3, 0xF8, 0x1F, 0xE3, 0xE3, 0xF8, 0x1F,
  0xE3, 0xE7, 0xF8, 0x1F, 0xE3, 0xF7, 0xF8, 0x1F, 0xC1, 0xF7, 0xF8, 0x1F,
  0xC1, 0xF7, 0xF0, 0x1F, 0xC1, 0xF7, 0xF0, 0x3F, 0xC1, 0xFF, 0xF0, 0x3F,
  0xC0, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0xE0, 0x3F,
  0x80, 0xFF, 0xE0, 0x3F, 0x80, 0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0xE0, 0x7F,
  0x80, 0x7F, 0xE0, 0x7F, 0x00, 0x7F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xE0,
  0x0F, 0xF1, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x7F,
  0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF8,
  0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xEF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x03,
  0xFC, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x87,
  0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF,
  0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F,
  0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x87, 0xF8, 0x03, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE1, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF,
  0x83, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0xFE,
  0x1F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x07, 0xF3, 0xF8,
  0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F,
  0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xCF,
  0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x3F, 0x8F, 0xF0, 0x03, 0xF8, 0x7F, 0x00,
  0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF8,
  0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF,
  0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F,
  0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0x81, 0xFE, 0x03,
  0xF8, 0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x80,
  0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0,
  0x7F, 0x00, 0x7F, 0x8F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xF0,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x3F, 0x8F, 0xF0, 0x07, 0xF1, 0xFE, 0x01, 0xFE,
  0x3F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0x83, 0xF8, 0x01,
  0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF8,
  0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0xC3, 0xFC, 0x01,
  0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8,
  0x3F, 0x80, 0x3F, 0xC1, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF,
  0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01,
  0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8,
  0x3F, 0xC0, 0x1F, 0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F,
  0x80, 0x7F, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xBF, 0xC0, 0x07, 0xFC, 0xFE,
  0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0xFF, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x83,
  0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x0F, 0xE0,
  0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F, 0x80, 0x03,
  0xFB, 0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xFF, 0xE0,
  0x3F, 0x80, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0x80, 0xFE,
  0xFE, 0x07, 0xF8, 0x1F, 0xEF, 0xE0, 0x7F, 0x81, 0xFC, 0xFE, 0x0F, 0xF8,
  0x1F, 0xCF, 0xE0, 0xFF, 0x83, 0xFC, 0xFE, 0x0F, 0xF8, 0x3F, 0x8F, 0xE1,
  0xFF, 0x83, 0xF8, 0xFE, 0x1F, 0xF8, 0x7F, 0x8F, 0xE1, 0xFF, 0x87, 0xF0,
  0xFE, 0x3F, 0xF8, 0x7F, 0x0F, 0xE3, 0xFF, 0x87, 0xF0, 0xFE, 0x3F, 0xF8,
  0xFE, 0x0F, 0xE7, 0xFF, 0x8F, 0xE0, 0xFE, 0x7F, 0xF8, 0xFE, 0x0F, 0xE7,
  0xEF, 0x9F, 0xC0, 0xFE, 0xFC, 0xF9, 0xFC, 0x0F, 0xEF, 0xCF, 0x9F, 0xC0,
  0xFE, 0xFC, 0xFB, 0xF8, 0x0F, 0xFF, 0x8F, 0xBF, 0x80, 0xFF, 0xF8, 0xFB,
  0xF8, 0x0F, 0xFF, 0x8F, 0xBF, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0xC0, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0x9F, 0xC0,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0xE3, 0xFC,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x0F, 0xF8, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x07, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xE7, 0xF0, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xC7, 0xF8, 0x07, 0xF8,
  0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x03, 0xF8,
  0x1F, 0xE0, 0x3F, 0x81, 0xFE, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xC3, 0xF8,
  0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFC, 0xFF, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0xFD, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F,
  0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFE, 0x07, 0xDF,
  0x07, 0xEF, 0x83, 0xE7, 0xC3, 0xF3, 0xE1, 0xF1, 0xF1, 0xF8, 0x7C, 0xFC,
  0x3E, 0xFC, 0x1F, 0x7E, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xE0, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7F, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0x3F, 0xC7, 0xF8, 0x7F, 0x1F,
  0xE1, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xF3, 0xF9,
  0xFF, 0x0F, 0xE7, 0xF8, 0x3F, 0x9F, 0xC0, 0xFE, 0x7F, 0x07, 0xF1, 0xFC,
  0x1F, 0xC7, 0xF0, 0x7F, 0x1F, 0xE7, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x07, 0xFD, 0xFC, 0x0F, 0xE7, 0xF0, 0x04, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF7, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0xFF, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE,
  0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x7F, 0x01, 0xFE,
  0x7F, 0x81, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFE, 0xFF, 0xF0, 0xFE, 0x7F, 0xE0, 0xFE, 0x3F, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x01,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0x7F, 0x8F, 0xF0,
  0xFE, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0xFE, 0x07,
  0xF3, 0xF8, 0x1F, 0xC7, 0xF0, 0xFE, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x7F, 0x01, 0xFF, 0x9F, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x1F, 0xC0,
  0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x3F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x03, 0xF8,
  0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x3F, 0xC1, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0x7E, 0x00, 0x3F, 0x9F, 0x80,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC7,
  0xF0, 0x7F, 0x3F, 0x81, 0xFC, 0xFE, 0x07, 0xF3, 0xF0, 0x1F, 0xDF, 0xC0,
  0x7F, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x01, 0x07, 0xF8, 0x1C, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xFF, 0xC7, 0xFF,
  0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x81, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x7F, 0xE7, 0xE0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xC1,
  0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0,
  0x0F, 0xE3, 0xF8, 0x0F, 0xF1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFF,
  0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x7F, 0x0F,
  0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC3, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0x80, 0x04, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x20, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x7F, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0x83, 0xF8,
  0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x8F,
  0xE0, 0x7F, 0x3F, 0x80, 0xFE, 0x7F, 0x03, 0xFC, 0xFE, 0x07, 0xF1, 0xFC,
  0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0x81,
  0xFE, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF8, 0x1F,
  0xCF, 0xE0, 0x3F, 0x9F, 0xC0, 0xFF, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8,
  0x00, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F,
  0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x1F,
  0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0xC3, 0xFC, 0x3F, 0xE0,
  0xFE, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x0F, 0xE3, 0xFC, 0x03, 0xF9, 0xFF,
  0x00, 0xFE, 0xFF, 0x80, 0x7F, 0xBF, 0xC0, 0x1F, 0xDF, 0xE0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFD, 0xFE, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x0F,
  0xE0, 0x1F, 0xC3, 0xFC, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xFF,
  0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xF0,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x81, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x7E, 0x7F, 0x83, 0xF8, 0x07, 0xEF, 0xFC, 0xFF, 0xC0,
  0xFF, 0xFF, 0xDF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0,
  0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x07, 0xF1,
  0xFC, 0x0F, 0xE0, 0x7F, 0x1F, 0xC0, 0xFE, 0x0F, 0xF1, 0xFC, 0x1F, 0xC0,
  0xFE, 0x3F, 0xC1, 0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC0, 0xFE, 0x3F, 0x81,
  0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x1F, 0xE3,
  0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x83, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x81,
  0xFC, 0x7F, 0x03, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x81, 0xFC, 0x7F, 0x03,
  0xF8, 0x3F, 0xC7, 0xF0, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x3F, 0x8F,
  0xE0, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x3F, 0xBF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F, 0xF0, 0x7F, 0x1F, 0xC0, 0xFE, 0x3F,
  0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xE7, 0xF8,
  0x1F, 0xCF, 0xE0, 0x7F, 0x9F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03,
  0xF8, 0xFE, 0x07, 0xF3, 0xFC, 0x0F, 0xE7, 0xF0, 0x3F, 0xCF, 0xE0, 0x7F,
  0x1F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0xFF, 0x03, 0xF9, 0xFC, 0x07, 0xF3,
  0xF8, 0x1F, 0xE7, 0xF0, 0x3F, 0x8F, 0xE0, 0x7F, 0x00, 0x00, 0x04, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x07, 0xFD, 0xFF, 0x1F, 0xE0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F,
  0x01, 0xFD, 0xFC, 0x03, 0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0,
  0x1F, 0xDF, 0xC0, 0x3F, 0xFF, 0x80, 0xFE, 0xFF, 0x01, 0xFD, 0xFC, 0x03,
  0xFB, 0xF8, 0x07, 0xF7, 0xF0, 0x0F, 0xEF, 0xE0, 0x3F, 0x8F, 0xE0, 0x7F,
  0x1F, 0xC1, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC,
  0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFE, 0x03,
  0xFC, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFE,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xF8, 0x1F, 0xC1,
  0xFE, 0x0F, 0xF0, 0x7F, 0xEF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x03, 0xFB, 0xFF, 0xC0, 0xFE, 0x7F, 0xE0, 0x3F, 0x8F, 0xE0, 0x0F, 0xE0,
  0xC0, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x3F, 0x07, 0xFE, 0x7F, 0x0F, 0xFF, 0x7F, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0x81,
  0xFE, 0x7F, 0x81, 0xFE, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01,
  0xFC, 0x7F, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0xFE, 0x03, 0xFC, 0xFE, 0x03,
  0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03,
  0xF8, 0xFE, 0x07, 0xF0, 0xFF, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xEF,
  0xE0, 0x01, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xF9, 0xF0, 0xFE, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0,
  0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x1F, 0xC7,
  0xF0, 0x7F, 0x1F, 0xC1, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0xFE,
  0x07, 0xF3, 0xF8, 0x1F, 0xCF, 0xE0, 0x7F, 0x1F, 0xC3, 0xFC, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x01, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x3F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7,
  0xFF, 0xE1, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x0F, 0xFC, 0x1F,
  0xF8, 0x3F, 0xF0, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x10, 0x00, 0x0F,
  0xE0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0xFE, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F,
  0x81, 0xFE, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x3F, 0x81, 0xFC, 0x7F,
  0x81, 0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F,
  0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0xFF, 0x07, 0xF8, 0xFF,
  0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xF7, 0xE0, 0x1F, 0xE7, 0xE0, 0x03,
  0x00, 0x00, 0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFD, 0xFC, 0x0F,
  0xEF, 0xE0, 0xFF, 0x7F, 0x07, 0xF3, 0xF8, 0x3F, 0x9F, 0xC3, 0xF8, 0x7E,
  0x1F, 0xC3, 0xF1, 0xFC, 0x1F, 0x8F, 0xE0, 0xFC, 0x7F, 0x07, 0xE7, 0xF0,
  0x3F, 0x3F, 0x81, 0xFD, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xC0, 0xFF, 0xFC, 0x1F, 0x83, 0xFB,
  0xF8, 0x3F, 0x07, 0xF7, 0xF0, 0xFE, 0x0F, 0xEF, 0xE1, 0xFC, 0x3F, 0x9F,
  0xC3, 0xF8, 0x7F, 0x3F, 0x8F, 0xF0, 0xFC, 0x7F, 0x1F, 0xE3, 0xF8, 0xFE,
  0x7F, 0xC7, 0xF1, 0xFC, 0xFF, 0x8F, 0xC3, 0xF9, 0xFF, 0x3F, 0x87, 0xF7,
  0xFF, 0x7F, 0x0F, 0xEF, 0xBE, 0xFC, 0x1F, 0xFF, 0x7D, 0xF8, 0x1F, 0xFC,
  0xFF, 0xE0, 0x3F, 0xF9, 0xFF, 0xC0, 0x7F, 0xF3, 0xFF, 0x80, 0xFF, 0xC7,
  0xFE, 0x01, 0xFF, 0x8F, 0xFC, 0x03, 0xFE, 0x1F, 0xF8, 0x07, 0xFC, 0x3F,
  0xE0, 0x0F, 0xF8, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE,
  0x00, 0x7F, 0x03, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xE0,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x0F, 0xF0,
  0x3F, 0x87, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0xFF, 0x00, 0x7F, 0x3F,
  0x80, 0x1F, 0xDF, 0xE0, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xF7,
  0xF0, 0x03, 0xFD, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x7F, 0x8F, 0xE0, 0x3F,
  0xC3, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC3, 0xF8, 0x1F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0xFF, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0x3F,
  0x87, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x80,
  0x1F, 0x9F, 0xE0, 0x07, 0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0x80, 0x01, 0x00, 0x01,
  0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F,
  0x00, 0x00, 0x80, 0x00, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x70, 0x00, 0x40, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x07, 0xC7,
  0xFE, 0x07, 0xE7, 0xFF, 0x83, 0xE3, 0xFF, 0xC1, 0xF3, 0xFF, 0xF1, 0xF9,
  0xF9, 0xFF, 0xF9, 0xF8, 0x7F, 0xFC, 0xFC, 0x1F, 0xFC, 0x7C, 0x07, 0xFE,
  0x3E, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0x00,
};

const GFXglyph RobotoCondensed_BoldItalic53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 39, 13, 1, -38 },
  { 70, 16, 14, 16, 3, -40 },
  { 98, 26, 38, 27, 1, -38 },
  { 222, 23, 50, 26, 2, -44 },
  { 366, 25, 40, 33, 5, -39 },
  { 491, 26, 40, 30, 1, -39 },
  { 621, 8, 14, 8, 3, -40 },
  { 635, 17, 54, 17, 2, -42 },
  { 750, 16, 54, 17, -2, -42 },
  { 858, 22, 23, 23, 3, -38 },
  { 922, 23, 28, 24, 1, -31 },
  { 1003, 11, 16, 13, -3, -6 },
  { 1025, 13, 6, 19, 3, -19 },
  { 1035, 8, 9, 15, 1, -8 },
  { 1044, 23, 41, 17, -3, -38 },
  { 1162, 23, 40, 26, 2, -39 },
  { 1277, 16, 38, 26, 6, -38 },
  { 1353, 25, 39, 26, 0, -39 },
  { 1475, 24, 40, 26, 1, -39 },
  { 1595, 24, 38, 26, 1, -38 },
  { 1709, 25, 39, 26, 1, -38 },
  { 1831, 22, 39, 26, 2, -38 },
  { 1939, 25, 38, 26, 2, -38 },
  { 2058, 24, 40, 26, 1, -39 },
  { 2178, 21, 39, 26, 4, -39 },
  { 2281, 12, 30, 14, 1, -29 },
  { 2326, 15, 39, 13, -2, -29 },
  { 2400, 21, 25, 23, 1, -29 },
  { 2466, 22, 17, 26, 2, -25 },
  { 2513, 21, 25, 23, 1, -28 },
  { 2579, 19, 40, 23, 4, -39 },
  { 2674, 37, 49, 39, 1, -37 },
  { 2901, 29, 38, 31, -2, -38 },
  { 3039, 28, 38, 29, 0, -38 },
  { 3172, 27, 40, 29, 2, -39 },
  { 3307, 28, 38, 29, 0, -38 },
  { 3440, 28, 38, 25, 0, -38 },
  { 3573, 27, 38, 24, 0, -38 },
  { 3702, 28, 40, 30, 2, -39 },
  { 3842, 32, 38, 32, 0, -38 },
  { 3994, 13, 38, 14, 1, -38 },
  { 4056, 26, 39, 25, 0, -38 },
  { 4183, 33, 38, 28, 0, -38 },
  { 4340, 22, 38, 25, 0, -38 },
  { 4445, 40, 38, 39, 0, -38 },
  { 4635, 32, 38, 31, 0, -38 },
  { 4787, 28, 40, 31, 2, -39 },
  { 4927, 29, 38, 29, 0, -38 },
  { 5065, 28, 46, 31, 2, -39 },
  { 5226, 28, 38, 28, 0, -38 },
  { 5359, 27, 40, 28, 1, -39 },
  { 5494, 26, 38, 28, 4, -38 },
  { 5618, 29, 39, 29, 2, -38 },
  { 5760, 29, 38, 30, 4, -38 },
  { 5898, 36, 38, 39, 5, -38 },
  { 6069, 33, 38, 29, -2, -38 },
  { 6226, 28, 38, 28, 4, -38 },
  { 6359, 30, 38, 27, -1, -38 },
  { 6502, 18, 53, 14, -1, -44 },
  { 6622, 13, 41, 20, 4, -38 },
  { 6689, 18, 53, 14, -3, -44 },
  { 6809, 17, 19, 20, 2, -38 },
  { 6850, 20, 6, 21, -3, 0 },
  { 6865, 12, 8, 17, 5, -40 },
  { 6877, 22, 30, 24, 0, -29 },
  { 6960, 24, 41, 25, 0, -40 },
  { 7083, 22, 30, 24, 1, -29 },
  { 7166, 26, 41, 25, 1, -40 },
  { 7300, 22, 30, 25, 1, -29 },
  { 7383, 18, 41, 17, 2, -41 },
  { 7476, 25, 40, 26, 0, -29 },
  { 7601, 23, 40, 25, 0, -40 },
  { 7716, 14, 39, 13, 0, -39 },
  { 7785, 20, 50, 13, -6, -39 },
  { 7910, 26, 40, 25, 0, -40 },
  { 8040, 14, 40, 13, 0, -40 },
  { 8110, 36, 29, 38, 0, -29 },
  { 8241, 23, 29, 25, 0, -29 },
  { 8325, 23, 30, 26, 1, -29 },
  { 8412, 26, 40, 25, -2, -29 },
  { 8542, 24, 40, 26, 1, -29 },
  { 8662, 18, 29, 17, 0, -29 },
  { 8728, 22, 30, 23, 0, -29 },
  { 8811, 15, 36, 16, 2, -35 },
  { 8879, 24, 29, 25, 1, -28 },
  { 8966, 21, 28, 23, 3, -28 },
  { 9040, 31, 28, 33, 3, -28 },
  { 9149, 26, 28, 23, -2, -28 },
  { 9240, 26, 39, 23, -1, -28 },
  { 9367, 24, 28, 23, -1, -28 },
  { 9451, 16, 50, 15, 1, -41 },
  { 9551, 11, 45, 13, 1, -38 },
  { 9613, 16, 50, 15, -2, -41 },
  { 9713, 25, 12, 29, 2, -22 },
};

const GFXfont RobotoCondensed_BoldItalic53pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic53pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic53pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _ROBOTOCONDENSED_BOLDITALIC53PT7B_H_
