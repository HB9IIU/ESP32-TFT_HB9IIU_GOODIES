#ifndef _ROBOTOCONDENSED_BOLDITALIC15PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x32, 0x66, 0x66, 0x0C, 0xC0, 0xDD, 0xBB, 0x0A, 0x0A, 0x1E,
  0x7F, 0x14, 0x34, 0x28, 0xFE, 0x68, 0x58, 0x50, 0x04, 0x10, 0x71, 0xF3,
  0x64, 0x0C, 0x1C, 0x0D, 0x99, 0xB3, 0xE3, 0x84, 0x00, 0x70, 0xA7, 0x5E,
  0xA6, 0x83, 0x0F, 0x95, 0x5A, 0xB4, 0x38, 0x1C, 0x3E, 0x36, 0x34, 0x3C,
  0x38, 0x7B, 0xDE, 0xCE, 0x7E, 0x7E, 0xFE, 0x13, 0x66, 0x4C, 0xCC, 0x88,
  0x88, 0xCC, 0x40, 0x10, 0x86, 0x31, 0x8C, 0x63, 0x18, 0xCC, 0x66, 0x31,
  0x00, 0x10, 0x4F, 0xCC, 0x52, 0x40, 0x18, 0x30, 0x63, 0xFF, 0xC6, 0x0C,
  0x18, 0x6D, 0xE0, 0xEE, 0xF8, 0x04, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x18,
  0x20, 0xC1, 0x06, 0x00, 0x39, 0xFC, 0xF3, 0xCF, 0x3C, 0xF2, 0xDB, 0xE7,
  0x00, 0x1F, 0xF3, 0x66, 0x66, 0x66, 0xC0, 0x1C, 0x7D, 0x98, 0x30, 0xE1,
  0x86, 0x18, 0x71, 0xFB, 0xF0, 0x1C, 0x7D, 0x98, 0x31, 0xC3, 0x83, 0x06,
  0xCC, 0xF9, 0xE0, 0x06, 0x1C, 0x78, 0xE3, 0xC5, 0x9B, 0x7F, 0xFE, 0x30,
  0x60, 0x3E, 0x7C, 0xC1, 0x07, 0xCF, 0x81, 0x83, 0xCC, 0xF8, 0xE0, 0x18,
  0xE6, 0x30, 0xFB, 0xFC, 0xF3, 0xDB, 0xE7, 0x00, 0xFF, 0xF8, 0x30, 0xC1,
  0x86, 0x0C, 0x38, 0x61, 0xC3, 0x00, 0x1C, 0x7C, 0xD9, 0x33, 0xC7, 0x9B,
  0x76, 0xEC, 0xF9, 0xE0, 0x39, 0xFC, 0xF3, 0xCF, 0xF7, 0xC6, 0x1B, 0xCE,
  0x00, 0x72, 0x00, 0x00, 0xE4, 0x39, 0x80, 0x00, 0x00, 0x8C, 0x66, 0x00,
  0x04, 0x77, 0xB8, 0x70, 0xE0, 0x80, 0xFF, 0xF0, 0x3E, 0xF8, 0x41, 0xC3,
  0xC3, 0x3D, 0xC8, 0x00, 0x7B, 0xEC, 0xC6, 0x18, 0xC6, 0x18, 0x03, 0x84,
  0x00, 0x0F, 0x83, 0x18, 0xC1, 0x13, 0xB4, 0xD6, 0xB6, 0xF6, 0xD6, 0x92,
  0xDE, 0xDB, 0xF1, 0x00, 0x30, 0x03, 0xC0, 0x06, 0x03, 0x83, 0xC1, 0xE1,
  0xB0, 0xD8, 0xEC, 0x7E, 0x3F, 0x31, 0xD8, 0x60, 0x3E, 0x3F, 0x33, 0x63,
  0x7E, 0x7E, 0x66, 0x66, 0xE6, 0xFE, 0xFC, 0x3C, 0xFD, 0x9E, 0x3C, 0x18,
  0x30, 0x63, 0xCD, 0xF9, 0xE0, 0x3C, 0x3E, 0x33, 0x63, 0x63, 0x63, 0x67,
  0x66, 0xE6, 0xFC, 0xF8, 0x3F, 0x3F, 0x30, 0x60, 0x7C, 0x7C, 0x60, 0x60,
  0xE0, 0xFC, 0xFC, 0x3F, 0x3E, 0x30, 0x60, 0x7C, 0x7C, 0x60, 0x60, 0xE0,
  0xC0, 0xC0, 0x3C, 0xFD, 0x9E, 0x3C, 0x1B, 0xF7, 0xE3, 0xCF, 0xF9, 0xE0,
  0x31, 0x98, 0xCC, 0x6C, 0x37, 0xF3, 0xF9, 0x8C, 0xC6, 0xE3, 0x61, 0xB1,
  0x80, 0x33, 0x37, 0x66, 0x66, 0x6C, 0xC0, 0x06, 0x0C, 0x18, 0x30, 0x61,
  0x83, 0x06, 0xCD, 0xF1, 0xC0, 0x33, 0x9B, 0x8D, 0x8D, 0x87, 0xC3, 0xE1,
  0xF0, 0xD8, 0xEC, 0x63, 0x31, 0x80, 0x30, 0xC3, 0x18, 0x61, 0x86, 0x18,
  0xE3, 0xFF, 0xC0, 0x38, 0xE7, 0x1C, 0xE7, 0xBC, 0xF7, 0x96, 0xF7, 0x9A,
  0xB3, 0x76, 0xEE, 0xD9, 0x9B, 0x37, 0x00, 0x31, 0x98, 0xCE, 0x6F, 0x76,
  0xB3, 0x59, 0xBC, 0xDE, 0xE7, 0x63, 0xB1, 0x80, 0x3C, 0x7E, 0x66, 0xC6,
  0xC6, 0xC6, 0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0x3E, 0x3F, 0x33, 0x63, 0x63,
  0x7E, 0x7C, 0x60, 0xE0, 0xC0, 0xC0, 0x3C, 0x7E, 0x66, 0xC6, 0xC6, 0xC6,
  0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0x0C, 0x08, 0x3E, 0x3F, 0x33, 0x63, 0x63,
  0x7E, 0x7C, 0x6C, 0xEC, 0xCE, 0xC6, 0x1E, 0x3F, 0x73, 0x60, 0x38, 0x3C,
  0x0E, 0xC6, 0xE6, 0x7E, 0x3C, 0xFF, 0xFE, 0x18, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x60, 0x60, 0x33, 0x99, 0x9C, 0xCC, 0x66, 0x33, 0x19, 0x8C,
  0xCC, 0x66, 0x3F, 0x0F, 0x00, 0xC3, 0xE7, 0xE6, 0x66, 0x6C, 0x6C, 0x7C,
  0x78, 0x78, 0x70, 0x70, 0xCC, 0xD9, 0x9B, 0x33, 0x6E, 0xCD, 0xD9, 0xAB,
  0x3D, 0x67, 0xB8, 0xE7, 0x1C, 0xE1, 0x98, 0x00, 0x73, 0x99, 0x8D, 0x86,
  0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x6C, 0x73, 0x31, 0x80, 0xE7, 0x66, 0x6E,
  0x6C, 0x78, 0x78, 0x30, 0x30, 0x30, 0x60, 0x60, 0x3F, 0x7F, 0x06, 0x0E,
  0x0C, 0x18, 0x30, 0x30, 0x60, 0xFE, 0xFE, 0x39, 0xCC, 0xC6, 0x31, 0x8C,
  0x66, 0x31, 0x8E, 0x70, 0xCC, 0x66, 0x66, 0x66, 0x66, 0x33, 0x39, 0xC6,
  0x31, 0x98, 0xC6, 0x31, 0x8C, 0xCE, 0x70, 0x18, 0xE2, 0x9A, 0x48, 0xFF,
  0xF0, 0x62, 0x3D, 0xF6, 0xDF, 0xEF, 0x3F, 0xDB, 0x30, 0x60, 0xC3, 0x07,
  0xCF, 0xD9, 0xB3, 0x67, 0x9B, 0xF7, 0xC0, 0x3D, 0xF6, 0x70, 0xC3, 0x37,
  0xDE, 0x03, 0x06, 0x06, 0x06, 0x3E, 0x7E, 0x66, 0xCC, 0xCC, 0xCC, 0xFC,
  0x7C, 0x3C, 0xF9, 0x9B, 0x3F, 0xD8, 0x1F, 0x3C, 0x1C, 0xF3, 0x0C, 0x79,
  0xE6, 0x18, 0x61, 0x86, 0x18, 0x3E, 0xFD, 0x9E, 0x3C, 0xD9, 0x9F, 0x3E,
  0x0D, 0xF3, 0xC0, 0x30, 0x61, 0x83, 0x07, 0xCF, 0x99, 0xB6, 0xCD, 0x9B,
  0x36, 0x60, 0x33, 0x06, 0x66, 0x66, 0xEC, 0xC0, 0x0C, 0x30, 0x06, 0x18,
  0x61, 0x86, 0x38, 0xC3, 0x0C, 0x73, 0x80, 0x30, 0x60, 0xC3, 0x06, 0x6D,
  0x9E, 0x3C, 0x79, 0xF3, 0x36, 0x60, 0x33, 0x36, 0x66, 0x66, 0x6C, 0xCC,
  0x7D, 0xDF, 0xF6, 0xED, 0xB3, 0x6C, 0xF3, 0x3C, 0xCF, 0x36, 0x7C, 0xF9,
  0x9B, 0x66, 0xD9, 0xB3, 0x66, 0x3C, 0xF9, 0x9B, 0x3C, 0x79, 0x9F, 0x3C,
  0x3E, 0x3F, 0x33, 0x33, 0x33, 0x66, 0x7E, 0x7C, 0x60, 0x60, 0x60, 0x3E,
  0xFD, 0x9E, 0x6C, 0xD9, 0xBF, 0x3E, 0x0C, 0x30, 0x60, 0x7B, 0xD8, 0xC6,
  0x63, 0x18, 0x39, 0xF6, 0x1C, 0x3B, 0x3F, 0xDE, 0x31, 0x9E, 0xE6, 0x31,
  0x8C, 0x73, 0x00, 0x66, 0xCD, 0x9B, 0x66, 0xD9, 0x9F, 0x3E, 0xCF, 0x6D,
  0xB4, 0xF3, 0xCE, 0x18, 0xDB, 0x6D, 0xBE, 0xDF, 0xCE, 0xE7, 0x73, 0x31,
  0x98, 0x37, 0x36, 0x1C, 0x1C, 0x1C, 0x3C, 0x7C, 0x66, 0x66, 0xD9, 0xB3,
  0xC7, 0x8F, 0x1C, 0x18, 0x61, 0xC3, 0x00, 0x7C, 0xF8, 0x61, 0xC3, 0x0C,
  0x3E, 0x7C, 0x08, 0xCC, 0x63, 0x13, 0x98, 0x63, 0x18, 0xC6, 0x30, 0x80,
  0x24, 0x92, 0xD2, 0x49, 0x6C, 0x10, 0x86, 0x31, 0x08, 0x63, 0x31, 0x8C,
  0x46, 0x31, 0x00, 0x67, 0xFA, 0x70,
};

const GFXglyph RobotoCondensed_BoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 5, 1, -11 },
  { 9, 8, 11, 8, 0, -11 },
  { 20, 7, 14, 7, 0, -13 },
  { 33, 7, 11, 9, 1, -11 },
  { 43, 8, 11, 8, 0, -11 },
  { 54, 2, 4, 2, 1, -11 },
  { 55, 4, 15, 5, 1, -12 },
  { 63, 5, 15, 5, -1, -12 },
  { 73, 6, 6, 7, 1, -11 },
  { 78, 7, 8, 7, 0, -9 },
  { 85, 3, 4, 4, -1, -2 },
  { 87, 4, 2, 5, 1, -6 },
  { 88, 3, 2, 4, 0, -2 },
  { 89, 7, 12, 5, -1, -11 },
  { 100, 6, 11, 7, 1, -11 },
  { 109, 4, 11, 7, 2, -11 },
  { 115, 7, 11, 7, 0, -11 },
  { 125, 7, 11, 7, 0, -11 },
  { 135, 7, 11, 7, 0, -11 },
  { 145, 7, 11, 7, 0, -11 },
  { 155, 6, 11, 7, 1, -11 },
  { 164, 7, 11, 7, 1, -11 },
  { 174, 7, 11, 7, 0, -11 },
  { 184, 6, 11, 7, 1, -11 },
  { 193, 4, 8, 4, 0, -8 },
  { 197, 5, 10, 4, -1, -8 },
  { 204, 6, 7, 7, 0, -8 },
  { 210, 6, 5, 7, 1, -7 },
  { 214, 6, 7, 7, 0, -8 },
  { 220, 6, 11, 7, 1, -11 },
  { 229, 11, 13, 11, 0, -10 },
  { 247, 9, 11, 9, -1, -11 },
  { 260, 8, 11, 8, 0, -11 },
  { 271, 7, 11, 8, 1, -11 },
  { 281, 8, 11, 8, 0, -11 },
  { 292, 8, 11, 7, 0, -11 },
  { 303, 8, 11, 7, 0, -11 },
  { 314, 7, 11, 9, 1, -11 },
  { 324, 9, 11, 9, 0, -11 },
  { 337, 4, 11, 4, 0, -11 },
  { 343, 7, 11, 7, 0, -11 },
  { 353, 9, 11, 8, 0, -11 },
  { 366, 6, 11, 7, 0, -11 },
  { 375, 11, 11, 11, 0, -11 },
  { 391, 9, 11, 9, 0, -11 },
  { 404, 8, 11, 9, 1, -11 },
  { 415, 8, 11, 8, 0, -11 },
  { 426, 8, 13, 9, 1, -11 },
  { 439, 8, 11, 8, 0, -11 },
  { 450, 8, 11, 8, 0, -11 },
  { 461, 8, 11, 8, 1, -11 },
  { 472, 9, 11, 8, 0, -11 },
  { 485, 8, 11, 8, 1, -11 },
  { 496, 11, 11, 11, 1, -11 },
  { 512, 9, 11, 8, 0, -11 },
  { 525, 8, 11, 8, 1, -11 },
  { 536, 8, 11, 8, 0, -11 },
  { 547, 5, 14, 4, 0, -12 },
  { 556, 4, 12, 6, 1, -11 },
  { 562, 5, 14, 4, -1, -12 },
  { 571, 6, 5, 6, 0, -11 },
  { 575, 6, 2, 6, -1, 0 },
  { 577, 4, 2, 5, 1, -11 },
  { 578, 6, 8, 7, 0, -8 },
  { 584, 7, 12, 7, 0, -12 },
  { 595, 6, 8, 7, 0, -8 },
  { 601, 8, 12, 7, 0, -12 },
  { 613, 7, 8, 7, 0, -8 },
  { 620, 6, 12, 5, 0, -12 },
  { 629, 7, 11, 7, 0, -8 },
  { 639, 7, 12, 7, 0, -12 },
  { 650, 4, 11, 4, 0, -11 },
  { 656, 6, 14, 4, -2, -11 },
  { 667, 7, 12, 7, 0, -12 },
  { 678, 4, 12, 4, 0, -12 },
  { 684, 10, 8, 11, 0, -8 },
  { 694, 7, 8, 7, 0, -8 },
  { 701, 7, 8, 7, 0, -8 },
  { 708, 8, 11, 7, -1, -8 },
  { 719, 7, 11, 7, 0, -8 },
  { 729, 5, 8, 5, 0, -8 },
  { 734, 6, 8, 7, 0, -8 },
  { 740, 5, 10, 4, 0, -10 },
  { 747, 7, 8, 7, 0, -8 },
  { 754, 6, 8, 7, 1, -8 },
  { 760, 9, 8, 9, 1, -8 },
  { 769, 8, 8, 7, -1, -8 },
  { 777, 7, 11, 6, 0, -8 },
  { 787, 7, 8, 7, 0, -8 },
  { 794, 5, 15, 4, 0, -12 },
  { 804, 3, 13, 4, 0, -11 },
  { 809, 5, 15, 4, -1, -12 },
  { 819, 7, 3, 8, 1, -6 },
};

const GFXfont RobotoCondensed_BoldItalic15pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic15pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _ROBOTOCONDENSED_BOLDITALIC15PT7B_H_
