#ifndef _ROBOTOCONDENSED_BOLDITALIC56PT7B_H_
#define _ROBOTOCONDENSED_BOLDITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoCondensed-BoldItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoCondensed_BoldItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0x80, 0x10,
  0x00, 0x1F, 0x1F, 0x9F, 0x8F, 0x8F, 0xC7, 0xC7, 0xE3, 0xE3, 0xE1, 0xF1,
  0xF1, 0xF8, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C, 0x3E, 0x3E, 0x1F, 0x1F, 0x0F,
  0x0F, 0x87, 0x87, 0x87, 0xC3, 0xC3, 0xE3, 0xE1, 0xF0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00,
  0x07, 0x87, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF0,
  0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1E, 0x1F, 0x00,
  0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x87, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1F,
  0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x7F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xC7,
  0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xE0, 0xFF, 0x0F, 0xE0, 0x7F, 0x87, 0xF0,
  0x3F, 0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x0F, 0xF0, 0x7F, 0x8F,
  0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x9F, 0x01, 0x87, 0xC3,
  0xE0, 0xF3, 0xF0, 0xF8, 0x3E, 0xF8, 0x3E, 0x1F, 0x3E, 0x0F, 0x8F, 0xCF,
  0x83, 0xE3, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0xF8, 0x3E, 0x1F, 0x3E,
  0x0F, 0xCF, 0xDF, 0x01, 0xFF, 0xEF, 0x80, 0x7F, 0xFB, 0xE0, 0x0F, 0xFD,
  0xF0, 0x01, 0xFC, 0xF8, 0x00, 0x08, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF3, 0xF8, 0x00, 0xFB, 0xFF,
  0x00, 0x7E, 0xFF, 0xE0, 0x1F, 0x7F, 0xF8, 0x0F, 0xBF, 0x1F, 0x07, 0xEF,
  0x87, 0xC1, 0xF3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x3C, 0x1F, 0x1F,
  0x1F, 0x07, 0xCF, 0x87, 0xC1, 0xF7, 0xC1, 0xF0, 0x7D, 0xF0, 0x3E, 0x3E,
  0x38, 0x0F, 0x8F, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xC7, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F,
  0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x7F, 0x0F, 0xFF, 0x87, 0xF1, 0xFF, 0xF8, 0x7E, 0x3F, 0xFF, 0xC7, 0xE3,
  0xF9, 0xFC, 0xFE, 0x7F, 0x9F, 0xEF, 0xE7, 0xF0, 0xFF, 0xFC, 0xFF, 0x0F,
  0xFF, 0xCF, 0xF0, 0x7F, 0xFC, 0xFF, 0x07, 0xFF, 0x8F, 0xF0, 0x3F, 0xF8,
  0xFF, 0x03, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFB, 0xFC, 0x07, 0xFE, 0x3F, 0xC0, 0x06, 0x00, 0x00, 0x1F,
  0x3F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0xF8, 0x00, 0x01, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0C, 0x00, 0x02,
  0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x00,
  0x40, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x08, 0x0F, 0x80, 0xBC,
  0x1F, 0x0F, 0x7E, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xBF, 0x00, 0x7E, 0x3E, 0x01, 0xF8, 0x7E,
  0x07, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x07, 0x00, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE,
  0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x7F, 0x07, 0xE0,
  0xFC, 0x07, 0x80, 0x10, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFE,
  0xFF, 0xFB, 0xFF, 0xE0, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC,
  0x7C, 0x08, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xF0, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F,
  0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x3F, 0xC0, 0x7F,
  0x3F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFF, 0x7F, 0x80, 0xFE,
  0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0x7F, 0x00, 0xFE, 0xFF, 0x01, 0xFE,
  0xFF, 0x01, 0xFE, 0xFF, 0x01, 0xFC, 0xFF, 0x01, 0xFC, 0xFF, 0x01, 0xFC,
  0xFF, 0x01, 0xFC, 0xFF, 0x03, 0xF8, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8,
  0x7F, 0x8F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x01, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xF1, 0xFF,
  0xF9, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x3F, 0xFF, 0x3E, 0x3F, 0x9C,
  0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F,
  0xC0, 0x7F, 0x07, 0xF8, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xE1, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xF8, 0x0F, 0xE1, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x1F,
  0xE3, 0xF8, 0x07, 0xF8, 0xFF, 0x01, 0xFC, 0x3F, 0xC0, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xEF, 0xE0, 0x07, 0xF7, 0xF0, 0x03, 0xF7, 0xF8,
  0x03, 0xFB, 0xFC, 0x03, 0xF9, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x7F,
  0x01, 0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0xC0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F,
  0xC3, 0xFC, 0x00, 0xC0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x3F, 0xC3, 0xF8,
  0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xE3, 0xFE, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF9, 0xF8,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF3, 0xFF, 0x3F, 0xF7, 0xFC, 0x1F, 0xEF, 0xF0, 0x3F, 0xDF,
  0xC0, 0x7F, 0xBF, 0x80, 0x7F, 0x7F, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xDF, 0xC0,
  0x7F, 0x3F, 0x81, 0xFE, 0x7F, 0x03, 0xF8, 0xFF, 0x0F, 0xF0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xF1, 0xFE, 0x07,
  0xF8, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x07, 0xF8, 0x1F, 0xC1,
  0xFE, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0x01, 0xFE, 0x1F, 0xC0, 0x7F, 0x87, 0xF0,
  0x1F, 0xE1, 0xFC, 0x07, 0xF8, 0x7F, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xF0, 0xFE,
  0x3F, 0x83, 0xF9, 0xFE, 0x0F, 0xF7, 0xF0, 0x1F, 0xDF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0xFF, 0x07, 0xFB,
  0xFE, 0x3F, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0x7F, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFC,
  0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0xE0, 0x7F, 0x87,
  0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF0, 0x1F, 0x00, 0x20, 0x00, 0x00, 0x3C,
  0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x7E, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x00, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x04, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3E, 0x00, 0x00, 0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0xF1, 0xFE, 0xFF, 0x07, 0xF7, 0xF8, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0xFC, 0x03, 0xC0, 0xF8, 0x07, 0xFE, 0x07, 0x83, 0xF0, 0x3F, 0xFE,
  0x0F, 0x07, 0xC0, 0xFF, 0xFE, 0x1E, 0x1F, 0x81, 0xFF, 0xF8, 0x3E, 0x3E,
  0x07, 0xE1, 0xF0, 0x7C, 0x7C, 0x1F, 0x83, 0xE0, 0xF9, 0xF0, 0x3E, 0x07,
  0xC1, 0xF3, 0xE0, 0xFC, 0x1F, 0x83, 0xE7, 0xC1, 0xF0, 0x3E, 0x07, 0x9F,
  0x07, 0xE0, 0x7C, 0x0F, 0x3E, 0x0F, 0xC0, 0xF8, 0x1E, 0x7C, 0x1F, 0x83,
  0xF0, 0x3C, 0xF8, 0x7E, 0x07, 0xC0, 0xFB, 0xF0, 0xFC, 0x0F, 0x81, 0xF7,
  0xC1, 0xF8, 0x1F, 0x03, 0xCF, 0x83, 0xF0, 0x7E, 0x07, 0x9F, 0x07, 0xE0,
  0xF8, 0x1F, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x7C, 0x1F, 0x07, 0xE0, 0x78,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF1, 0xF0, 0x7E, 0x3F, 0x87, 0xC3, 0xE0, 0xFE,
  0xFF, 0x0F, 0x87, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0x81, 0xFF, 0xFF, 0xF8,
  0x1F, 0x03, 0xFE, 0x7F, 0xE0, 0x3E, 0x03, 0xF8, 0x7F, 0x80, 0x3E, 0x00,
  0x80, 0x18, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x20, 0x00, 0x03, 0xFC, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0xFF, 0x00, 0x0F,
  0xF1, 0xFE, 0x00, 0x0F, 0xE7, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFC, 0x01,
  0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0xC1,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F,
  0x80, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00,
  0x7F, 0x9F, 0xE0, 0x03, 0xFC, 0xFF, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F,
  0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00,
  0x7F, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xF8,
  0x1F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F,
  0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC,
  0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F,
  0xC1, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0,
  0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F,
  0x80, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC3, 0xFE,
  0x07, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFC, 0x00, 0xFE, 0x3F,
  0xC0, 0x07, 0xF1, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xFF, 0x3F,
  0xC0, 0xFF, 0xF9, 0xFE, 0x0F, 0xFF, 0xCF, 0xF0, 0x7F, 0xFE, 0x7F, 0x03,
  0xFF, 0xE7, 0xF8, 0x1F, 0xFF, 0x3F, 0xC0, 0x07, 0xF9, 0xFE, 0x00, 0x3F,
  0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF1, 0xFC, 0x00, 0xFF, 0x8F,
  0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFE, 0x01, 0xFE, 0x0F, 0xF8,
  0x7F, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F,
  0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF8,
  0x1F, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0,
  0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07, 0xF8,
  0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F,
  0xE0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x07,
  0xF8, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x7F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x07, 0xF0, 0x0F, 0xFC, 0x03, 0xFC, 0x07,
  0xFE, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x0F, 0xF0,
  0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xF0, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0x87, 0xFC, 0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x07, 0xF9, 0xFF, 0x00, 0x01,
  0xFE, 0x7F, 0xC0, 0x00, 0x7F, 0x3F, 0xE0, 0x00, 0x3F, 0xDF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x07, 0xFE, 0xFF, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0xFF,
  0x87, 0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x03,
  0xFC, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x80,
  0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x7F, 0xF0,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F,
  0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xF7, 0xE0, 0x7E, 0xFE, 0x03, 0xF9, 0xF8, 0x3F, 0xBF, 0x80,
  0xFE, 0x7E, 0x0F, 0xCF, 0xE0, 0x3F, 0x9F, 0x83, 0xF7, 0xF8, 0x0F, 0xE7,
  0xE1, 0xF9, 0xFE, 0x07, 0xF9, 0xF8, 0x7E, 0x7F, 0x01, 0xFE, 0x7E, 0x3F,
  0x1F, 0xC0, 0x7F, 0x9F, 0x8F, 0xCF, 0xF0, 0x1F, 0xE7, 0xE7, 0xF3, 0xFC,
  0x07, 0xF0, 0xF9, 0xF8, 0xFF, 0x01, 0xFC, 0x3E, 0x7E, 0x3F, 0xC0, 0xFF,
  0x0F, 0xBF, 0x0F, 0xE0, 0x3F, 0xC3, 0xFF, 0xC7, 0xF8, 0x0F, 0xF0, 0xFF,
  0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xF8, 0x7F, 0x80, 0xFF, 0x0F, 0xFC, 0x1F,
  0xE0, 0x3F, 0x83, 0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x81, 0xFC, 0x07,
  0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0x7F, 0x81,
  0xFC, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0xFE, 0x03, 0xFC, 0x07, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFF,
  0x03, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x3F, 0xF8, 0x07,
  0xF8, 0x0F, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xE0,
  0x1F, 0xE0, 0x7F, 0xFC, 0x07, 0xF0, 0x1F, 0xFF, 0x03, 0xFC, 0x07, 0xFF,
  0xC0, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xC0, 0x7F, 0xFE, 0x0F, 0xF0, 0x3F,
  0xDF, 0x83, 0xFC, 0x0F, 0xF3, 0xE0, 0xFE, 0x03, 0xFC, 0xF8, 0x7F, 0x80,
  0xFF, 0x3F, 0x1F, 0xE0, 0x3F, 0xCF, 0xC7, 0xF8, 0x0F, 0xE1, 0xF1, 0xFE,
  0x07, 0xF8, 0x7C, 0x7F, 0x01, 0xFE, 0x1F, 0x9F, 0xC0, 0x7F, 0x87, 0xEF,
  0xF0, 0x1F, 0xE0, 0xFB, 0xFC, 0x07, 0xF8, 0x3F, 0xFF, 0x01, 0xFC, 0x0F,
  0xFF, 0xC0, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xFE, 0x03, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0xE0, 0x3F,
  0x80, 0x3F, 0xF8, 0x1F, 0xE0, 0x0F, 0xFC, 0x07, 0xF8, 0x03, 0xFF, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xFC,
  0x07, 0xF0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03,
  0xF8, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01, 0xFE,
  0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F,
  0xE0, 0x01, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F,
  0xC1, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF0,
  0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80,
  0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01,
  0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0,
  0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0xFF,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0x80,
  0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x01,
  0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F,
  0x9F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x3F, 0xCF,
  0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F, 0xE3, 0xFC,
  0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x80,
  0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x6F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFC, 0x01, 0xFE, 0x0F, 0xF0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01,
  0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0xFF,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0x80,
  0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F,
  0xE0, 0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xC3, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x83, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xE0,
  0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x03,
  0xF8, 0x7F, 0x80, 0x1F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x00, 0x7F, 0x83, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x03,
  0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x83,
  0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE,
  0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0, 0x0F,
  0xF0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF8,
  0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F,
  0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x0F, 0xF0,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x01,
  0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0xFF,
  0x01, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0xFF,
  0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x7F, 0xC7, 0xF8,
  0x00, 0xFF, 0x8F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x07, 0xFC, 0x3F, 0xC0,
  0x0F, 0xF0, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0xC0, 0xFE, 0x00,
  0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x1F, 0xE0,
  0x01, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFE, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x3F, 0xDF, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFF, 0xFC,
  0x07, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0x01,
  0xFE, 0xFF, 0x03, 0xFC, 0x07, 0xFB, 0xFC, 0x0F, 0xF0, 0x1F, 0xEF, 0xF0,
  0x3F, 0xC0, 0x7F, 0x3F, 0x81, 0xFF, 0x03, 0xFC, 0xFE, 0x07, 0xFC, 0x0F,
  0xF3, 0xF8, 0x1F, 0xF8, 0x3F, 0x8F, 0xE0, 0xFF, 0xE1, 0xFE, 0x3F, 0x83,
  0xFF, 0x87, 0xF8, 0xFE, 0x0F, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0xF8, 0xFF,
  0x0F, 0xE1, 0xFF, 0xE3, 0xFC, 0x3F, 0x8F, 0xFF, 0x8F, 0xE0, 0xFE, 0x3F,
  0xFE, 0x3F, 0x83, 0xF8, 0xFD, 0xF9, 0xFE, 0x0F, 0xE7, 0xF7, 0xE7, 0xF0,
  0x3F, 0x9F, 0xDF, 0x9F, 0xC0, 0xFE, 0x7E, 0x7E, 0xFF, 0x03, 0xFB, 0xF9,
  0xFB, 0xF8, 0x0F, 0xEF, 0xC7, 0xEF, 0xE0, 0x3F, 0xBF, 0x1F, 0xFF, 0x80,
  0xFF, 0xFC, 0x7F, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xF0, 0x0F, 0xFF, 0x87,
  0xFF, 0xC0, 0x3F, 0xFE, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x03,
  0xFF, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x1F,
  0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x07,
  0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x7F,
  0xC0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xF8,
  0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00,
  0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x01, 0xFD, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x03,
  0xFC, 0x7F, 0x80, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x3F, 0xE1, 0xFE, 0x00,
  0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03,
  0xFC, 0x7F, 0x80, 0x7F, 0xC7, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x87,
  0xF8, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x83,
  0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xC7, 0xF8, 0x01, 0xFC, 0x7F, 0x00,
  0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x7F,
  0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x81,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0xFD,
  0xF0, 0x1F, 0x3E, 0x07, 0xE7, 0xC0, 0xF8, 0xF8, 0x3F, 0x1F, 0x07, 0xC3,
  0xF1, 0xF8, 0x7E, 0x3E, 0x07, 0xCF, 0xC0, 0xF9, 0xF8, 0x1F, 0x7E, 0x03,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F,
  0xE1, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x03, 0xFC, 0x7F,
  0x03, 0xFC, 0x7F, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFB, 0xF8, 0x0F,
  0xF3, 0xF8, 0x01, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC3, 0xFC, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0xFF,
  0x01, 0xFC, 0x7F, 0x80, 0xFE, 0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F,
  0xE0, 0x3F, 0xC7, 0xF0, 0x1F, 0xE7, 0xF8, 0x0F, 0xF3, 0xFC, 0x07, 0xF9,
  0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x80, 0xFF,
  0x3F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0x8F, 0xF8, 0x3F, 0xC7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFD, 0xFF, 0xF0, 0xFE, 0x7F,
  0xF0, 0x7F, 0x1F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xF0, 0xFF, 0x3F, 0xC0, 0xFE, 0x7F, 0x01,
  0xFC, 0xFE, 0x03, 0xFB, 0xFC, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x3F,
  0xC0, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x87, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x01, 0xFE,
  0x3F, 0x80, 0x3F, 0xF3, 0xF8, 0x07, 0xFF, 0xBF, 0x80, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF, 0x03, 0xFC,
  0x0F, 0xF0, 0x3F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF,
  0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0xFF,
  0x01, 0xFE, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x01, 0xFE, 0x0F, 0xF0, 0x1F,
  0xC0, 0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF8, 0x7F, 0x80, 0x7F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x1F, 0xFB, 0xF8, 0x00, 0xFF, 0x3F, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F,
  0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x7F,
  0x80, 0xFE, 0x7F, 0x80, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x60, 0x7F,
  0xC1, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF1,
  0xFC, 0x07, 0xFF, 0x3F, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0x83, 0xFE, 0x1F, 0xE0, 0x3F,
  0xC3, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC,
  0x07, 0xF8, 0x7F, 0x00, 0xFF, 0x0F, 0xE0, 0x1F, 0xE1, 0xFC, 0x03, 0xF8,
  0x3F, 0x80, 0x7F, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0,
  0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x81,
  0xFC, 0x07, 0xF0, 0x3F, 0xC3, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x01,
  0xFE, 0xFF, 0x00, 0x02, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0xC0, 0x3F, 0xE0, 0x3E, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xFC, 0x3F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFE, 0x07, 0xF0, 0xFF, 0x03,
  0xF8, 0x7F, 0x81, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x03, 0xFC, 0x7F, 0x81, 0xFE, 0x3F,
  0xC0, 0xFF, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0xC7,
  0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFE, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x5F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0x07,
  0xFE, 0x07, 0xF0, 0x7F, 0xC0, 0xFF, 0x0F, 0xF8, 0x0F, 0xF1, 0xFF, 0x00,
  0xFF, 0x3F, 0xE0, 0x0F, 0xE3, 0xFC, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xEF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F,
  0x87, 0xF0, 0x07, 0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x3F,
  0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFE, 0x0F,
  0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x20, 0x01, 0x00, 0x1F, 0xCF, 0xF0, 0x7F, 0x80, 0x7F, 0xFF, 0xE3, 0xFF,
  0x01, 0xFF, 0xFF, 0x9F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F, 0xF0, 0xFF,
  0x0F, 0xE0, 0x7F, 0x83, 0xFC, 0x3F, 0x81, 0xFC, 0x0F, 0xF1, 0xFE, 0x07,
  0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x03, 0xFC,
  0x7F, 0x03, 0xFC, 0x0F, 0xF1, 0xFC, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x3F,
  0xC0, 0xFE, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0xFF, 0x03, 0xF8, 0x1F, 0xE3,
  0xFC, 0x0F, 0xE0, 0x7F, 0x8F, 0xE0, 0x7F, 0x81, 0xFE, 0x3F, 0x81, 0xFE,
  0x07, 0xF0, 0xFE, 0x07, 0xF8, 0x1F, 0xC7, 0xF8, 0x1F, 0xC0, 0x7F, 0x1F,
  0xE0, 0x7F, 0x03, 0xFC, 0x7F, 0x81, 0xFC, 0x0F, 0xF1, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC7, 0xF0, 0x3F, 0xC0, 0xFE, 0x1F, 0xC0, 0xFF, 0x03, 0xF8, 0xFF,
  0x03, 0xF8, 0x0F, 0xE3, 0xFC, 0x0F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0x81,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF9, 0xFE, 0x01, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x7F, 0x0F, 0xF0, 0x3F, 0x87, 0xF8, 0x1F,
  0xC3, 0xFC, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0x03,
  0xFC, 0x7F, 0x81, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x1F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE,
  0x07, 0xF8, 0xFF, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x3F,
  0xC0, 0xFF, 0x1F, 0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF8, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x1F, 0xE1, 0xFE, 0x3F, 0xC0, 0xFF, 0x3F, 0xC0, 0xFF, 0x3F, 0x80, 0x7F,
  0x7F, 0x80, 0x7F, 0x7F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x7F, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFE, 0xFF, 0x00, 0xFE, 0xFF, 0x01, 0xFE, 0x7F, 0x01, 0xFC,
  0x7F, 0x03, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x1F, 0xE0, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x01,
  0xFC, 0x1F, 0xE0, 0x3F, 0x83, 0xFC, 0x07, 0xF0, 0x7F, 0x80, 0xFE, 0x0F,
  0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F,
  0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xE0, 0xFE,
  0x01, 0xFC, 0x3F, 0xC0, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0xFF, 0x03, 0xFC,
  0x1F, 0xF0, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xBF, 0xF8, 0x0F, 0xE3, 0xFC, 0x01,
  0xFC, 0x0C, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xC0, 0xFF, 0xCF, 0xE0, 0xFF,
  0xF7, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F,
  0xC3, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F, 0xC0, 0x7F, 0x9F, 0xE0, 0x3F, 0xCF,
  0xF0, 0x1F, 0xE7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8,
  0xFE, 0x03, 0xFC, 0xFF, 0x01, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x7F,
  0x1F, 0xE0, 0x3F, 0x8F, 0xF0, 0x1F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F,
  0xF1, 0xFE, 0x07, 0xF8, 0x7F, 0x87, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F,
  0xDF, 0xC0, 0x02, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xF9, 0xFE,
  0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0xFF, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0xFE, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x8F, 0xF8, 0x7F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x00, 0x60, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x03, 0x00, 0x0F, 0xE0, 0x3F, 0x87, 0xF0,
  0x1F, 0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF1, 0xFE, 0x07, 0xF8, 0xFE,
  0x03, 0xFC, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0xC0, 0xFF, 0x1F,
  0xE0, 0x7F, 0x8F, 0xF0, 0x3F, 0xC7, 0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x07, 0xF1, 0xFE, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x81, 0xFE,
  0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x3F,
  0xC3, 0xF8, 0x1F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xBF, 0x80, 0x04, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xFE,
  0x07, 0xFB, 0xFC, 0x0F, 0xF7, 0xF8, 0x1F, 0xCF, 0xF0, 0x7F, 0x9F, 0xE0,
  0xFF, 0x1F, 0xC1, 0xFC, 0x3F, 0x87, 0xF8, 0x7F, 0x0F, 0xE0, 0xFE, 0x3F,
  0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xF3, 0xFC, 0x0F, 0xE7, 0xF0,
  0x1F, 0xCF, 0xE0, 0x3F, 0xBF, 0x80, 0x3F, 0x7F, 0x00, 0x7E, 0xFE, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x07, 0xE0, 0x7F, 0xFF, 0x03, 0xF0, 0x3F, 0xBF, 0x81, 0xF8, 0x1F, 0xDF,
  0xC1, 0xFC, 0x1F, 0xEF, 0xE0, 0xFE, 0x0F, 0xE7, 0xF0, 0xFF, 0x07, 0xF3,
  0xF8, 0x7F, 0x87, 0xF1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7E, 0x3F, 0xF1, 0xFC,
  0x3F, 0x1F, 0xF9, 0xFC, 0x1F, 0x9F, 0xFC, 0xFE, 0x0F, 0xCF, 0xFE, 0x7F,
  0x07, 0xE7, 0xFF, 0x7F, 0x03, 0xF7, 0xFF, 0xBF, 0x81, 0xFB, 0xF7, 0xDF,
  0x80, 0xFF, 0xF3, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF,
  0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x0F, 0xFE, 0x3F, 0xF8, 0x07, 0xFE, 0x1F,
  0xF8, 0x03, 0xFF, 0x0F, 0xFC, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83,
  0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0x81, 0xFE, 0x03, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x01, 0xFC, 0x7F, 0x80, 0x1F, 0xC7, 0xF8,
  0x01, 0xFC, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xBF, 0x80, 0x07, 0xF3, 0xF8, 0x00,
  0xFF, 0x3F, 0x80, 0x1F, 0xE3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC1,
  0xFC, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x07, 0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xF8,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x01, 0xFC, 0x3F, 0xC0,
  0x3F, 0x87, 0xF8, 0x07, 0xF1, 0xFE, 0x00, 0xFE, 0x3F, 0xC0, 0x1F, 0xC7,
  0xF0, 0x03, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xEF, 0xF0, 0x01,
  0xFD, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x02, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0x00,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0xC0,
  0x7F, 0xC0, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x38, 0x00, 0x04, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x03,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0x00, 0x02, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xFE, 0x01, 0xF1, 0xFF, 0xC0, 0x7C, 0xFF, 0xF8, 0x3F, 0x3F,
  0xFF, 0x0F, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xF8, 0x7F, 0xFC,
  0xFC, 0x0F, 0xFF, 0x3F, 0x03, 0xFF, 0x8F, 0xC0, 0x3F, 0xC0, 0x00, 0x07,
  0xC0,
};

const GFXglyph RobotoCondensed_BoldItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 41, 14, 1, -40 },
  { 73, 17, 15, 17, 3, -42 },
  { 105, 28, 40, 29, 1, -40 },
  { 245, 25, 53, 27, 2, -47 },
  { 411, 26, 42, 35, 5, -41 },
  { 548, 28, 42, 31, 1, -41 },
  { 695, 8, 15, 9, 3, -42 },
  { 710, 17, 56, 18, 3, -44 },
  { 829, 17, 57, 18, -2, -44 },
  { 951, 23, 24, 25, 3, -40 },
  { 1020, 24, 29, 26, 1, -33 },
  { 1107, 12, 17, 13, -3, -7 },
  { 1133, 14, 6, 20, 3, -20 },
  { 1144, 9, 9, 16, 1, -8 },
  { 1155, 25, 43, 18, -4, -40 },
  { 1290, 24, 42, 27, 2, -41 },
  { 1416, 17, 40, 27, 6, -40 },
  { 1501, 27, 41, 27, 0, -41 },
  { 1640, 26, 42, 27, 1, -41 },
  { 1777, 25, 40, 27, 1, -40 },
  { 1902, 26, 41, 27, 2, -40 },
  { 2036, 23, 41, 27, 2, -40 },
  { 2154, 27, 40, 27, 2, -40 },
  { 2289, 26, 42, 27, 1, -41 },
  { 2426, 22, 41, 27, 4, -41 },
  { 2539, 13, 31, 15, 1, -30 },
  { 2590, 16, 40, 14, -3, -30 },
  { 2670, 22, 26, 24, 1, -30 },
  { 2742, 24, 17, 27, 2, -26 },
  { 2793, 22, 26, 25, 1, -30 },
  { 2865, 21, 42, 24, 4, -41 },
  { 2976, 39, 51, 42, 1, -39 },
  { 3225, 31, 40, 32, -2, -40 },
  { 3380, 30, 40, 30, 0, -40 },
  { 3530, 29, 42, 31, 2, -41 },
  { 3683, 30, 40, 31, 0, -40 },
  { 3833, 29, 40, 27, 0, -40 },
  { 3978, 29, 40, 26, 0, -40 },
  { 4123, 29, 42, 32, 2, -41 },
  { 4276, 34, 40, 33, 0, -40 },
  { 4446, 14, 40, 15, 1, -40 },
  { 4516, 28, 41, 27, 0, -40 },
  { 4660, 34, 40, 30, 0, -40 },
  { 4830, 23, 40, 26, 0, -40 },
  { 4945, 42, 40, 41, 0, -40 },
  { 5155, 34, 40, 33, 0, -40 },
  { 5325, 30, 42, 33, 2, -41 },
  { 5483, 31, 40, 31, 0, -40 },
  { 5638, 30, 48, 33, 2, -41 },
  { 5818, 30, 40, 30, 0, -40 },
  { 5968, 29, 42, 29, 1, -41 },
  { 6121, 28, 40, 30, 4, -40 },
  { 6261, 30, 41, 31, 2, -40 },
  { 6415, 31, 40, 31, 4, -40 },
  { 6570, 38, 40, 41, 5, -40 },
  { 6760, 35, 40, 30, -2, -40 },
  { 6935, 28, 40, 30, 5, -40 },
  { 7075, 32, 40, 29, -1, -40 },
  { 7235, 19, 55, 14, -1, -46 },
  { 7366, 14, 43, 21, 4, -40 },
  { 7442, 19, 55, 14, -3, -46 },
  { 7573, 19, 20, 21, 2, -40 },
  { 7621, 21, 6, 22, -3, 0 },
  { 7637, 12, 8, 18, 6, -42 },
  { 7649, 24, 32, 26, 0, -31 },
  { 7745, 25, 43, 27, 0, -42 },
  { 7880, 23, 32, 25, 1, -31 },
  { 7972, 28, 43, 27, 1, -42 },
  { 8123, 24, 32, 26, 1, -31 },
  { 8219, 19, 43, 18, 2, -43 },
  { 8322, 27, 42, 27, 0, -31 },
  { 8464, 25, 42, 27, 0, -42 },
  { 8596, 15, 42, 14, 0, -42 },
  { 8675, 20, 53, 13, -6, -42 },
  { 8808, 28, 42, 26, 0, -42 },
  { 8955, 15, 42, 14, 0, -42 },
  { 9034, 38, 31, 40, 0, -31 },
  { 9182, 25, 31, 27, 0, -31 },
  { 9279, 24, 32, 27, 1, -31 },
  { 9375, 27, 42, 27, -2, -31 },
  { 9517, 25, 42, 27, 1, -31 },
  { 9649, 19, 31, 18, 0, -31 },
  { 9723, 24, 32, 25, 0, -31 },
  { 9819, 16, 38, 17, 2, -37 },
  { 9895, 25, 31, 27, 1, -30 },
  { 9992, 23, 30, 24, 3, -30 },
  { 10079, 33, 30, 34, 3, -30 },
  { 10203, 28, 30, 25, -2, -30 },
  { 10308, 27, 41, 24, -1, -30 },
  { 10447, 26, 30, 25, -1, -30 },
  { 10545, 17, 54, 16, 1, -44 },
  { 10660, 12, 47, 14, 1, -40 },
  { 10731, 17, 54, 16, -2, -44 },
  { 10846, 26, 12, 30, 2, -22 },
};

const GFXfont RobotoCondensed_BoldItalic56pt7b PROGMEM = {
  (uint8_t  *)RobotoCondensed_BoldItalic56pt7bBitmaps,
  (GFXglyph *)RobotoCondensed_BoldItalic56pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOCONDENSED_BOLDITALIC56PT7B_H_
