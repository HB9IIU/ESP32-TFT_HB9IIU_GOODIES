#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC61PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x00, 0x1C, 0x1E, 0x38, 0x3C, 0xF0, 0x71, 0xE0, 0xE3, 0x81, 0xC7, 0x07,
  0x8E, 0x0E, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xC0, 0xC3, 0x83, 0x86,
  0x07, 0x0C, 0x0E, 0x38, 0x18, 0x70, 0x30, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x60, 0x18, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00,
  0x0E, 0x03, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0,
  0x60, 0x00, 0x18, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x60,
  0x18, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x18,
  0x06, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xC0, 0x70,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x18, 0x06, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x00, 0xC0, 0x00, 0x70, 0x1C,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF1, 0x87, 0x01, 0xE0, 0xC0,
  0x80, 0xE0, 0xE0, 0x00, 0xF0, 0x60, 0x00, 0x70, 0x30, 0x00, 0x38, 0x18,
  0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x06, 0x00, 0x03, 0x83,
  0x00, 0x01, 0xE1, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x1E, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x06, 0xF0, 0x00, 0x03, 0x3C, 0x00, 0x01, 0x8F, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xC1, 0xC0, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x78,
  0x00, 0x38, 0x38, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x07,
  0x00, 0x03, 0x07, 0x02, 0x03, 0x87, 0x81, 0xC1, 0x8F, 0x80, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1C, 0x03, 0xF8,
  0x00, 0x38, 0x07, 0xBC, 0x00, 0x38, 0x0E, 0x1C, 0x00, 0x70, 0x1C, 0x0E,
  0x00, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x07, 0x00, 0x60, 0x0C, 0x0E, 0x00, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0x1C,
  0x1C, 0x00, 0xE0, 0x1C, 0x1C, 0x00, 0xE0, 0x1C, 0x38, 0x00, 0xE0, 0x18,
  0x38, 0x00, 0xC0, 0x38, 0x70, 0x30, 0xC0, 0x38, 0xE1, 0xFC, 0xC0, 0x30,
  0xE3, 0xFE, 0xC0, 0x71, 0xC7, 0x8E, 0xC0, 0x71, 0xC7, 0x07, 0xE0, 0xE3,
  0x8E, 0x07, 0xE1, 0xC7, 0x0E, 0x07, 0xFF, 0xC7, 0x1C, 0x07, 0x7F, 0x8E,
  0x1C, 0x07, 0x3E, 0x0E, 0x38, 0x07, 0x00, 0x1C, 0x38, 0x07, 0x00, 0x1C,
  0x38, 0x07, 0x00, 0x38, 0x30, 0x06, 0x00, 0x70, 0x70, 0x0E, 0x00, 0x70,
  0x70, 0x0E, 0x00, 0xE0, 0x70, 0x0E, 0x00, 0xE0, 0x70, 0x0E, 0x01, 0xC0,
  0x70, 0x1C, 0x01, 0xC0, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00,
  0x60, 0x38, 0x07, 0x00, 0x60, 0x38, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x00,
  0x70, 0x70, 0x1C, 0x00, 0x78, 0xE0, 0x1C, 0x00, 0x3F, 0xC0, 0x38, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x70, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E,
  0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0x87, 0x80,
  0x00, 0x79, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1E, 0x70, 0x00, 0x07, 0x8F, 0x00, 0xE1, 0xE0, 0xE0, 0x3C, 0x78, 0x1E,
  0x07, 0x0E, 0x01, 0xC0, 0xE3, 0xC0, 0x3C, 0x3C, 0x70, 0x07, 0x87, 0x1E,
  0x00, 0x71, 0xE3, 0x80, 0x0F, 0x38, 0x70, 0x00, 0xEF, 0x0E, 0x00, 0x1F,
  0xC3, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x81, 0xE0,
  0x01, 0xF0, 0x1C, 0x00, 0x7F, 0x03, 0xC0, 0x1E, 0xE0, 0x78, 0x07, 0x9E,
  0x07, 0xC3, 0xE1, 0xC0, 0x7F, 0xF8, 0x3C, 0x07, 0xFC, 0x07, 0x80, 0x18,
  0x00, 0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0xE1, 0xC3,
  0x86, 0x0C, 0x18, 0x70, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x08, 0x07, 0x01, 0xC0, 0xC0, 0x3E, 0x18, 0x03, 0xE3,
  0x00, 0x1F, 0x63, 0xE0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0xF0, 0x00, 0x7F,
  0x00, 0x1E, 0x60, 0x07, 0x8E, 0x01, 0xE1, 0xC0, 0x78, 0x1C, 0x0E, 0x03,
  0x80, 0x80, 0x38, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0xE0, 0x78,
  0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x0E, 0x03, 0x80, 0xC0, 0x70,
  0x38, 0x00, 0x7F, 0xFD, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xC1, 0xE0, 0x0F, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x70,
  0x03, 0x81, 0xE0, 0x07, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x78, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x80, 0x03,
  0x8E, 0x00, 0x07, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x3C, 0xE0, 0x00, 0x79,
  0xC0, 0x00, 0xF7, 0x80, 0x01, 0xCF, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38,
  0x00, 0x1E, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xE7, 0x80,
  0x03, 0xCF, 0x00, 0x07, 0x9C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x78, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80,
  0x78, 0x1E, 0x00, 0x7D, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x7F, 0x03, 0xF8,
  0x1E, 0xE1, 0xF3, 0x8F, 0x8E, 0xF8, 0x79, 0xC1, 0xC2, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x70, 0x07,
  0x80, 0x10, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3E, 0x03, 0xE0, 0x0C, 0x00, 0x78, 0x04,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x81, 0x00, 0x07, 0xC0,
  0xC0, 0x07, 0xC0, 0x7C, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xB8, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x77, 0x80, 0x00, 0x39,
  0xC0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x0E, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C,
  0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x1C,
  0x00, 0x70, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x01, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00,
  0x80, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x02, 0x00, 0x0F,
  0x80, 0xC0, 0x07, 0xC0, 0x3E, 0x1F, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xE0, 0x20, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x0F, 0xC0, 0x0F, 0x3F, 0xF0, 0x07, 0x3F, 0xFC, 0x03, 0xBC, 0x1F, 0x01,
  0xF8, 0x07, 0x81, 0xF8, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x78, 0x00, 0x38,
  0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0F, 0x00, 0x03,
  0x87, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x0E, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x3C,
  0x0F, 0x80, 0x1F, 0x1F, 0x80, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x01,
  0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x0F,
  0x01, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xCF, 0x80, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x70, 0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x0F,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x0E,
  0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0xE1,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xF8, 0x3C,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x0E, 0x03, 0x80, 0x0F, 0x07, 0x80, 0x0F,
  0x07, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x0F,
  0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1E,
  0x1E, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x6E, 0x0F, 0x01, 0xFC,
  0x07, 0xEF, 0xDC, 0x03, 0xFF, 0x9C, 0x01, 0xFE, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0xE1, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0x18, 0x00,
  0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x3F, 0xFF,
  0x07, 0x01, 0xE0, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00, 0x06, 0x07, 0x00, 0x04, 0x00,
  0x70, 0x70, 0x07, 0xFE, 0x07, 0x0E, 0x00, 0xFF, 0xE0, 0x70, 0xE0, 0x1E,
  0x0C, 0x07, 0x1C, 0x03, 0x81, 0xC0, 0x71, 0xC0, 0x70, 0x1C, 0x07, 0x18,
  0x07, 0x01, 0xC0, 0x73, 0x80, 0xE0, 0x18, 0x06, 0x38, 0x1C, 0x03, 0x80,
  0xE3, 0x01, 0xC0, 0x38, 0x0E, 0x70, 0x1C, 0x03, 0x80, 0xE7, 0x03, 0x80,
  0x30, 0x0E, 0x70, 0x38, 0x07, 0x00, 0xC7, 0x03, 0x80, 0x70, 0x1C, 0x60,
  0x30, 0x07, 0x01, 0xCE, 0x07, 0x00, 0xE0, 0x1C, 0xE0, 0x70, 0x0E, 0x03,
  0x8E, 0x07, 0x00, 0xE0, 0x38, 0xE0, 0x70, 0x1E, 0x07, 0x0E, 0x07, 0x01,
  0xE0, 0x70, 0xE0, 0x70, 0x36, 0x0E, 0x0E, 0x07, 0x87, 0x61, 0xE0, 0xE0,
  0x3C, 0xE7, 0x3C, 0x0E, 0x03, 0xFC, 0x7F, 0x80, 0xE0, 0x1F, 0x83, 0xE0,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x40, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x78, 0x0E,
  0x00, 0x1C, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xE0,
  0x0E, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0xE0, 0x3C, 0x00, 0x38,
  0x0E, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x70, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xC0,
  0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x78, 0x3F, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xC0, 0x07, 0xC0, 0x38, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0xE0, 0x3C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x1C,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x1E,
  0x03, 0x80, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0x80,
  0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0x78, 0x03, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00,
  0x38, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x07,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0x70, 0x07, 0xE0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x80,
  0x60, 0x07, 0xC0, 0x04, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x40, 0x03, 0xFD, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0x00,
  0xFC, 0x00, 0x70, 0x01, 0xF0, 0x03, 0x80, 0x07, 0x80, 0x1C, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0E, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x03,
  0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0E, 0x00,
  0x00, 0xE0, 0x70, 0x00, 0x07, 0x03, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x78, 0x0E, 0x00,
  0x07, 0x80, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x3C,
  0x01, 0xC0, 0x07, 0xC0, 0x0E, 0x00, 0x7C, 0x00, 0x70, 0x1F, 0xC0, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x1F,
  0x00, 0x7C, 0x00, 0x18, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xFE, 0x3C,
  0x00, 0x3F, 0xF8, 0xF0, 0x00, 0xFF, 0xC3, 0xC0, 0x00, 0x07, 0x0F, 0x00,
  0x00, 0x3C, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x0E, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0,
  0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xE0, 0x0F,
  0x80, 0x03, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xE0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80,
  0x00, 0x78, 0x03, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x70, 0x07, 0x80,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x0E, 0x00,
  0x01, 0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1E, 0x00,
  0x01, 0xC0, 0x1E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x03, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x20, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xE0,
  0x07, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xE0,
  0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x70, 0x1E,
  0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x38, 0x3E, 0x00,
  0x00, 0xE0, 0xF0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1D,
  0xF8, 0x00, 0x00, 0xFE, 0xE0, 0x00, 0x03, 0xF3, 0x80, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x70, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x38, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xDC, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0xEF, 0x00,
  0x00, 0x77, 0x00, 0x73, 0x80, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x00, 0x39,
  0xC0, 0x1C, 0xE0, 0x00, 0x39, 0xE0, 0x1E, 0x70, 0x00, 0x1C, 0xE0, 0x0E,
  0x38, 0x00, 0x1C, 0x70, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x03, 0x8E, 0x00,
  0x0E, 0x3C, 0x03, 0xC7, 0x00, 0x07, 0x1E, 0x01, 0xE3, 0x80, 0x07, 0x0E,
  0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x38,
  0x70, 0x01, 0xC3, 0xC0, 0x3C, 0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x0E, 0x00,
  0xE0, 0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x70, 0x38,
  0x03, 0x81, 0xC0, 0x70, 0x3C, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x01, 0xC0,
  0x70, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x1C,
  0x07, 0x80, 0x38, 0x0E, 0x0E, 0x03, 0xC0, 0x3C, 0x07, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0x87, 0x00, 0xE0, 0x0E, 0x01, 0xC7, 0x00, 0x70, 0x07, 0x00,
  0xE3, 0x80, 0x78, 0x07, 0x80, 0x3B, 0x80, 0x3C, 0x03, 0x80, 0x1D, 0xC0,
  0x1C, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00,
  0x70, 0x03, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xF0, 0x03, 0x80, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x1F, 0x80,
  0x00, 0xF0, 0x0F, 0xC0, 0x00, 0x70, 0x07, 0xE0, 0x00, 0x38, 0x03, 0xF0,
  0x00, 0x1C, 0x01, 0xFC, 0x00, 0x1E, 0x01, 0xEE, 0x00, 0x0F, 0x00, 0xE7,
  0x00, 0x07, 0x00, 0x73, 0x80, 0x03, 0x80, 0x39, 0xE0, 0x01, 0xC0, 0x1C,
  0x70, 0x01, 0xE0, 0x1E, 0x38, 0x00, 0xE0, 0x0E, 0x1C, 0x00, 0x70, 0x07,
  0x0F, 0x00, 0x38, 0x03, 0x83, 0x80, 0x1C, 0x03, 0xC1, 0xC0, 0x1E, 0x01,
  0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x78, 0x07, 0x00, 0x70, 0x1C, 0x03, 0x80,
  0x38, 0x0E, 0x03, 0xC0, 0x3C, 0x07, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0xE0,
  0x0E, 0x00, 0xE0, 0x70, 0x07, 0x00, 0x70, 0x38, 0x03, 0x80, 0x38, 0x3C,
  0x03, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0x07, 0x0E, 0x00, 0xE0, 0x03, 0x87,
  0x00, 0x70, 0x01, 0xC3, 0x80, 0x38, 0x00, 0xE3, 0xC0, 0x3C, 0x00, 0x79,
  0xC0, 0x1C, 0x00, 0x1C, 0xE0, 0x0E, 0x00, 0x0E, 0x70, 0x07, 0x00, 0x07,
  0x38, 0x07, 0x80, 0x03, 0xFC, 0x03, 0x80, 0x00, 0xFC, 0x01, 0xC0, 0x00,
  0x7E, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x78, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFC,
  0x0F, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x03,
  0xC0, 0x78, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0x3C, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x79, 0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0x79, 0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0x80, 0x1F, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xC3, 0xFC, 0x00, 0xF0, 0x0F, 0x80,
  0x38, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x01, 0xE0, 0x03,
  0xC0, 0x78, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0,
  0x01, 0xC0, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x03,
  0x80, 0x03, 0x80, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x1C, 0x00, 0x3C,
  0x07, 0x00, 0x1E, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0x1E,
  0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x70, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x38, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x01,
  0xE0, 0x01, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xFE,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xC3, 0xFC, 0x00,
  0xF0, 0x0F, 0x80, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x0F,
  0x01, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00,
  0x07, 0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x0E,
  0x00, 0x0E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x1C, 0x00, 0x78, 0x07, 0x00, 0x3E, 0x01, 0xC0, 0x3F, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0x78, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01,
  0xC0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0x78, 0x00, 0xE0, 0x1E, 0x00,
  0x38, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x3C,
  0x00, 0x1C, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x01, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x01, 0xE0, 0x0F,
  0x80, 0x04, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x04, 0x00, 0x0F, 0x80,
  0xE0, 0x03, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x70,
  0x1E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x38, 0x0E, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1C, 0x07, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFE, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x1C, 0x70, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03,
  0x81, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x07, 0x00,
  0x0E, 0x01, 0xC0, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x1C, 0x00, 0x70, 0x07,
  0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x01, 0xC0,
  0x07, 0x00, 0xF0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x1E, 0x07,
  0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0E,
  0x1E, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x38, 0xE0, 0x00,
  0x0E, 0x78, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xB8, 0x00,
  0x0F, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x80, 0x01, 0xCE, 0x00, 0x07, 0xC0,
  0x00, 0xE7, 0x00, 0x03, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0xF0, 0x00, 0x71,
  0xC0, 0x01, 0xF8, 0x00, 0x78, 0xE0, 0x01, 0xDC, 0x00, 0x38, 0x70, 0x00,
  0xEE, 0x00, 0x3C, 0x38, 0x00, 0xF7, 0x00, 0x1E, 0x1C, 0x00, 0x73, 0x80,
  0x0E, 0x0E, 0x00, 0x39, 0xC0, 0x0F, 0x07, 0x00, 0x38, 0xE0, 0x07, 0x03,
  0x80, 0x1C, 0x70, 0x07, 0x81, 0xC0, 0x1C, 0x38, 0x03, 0x80, 0xE0, 0x0E,
  0x1C, 0x01, 0xC0, 0x70, 0x07, 0x0E, 0x01, 0xE0, 0x38, 0x07, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x83, 0x80, 0xF0, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x01, 0xC0, 0xE0,
  0x38, 0x1C, 0x00, 0xE0, 0x70, 0x1C, 0x1E, 0x00, 0x70, 0x70, 0x0E, 0x0E,
  0x00, 0x38, 0x38, 0x07, 0x0F, 0x00, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x0E,
  0x1C, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0xE3, 0xC0, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x01, 0xC7, 0x00, 0x39, 0xE0, 0x00, 0xE7, 0x00, 0x1C, 0xE0,
  0x00, 0x73, 0x80, 0x0E, 0x70, 0x00, 0x39, 0xC0, 0x07, 0x78, 0x00, 0x1D,
  0xC0, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x03, 0x87, 0x00, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x78,
  0x78, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x80,
  0x1C, 0x00, 0x07, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D,
  0xC0, 0x00, 0xF3, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x1C,
  0x00, 0x3C, 0x3C, 0x00, 0x70, 0x38, 0x01, 0xE0, 0x70, 0x07, 0x80, 0xE0,
  0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x01, 0xE0, 0x0F, 0x03,
  0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x70, 0x00, 0x71, 0xE0,
  0x00, 0xE3, 0x80, 0x01, 0xCF, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xE0, 0x38,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3B, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0xF1,
  0xC0, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xF0, 0x03, 0x80,
  0x70, 0x03, 0x80, 0x70, 0x07, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF1, 0xE1, 0xC3, 0xC3, 0x87, 0x07, 0x06, 0x0E, 0x0C,
  0x00, 0x1F, 0x80, 0x80, 0x3F, 0xE1, 0x80, 0x3F, 0xF9, 0xC0, 0x3E, 0x0E,
  0xE0, 0x3C, 0x03, 0x70, 0x3C, 0x01, 0xB8, 0x3C, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x87, 0x80,
  0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x03, 0xC1,
  0xC0, 0x01, 0xE0, 0xE0, 0x01, 0xF0, 0x70, 0x00, 0xF0, 0x3C, 0x00, 0xF8,
  0x1E, 0x00, 0xFC, 0x07, 0x00, 0x6E, 0x03, 0xC0, 0xE6, 0x00, 0xF9, 0xE7,
  0x00, 0x7F, 0xE3, 0x80, 0x1F, 0xE1, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC1, 0xF0, 0x03, 0xC7, 0xFC, 0x03, 0x9F, 0xFE, 0x03,
  0xBC, 0x1E, 0x03, 0xB0, 0x0F, 0x07, 0xE0, 0x0F, 0x07, 0xE0, 0x07, 0x07,
  0xC0, 0x07, 0x07, 0x80, 0x07, 0x07, 0x80, 0x07, 0x0F, 0x00, 0x07, 0x0F,
  0x00, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x1E,
  0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x3C, 0x78, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0x7C,
  0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xEE, 0x03, 0xC0, 0xE7, 0x8F, 0x80, 0xE7,
  0xFF, 0x00, 0xC1, 0xFE, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0x02, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x20, 0x3E,
  0x1E, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x01, 0xF8, 0x78, 0x00, 0x7F,
  0xC7, 0x80, 0x0F, 0xFE, 0x70, 0x01, 0xF0, 0x77, 0x00, 0x3C, 0x03, 0x70,
  0x07, 0x80, 0x3F, 0x00, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x01, 0xE0,
  0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1C,
  0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x80, 0x03, 0xC0, 0x70,
  0x00, 0x3C, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x0F, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x0E,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x1F, 0x00, 0xE0, 0x01,
  0xE0, 0x0F, 0x00, 0x3E, 0x00, 0xF0, 0x07, 0xE0, 0x07, 0x00, 0xEE, 0x00,
  0x78, 0x1C, 0xE0, 0x07, 0xE7, 0x8C, 0x00, 0x3F, 0xF1, 0xC0, 0x01, 0xFE,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00,
  0x3F, 0xFC, 0x03, 0xC1, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x1C, 0x3C, 0x00,
  0xE1, 0xC0, 0x07, 0x1E, 0x00, 0x78, 0xE0, 0x03, 0x8F, 0x00, 0x1C, 0x70,
  0x01, 0xE3, 0x80, 0x1E, 0x3C, 0x03, 0xE1, 0xC0, 0x7E, 0x0F, 0xFF, 0xE0,
  0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x80, 0xFC, 0x3C, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xC6, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x08, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFE, 0x1C,
  0x00, 0xFF, 0xE3, 0x00, 0x3E, 0x0E, 0xE0, 0x0F, 0x00, 0xDC, 0x03, 0xC0,
  0x1B, 0x80, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80,
  0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00,
  0x70, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x1C,
  0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F,
  0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x01, 0xC0,
  0x01, 0xE0, 0x38, 0x00, 0x7C, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0xE0,
  0x1E, 0x00, 0xFC, 0x01, 0xC0, 0x3B, 0x80, 0x3C, 0x0E, 0xF0, 0x07, 0xE7,
  0xDC, 0x00, 0x7F, 0xF3, 0x80, 0x07, 0xF8, 0x70, 0x00, 0x18, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x40, 0x07, 0x80, 0x0F, 0x87, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x7E, 0x00, 0xF3, 0xFF, 0x01, 0xCF, 0xFF, 0x03, 0xBC, 0x1E,
  0x07, 0xE0, 0x1C, 0x1F, 0x80, 0x38, 0x3E, 0x00, 0x70, 0x7C, 0x00, 0xE0,
  0xF0, 0x01, 0xC1, 0xE0, 0x03, 0x87, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1C,
  0x00, 0x3C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0x80,
  0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78, 0x00,
  0x70, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x0F, 0x00, 0x0E,
  0x1E, 0x00, 0x1C, 0x38, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC3,
  0xC0, 0x03, 0x87, 0x80, 0x07, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x11, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x01, 0x03,
  0xC0, 0x1E, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x80, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x07,
  0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x0E,
  0x78, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1D, 0xFC, 0x00, 0x1F,
  0xBC, 0x00, 0x1F, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x38,
  0x1E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0xF0,
  0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x1C, 0x7F, 0xC1, 0xFF, 0x00,
  0xE7, 0xFF, 0x1F, 0xFC, 0x07, 0x70, 0x79, 0xE1, 0xF0, 0x3F, 0x01, 0xDC,
  0x07, 0x83, 0xB0, 0x0F, 0xC0, 0x1C, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0xF0,
  0x03, 0xE0, 0x07, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x01,
  0xC3, 0xC0, 0x07, 0x00, 0x1E, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0xE0, 0x01,
  0xC0, 0x07, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x01, 0xC3,
  0xC0, 0x07, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0xC0,
  0x07, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0xC0, 0x07,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x78, 0x00, 0xE0, 0x03, 0xC3, 0xC0, 0x07,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0xC0, 0x07, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x78, 0x00, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x00,
  0x1C, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x00,
  0x03, 0xF0, 0x07, 0x1F, 0xF8, 0x0E, 0x7F, 0xF8, 0x1D, 0xE0, 0xF0, 0x3F,
  0x00, 0xE0, 0xEC, 0x01, 0xC1, 0xF0, 0x03, 0x83, 0xE0, 0x07, 0x07, 0x80,
  0x0E, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0xE0, 0x01,
  0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x3C,
  0x38, 0x00, 0x78, 0x70, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87,
  0x00, 0x0F, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xF0,
  0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1E, 0x00,
  0x1C, 0x3C, 0x00, 0x78, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0xF0, 0x07, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x1C,
  0x38, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xEF,
  0x00, 0x03, 0x9E, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0,
  0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xCF, 0x00, 0x03, 0x9C, 0x00,
  0x0F, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x38, 0xF0, 0x00, 0xF1, 0xE0, 0x01,
  0xC3, 0xC0, 0x07, 0x83, 0x80, 0x1E, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xF0,
  0x0F, 0xCF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x0E, 0x1F, 0xF0, 0x01, 0xCF, 0xFF, 0x00, 0x39,
  0xC1, 0xE0, 0x07, 0x70, 0x1E, 0x00, 0xDC, 0x03, 0xC0, 0x3F, 0x00, 0x38,
  0x07, 0xC0, 0x07, 0x00, 0xF8, 0x00, 0xE0, 0x1E, 0x00, 0x1C, 0x07, 0xC0,
  0x03, 0x80, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0,
  0x70, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00,
  0x3C, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x07,
  0x01, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x38, 0x07, 0xC0, 0x0F, 0x00, 0xF8,
  0x03, 0xC0, 0x3F, 0x80, 0xF0, 0x07, 0x3C, 0x7C, 0x00, 0xE3, 0xFF, 0x00,
  0x1C, 0x3F, 0xC0, 0x03, 0x81, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xE1, 0xC0, 0x3F, 0xF8,
  0xC0, 0x3E, 0x0E, 0xE0, 0x3C, 0x03, 0x70, 0x3C, 0x01, 0xB8, 0x3C, 0x00,
  0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x00,
  0x07, 0x87, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x3C,
  0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x00, 0x03, 0x83,
  0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x01, 0xF0, 0x70, 0x00, 0xF0,
  0x3C, 0x00, 0xF8, 0x1E, 0x00, 0xFC, 0x07, 0x00, 0xEE, 0x03, 0xC0, 0xEF,
  0x01, 0xF8, 0xF7, 0x00, 0x7F, 0xE3, 0x80, 0x1F, 0xE1, 0xC0, 0x01, 0x80,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x71, 0xFC, 0x0E,
  0x7F, 0x81, 0xDE, 0x10, 0x3F, 0x00, 0x0E, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0x80, 0xE0,
  0x70, 0x01, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x40, 0x0F, 0x03, 0xC1, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x3F, 0xFD, 0xFF,
  0xF0, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC6, 0x07, 0xF8, 0x1F, 0xE0, 0x0C, 0x00, 0x07, 0x80, 0x0F, 0x07, 0x00,
  0x0E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00,
  0x1E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1E, 0x00,
  0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x3C, 0x00,
  0x38, 0x38, 0x00, 0x78, 0x38, 0x00, 0x78, 0x38, 0x00, 0x70, 0x38, 0x00,
  0x70, 0x78, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xE0, 0x03, 0xE0, 0xE0, 0x03,
  0xC0, 0xE0, 0x07, 0xC0, 0xF0, 0x0F, 0xC0, 0xF0, 0x1D, 0xC0, 0x7C, 0xF9,
  0xC0, 0x7F, 0xF1, 0x80, 0x3F, 0xE3, 0x80, 0x06, 0x00, 0x00, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xBC, 0x00, 0x3C, 0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x38,
  0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x07, 0x83, 0x80, 0x38,
  0x1C, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x83, 0xC0, 0x1C, 0x1C, 0x00,
  0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00, 0x06, 0x78,
  0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0xF0, 0x01, 0xE0, 0x07, 0xB8, 0x01, 0xF0, 0x03, 0x9C, 0x00,
  0xF8, 0x01, 0xCE, 0x00, 0xFC, 0x01, 0xE7, 0x00, 0x7E, 0x00, 0xE3, 0x80,
  0x37, 0x00, 0xF1, 0xC0, 0x3B, 0x80, 0x70, 0xE0, 0x1D, 0xC0, 0x38, 0x70,
  0x1C, 0xE0, 0x38, 0x38, 0x0E, 0x70, 0x1C, 0x1C, 0x0E, 0x38, 0x1E, 0x0E,
  0x07, 0x1C, 0x0E, 0x07, 0x07, 0x0E, 0x07, 0x03, 0x83, 0x87, 0x07, 0x01,
  0xC1, 0xC3, 0x83, 0x80, 0xE1, 0xC1, 0xC3, 0xC0, 0x70, 0xE0, 0xE1, 0xC0,
  0x38, 0xE0, 0x70, 0xE0, 0x1C, 0x70, 0x38, 0xE0, 0x0E, 0x70, 0x1C, 0x70,
  0x07, 0x38, 0x0E, 0x70, 0x03, 0x9C, 0x07, 0x38, 0x01, 0xDC, 0x03, 0x9C,
  0x00, 0xEE, 0x01, 0xDC, 0x00, 0x7E, 0x00, 0xEE, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0, 0x0F,
  0x80, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x01, 0xE0, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x38, 0x03, 0x80,
  0x07, 0x00, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x38, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x73, 0x80, 0x00,
  0x0E, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x38, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x78, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0x3C, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x1E, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x70, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x1C, 0x1E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x03, 0x8E, 0x00, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00,
  0x1B, 0x80, 0x00, 0x00, 0x37, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x04, 0x7C, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x10, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x30, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xF0, 0xFF, 0x1F,
  0xC0, 0x1F, 0xFE, 0x80, 0x07, 0xF8, 0x80, 0x01, 0xE0,
};

const GFXglyph NotoSans_Condensed_LightItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 44, 14, 1, -44 },
  { 73, 15, 16, 19, 6, -44 },
  { 103, 28, 44, 28, 1, -44 },
  { 257, 25, 50, 26, 1, -46 },
  { 414, 32, 45, 38, 4, -44 },
  { 594, 27, 45, 28, 0, -44 },
  { 746, 7, 16, 11, 6, -44 },
  { 760, 17, 54, 16, 2, -44 },
  { 875, 17, 54, 16, -4, -44 },
  { 990, 19, 21, 24, 7, -46 },
  { 1040, 23, 29, 28, 3, -36 },
  { 1124, 10, 14, 12, -3, -6 },
  { 1142, 14, 3, 17, 1, -18 },
  { 1148, 5, 5, 12, 1, -5 },
  { 1152, 27, 44, 19, -3, -44 },
  { 1301, 23, 45, 26, 2, -44 },
  { 1431, 14, 44, 26, 7, -44 },
  { 1508, 26, 44, 26, -1, -44 },
  { 1651, 25, 45, 26, 0, -44 },
  { 1792, 26, 44, 26, -1, -44 },
  { 1935, 26, 45, 26, 0, -44 },
  { 2082, 25, 45, 26, 2, -44 },
  { 2223, 25, 44, 26, 3, -44 },
  { 2361, 26, 45, 26, 0, -44 },
  { 2508, 24, 45, 26, 1, -44 },
  { 2643, 10, 33, 12, 1, -33 },
  { 2685, 14, 41, 12, -3, -33 },
  { 2757, 23, 27, 28, 3, -35 },
  { 2835, 23, 15, 28, 3, -29 },
  { 2879, 23, 27, 28, 3, -35 },
  { 2957, 19, 44, 19, 2, -44 },
  { 3062, 36, 49, 39, 2, -44 },
  { 3283, 26, 44, 26, -4, -44 },
  { 3426, 27, 44, 28, 1, -44 },
  { 3575, 27, 45, 26, 3, -44 },
  { 3727, 29, 44, 31, 1, -44 },
  { 3887, 26, 44, 25, 1, -44 },
  { 4030, 26, 44, 23, 1, -44 },
  { 4173, 30, 45, 33, 3, -44 },
  { 4342, 32, 44, 32, 1, -44 },
  { 4518, 20, 44, 15, -2, -44 },
  { 4628, 22, 55, 12, -9, -44 },
  { 4780, 30, 44, 26, 1, -44 },
  { 4945, 17, 44, 23, 1, -44 },
  { 5039, 41, 44, 41, 1, -44 },
  { 5265, 33, 44, 33, 1, -44 },
  { 5447, 29, 45, 33, 3, -44 },
  { 5611, 26, 44, 26, 1, -44 },
  { 5754, 29, 54, 33, 3, -44 },
  { 5950, 26, 44, 27, 1, -44 },
  { 6093, 27, 45, 24, -1, -44 },
  { 6245, 23, 44, 23, 5, -44 },
  { 6372, 30, 45, 32, 3, -44 },
  { 6541, 26, 44, 26, 5, -44 },
  { 6684, 41, 44, 42, 6, -44 },
  { 6910, 32, 44, 24, -4, -44 },
  { 7086, 23, 44, 23, 5, -44 },
  { 7213, 29, 44, 23, -2, -44 },
  { 7373, 22, 54, 17, -1, -44 },
  { 7522, 10, 44, 20, 6, -44 },
  { 7577, 22, 54, 17, -4, -44 },
  { 7726, 24, 24, 27, 2, -44 },
  { 7798, 19, 2, 19, -5, 6 },
  { 7803, 7, 10, 14, 9, -47 },
  { 7812, 25, 34, 27, 2, -33 },
  { 7919, 24, 47, 27, 1, -46 },
  { 8060, 20, 34, 21, 2, -33 },
  { 8145, 28, 47, 28, 2, -46 },
  { 8310, 21, 34, 24, 2, -33 },
  { 8400, 30, 62, 14, -8, -47 },
  { 8633, 27, 48, 28, 0, -33 },
  { 8795, 23, 46, 27, 1, -46 },
  { 8928, 12, 44, 12, 1, -44 },
  { 8994, 21, 59, 12, -8, -44 },
  { 9149, 24, 46, 23, 1, -46 },
  { 9287, 13, 46, 11, 1, -46 },
  { 9362, 37, 33, 40, 1, -33 },
  { 9515, 23, 33, 27, 1, -33 },
  { 9610, 23, 34, 27, 2, -33 },
  { 9708, 27, 47, 27, -2, -33 },
  { 9867, 25, 47, 28, 2, -33 },
  { 10014, 19, 33, 18, 1, -33 },
  { 10093, 21, 34, 20, 0, -33 },
  { 10183, 14, 41, 15, 2, -40 },
  { 10255, 24, 33, 27, 2, -32 },
  { 10354, 21, 32, 21, 3, -32 },
  { 10438, 33, 32, 34, 4, -32 },
  { 10570, 27, 32, 22, -3, -32 },
  { 10678, 31, 47, 22, -6, -32 },
  { 10861, 22, 32, 19, -2, -32 },
  { 10949, 21, 54, 20, 2, -44 },
  { 11091, 3, 61, 25, 11, -46 },
  { 11114, 21, 54, 20, -3, -44 },
  { 11256, 24, 7, 28, 3, -25 },
};

const GFXfont NotoSans_Condensed_LightItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC61PT7B_H_
