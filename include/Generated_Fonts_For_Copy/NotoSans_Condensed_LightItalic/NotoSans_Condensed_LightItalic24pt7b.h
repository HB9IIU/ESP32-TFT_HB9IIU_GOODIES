#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC24PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x20, 0x86, 0x18, 0x41, 0x04, 0x30, 0x82, 0x08, 0x20, 0x00,
  0x10, 0xC0, 0x65, 0x94, 0xD2, 0x4B, 0x20, 0x02, 0x20, 0x64, 0x04, 0x40,
  0x44, 0x04, 0xC3, 0xFF, 0x08, 0x80, 0x88, 0x11, 0x01, 0x10, 0x11, 0x0F,
  0xFC, 0x22, 0x02, 0x20, 0x26, 0x04, 0x40, 0x44, 0x00, 0x01, 0x00, 0x40,
  0xFC, 0x69, 0x32, 0x0C, 0x83, 0x40, 0x50, 0x1C, 0x01, 0x80, 0x70, 0x24,
  0x09, 0x02, 0x40, 0x93, 0x38, 0x7C, 0x04, 0x01, 0x00, 0x1C, 0x11, 0x21,
  0x19, 0x08, 0x88, 0x84, 0x4C, 0x22, 0x43, 0x14, 0x11, 0x2F, 0xCA, 0xCB,
  0x94, 0x41, 0x22, 0x1B, 0x10, 0x90, 0x88, 0x88, 0x44, 0x44, 0x26, 0x60,
  0xE0, 0x07, 0x81, 0x10, 0x22, 0x0C, 0x41, 0x98, 0x32, 0x02, 0x80, 0x60,
  0x1C, 0x04, 0x8D, 0x99, 0x21, 0x6C, 0x39, 0x03, 0x30, 0xC6, 0x3C, 0x7C,
  0xC0, 0x6D, 0x25, 0x80, 0x06, 0x10, 0x60, 0x82, 0x04, 0x10, 0x20, 0xC1,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x02, 0x04, 0x00, 0x04,
  0x0C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x30, 0x40, 0x83,
  0x04, 0x18, 0x20, 0x83, 0x0C, 0x00, 0x18, 0x23, 0x43, 0xF3, 0x0D, 0x32,
  0x06, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x00, 0x32, 0x24, 0x48, 0xF8, 0x70, 0x00, 0x40, 0x30, 0x08, 0x04,
  0x01, 0x00, 0x80, 0x20, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08,
  0x06, 0x01, 0x00, 0x80, 0x00, 0x0F, 0x08, 0xCC, 0x24, 0x16, 0x0A, 0x05,
  0x07, 0x83, 0xC1, 0x40, 0xA0, 0x50, 0x68, 0x24, 0x12, 0x11, 0x98, 0x78,
  0x00, 0x19, 0xDB, 0x31, 0x08, 0x46, 0x31, 0x08, 0x46, 0x31, 0x08, 0xC0,
  0x07, 0xC1, 0x0C, 0x01, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x04, 0x01,
  0x80, 0x60, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xFF, 0x80,
  0x1F, 0x84, 0x30, 0x04, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x1C, 0x1E, 0x00,
  0xC0, 0x10, 0x04, 0x01, 0x00, 0x40, 0x32, 0x18, 0xFC, 0x00, 0x00, 0xC0,
  0x70, 0x38, 0x0A, 0x04, 0x83, 0x60, 0x98, 0x44, 0x31, 0x08, 0x44, 0x33,
  0x0C, 0xFF, 0x80, 0x80, 0x20, 0x18, 0x04, 0x00, 0x0F, 0xC2, 0x01, 0x80,
  0x40, 0x10, 0x0C, 0x02, 0x00, 0xFC, 0x01, 0x00, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x40, 0x32, 0x18, 0xFC, 0x00, 0x07, 0x84, 0x04, 0x04, 0x02, 0x02,
  0x01, 0x30, 0xFC, 0xE3, 0x60, 0xA0, 0x50, 0x28, 0x34, 0x1A, 0x09, 0x88,
  0x78, 0x00, 0x7F, 0xC0, 0x20, 0x08, 0x04, 0x01, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x02, 0x00, 0x80, 0x40, 0x10, 0x08, 0x02, 0x01, 0x00, 0xC0, 0x00,
  0x0F, 0x86, 0x31, 0x04, 0x41, 0x10, 0x44, 0x31, 0x98, 0x38, 0x1E, 0x0C,
  0xC6, 0x13, 0x06, 0xC1, 0xA0, 0x6C, 0x11, 0x0C, 0x3E, 0x00, 0x0F, 0x86,
  0x21, 0x0C, 0x81, 0x20, 0x48, 0x32, 0x0C, 0x83, 0x21, 0x8F, 0xA0, 0x88,
  0x04, 0x01, 0x00, 0xC0, 0x20, 0x30, 0xF8, 0x00, 0x13, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0xC0, 0x08, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x46, 0x21,
  0x10, 0x00, 0x80, 0xC1, 0x83, 0x06, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xC0, 0x20, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x04, 0x0C, 0x18, 0x30, 0x60, 0x20, 0x00, 0x7E,
  0x84, 0x08, 0x10, 0x20, 0x83, 0x0C, 0x30, 0x41, 0x02, 0x04, 0x00, 0x00,
  0x60, 0xC0, 0x03, 0xF0, 0x30, 0x61, 0x80, 0x84, 0x03, 0x20, 0x05, 0x8F,
  0x14, 0x44, 0x53, 0x11, 0x88, 0xCE, 0x22, 0x29, 0x88, 0xA6, 0x66, 0x99,
  0x92, 0x3B, 0x88, 0x00, 0x20, 0x00, 0x40, 0x01, 0x82, 0x03, 0xF0, 0x00,
  0x00, 0xC0, 0x18, 0x05, 0x00, 0xA0, 0x24, 0x04, 0x81, 0x90, 0x22, 0x0C,
  0x41, 0x08, 0x7F, 0x08, 0x21, 0x04, 0x60, 0xC8, 0x1B, 0x03, 0xC0, 0x60,
  0x0F, 0xC1, 0x0C, 0x60, 0x8C, 0x11, 0x02, 0x20, 0xC4, 0x31, 0xFC, 0x3F,
  0x04, 0x10, 0x83, 0x10, 0x66, 0x0C, 0x81, 0x10, 0x62, 0x18, 0xFE, 0x00,
  0x07, 0xE1, 0x80, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x8E, 0x18, 0x21, 0x82, 0x10, 0x31, 0x03, 0x10, 0x33, 0x03,
  0x20, 0x22, 0x02, 0x20, 0x62, 0x04, 0x60, 0x44, 0x08, 0x41, 0x84, 0x70,
  0xFC, 0x00, 0x0F, 0xE1, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01,
  0xFC, 0x3F, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xFE, 0x00, 0x0F, 0xE1, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x80, 0x3F, 0x84, 0x00, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00,
  0xC0, 0x00, 0x07, 0xF0, 0xC1, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x04, 0x00, 0xC1, 0xEC, 0x26, 0xC0, 0x4C, 0x04, 0xC0, 0x4C, 0x0C, 0x40,
  0x86, 0x08, 0x3F, 0x80, 0x08, 0x18, 0x40, 0xC6, 0x04, 0x30, 0x21, 0x01,
  0x08, 0x18, 0x40, 0xC7, 0xFC, 0x3F, 0xE1, 0x01, 0x08, 0x18, 0xC0, 0x86,
  0x04, 0x20, 0x21, 0x01, 0x08, 0x18, 0xC0, 0x80, 0x0F, 0x04, 0x04, 0x04,
  0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30, 0x30, 0x20,
  0xF8, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08, 0x04, 0x06, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x03, 0x0F,
  0x00, 0x08, 0x30, 0x86, 0x18, 0xC1, 0x88, 0x11, 0x01, 0x30, 0x16, 0x03,
  0xC0, 0x2C, 0x03, 0x60, 0x22, 0x06, 0x20, 0x62, 0x04, 0x30, 0x41, 0x04,
  0x10, 0xC1, 0x80, 0x08, 0x10, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x20, 0x40,
  0x83, 0x06, 0x08, 0x10, 0x20, 0xFE, 0x0C, 0x03, 0x86, 0x01, 0x87, 0x01,
  0xC2, 0x80, 0xA1, 0x40, 0xF0, 0xA0, 0x50, 0x50, 0x68, 0x68, 0x24, 0x24,
  0x36, 0x13, 0x13, 0x09, 0x99, 0x0C, 0x48, 0x86, 0x2C, 0x42, 0x14, 0x61,
  0x0E, 0x20, 0x86, 0x10, 0xC3, 0x08, 0x00, 0x0C, 0x08, 0x60, 0x47, 0x02,
  0x28, 0x31, 0x61, 0x09, 0x08, 0x48, 0x46, 0x42, 0x23, 0x31, 0x09, 0x08,
  0x48, 0xC2, 0x46, 0x1E, 0x20, 0x71, 0x03, 0x08, 0x18, 0xC0, 0xC0, 0x07,
  0xC1, 0x86, 0x10, 0x23, 0x02, 0x20, 0x36, 0x03, 0x40, 0x24, 0x02, 0xC0,
  0x2C, 0x02, 0xC0, 0x6C, 0x04, 0xC0, 0x4C, 0x0C, 0xC1, 0x86, 0x30, 0x3E,
  0x00, 0x0F, 0x81, 0x18, 0x61, 0x8C, 0x31, 0x06, 0x20, 0x84, 0x11, 0x86,
  0x23, 0x87, 0xC0, 0x80, 0x10, 0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0,
  0x00, 0x07, 0xC1, 0x86, 0x10, 0x23, 0x02, 0x20, 0x36, 0x03, 0x40, 0x24,
  0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x6C, 0x04, 0xC0, 0x4C, 0x0C, 0x41, 0x86,
  0x30, 0x3E, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00, 0x0F, 0x81, 0x18,
  0x61, 0x8C, 0x31, 0x06, 0x20, 0x84, 0x11, 0x86, 0x3F, 0x87, 0xC0, 0x88,
  0x11, 0x06, 0x30, 0x86, 0x10, 0x42, 0x08, 0xC1, 0x80, 0x0F, 0xC6, 0x13,
  0x00, 0xC0, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04,
  0x01, 0x00, 0x40, 0x32, 0x18, 0xFC, 0x00, 0xFF, 0x84, 0x06, 0x02, 0x01,
  0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00,
  0x80, 0xC0, 0x00, 0x10, 0x33, 0x03, 0x30, 0x22, 0x02, 0x20, 0x22, 0x06,
  0x60, 0x46, 0x04, 0x40, 0x44, 0x0C, 0x40, 0xCC, 0x08, 0xC0, 0x88, 0x18,
  0xC1, 0x04, 0x30, 0x7E, 0x00, 0x80, 0xE0, 0x2C, 0x0B, 0x04, 0xC1, 0x30,
  0xCC, 0x23, 0x18, 0xC4, 0x13, 0x04, 0x81, 0x60, 0x50, 0x14, 0x06, 0x01,
  0x80, 0x60, 0x00, 0xC1, 0x81, 0xC1, 0x83, 0xC1, 0x82, 0xC2, 0x86, 0xC2,
  0x84, 0xC6, 0x84, 0xC4, 0x8C, 0xC4, 0x88, 0xC8, 0x98, 0xC8, 0x90, 0xD8,
  0x90, 0xD0, 0xB0, 0xB0, 0xA0, 0xA0, 0xE0, 0xA0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x80, 0x08, 0x30, 0x82, 0x0C, 0x40, 0xCC, 0x04, 0x80, 0x58, 0x05, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0A, 0x01, 0xB0, 0x33, 0x02, 0x10, 0x61, 0x04,
  0x10, 0x81, 0x80, 0xC1, 0xE0, 0xB0, 0xC8, 0x44, 0x42, 0x61, 0x20, 0xB0,
  0x70, 0x18, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x00, 0x0F,
  0xF0, 0x06, 0x00, 0x40, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x02, 0x00, 0x60, 0x04, 0x00, 0xFF,
  0x00, 0x0F, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x80, 0x80, 0xF0, 0xC4, 0x44,
  0x44, 0x62, 0x22, 0x22, 0x23, 0x11, 0x10, 0x07, 0x80, 0x40, 0x60, 0x20,
  0x10, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0x40, 0x60, 0x20, 0x10,
  0x08, 0x0C, 0x04, 0x02, 0x01, 0x0F, 0x80, 0x04, 0x06, 0x06, 0x82, 0x43,
  0x31, 0x09, 0x04, 0x83, 0x80, 0x80, 0xFF, 0xCC, 0x80, 0x0E, 0x99, 0xC8,
  0x68, 0x34, 0x1E, 0x0A, 0x05, 0x02, 0x83, 0x41, 0xA1, 0x99, 0x47, 0xA0,
  0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x05, 0xE1, 0xCC, 0xE3, 0x30, 0x4C,
  0x12, 0x04, 0x83, 0x60, 0x98, 0x24, 0x19, 0x84, 0x63, 0x27, 0x80, 0x0F,
  0x31, 0x20, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x7C,
  0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x0C, 0x1D, 0x0C, 0xE1, 0x0C, 0x41,
  0x88, 0x33, 0x04, 0x40, 0x88, 0x11, 0x06, 0x20, 0xC4, 0x30, 0xCE, 0x0F,
  0x40, 0x0E, 0x33, 0x21, 0x41, 0x43, 0xC6, 0xF8, 0x80, 0x80, 0x80, 0x80,
  0xC2, 0x7C, 0x00, 0xF0, 0x18, 0x01, 0x00, 0x10, 0x03, 0x00, 0xF8, 0x02,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x80, 0x18, 0x01, 0x00, 0x10, 0x01, 0x00, 0xA0,
  0x0C, 0x00, 0x07, 0x63, 0x38, 0x43, 0x10, 0x62, 0x0C, 0xC1, 0x10, 0x22,
  0x04, 0x41, 0x88, 0x31, 0x0C, 0x33, 0x83, 0xD0, 0x06, 0x00, 0x80, 0x10,
  0x06, 0x1B, 0x81, 0xC0, 0x00, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x05,
  0xE1, 0xC8, 0xC3, 0x30, 0xC8, 0x22, 0x08, 0x82, 0x61, 0x98, 0x64, 0x11,
  0x04, 0x41, 0x30, 0xC0, 0x18, 0x40, 0x01, 0x08, 0xC6, 0x21, 0x08, 0xC6,
  0x21, 0x08, 0xC0, 0x01, 0x01, 0x00, 0x00, 0x02, 0x02, 0x02, 0x06, 0x04,
  0x04, 0x04, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30,
  0xE0, 0xC0, 0x08, 0x02, 0x00, 0x80, 0x60, 0x10, 0x04, 0x31, 0x18, 0xCC,
  0x32, 0x09, 0x02, 0x80, 0xF0, 0x64, 0x11, 0x04, 0x61, 0x18, 0x42, 0x30,
  0x80, 0x08, 0x42, 0x31, 0x08, 0x46, 0x31, 0x08, 0x46, 0x31, 0x08, 0x46,
  0x00, 0x17, 0x1C, 0x3B, 0x4C, 0xC3, 0x09, 0x84, 0x12, 0x08, 0x64, 0x10,
  0xC8, 0x61, 0x30, 0x82, 0x61, 0x04, 0x82, 0x19, 0x0C, 0x22, 0x18, 0x4C,
  0x20, 0x80, 0x17, 0x87, 0x23, 0x0C, 0xC3, 0x20, 0x88, 0x22, 0x09, 0x86,
  0x61, 0x90, 0x44, 0x11, 0x04, 0xC3, 0x00, 0x0E, 0x19, 0x88, 0x48, 0x34,
  0x1E, 0x0E, 0x05, 0x02, 0x81, 0x41, 0xA0, 0x98, 0x87, 0x80, 0x09, 0xC1,
  0xCC, 0x70, 0x8C, 0x11, 0x82, 0x20, 0x44, 0x19, 0x83, 0x30, 0x46, 0x18,
  0xC2, 0x18, 0xC6, 0xF0, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00,
  0x00, 0x0E, 0xCC, 0xE2, 0x19, 0x86, 0x41, 0xB0, 0x48, 0x12, 0x04, 0x83,
  0x20, 0xC8, 0x63, 0x38, 0x7A, 0x01, 0x80, 0x60, 0x10, 0x04, 0x01, 0x00,
  0xC0, 0x17, 0x1C, 0x38, 0x30, 0x30, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40,
  0x40, 0xC0, 0x1F, 0x31, 0x20, 0x60, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x04,
  0x04, 0x8C, 0xF8, 0x11, 0x89, 0xF2, 0x31, 0x88, 0x42, 0x31, 0x08, 0x42,
  0x1C, 0x20, 0x90, 0x58, 0x68, 0x34, 0x12, 0x09, 0x05, 0x86, 0x82, 0x41,
  0x21, 0x91, 0x4F, 0x60, 0xC1, 0xC1, 0xC2, 0xC2, 0x44, 0x44, 0x48, 0x48,
  0x58, 0x50, 0x70, 0x60, 0x60, 0xC3, 0x0E, 0x18, 0x71, 0x45, 0x8A, 0x2C,
  0xD3, 0x64, 0x91, 0x24, 0x8A, 0x28, 0x51, 0x43, 0x0E, 0x18, 0x60, 0xC3,
  0x04, 0x10, 0x00, 0x10, 0x46, 0x30, 0x98, 0x24, 0x0A, 0x03, 0x80, 0xC0,
  0x30, 0x16, 0x0C, 0x82, 0x21, 0x08, 0xC3, 0x00, 0x04, 0x18, 0x20, 0x81,
  0x0C, 0x08, 0x40, 0x46, 0x02, 0x20, 0x13, 0x00, 0x90, 0x05, 0x80, 0x28,
  0x01, 0x40, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x00, 0x18, 0x05,
  0x80, 0x38, 0x00, 0x1F, 0x80, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x20, 0x30,
  0x10, 0x18, 0x18, 0x08, 0x0F, 0xE0, 0x07, 0x0C, 0x08, 0x08, 0x18, 0x18,
  0x10, 0x10, 0x30, 0x60, 0xC0, 0x60, 0x20, 0x20, 0x60, 0x40, 0x40, 0x40,
  0x40, 0x60, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x06, 0x02,
  0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x06, 0x03, 0x0C, 0x08, 0x08, 0x18,
  0x10, 0x10, 0x10, 0x30, 0x60, 0xC0, 0x70, 0xEE, 0x60, 0xC0,
};

const GFXglyph NotoSans_Condensed_LightItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 17, 5, 0, -17 },
  { 14, 6, 6, 8, 2, -17 },
  { 19, 12, 17, 11, 0, -17 },
  { 45, 10, 19, 10, 0, -18 },
  { 69, 13, 17, 15, 1, -17 },
  { 97, 11, 17, 11, 0, -17 },
  { 121, 3, 6, 4, 2, -17 },
  { 124, 7, 21, 6, 1, -17 },
  { 143, 7, 21, 6, -2, -17 },
  { 162, 7, 8, 10, 3, -18 },
  { 169, 9, 11, 11, 1, -14 },
  { 182, 4, 6, 5, -1, -3 },
  { 185, 5, 1, 7, 1, -7 },
  { 186, 2, 2, 5, 0, -2 },
  { 187, 10, 17, 8, -1, -17 },
  { 209, 9, 17, 10, 1, -17 },
  { 229, 5, 17, 10, 3, -17 },
  { 240, 11, 17, 10, -1, -17 },
  { 264, 10, 17, 10, 0, -17 },
  { 286, 10, 17, 10, 0, -17 },
  { 308, 10, 17, 10, 0, -17 },
  { 330, 9, 17, 10, 1, -17 },
  { 350, 10, 17, 10, 1, -17 },
  { 372, 10, 17, 10, 0, -17 },
  { 394, 10, 17, 10, 0, -17 },
  { 416, 4, 13, 5, 0, -13 },
  { 423, 5, 16, 5, -1, -13 },
  { 433, 9, 11, 11, 1, -14 },
  { 446, 9, 7, 11, 1, -12 },
  { 454, 9, 11, 11, 1, -14 },
  { 467, 7, 17, 7, 1, -17 },
  { 482, 14, 19, 15, 1, -17 },
  { 516, 11, 17, 10, -2, -17 },
  { 540, 11, 17, 11, 0, -17 },
  { 564, 11, 17, 10, 1, -17 },
  { 588, 12, 17, 12, 0, -17 },
  { 614, 11, 17, 10, 0, -17 },
  { 638, 11, 17, 9, 0, -17 },
  { 662, 12, 17, 13, 1, -17 },
  { 688, 13, 17, 13, 0, -17 },
  { 716, 8, 17, 6, -1, -17 },
  { 733, 9, 21, 5, -4, -17 },
  { 757, 12, 17, 10, 0, -17 },
  { 783, 7, 17, 9, 0, -17 },
  { 798, 17, 17, 16, 0, -17 },
  { 835, 13, 17, 13, 0, -17 },
  { 863, 12, 17, 13, 1, -17 },
  { 889, 11, 17, 10, 0, -17 },
  { 913, 12, 21, 13, 1, -17 },
  { 945, 11, 17, 11, 0, -17 },
  { 969, 10, 17, 10, 0, -17 },
  { 991, 9, 17, 9, 2, -17 },
  { 1011, 12, 17, 12, 1, -17 },
  { 1037, 10, 17, 10, 2, -17 },
  { 1059, 16, 17, 17, 2, -17 },
  { 1093, 12, 17, 9, -1, -17 },
  { 1119, 9, 17, 9, 2, -17 },
  { 1139, 12, 17, 9, -1, -17 },
  { 1165, 8, 21, 7, 0, -17 },
  { 1186, 4, 17, 8, 2, -17 },
  { 1195, 9, 21, 7, -2, -17 },
  { 1219, 9, 9, 11, 1, -17 },
  { 1230, 8, 1, 7, -2, 2 },
  { 1231, 3, 3, 6, 3, -18 },
  { 1233, 9, 13, 11, 1, -13 },
  { 1248, 10, 18, 11, 0, -18 },
  { 1271, 8, 13, 8, 1, -13 },
  { 1284, 11, 18, 11, 1, -18 },
  { 1309, 8, 13, 10, 1, -13 },
  { 1322, 12, 24, 6, -3, -18 },
  { 1358, 11, 19, 11, 0, -13 },
  { 1385, 10, 18, 11, 0, -18 },
  { 1408, 5, 17, 5, 0, -17 },
  { 1419, 8, 23, 5, -3, -17 },
  { 1442, 10, 18, 9, 0, -18 },
  { 1465, 5, 18, 5, 0, -18 },
  { 1477, 15, 13, 16, 0, -13 },
  { 1502, 10, 13, 11, 0, -13 },
  { 1519, 9, 13, 10, 1, -13 },
  { 1534, 11, 19, 11, -1, -13 },
  { 1561, 10, 19, 11, 1, -13 },
  { 1585, 8, 13, 7, 0, -13 },
  { 1598, 8, 13, 8, 0, -13 },
  { 1611, 5, 16, 6, 1, -16 },
  { 1621, 9, 13, 11, 1, -13 },
  { 1636, 8, 13, 8, 1, -13 },
  { 1649, 13, 13, 13, 1, -13 },
  { 1671, 10, 13, 9, -1, -13 },
  { 1688, 13, 19, 8, -3, -13 },
  { 1719, 9, 13, 7, -1, -13 },
  { 1734, 8, 21, 8, 1, -17 },
  { 1755, 2, 24, 10, 4, -18 },
  { 1761, 8, 21, 8, -1, -17 },
  { 1782, 9, 3, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_LightItalic24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC24PT7B_H_
