#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC9PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x20, 0xF0, 0x37, 0x57, 0xAA, 0x27, 0x44, 0x66, 0xC4, 0x4D,
  0xEB, 0xFB, 0xB0, 0x25, 0x64, 0xBA, 0xF0, 0xC0, 0x6A, 0x49, 0x20, 0x24,
  0x92, 0xB0, 0x5F, 0x00, 0x2F, 0x22, 0xC0, 0xC0, 0x80, 0x32, 0x44, 0x88,
  0x25, 0x59, 0x9A, 0xE0, 0xD5, 0xA0, 0x61, 0x12, 0x24, 0xE0, 0x61, 0x16,
  0x22, 0xE0, 0x32, 0x6A, 0xF2, 0x74, 0x61, 0x2E, 0x34, 0x46, 0x9A, 0xE0,
  0x72, 0x24, 0x48, 0x25, 0x56, 0xA9, 0xE0, 0x25, 0x99, 0x72, 0xC0, 0x40,
  0x80, 0x40, 0xA0, 0x3C, 0x61, 0xFF, 0xC3, 0x68, 0x44, 0xA4, 0x20, 0x7D,
  0x5B, 0x75, 0xFA, 0x07, 0x00, 0x13, 0x33, 0x59, 0x75, 0x69, 0x9E, 0x34,
  0x48, 0x88, 0x70, 0x75, 0x59, 0x9E, 0x74, 0x68, 0x8E, 0x74, 0x68, 0x88,
  0x3A, 0x11, 0x09, 0x49, 0xC0, 0x4A, 0x5D, 0x29, 0x48, 0x69, 0x29, 0x00,
  0x24, 0xA4, 0x94, 0x5B, 0x11, 0x4A, 0x50, 0x49, 0x49, 0xC0, 0x45, 0x14,
  0xED, 0xAA, 0xA0, 0x4B, 0x5B, 0x69, 0x48, 0x32, 0x53, 0x18, 0xC9, 0x80,
  0x75, 0x5A, 0x88, 0x32, 0x53, 0x18, 0xC9, 0x84, 0x20, 0x75, 0x5A, 0xAA,
  0x34, 0x44, 0x22, 0xE0, 0xEA, 0x49, 0x00, 0x4A, 0x55, 0x29, 0x70, 0xBA,
  0xCC, 0x88, 0xA6, 0xAE, 0xAA, 0x92, 0x40, 0x29, 0x88, 0x45, 0x68, 0xBA,
  0x49, 0x00, 0x72, 0x24, 0x8E, 0x69, 0x49, 0x30, 0xFC, 0x31, 0x22, 0x22,
  0xC0, 0x25, 0x90, 0xE0, 0xC0, 0x75, 0x9A, 0xE0, 0x44, 0x65, 0x99, 0xE0,
  0x72, 0x4E, 0x11, 0x75, 0x9A, 0xE0, 0x77, 0x4E, 0x12, 0x62, 0x44, 0x44,
  0x80, 0x75, 0x9A, 0xE2, 0xE0, 0x44, 0x65, 0x9A, 0xA0, 0x45, 0xA8, 0x20,
  0x94, 0x92, 0x80, 0x44, 0x56, 0x4A, 0xA0, 0x55, 0xA8, 0x69, 0x59, 0x6A,
  0xA8, 0x65, 0x9A, 0xA0, 0x69, 0x99, 0xE0, 0x65, 0x99, 0xE8, 0x80, 0x75,
  0x9A, 0xE2, 0x20, 0x6A, 0x48, 0x71, 0x1C, 0x76, 0xB0, 0x55, 0x9A, 0xE0,
  0x9A, 0xA4, 0x40, 0xDD, 0xAA, 0xA0, 0x56, 0x4C, 0xA0, 0x4A, 0x94, 0xC2,
  0x23, 0x00, 0x65, 0x4C, 0x29, 0x44, 0xB0, 0xFF, 0x80, 0x32, 0x21, 0x22,
  0xC0, 0xF0,
};

const GFXglyph NotoSans_Condensed_LightItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 4, 8, 4, 0, -7 },
  { 11, 4, 7, 6, 1, -7 },
  { 15, 4, 7, 4, 0, -7 },
  { 19, 1, 2, 2, 1, -6 },
  { 20, 3, 7, 2, 0, -6 },
  { 23, 3, 7, 2, -1, -6 },
  { 26, 3, 3, 4, 1, -7 },
  { 28, 4, 4, 4, 0, -5 },
  { 30, 1, 2, 2, 0, -1 },
  { 31, 2, 1, 2, 0, -3 },
  { 32, 1, 1, 2, 0, -1 },
  { 33, 4, 6, 3, 0, -6 },
  { 36, 4, 7, 4, 0, -7 },
  { 40, 2, 6, 4, 1, -6 },
  { 42, 4, 7, 4, 0, -7 },
  { 46, 4, 7, 4, 0, -7 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 7, 4, 0, -7 },
  { 60, 4, 6, 4, 0, -6 },
  { 63, 4, 7, 4, 0, -7 },
  { 67, 4, 7, 4, 0, -7 },
  { 71, 2, 5, 2, 0, -5 },
  { 73, 2, 6, 2, 0, -5 },
  { 75, 4, 4, 4, 0, -5 },
  { 77, 4, 2, 4, 0, -4 },
  { 78, 4, 4, 4, 0, -5 },
  { 80, 3, 7, 3, 0, -7 },
  { 83, 6, 7, 6, 0, -6 },
  { 89, 4, 6, 4, -1, -6 },
  { 92, 4, 6, 4, 0, -6 },
  { 95, 4, 7, 4, 0, -7 },
  { 99, 4, 6, 5, 0, -6 },
  { 102, 4, 6, 4, 0, -6 },
  { 105, 4, 6, 3, 0, -6 },
  { 108, 5, 7, 5, 0, -7 },
  { 113, 5, 6, 5, 0, -6 },
  { 117, 3, 6, 2, 0, -6 },
  { 120, 3, 8, 2, -1, -6 },
  { 123, 5, 6, 4, 0, -6 },
  { 127, 3, 6, 3, 0, -6 },
  { 130, 6, 6, 6, 0, -6 },
  { 135, 5, 6, 5, 0, -6 },
  { 139, 5, 7, 5, 0, -7 },
  { 144, 4, 6, 4, 0, -6 },
  { 147, 5, 9, 5, 0, -7 },
  { 153, 4, 6, 4, 0, -6 },
  { 156, 4, 7, 4, 0, -7 },
  { 160, 3, 6, 3, 1, -6 },
  { 163, 5, 6, 5, 0, -6 },
  { 167, 4, 6, 4, 1, -6 },
  { 170, 6, 6, 6, 1, -6 },
  { 175, 5, 6, 3, -1, -6 },
  { 179, 3, 6, 3, 1, -6 },
  { 182, 4, 6, 3, 0, -6 },
  { 185, 3, 7, 3, 0, -6 },
  { 188, 1, 6, 3, 1, -6 },
  { 189, 4, 7, 3, -1, -6 },
  { 193, 4, 3, 4, 0, -6 },
  { 195, 3, 1, 3, -1, 1 },
  { 196, 1, 2, 2, 1, -7 },
  { 197, 4, 5, 4, 0, -5 },
  { 200, 4, 7, 4, 0, -7 },
  { 204, 3, 5, 3, 0, -5 },
  { 206, 4, 7, 4, 0, -7 },
  { 210, 3, 5, 4, 0, -5 },
  { 212, 4, 9, 2, -1, -7 },
  { 217, 4, 7, 4, 0, -5 },
  { 221, 4, 7, 4, 0, -7 },
  { 225, 2, 7, 2, 0, -7 },
  { 227, 3, 9, 2, -1, -7 },
  { 231, 4, 7, 3, 0, -7 },
  { 235, 2, 7, 2, 0, -7 },
  { 237, 6, 5, 6, 0, -5 },
  { 241, 4, 5, 4, 0, -5 },
  { 244, 4, 5, 4, 0, -5 },
  { 247, 4, 7, 4, 0, -5 },
  { 251, 4, 7, 4, 0, -5 },
  { 255, 3, 5, 3, 0, -5 },
  { 257, 3, 5, 3, 0, -5 },
  { 259, 2, 6, 2, 0, -6 },
  { 261, 4, 5, 4, 0, -5 },
  { 264, 4, 5, 3, 0, -5 },
  { 267, 4, 5, 5, 1, -5 },
  { 270, 4, 5, 3, 0, -5 },
  { 273, 5, 7, 3, -1, -5 },
  { 278, 3, 5, 3, 0, -5 },
  { 280, 3, 7, 3, 0, -6 },
  { 283, 1, 9, 4, 1, -7 },
  { 285, 4, 7, 3, -1, -6 },
  { 289, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_LightItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC9PT7B_H_
