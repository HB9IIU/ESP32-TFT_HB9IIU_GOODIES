#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC59PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x1C,
  0xF0, 0x73, 0x83, 0xCE, 0x0E, 0x38, 0x38, 0xE0, 0xE7, 0x03, 0x9C, 0x1C,
  0x70, 0x71, 0xC1, 0xC6, 0x07, 0x18, 0x18, 0xE0, 0x63, 0x83, 0x8C, 0x0E,
  0x00, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x1C, 0x06, 0x00,
  0x03, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x01,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x06, 0x00, 0x03, 0x01, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x1C, 0x06, 0x00, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x1C,
  0x07, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x1C, 0x07, 0x00,
  0x03, 0x80, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80,
  0xC0, 0x00, 0x70, 0x18, 0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x18,
  0x00, 0x0C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x18, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x00,
  0x01, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01,
  0xF3, 0x0E, 0x03, 0xC3, 0x02, 0x03, 0x83, 0x00, 0x07, 0x03, 0x00, 0x07,
  0x07, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07,
  0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x8C, 0x00, 0x03, 0xCC, 0x00, 0x03,
  0xEC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x31, 0xE0, 0x00,
  0x30, 0xE0, 0x00, 0x30, 0xF0, 0x00, 0x30, 0x70, 0x00, 0x70, 0x70, 0x00,
  0x60, 0x70, 0x00, 0x60, 0x70, 0x00, 0x60, 0x70, 0x00, 0x60, 0xE0, 0x00,
  0xE0, 0xE0, 0x80, 0xC1, 0xC0, 0xC0, 0xC7, 0xC0, 0xFE, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x04, 0x01, 0xFC, 0x00, 0x38, 0x03, 0xFC, 0x00, 0x38, 0x07,
  0x0E, 0x00, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0x0E, 0x0E, 0x00, 0xE0, 0x1C,
  0x0E, 0x00, 0xC0, 0x1C, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x38,
  0x0E, 0x03, 0x80, 0x30, 0x0E, 0x07, 0x00, 0x70, 0x0E, 0x07, 0x00, 0x70,
  0x0E, 0x0E, 0x00, 0x70, 0x0C, 0x1C, 0x00, 0x70, 0x0C, 0x1C, 0x00, 0x60,
  0x1C, 0x38, 0x00, 0x60, 0x1C, 0x38, 0x00, 0xE0, 0x18, 0x70, 0x70, 0xE0,
  0x38, 0x61, 0xFC, 0xE0, 0x38, 0xE3, 0xFE, 0xE0, 0x31, 0xC7, 0x8E, 0x60,
  0x71, 0xC7, 0x07, 0x60, 0xE3, 0x8E, 0x07, 0x71, 0xE3, 0x8C, 0x07, 0x7F,
  0xC7, 0x1C, 0x07, 0x3F, 0x86, 0x1C, 0x07, 0x0E, 0x0E, 0x18, 0x07, 0x00,
  0x1C, 0x38, 0x06, 0x00, 0x1C, 0x38, 0x06, 0x00, 0x38, 0x38, 0x0E, 0x00,
  0x38, 0x30, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x00, 0x60, 0x70, 0x0E, 0x00,
  0xE0, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x01, 0xC0, 0x70, 0x1C, 0x03,
  0x80, 0x70, 0x38, 0x03, 0x80, 0x70, 0x38, 0x07, 0x00, 0x70, 0x70, 0x0E,
  0x00, 0x70, 0x70, 0x0E, 0x00, 0x78, 0xE0, 0x1C, 0x00, 0x3F, 0xC0, 0x3C,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x1C, 0x00,
  0x1E, 0x07, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x1E,
  0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0,
  0x38, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x71, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x38,
  0x00, 0x07, 0x8F, 0x01, 0xC3, 0xC1, 0xC0, 0x71, 0xE0, 0x70, 0x38, 0xF0,
  0x1E, 0x0E, 0x38, 0x03, 0x87, 0x9E, 0x00, 0xF1, 0xC7, 0x00, 0x1C, 0xF1,
  0xC0, 0x07, 0x38, 0x70, 0x01, 0xFC, 0x3C, 0x00, 0x3F, 0x0F, 0x00, 0x0F,
  0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x1C, 0x00, 0x7E, 0x07, 0x00,
  0x3F, 0x81, 0xE0, 0x1E, 0xF0, 0x3E, 0x1F, 0x1C, 0x07, 0xFF, 0x07, 0x80,
  0xFF, 0x80, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0xF3, 0xCE, 0x38, 0xE3, 0x1C,
  0x71, 0xC6, 0x18, 0xE3, 0x8C, 0x00, 0x00, 0x07, 0x80, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x30, 0x38, 0x0F, 0x0E, 0x03,
  0xE3, 0x00, 0x3E, 0xC3, 0xC3, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0x00, 0x07,
  0x60, 0x03, 0x9C, 0x01, 0xC3, 0x00, 0xE0, 0xE0, 0xF8, 0x38, 0x1C, 0x07,
  0x02, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0x38, 0x38, 0x1C,
  0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x00, 0x7F, 0xFD, 0xFF, 0xEF, 0xFF, 0x80,
  0x77, 0xFF, 0xEF, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1E, 0x3E, 0x00, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x3C, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x80, 0x1C, 0x1C, 0x00,
  0x70, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x78, 0x00, 0x71,
  0xC0, 0x01, 0xC7, 0x00, 0x07, 0x3C, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80,
  0x01, 0xCE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x00, 0x03,
  0x9C, 0x00, 0x0E, 0x70, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00,
  0x78, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0xE0,
  0xE0, 0x07, 0x83, 0xC0, 0x3C, 0x07, 0x00, 0xE0, 0x1E, 0x07, 0x80, 0x3E,
  0x7C, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3C,
  0x01, 0xE0, 0x1F, 0x80, 0xFE, 0x07, 0xB8, 0x7D, 0xC3, 0xE7, 0x1E, 0x1C,
  0xF0, 0x71, 0x83, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0x83,
  0xE0, 0x07, 0x00, 0xF0, 0x02, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x04, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x01, 0x00, 0x0F, 0x00, 0xF8, 0x3F, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x9C, 0x00,
  0x01, 0xC7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1C, 0x38,
  0x00, 0x07, 0x0E, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x03, 0xC0, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x03, 0x00, 0x1E, 0x01, 0xF0, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0x02, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x3F, 0x00, 0x38,
  0xFF, 0xC0, 0x39, 0xFF, 0xE0, 0x3B, 0x81, 0xE0, 0x7E, 0x00, 0xF0, 0x7C,
  0x00, 0x70, 0x7C, 0x00, 0x70, 0x78, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70,
  0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x70,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0x83, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x00, 0x3C, 0x07, 0x80, 0x0E, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x78, 0x00,
  0x70, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x3C, 0x00, 0xE0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xC7, 0x80, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x1C, 0x07,
  0x80, 0x0F, 0x03, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x0E,
  0x1E, 0x00, 0x07, 0x07, 0x00, 0x07, 0x83, 0x80, 0x03, 0x81, 0xE0, 0x03,
  0xC0, 0x78, 0x03, 0xC0, 0x3F, 0x07, 0xC0, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xE0, 0x07, 0xC3, 0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x03, 0x80, 0xE0,
  0x07, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03,
  0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x78,
  0xE0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0xC0, 0x0F, 0x83, 0x80, 0x37, 0x07,
  0xC1, 0xEE, 0x07, 0xFF, 0xB8, 0x07, 0xFC, 0x70, 0x07, 0xE0, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0xC1, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x01, 0x80, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x80, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x78, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x01, 0xFF, 0x81, 0xFF, 0xF8, 0x3C, 0x3E, 0x0C,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x06, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x70, 0x30, 0x00,
  0x00, 0x0C, 0x1C, 0x00, 0x20, 0x03, 0x0E, 0x00, 0x7F, 0xC0, 0xC3, 0x80,
  0x7F, 0xF0, 0x30, 0xC0, 0x3C, 0x1C, 0x0C, 0x70, 0x1E, 0x06, 0x03, 0x18,
  0x07, 0x03, 0x80, 0xCE, 0x03, 0x80, 0xE0, 0x33, 0x81, 0xC0, 0x38, 0x1C,
  0xC0, 0x70, 0x1C, 0x07, 0x70, 0x18, 0x07, 0x01, 0xDC, 0x0E, 0x01, 0xC0,
  0x77, 0x03, 0x80, 0x70, 0x19, 0x80, 0xC0, 0x38, 0x0E, 0x60, 0x70, 0x0E,
  0x03, 0xB8, 0x1C, 0x03, 0x80, 0xEE, 0x07, 0x01, 0xC0, 0x33, 0x81, 0xC0,
  0x70, 0x1C, 0xE0, 0x70, 0x1C, 0x06, 0x38, 0x1C, 0x0F, 0x03, 0x8E, 0x07,
  0x03, 0xC0, 0xC3, 0x81, 0xC1, 0xB0, 0x70, 0xE0, 0x78, 0xCE, 0x38, 0x38,
  0x0F, 0xF3, 0xFC, 0x0E, 0x01, 0xF8, 0x7E, 0x03, 0x80, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x20, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1E,
  0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03,
  0x80, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x01, 0xE0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x38, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E,
  0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC3, 0x80, 0x00,
  0xE3, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0x80, 0x3E,
  0x00, 0xE0, 0x07, 0xC0, 0x38, 0x00, 0xF0, 0x1E, 0x00, 0x1C, 0x07, 0x00,
  0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x0F,
  0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x7F,
  0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0x80, 0xFC, 0x00, 0xE0,
  0x07, 0x80, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x81,
  0xC0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0xF8, 0x1C,
  0x00, 0x7C, 0x07, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0xFE, 0x1E, 0x00, 0x7C, 0x00, 0x80, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x01, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x0E, 0x01, 0xF8, 0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x00, 0x3C,
  0x01, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xE0, 0x1C,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0xF0, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0,
  0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x1C, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70,
  0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x1E, 0x03, 0x80,
  0x03, 0xC0, 0x78, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x80, 0x70, 0x01, 0xF0,
  0x07, 0x00, 0x3E, 0x00, 0x70, 0x1F, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x03, 0xF0, 0x07, 0xC0, 0x03,
  0x00, 0x7C, 0x00, 0x08, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x03, 0xFF, 0x1E, 0x00, 0x3F, 0xF8, 0xE0, 0x00, 0x03,
  0x87, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x0F, 0x0E,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x1C, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x70, 0x03, 0xE0, 0x03, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x70, 0x07, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78,
  0x07, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0x38, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x01, 0x0F, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80,
  0x38, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x00, 0x70,
  0x03, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0, 0x3C,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x38, 0x1E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x0E, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0x7F, 0x00, 0x00,
  0x3F, 0x38, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x78,
  0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x38, 0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0xEE, 0x01, 0xDC, 0x00, 0x00, 0xFC,
  0x01, 0xDC, 0x00, 0x01, 0xDC, 0x01, 0xDC, 0x00, 0x01, 0xDC, 0x01, 0xDC,
  0x00, 0x03, 0x9C, 0x01, 0xDC, 0x00, 0x03, 0xBC, 0x03, 0x9C, 0x00, 0x07,
  0x38, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x03, 0x9C, 0x00, 0x0E, 0x38, 0x03,
  0x9C, 0x00, 0x0E, 0x78, 0x07, 0x8E, 0x00, 0x1C, 0x70, 0x07, 0x0E, 0x00,
  0x1C, 0x70, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x07, 0x0E, 0x00, 0x70, 0xF0, 0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x0E,
  0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x01, 0xC0,
  0xE0, 0x0E, 0x0E, 0x01, 0xC1, 0xE0, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x1C,
  0x0E, 0x03, 0x81, 0xC0, 0x1C, 0x06, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x07,
  0x01, 0xC0, 0x3C, 0x07, 0x0E, 0x03, 0xC0, 0x38, 0x07, 0x0E, 0x03, 0x80,
  0x38, 0x07, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x38, 0x07, 0x00, 0x70, 0x07, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x70, 0x07, 0x00, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x70,
  0x07, 0xE0, 0x0F, 0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0xC0,
  0x0E, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x07, 0x00,
  0xF8, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0E, 0x00,
  0xFC, 0x00, 0x0E, 0x00, 0xDC, 0x00, 0x0E, 0x01, 0xDC, 0x00, 0x0E, 0x01,
  0xDC, 0x00, 0x1C, 0x01, 0xDE, 0x00, 0x1C, 0x01, 0xCE, 0x00, 0x1C, 0x01,
  0xCE, 0x00, 0x1C, 0x03, 0x8E, 0x00, 0x3C, 0x03, 0x8E, 0x00, 0x38, 0x03,
  0x87, 0x00, 0x38, 0x03, 0x87, 0x00, 0x38, 0x07, 0x87, 0x00, 0x38, 0x07,
  0x07, 0x00, 0x78, 0x07, 0x03, 0x80, 0x70, 0x07, 0x03, 0x80, 0x70, 0x07,
  0x03, 0x80, 0x70, 0x0F, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0xE0, 0x0E,
  0x01, 0xC0, 0xE0, 0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x01, 0xC0, 0xE0, 0x1C,
  0x00, 0xE1, 0xE0, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x00, 0xE1, 0xC0, 0x1C,
  0x00, 0xE1, 0xC0, 0x3C, 0x00, 0x71, 0xC0, 0x38, 0x00, 0x73, 0xC0, 0x38,
  0x00, 0x73, 0x80, 0x38, 0x00, 0x73, 0x80, 0x38, 0x00, 0x3B, 0x80, 0x78,
  0x00, 0x3B, 0x80, 0x70, 0x00, 0x3B, 0x80, 0x70, 0x00, 0x3F, 0x00, 0x70,
  0x00, 0x3F, 0x00, 0x70, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0x1C, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x0F, 0x38, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x1C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x3E, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x1C, 0x03, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x3C,
  0x07, 0x80, 0x1E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01,
  0xC0, 0x70, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x3C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x03, 0x80,
  0x07, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0x70,
  0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0x1C, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x0F, 0x38, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x03, 0x8E, 0x00,
  0x00, 0x78, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x3E,
  0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1C, 0x03, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x78, 0x00,
  0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x0F, 0x00,
  0x0E, 0x07, 0x80, 0x0F, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x0F, 0x80, 0xE0,
  0x0F, 0x80, 0xF0, 0x1F, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03,
  0x80, 0xF0, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x1E, 0x00, 0x70,
  0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03,
  0x81, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x01, 0xFC, 0x3F,
  0x00, 0xF8, 0x01, 0x80, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x08, 0x00, 0x1E, 0x03, 0x80, 0x1F, 0x80, 0xFE, 0x3F, 0xC0,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0F,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x0F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0xE3, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x78, 0x38, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x0E, 0x03, 0x80,
  0x0F, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0x70, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x01, 0xE0, 0x07, 0x00, 0xE0, 0x03,
  0x80, 0x70, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x3C, 0x00,
  0x38, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x0F, 0x00,
  0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x19, 0xC0, 0x00, 0x0C, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x70,
  0x00, 0x01, 0xB8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xC0,
  0x01, 0xEE, 0x00, 0x0F, 0x80, 0x03, 0x9C, 0x00, 0x1F, 0x00, 0x0F, 0x38,
  0x00, 0x7E, 0x00, 0x1C, 0x70, 0x00, 0xFC, 0x00, 0x38, 0xE0, 0x03, 0xB8,
  0x00, 0xF1, 0xC0, 0x07, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0xE0, 0x07, 0x87,
  0x00, 0x39, 0xC0, 0x0E, 0x0E, 0x00, 0x73, 0x80, 0x1C, 0x1C, 0x01, 0xC7,
  0x00, 0x78, 0x38, 0x03, 0x8E, 0x00, 0xE0, 0x70, 0x0E, 0x1C, 0x03, 0xC0,
  0xE0, 0x1C, 0x38, 0x07, 0x01, 0xC0, 0x30, 0x70, 0x0E, 0x03, 0x80, 0xE0,
  0xE0, 0x38, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x0E, 0x07, 0x03, 0x81, 0xE0,
  0x1C, 0x0E, 0x07, 0x03, 0x80, 0x38, 0x38, 0x0E, 0x0F, 0x00, 0x70, 0x70,
  0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x38, 0x38, 0x01, 0xC3, 0x80, 0x70, 0xF0,
  0x03, 0x87, 0x00, 0xE1, 0xC0, 0x07, 0x1C, 0x01, 0xC7, 0x80, 0x0E, 0x38,
  0x03, 0x8E, 0x00, 0x1C, 0x70, 0x07, 0x1C, 0x00, 0x39, 0xC0, 0x0E, 0x70,
  0x00, 0x73, 0x80, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x3B, 0xC0, 0x01, 0xDC,
  0x00, 0x77, 0x00, 0x03, 0xB0, 0x00, 0xEE, 0x00, 0x06, 0xE0, 0x01, 0xF8,
  0x00, 0x0D, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0xE0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x38, 0x1C, 0x00, 0x00, 0xE0, 0xF0,
  0x00, 0x03, 0x83, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0x8E, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x1C, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0xF0, 0x07, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x38, 0x03, 0x80, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xE7, 0x00, 0x07, 0x9C, 0x00, 0x1C, 0x70, 0x00, 0xF1, 0xC0,
  0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0x78, 0x03, 0x80, 0xE0, 0x1E,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x03,
  0x83, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xCF,
  0x00, 0x07, 0x38, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x00, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x02,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x0E, 0x03, 0x80, 0x1C, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xE0, 0x00, 0x73, 0x80, 0x00, 0xE7,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE1, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0x06,
  0x0E, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x87, 0x01, 0xFF, 0xC6, 0x03, 0xE0,
  0xEE, 0x03, 0xC0, 0x6E, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x0E, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00,
  0x78, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xE0, 0x00,
  0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01,
  0xE0, 0xE0, 0x03, 0xE0, 0xE0, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0x70, 0x0F,
  0xC0, 0x78, 0x1D, 0xC0, 0x7C, 0x79, 0xC0, 0x3F, 0xF1, 0x80, 0x1F, 0xE1,
  0x80, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x83, 0xE0, 0x03, 0x8F,
  0xF8, 0x03, 0x9F, 0xFC, 0x03, 0xB8, 0x3C, 0x07, 0x70, 0x1E, 0x07, 0x60,
  0x0E, 0x07, 0xC0, 0x0E, 0x07, 0xC0, 0x0E, 0x07, 0x80, 0x0F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x1C, 0x00,
  0x1E, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0x78, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0x6C, 0x01, 0xE0, 0xEE, 0x03, 0xC0, 0xE7, 0x0F,
  0x80, 0xE7, 0xFF, 0x00, 0xC3, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F,
  0xC0, 0x0F, 0xFC, 0x03, 0xFF, 0x81, 0xF0, 0x30, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x20, 0x7C, 0x38, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x3E, 0x0E, 0x00, 0x1F, 0xF1, 0xC0, 0x0F, 0xFE, 0x70, 0x03,
  0xE0, 0xEE, 0x00, 0x78, 0x0D, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x1F,
  0x00, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x01, 0xE0,
  0x01, 0xE0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xE0,
  0x38, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x1C, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x03,
  0x80, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x01, 0xC0, 0x07,
  0xC0, 0x38, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x0F, 0xC0, 0x0F,
  0x03, 0xB8, 0x01, 0xF1, 0xE7, 0x00, 0x1F, 0xF8, 0xE0, 0x01, 0xFE, 0x18,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFC, 0x00, 0xFF,
  0xE0, 0x3E, 0x0F, 0x03, 0x80, 0x70, 0x70, 0x07, 0x0F, 0x00, 0x70, 0xE0,
  0x07, 0x1C, 0x00, 0x71, 0xC0, 0x0F, 0x38, 0x00, 0xE3, 0x80, 0x1E, 0x78,
  0x03, 0xC7, 0x00, 0xF8, 0x70, 0x7F, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x01, 0x03, 0xE0, 0xF0, 0x1F, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0xA0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xFC, 0x70, 0x07, 0xFF, 0x98, 0x03, 0xE0, 0xE6, 0x00, 0xF0, 0x1B, 0x80,
  0x78, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x0F,
  0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x0E, 0x00,
  0x0E, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x1C,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xF0,
  0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x80, 0xE0, 0x01,
  0xE0, 0x38, 0x00, 0xF8, 0x0E, 0x00, 0x3E, 0x03, 0xC0, 0x1F, 0x00, 0xF0,
  0x0F, 0xC0, 0x1E, 0x07, 0x70, 0x07, 0xC7, 0x9C, 0x00, 0xFF, 0xCF, 0x00,
  0x1F, 0xE3, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x20, 0x03, 0xC0, 0x0C,
  0x01, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x7C, 0x00, 0xE3, 0xFE, 0x01, 0xCF, 0xFE, 0x03,
  0xB8, 0x3C, 0x0E, 0xE0, 0x3C, 0x1F, 0x80, 0x78, 0x3E, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0xF0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xF0, 0xF0, 0x01, 0xC1, 0xC0, 0x03,
  0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x87, 0x80, 0x0E, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xE1, 0xE0,
  0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x00, 0x00,
  0x60, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x07, 0x81, 0xC0, 0x1E, 0x03, 0x80, 0x78, 0x0F,
  0x01, 0xE0, 0x1C, 0x07, 0x80, 0x38, 0x0E, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x0F, 0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x70,
  0x00, 0x39, 0xC0, 0x00, 0xE7, 0xC0, 0x01, 0xDF, 0x80, 0x03, 0xF7, 0x00,
  0x07, 0xCE, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x38, 0x00,
  0xE0, 0x78, 0x01, 0xC0, 0xF0, 0x07, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x01, 0xE0, 0x0E, 0x03, 0x80,
  0x1E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x38, 0xFF, 0x07,
  0xFC, 0x03, 0x9F, 0xF8, 0xFF, 0xE0, 0x33, 0x87, 0x9E, 0x1E, 0x07, 0x60,
  0x3F, 0x80, 0xF0, 0x7C, 0x01, 0xF0, 0x07, 0x07, 0xC0, 0x1E, 0x00, 0x70,
  0x78, 0x01, 0xE0, 0x07, 0x07, 0x80, 0x1C, 0x00, 0x70, 0xF0, 0x03, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x1E, 0x00, 0x78, 0x01, 0xE1,
  0xC0, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x00,
  0x1C, 0x3C, 0x00, 0x70, 0x01, 0xC3, 0x80, 0x0F, 0x00, 0x38, 0x38, 0x00,
  0xE0, 0x03, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x03, 0x87,
  0x80, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x70, 0x01, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xF0, 0x03,
  0xC0, 0x0F, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x07, 0x1F, 0xF0, 0x0E, 0x7F,
  0xF0, 0x19, 0xC1, 0xE0, 0x77, 0x01, 0xE0, 0xFC, 0x03, 0xC1, 0xF0, 0x07,
  0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x07, 0x87, 0x80, 0x0E, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xF0, 0xF0, 0x01, 0xC1, 0xC0,
  0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x3C, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0F,
  0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xE0,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xF8, 0x3C, 0x07,
  0x80, 0x78, 0x1C, 0x00, 0xE0, 0xF0, 0x03, 0x83, 0x80, 0x0F, 0x1C, 0x00,
  0x1C, 0x70, 0x00, 0x73, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x3D,
  0xE0, 0x00, 0xF7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0xC0,
  0x00, 0xEF, 0x00, 0x07, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x73, 0x80, 0x01,
  0xCE, 0x00, 0x0F, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x0F,
  0x00, 0x3C, 0x1C, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0xF8, 0xF8, 0x01, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0E,
  0x3F, 0xE0, 0x01, 0xCF, 0xFE, 0x00, 0x33, 0x83, 0xC0, 0x0E, 0xE0, 0x3C,
  0x01, 0xD8, 0x03, 0x80, 0x3E, 0x00, 0x70, 0x07, 0xC0, 0x0E, 0x00, 0xF0,
  0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xE0,
  0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x1C, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x03,
  0xC0, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01,
  0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0E, 0x01, 0xE0, 0x03, 0xC0, 0x3C,
  0x00, 0xF0, 0x07, 0xC0, 0x1C, 0x01, 0xDC, 0x07, 0x80, 0x39, 0xC3, 0xE0,
  0x07, 0x3F, 0xF8, 0x00, 0xE3, 0xFC, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xC7, 0x01, 0xFF, 0xC6, 0x03, 0xE0, 0xEE, 0x03, 0xC0, 0x6E, 0x07, 0x80,
  0x3E, 0x0F, 0x00, 0x3E, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x78, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78, 0xF0, 0x00,
  0x70, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xE0, 0xE0, 0x03,
  0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x0F, 0xC0, 0x78, 0x1D, 0xC0, 0x7C, 0x79,
  0xC0, 0x3F, 0xF3, 0xC0, 0x1F, 0xE3, 0x80, 0x03, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xE0, 0x71, 0xF8, 0x0E, 0x7F, 0x01, 0x9E, 0x20, 0x77,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x03, 0xFF,
  0xF0, 0x78, 0x0E, 0x0F, 0x00, 0x20, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x80, 0x1E, 0x0F, 0x07, 0xC0, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x3F, 0xFD, 0xFF, 0xE0, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF1, 0x03, 0xFC, 0x07, 0xF0,
  0x02, 0x00, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x70, 0x70,
  0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x0F, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03,
  0xC3, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x78, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07,
  0x00, 0x1E, 0x1E, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xE0,
  0x07, 0xC1, 0xC0, 0x0F, 0x83, 0x80, 0x36, 0x07, 0x80, 0xDC, 0x07, 0x8F,
  0xB8, 0x0F, 0xFE, 0x70, 0x0F, 0xF0, 0xE0, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x7E, 0x00, 0x0E, 0xE0, 0x00, 0xEF, 0x00, 0x1C, 0xF0, 0x01, 0xC7, 0x00,
  0x38, 0x70, 0x03, 0x87, 0x00, 0x78, 0x70, 0x07, 0x07, 0x00, 0xF0, 0x70,
  0x0E, 0x07, 0x01, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0x70, 0x38, 0x07,
  0x03, 0x80, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00,
  0x71, 0xC0, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x77, 0x00,
  0x03, 0x70, 0x00, 0x36, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x0F, 0x00, 0x3F,
  0x80, 0x1E, 0x00, 0x77, 0x00, 0x7C, 0x00, 0xEE, 0x00, 0xD8, 0x03, 0x9C,
  0x03, 0xB0, 0x07, 0x38, 0x07, 0x60, 0x1E, 0x70, 0x1C, 0xC0, 0x38, 0xE0,
  0x39, 0x80, 0x71, 0xC0, 0x63, 0x01, 0xC3, 0x81, 0xC6, 0x03, 0x87, 0x03,
  0x8C, 0x0E, 0x0E, 0x0E, 0x18, 0x1C, 0x1C, 0x1C, 0x30, 0x78, 0x38, 0x70,
  0x60, 0xE0, 0x70, 0xE0, 0xC1, 0xC0, 0xE1, 0x81, 0x87, 0x01, 0xC7, 0x03,
  0x0E, 0x03, 0x8E, 0x06, 0x3C, 0x07, 0x38, 0x0C, 0x70, 0x0E, 0x70, 0x18,
  0xE0, 0x1D, 0xC0, 0x33, 0x80, 0x3B, 0x80, 0x67, 0x00, 0x77, 0x00, 0xDC,
  0x00, 0xFC, 0x01, 0xB8, 0x01, 0xF8, 0x03, 0x70, 0x03, 0x60, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x07, 0x80,
  0x78, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xC0,
  0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x0E, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x0F,
  0x01, 0xC0, 0x07, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x07, 0x80, 0x1C, 0x03,
  0x80, 0x0E, 0x03, 0x80, 0x07, 0x80, 0x00, 0x38, 0x00, 0x3C, 0x00, 0xE0,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x00, 0xE0, 0x03, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x38, 0x03, 0xC0, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70,
  0xE0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x73, 0x80, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x02, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x3F, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xD0, 0x00, 0xFE,
  0x00,
};

const GFXglyph NotoSans_Condensed_LightItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 42, 13, 1, -42 },
  { 70, 14, 15, 19, 6, -42 },
  { 97, 27, 42, 27, 1, -42 },
  { 239, 24, 48, 25, 1, -45 },
  { 383, 32, 44, 37, 3, -43 },
  { 559, 26, 44, 28, 0, -43 },
  { 702, 6, 15, 10, 6, -42 },
  { 714, 17, 51, 15, 2, -42 },
  { 823, 17, 51, 15, -4, -42 },
  { 932, 18, 20, 24, 7, -45 },
  { 977, 23, 28, 27, 3, -35 },
  { 1058, 9, 14, 11, -3, -6 },
  { 1074, 14, 3, 16, 1, -17 },
  { 1080, 5, 5, 11, 1, -5 },
  { 1084, 26, 42, 19, -3, -42 },
  { 1221, 22, 44, 25, 2, -43 },
  { 1342, 14, 42, 25, 7, -42 },
  { 1416, 25, 43, 25, -1, -43 },
  { 1551, 25, 44, 25, 0, -43 },
  { 1689, 26, 42, 25, -1, -42 },
  { 1826, 25, 43, 25, 0, -42 },
  { 1961, 24, 44, 25, 2, -43 },
  { 2093, 24, 42, 25, 3, -42 },
  { 2219, 25, 44, 25, 0, -43 },
  { 2357, 23, 44, 25, 1, -43 },
  { 2484, 10, 32, 12, 1, -32 },
  { 2524, 14, 40, 12, -3, -32 },
  { 2594, 23, 26, 27, 3, -34 },
  { 2669, 22, 15, 27, 3, -28 },
  { 2711, 23, 26, 27, 3, -34 },
  { 2786, 18, 43, 18, 2, -43 },
  { 2883, 34, 47, 38, 2, -42 },
  { 3083, 25, 42, 25, -4, -42 },
  { 3215, 26, 42, 27, 1, -42 },
  { 3352, 26, 44, 25, 3, -43 },
  { 3495, 28, 42, 30, 1, -42 },
  { 3642, 25, 42, 24, 1, -42 },
  { 3774, 25, 42, 22, 1, -42 },
  { 3906, 29, 44, 32, 3, -43 },
  { 4066, 31, 42, 31, 1, -42 },
  { 4229, 20, 42, 14, -2, -42 },
  { 4334, 22, 53, 12, -9, -42 },
  { 4480, 29, 42, 25, 1, -42 },
  { 4633, 16, 42, 22, 1, -42 },
  { 4717, 40, 42, 40, 1, -42 },
  { 4927, 32, 42, 32, 1, -42 },
  { 5095, 28, 44, 32, 3, -43 },
  { 5249, 25, 42, 26, 1, -42 },
  { 5381, 28, 53, 32, 3, -43 },
  { 5567, 25, 42, 26, 1, -42 },
  { 5699, 26, 44, 24, -1, -43 },
  { 5842, 22, 42, 22, 5, -42 },
  { 5958, 29, 43, 31, 3, -42 },
  { 6114, 25, 42, 25, 5, -42 },
  { 6246, 39, 42, 41, 6, -42 },
  { 6451, 30, 42, 23, -3, -42 },
  { 6609, 22, 42, 22, 5, -42 },
  { 6725, 28, 42, 23, -2, -42 },
  { 6872, 22, 51, 17, -1, -42 },
  { 7013, 9, 42, 19, 6, -42 },
  { 7061, 22, 51, 17, -4, -42 },
  { 7202, 23, 23, 26, 2, -42 },
  { 7269, 19, 3, 18, -5, 5 },
  { 7277, 7, 9, 14, 9, -45 },
  { 7285, 24, 33, 26, 2, -32 },
  { 7384, 24, 46, 26, 1, -45 },
  { 7522, 19, 33, 20, 2, -32 },
  { 7601, 27, 46, 27, 2, -45 },
  { 7757, 20, 33, 23, 2, -32 },
  { 7840, 28, 59, 14, -7, -45 },
  { 8047, 26, 46, 27, 0, -32 },
  { 8197, 23, 45, 26, 1, -45 },
  { 8327, 12, 43, 11, 1, -43 },
  { 8392, 21, 57, 11, -8, -43 },
  { 8542, 23, 45, 22, 1, -45 },
  { 8672, 12, 45, 11, 1, -45 },
  { 8740, 36, 32, 39, 1, -32 },
  { 8884, 23, 32, 26, 1, -32 },
  { 8976, 22, 33, 26, 2, -32 },
  { 9067, 27, 46, 26, -2, -32 },
  { 9223, 24, 46, 27, 2, -32 },
  { 9361, 19, 32, 17, 1, -32 },
  { 9437, 20, 33, 20, 0, -32 },
  { 9520, 14, 40, 14, 2, -39 },
  { 9590, 23, 32, 26, 2, -31 },
  { 9682, 20, 31, 20, 3, -31 },
  { 9760, 31, 31, 33, 4, -31 },
  { 9881, 25, 31, 21, -2, -31 },
  { 9978, 30, 45, 21, -6, -31 },
  { 10147, 22, 31, 18, -2, -31 },
  { 10233, 22, 51, 19, 1, -42 },
  { 10374, 3, 59, 24, 11, -45 },
  { 10397, 21, 51, 19, -3, -42 },
  { 10531, 23, 6, 27, 3, -24 },
};

const GFXfont NotoSans_Condensed_LightItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC59PT7B_H_
