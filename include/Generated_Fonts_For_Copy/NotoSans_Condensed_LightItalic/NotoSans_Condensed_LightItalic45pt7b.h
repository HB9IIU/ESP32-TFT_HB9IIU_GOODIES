#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC45PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x38, 0x0E, 0x03, 0x80, 0x70, 0xDC, 0x37, 0x1D, 0x87, 0x61, 0x98,
  0x6E, 0x1B, 0x0E, 0xC3, 0x30, 0xCC, 0x30, 0x00, 0x18, 0x38, 0x00, 0x60,
  0xC0, 0x03, 0x03, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01, 0xC1, 0x80,
  0x06, 0x06, 0x00, 0x18, 0x30, 0x00, 0x60, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC0, 0x30, 0x60, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x00, 0x18, 0x30,
  0x00, 0xC0, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x30, 0x60, 0x01,
  0x81, 0x80, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0xC0, 0xC0, 0x03, 0x06,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x06, 0x0C, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0xC0, 0x03, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0xC0, 0xE2, 0x10, 0x38, 0xC0, 0x06, 0x18, 0x01, 0xC3, 0x00, 0x38,
  0x40, 0x07, 0x08, 0x00, 0xE3, 0x00, 0x0C, 0x60, 0x01, 0xCC, 0x00, 0x1D,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x2E, 0x00, 0x04,
  0xE0, 0x01, 0x8C, 0x00, 0x31, 0xC0, 0x06, 0x18, 0x00, 0x83, 0x00, 0x10,
  0xE0, 0x06, 0x1C, 0x00, 0xC3, 0x08, 0x18, 0xE1, 0xE2, 0x78, 0x3F, 0xFC,
  0x00, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x08, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xC0, 0x1C, 0x1C, 0xC0, 0x18,
  0x18, 0x60, 0x30, 0x30, 0x60, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xE0,
  0x60, 0x60, 0xC0, 0x60, 0x61, 0xC0, 0xC0, 0xC1, 0x80, 0xC0, 0xC3, 0x00,
  0xC0, 0xC3, 0x00, 0xC0, 0xC6, 0x00, 0xC1, 0xCE, 0x18, 0xC1, 0x8C, 0x7C,
  0xC1, 0x98, 0xEE, 0xC3, 0x19, 0x86, 0xC3, 0x31, 0x86, 0xEE, 0x33, 0x07,
  0x7C, 0x63, 0x06, 0x30, 0xE7, 0x06, 0x00, 0xC6, 0x06, 0x01, 0x86, 0x06,
  0x01, 0x86, 0x06, 0x03, 0x0E, 0x06, 0x07, 0x0C, 0x0C, 0x06, 0x0C, 0x0C,
  0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x18, 0x0E, 0x30,
  0x30, 0x07, 0xF0, 0x70, 0x07, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x08, 0x00,
  0x07, 0xF0, 0x00, 0xF7, 0x80, 0x0C, 0x38, 0x01, 0xC1, 0x80, 0x18, 0x18,
  0x03, 0x81, 0x80, 0x38, 0x18, 0x03, 0x83, 0x80, 0x38, 0x30, 0x03, 0x87,
  0x00, 0x18, 0x60, 0x01, 0x8C, 0x00, 0x1D, 0x80, 0x01, 0xF0, 0x00, 0x0E,
  0x00, 0x03, 0xE0, 0x00, 0x76, 0x00, 0x0E, 0x70, 0x31, 0xC7, 0x07, 0x38,
  0x38, 0x63, 0x03, 0x8E, 0x70, 0x18, 0xC6, 0x01, 0xCC, 0x60, 0x0D, 0x8E,
  0x00, 0xF8, 0xE0, 0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x0F, 0x06, 0x01, 0xF0,
  0x70, 0x7B, 0x83, 0xFE, 0x18, 0x1F, 0xC1, 0xC0, 0x77, 0x76, 0x66, 0xEC,
  0xCC, 0xC0, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0,
  0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x20, 0x60, 0xE1, 0x83, 0xE4, 0x01, 0xF7, 0xC1, 0xFF,
  0x07, 0x00, 0x36, 0x01, 0x88, 0x0E, 0x30, 0x70, 0xC0, 0x81, 0x80, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x1C,
  0x30, 0xE1, 0x87, 0x0C, 0x18, 0x60, 0xC3, 0x00, 0xFF, 0xFF, 0xF0, 0x7F,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x1F, 0x80, 0x1F, 0xF0, 0x07, 0x0E, 0x03, 0x81, 0x81, 0xC0, 0x60, 0x60,
  0x1C, 0x38, 0x07, 0x0C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x60, 0x07,
  0x38, 0x01, 0x8E, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x70, 0x03, 0x9C,
  0x00, 0xE7, 0x00, 0x31, 0x80, 0x0C, 0x60, 0x07, 0x18, 0x01, 0xC6, 0x00,
  0x61, 0x80, 0x18, 0xE0, 0x0E, 0x38, 0x03, 0x06, 0x01, 0xC1, 0x80, 0x60,
  0x60, 0x38, 0x1C, 0x1C, 0x07, 0x0E, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x00,
  0x01, 0xC1, 0xE0, 0xF8, 0x76, 0x7B, 0xBC, 0xEC, 0x32, 0x0C, 0x07, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0,
  0x3C, 0x0E, 0x01, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0x80,
  0xE0, 0x20, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x20, 0x1E, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0x60, 0x00, 0xFC, 0x00, 0x1B,
  0x00, 0x06, 0x60, 0x01, 0xCC, 0x00, 0x33, 0x80, 0x0C, 0x70, 0x03, 0x8C,
  0x00, 0x61, 0x80, 0x18, 0x30, 0x06, 0x0E, 0x01, 0xC1, 0xC0, 0x30, 0x30,
  0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x18, 0x07, 0x07, 0x00, 0xC0,
  0xC0, 0x18, 0x3F, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x03, 0x00,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC1, 0x80,
  0xF0, 0x3F, 0xFC, 0x03, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xF0, 0x0F,
  0xF8, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x7C, 0x07, 0x7F, 0x81, 0xB8, 0xF0, 0x78, 0x0E, 0x3C, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x18, 0xE0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x38,
  0xC0, 0x0E, 0x30, 0x03, 0x0C, 0x01, 0xC3, 0x00, 0x70, 0xC0, 0x38, 0x38,
  0x0C, 0x07, 0x07, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0xF0, 0x07, 0xFF, 0x01, 0xC0, 0xE0, 0x30, 0x0E, 0x0E, 0x00, 0xC1,
  0xC0, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x1C, 0x1C, 0x03, 0x03,
  0x80, 0xE0, 0x30, 0x38, 0x07, 0x0E, 0x00, 0x77, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7F, 0x00, 0x3C, 0x70, 0x0E, 0x07, 0x03, 0x80, 0x60, 0xE0,
  0x0E, 0x1C, 0x00, 0xC3, 0x00, 0x18, 0xE0, 0x03, 0x1C, 0x00, 0x63, 0x80,
  0x0C, 0x70, 0x03, 0x86, 0x00, 0x70, 0xE0, 0x1C, 0x1E, 0x07, 0x01, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0xE0,
  0x60, 0x60, 0x38, 0x70, 0x0C, 0x70, 0x06, 0x38, 0x03, 0x18, 0x01, 0x9C,
  0x00, 0xCE, 0x00, 0x67, 0x00, 0x33, 0x00, 0x19, 0x80, 0x1C, 0xC0, 0x0E,
  0x70, 0x0F, 0x38, 0x07, 0x8E, 0x07, 0x87, 0xCE, 0xC1, 0xFE, 0x60, 0x38,
  0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x01, 0xFF, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0x07, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x70, 0xF0, 0x60, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07,
  0x01, 0x80, 0x60, 0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1C,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x80, 0x1F, 0xF0, 0x7F, 0xF0, 0x40, 0xE0, 0x00, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x60, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xE0,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0x00, 0x01, 0x80,
  0xC0, 0x00, 0x30, 0x30, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x61, 0x80, 0xFE,
  0x0C, 0x70, 0x3F, 0xC1, 0x8C, 0x0C, 0x18, 0x31, 0x83, 0x87, 0x06, 0x60,
  0x60, 0xC0, 0xCC, 0x18, 0x18, 0x39, 0x83, 0x03, 0x06, 0x60, 0xC0, 0xE0,
  0xCC, 0x18, 0x18, 0x19, 0x83, 0x03, 0x03, 0x30, 0xE0, 0x60, 0xC6, 0x1C,
  0x1C, 0x18, 0xC3, 0x03, 0x07, 0x18, 0x60, 0xE0, 0xC7, 0x0C, 0x14, 0x30,
  0xE0, 0xC6, 0xCE, 0x0C, 0x1F, 0x9F, 0x81, 0x81, 0xE1, 0xE0, 0x30, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03, 0x30, 0x00, 0xE6,
  0x00, 0x18, 0xC0, 0x07, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x07, 0x0C,
  0x00, 0xC1, 0x80, 0x38, 0x30, 0x06, 0x07, 0x01, 0xC0, 0xE0, 0x30, 0x1C,
  0x0F, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFE, 0x0E, 0x01, 0xC1, 0x80, 0x38,
  0x70, 0x07, 0x0C, 0x00, 0xE3, 0x80, 0x1C, 0x60, 0x01, 0x9C, 0x00, 0x33,
  0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00, 0x1F, 0x00, 0x03, 0x03, 0xFF, 0x00,
  0x3F, 0xFC, 0x03, 0x01, 0xE0, 0x30, 0x0E, 0x07, 0x00, 0x70, 0x70, 0x07,
  0x07, 0x00, 0x70, 0x60, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x06, 0x0E, 0x00,
  0xE0, 0xC0, 0x0C, 0x0C, 0x01, 0xC0, 0xC0, 0x78, 0x1F, 0xFE, 0x01, 0xFF,
  0xC0, 0x18, 0x1E, 0x01, 0x80, 0x70, 0x18, 0x03, 0x83, 0x80, 0x38, 0x38,
  0x01, 0x83, 0x00, 0x18, 0x30, 0x01, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87,
  0x00, 0x38, 0x60, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x1E, 0x0E, 0x07, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x03, 0xFF, 0x00, 0x7F,
  0xF0, 0x1E, 0x02, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x04, 0x01, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xC0, 0xF8,
  0x06, 0x01, 0xC0, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xC0, 0xC0,
  0x07, 0x06, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x18, 0x00, 0x70,
  0xC0, 0x03, 0x86, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x06, 0x18, 0x00,
  0x30, 0xC0, 0x03, 0x86, 0x00, 0x1C, 0x70, 0x00, 0xC3, 0x80, 0x0E, 0x18,
  0x00, 0x70, 0xC0, 0x03, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x83, 0x00, 0x1C,
  0x18, 0x01, 0xC0, 0xC0, 0x1C, 0x0E, 0x03, 0xC0, 0x70, 0xFC, 0x03, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x10, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFE,
  0x03, 0xFF, 0xC0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x0F, 0x00, 0x60,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x1F, 0xE3, 0x80, 0x3F, 0xC7, 0x00, 0x03, 0x0E, 0x00, 0x06,
  0x1C, 0x00, 0x0C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xC1,
  0xC0, 0x01, 0x81, 0x80, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x30, 0x0F, 0x00, 0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x03,
  0x80, 0x06, 0x07, 0x00, 0x1C, 0x0C, 0x00, 0x38, 0x18, 0x00, 0x70, 0x70,
  0x00, 0xC0, 0xE0, 0x01, 0x81, 0xC0, 0x07, 0x03, 0x00, 0x0E, 0x06, 0x00,
  0x18, 0x1C, 0x00, 0x30, 0x38, 0x00, 0x60, 0x60, 0x01, 0xC0, 0xC0, 0x03,
  0x81, 0x80, 0x06, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x18, 0x00, 0x70,
  0x30, 0x00, 0xE0, 0xE0, 0x01, 0x81, 0xC0, 0x03, 0x03, 0x80, 0x0E, 0x06,
  0x00, 0x1C, 0x0C, 0x00, 0x30, 0x38, 0x00, 0x60, 0x70, 0x00, 0xC0, 0xC0,
  0x03, 0x81, 0x80, 0x07, 0x03, 0x00, 0x0C, 0x0E, 0x00, 0x18, 0x1C, 0x00,
  0x30, 0x30, 0x00, 0xE0, 0x60, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0xFC, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x04, 0x38, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0x03, 0x80, 0x3C, 0x0E, 0x00, 0xE0, 0x30, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x70, 0x01, 0x81, 0xC0, 0x06, 0x0E,
  0x00, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x1C, 0x00, 0x0C, 0x70, 0x00,
  0x33, 0x80, 0x01, 0xDC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x79,
  0x80, 0x03, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x30, 0x00, 0xC0, 0xC0,
  0x03, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x18, 0x01, 0xC0, 0x70, 0x06,
  0x01, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x0C, 0x03, 0x80, 0x38, 0x0C, 0x00,
  0xE0, 0x30, 0x01, 0x80, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xD8, 0x1F,
  0x00, 0x03, 0x60, 0x6C, 0x00, 0x1B, 0x81, 0xB8, 0x00, 0x6E, 0x06, 0xE0,
  0x03, 0x30, 0x3B, 0x80, 0x0C, 0xC0, 0xEE, 0x00, 0x67, 0x03, 0x18, 0x01,
  0x9C, 0x0C, 0x60, 0x0C, 0x60, 0x31, 0x80, 0x31, 0x81, 0xC6, 0x01, 0x86,
  0x07, 0x18, 0x06, 0x38, 0x18, 0x60, 0x30, 0xE0, 0x61, 0x80, 0xC3, 0x03,
  0x86, 0x06, 0x0C, 0x0E, 0x18, 0x18, 0x30, 0x30, 0x70, 0xC1, 0xC0, 0xC1,
  0xC3, 0x07, 0x03, 0x07, 0x18, 0x18, 0x1C, 0x0C, 0x60, 0x60, 0x70, 0x33,
  0x03, 0x81, 0x80, 0xCC, 0x0E, 0x06, 0x03, 0x60, 0x30, 0x18, 0x0D, 0x80,
  0xC0, 0xE0, 0x3C, 0x03, 0x03, 0x80, 0xF0, 0x1C, 0x0C, 0x03, 0x80, 0x70,
  0x30, 0x0E, 0x01, 0x80, 0x03, 0x80, 0x03, 0x03, 0xC0, 0x03, 0x03, 0xC0,
  0x07, 0x03, 0xC0, 0x06, 0x07, 0xC0, 0x06, 0x07, 0xE0, 0x06, 0x06, 0x60,
  0x0E, 0x06, 0x60, 0x0E, 0x06, 0x60, 0x0C, 0x0E, 0x70, 0x0C, 0x0E, 0x70,
  0x0C, 0x0C, 0x30, 0x1C, 0x0C, 0x30, 0x1C, 0x0C, 0x38, 0x18, 0x1C, 0x38,
  0x18, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x38, 0x18, 0x1C, 0x38, 0x38, 0x1C,
  0x30, 0x38, 0x0C, 0x30, 0x30, 0x0C, 0x70, 0x30, 0x0E, 0x70, 0x30, 0x0E,
  0x60, 0x70, 0x06, 0x60, 0x70, 0x06, 0x60, 0x60, 0x07, 0xE0, 0x60, 0x07,
  0xE0, 0x60, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0xC0, 0x03,
  0xC0, 0xC0, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0x80, 0xE0, 0x38, 0x03, 0x03, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0,
  0x03, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00, 0x06, 0x70, 0x00, 0x33,
  0x00, 0x01, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x07, 0x60, 0x00,
  0x3B, 0x00, 0x01, 0xF8, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00, 0x07, 0x70,
  0x00, 0x3B, 0x80, 0x01, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x0E,
  0x38, 0x00, 0x70, 0xC0, 0x07, 0x07, 0x00, 0x70, 0x38, 0x07, 0x80, 0xF0,
  0x78, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF0,
  0x0C, 0x0F, 0x01, 0x80, 0xE0, 0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38,
  0x30, 0x07, 0x06, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x86, 0x00, 0x60,
  0xC0, 0x1C, 0x18, 0x03, 0x87, 0x00, 0xE0, 0xE0, 0x38, 0x18, 0x7E, 0x03,
  0xFF, 0x80, 0x7F, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0x80, 0xE0, 0x38, 0x03,
  0x03, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0x1C, 0x00, 0x18, 0xE0,
  0x00, 0xC6, 0x00, 0x06, 0x70, 0x00, 0x33, 0x00, 0x01, 0xB8, 0x00, 0x0D,
  0xC0, 0x00, 0x6E, 0x00, 0x07, 0x60, 0x00, 0x3B, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x6E, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0x9C,
  0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0x70, 0xC0, 0x07,
  0x07, 0x00, 0x70, 0x38, 0x07, 0x80, 0xF0, 0x78, 0x03, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xF0, 0x0C, 0x0F, 0x01, 0x80, 0xE0, 0x70, 0x0E, 0x0E,
  0x01, 0xC1, 0xC0, 0x38, 0x30, 0x07, 0x06, 0x00, 0xE1, 0xC0, 0x1C, 0x38,
  0x03, 0x86, 0x00, 0x60, 0xC0, 0x1C, 0x18, 0x07, 0x07, 0x01, 0xE0, 0xE0,
  0x78, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x61, 0xC0, 0x1C, 0x18, 0x03, 0x83,
  0x00, 0x60, 0x70, 0x0C, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x81, 0x80, 0x70, 0x30, 0x0E, 0x0E, 0x00, 0xC1, 0xC0, 0x1C, 0x30, 0x03,
  0x86, 0x00, 0x70, 0x00, 0x06, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1E,
  0x02, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x08, 0x00, 0xE0, 0x60, 0x3C, 0x0F, 0xFF, 0x80, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x0C, 0x18, 0x00, 0x70,
  0x60, 0x01, 0xC3, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x38, 0x00, 0xE0, 0xC0,
  0x03, 0x83, 0x00, 0x0C, 0x1C, 0x00, 0x30, 0x70, 0x00, 0xC1, 0x80, 0x07,
  0x06, 0x00, 0x1C, 0x18, 0x00, 0x60, 0xE0, 0x01, 0x83, 0x80, 0x06, 0x0C,
  0x00, 0x38, 0x30, 0x00, 0xE1, 0xC0, 0x03, 0x07, 0x00, 0x0C, 0x1C, 0x00,
  0x70, 0x60, 0x01, 0xC1, 0x80, 0x06, 0x0E, 0x00, 0x18, 0x38, 0x00, 0xE0,
  0xE0, 0x03, 0x83, 0x80, 0x0C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xE0, 0x70, 0x03, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xE0, 0x00,
  0xFC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x06,
  0x38, 0x01, 0xC7, 0x00, 0x30, 0xE0, 0x0E, 0x1C, 0x01, 0x83, 0x80, 0x70,
  0x70, 0x0C, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x1C, 0x03, 0x03, 0x80,
  0x60, 0x60, 0x0C, 0x1C, 0x01, 0x83, 0x00, 0x30, 0xE0, 0x06, 0x18, 0x00,
  0xC7, 0x00, 0x18, 0xC0, 0x03, 0x38, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01,
  0xB8, 0x00, 0x36, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x0E, 0x00, 0x7E, 0x00, 0x78,
  0x01, 0xB8, 0x01, 0xE0, 0x0E, 0xE0, 0x0F, 0x80, 0x3B, 0x80, 0x3E, 0x00,
  0xCE, 0x01, 0xF8, 0x07, 0x38, 0x06, 0xE0, 0x18, 0xE0, 0x1B, 0x80, 0xE3,
  0x80, 0xCE, 0x03, 0x0E, 0x03, 0x38, 0x1C, 0x38, 0x1C, 0xE0, 0x70, 0xE0,
  0x63, 0x81, 0x83, 0x81, 0x8E, 0x0E, 0x0E, 0x0C, 0x30, 0x30, 0x38, 0x30,
  0xC1, 0xC0, 0xE1, 0xC3, 0x07, 0x03, 0x86, 0x0C, 0x18, 0x0E, 0x38, 0x30,
  0xE0, 0x38, 0xC0, 0xC3, 0x00, 0xE3, 0x03, 0x1C, 0x03, 0x98, 0x0C, 0x60,
  0x0E, 0x60, 0x31, 0x80, 0x3B, 0x80, 0xCE, 0x00, 0xEC, 0x03, 0x30, 0x03,
  0xB0, 0x0D, 0xC0, 0x0D, 0x80, 0x36, 0x00, 0x36, 0x00, 0xD8, 0x00, 0xF8,
  0x03, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x0C, 0x00,
  0x60, 0x1C, 0x00, 0x60, 0x38, 0x00, 0x70, 0x30, 0x00, 0x70, 0x70, 0x00,
  0x30, 0xE0, 0x00, 0x30, 0xC0, 0x00, 0x31, 0xC0, 0x00, 0x39, 0x80, 0x00,
  0x3B, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0xC6, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x86, 0x00, 0x03,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x06, 0x03, 0x00, 0x0E, 0x03, 0x00, 0x1C,
  0x03, 0x00, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x03, 0x80, 0xE0,
  0x01, 0x80, 0xC0, 0x03, 0xF0, 0x03, 0xB8, 0x01, 0x9C, 0x01, 0xC6, 0x01,
  0xC3, 0x00, 0xE1, 0x80, 0xE0, 0xC0, 0x60, 0x70, 0x70, 0x38, 0x30, 0x0C,
  0x38, 0x06, 0x18, 0x03, 0x1C, 0x01, 0x9C, 0x00, 0xCC, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xC3, 0x0C, 0x30,
  0xC3, 0x86, 0x18, 0x61, 0x86, 0x18, 0x70, 0xC3, 0x0C, 0x30, 0xC3, 0x8E,
  0x18, 0x61, 0x86, 0x18, 0x71, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0xFF, 0x80,
  0x7F, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x03, 0x60, 0x01, 0xDC, 0x00, 0x63, 0x00, 0x38, 0xC0,
  0x0C, 0x38, 0x06, 0x06, 0x01, 0x81, 0x80, 0xC0, 0x70, 0x70, 0x0C, 0x18,
  0x03, 0x8E, 0x00, 0x63, 0x00, 0x19, 0xC0, 0x07, 0xE0, 0x00, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF8, 0xE7, 0x18, 0xE3, 0x0C, 0x60, 0x01, 0xF8, 0xC1, 0xFE,
  0x60, 0xF0, 0xD8, 0x70, 0x16, 0x1C, 0x07, 0x8E, 0x01, 0xC3, 0x00, 0x71,
  0xC0, 0x1C, 0x70, 0x07, 0x18, 0x01, 0xCE, 0x00, 0x63, 0x80, 0x18, 0xC0,
  0x06, 0x30, 0x03, 0x8C, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x1C, 0x30, 0x07,
  0x0C, 0x03, 0xC3, 0x00, 0xF0, 0xE0, 0x78, 0x38, 0x36, 0x07, 0xF9, 0x80,
  0xFC, 0x60, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0xFC, 0x03, 0xBF, 0xC0, 0x6E, 0x1C, 0x0F, 0x01, 0x81,
  0xE0, 0x38, 0x78, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x30, 0x03, 0x86,
  0x00, 0x71, 0xC0, 0x0C, 0x38, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x0E, 0x38,
  0x01, 0xC7, 0x00, 0x30, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x70, 0xF0,
  0x0E, 0x1A, 0x03, 0x83, 0x60, 0xE0, 0x6F, 0xF8, 0x1C, 0xFE, 0x00, 0x01,
  0xFC, 0x1F, 0xF0, 0xF0, 0x47, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01,
  0xC1, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x3F, 0x38, 0x07, 0xFD,
  0x80, 0x78, 0x6C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x03, 0x80, 0x38, 0x18,
  0x01, 0x81, 0xC0, 0x0C, 0x0E, 0x00, 0xE0, 0x60, 0x07, 0x07, 0x00, 0x38,
  0x38, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0xE0, 0x60, 0x07, 0x03, 0x00,
  0x30, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x06, 0x01, 0xE0, 0x30, 0x0F, 0x01,
  0xC0, 0xF0, 0x0E, 0x0D, 0x80, 0x3F, 0xCC, 0x00, 0xFC, 0x60, 0x00, 0x01,
  0xF8, 0x0F, 0xF8, 0x38, 0x38, 0xE0, 0x71, 0x80, 0x67, 0x01, 0xCC, 0x03,
  0xB8, 0x06, 0x60, 0x1C, 0xC0, 0x73, 0x87, 0xC7, 0xFE, 0x0F, 0xE0, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0E, 0x04, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x09, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x30, 0x1F, 0xF6, 0x03, 0xC3, 0x60, 0x70, 0x1E, 0x07, 0x01,
  0xE0, 0xE0, 0x0E, 0x0C, 0x00, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0x80,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x18, 0x30, 0x01, 0x83, 0x00, 0x38, 0x30,
  0x03, 0x83, 0x00, 0x30, 0x70, 0x07, 0x07, 0x00, 0x70, 0x30, 0x0F, 0x03,
  0x00, 0xF0, 0x38, 0x1E, 0x03, 0x83, 0x60, 0x1F, 0xE6, 0x00, 0xFC, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x08, 0x07, 0x00, 0xF3, 0xE0, 0x0F, 0xFC,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x73, 0xF0, 0x1D, 0xFE, 0x06, 0xC1, 0xC1, 0xE0, 0x70,
  0x70, 0x0C, 0x3C, 0x03, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x18, 0x30,
  0x06, 0x1C, 0x01, 0x87, 0x00, 0xE1, 0x80, 0x38, 0x60, 0x0C, 0x38, 0x03,
  0x0E, 0x00, 0xC3, 0x80, 0x70, 0xC0, 0x1C, 0x30, 0x06, 0x1C, 0x01, 0x87,
  0x00, 0x61, 0x80, 0x38, 0x60, 0x0E, 0x38, 0x03, 0x00, 0x00, 0x80, 0x70,
  0x1C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x18,
  0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06,
  0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01,
  0x80, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x9C, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x1C, 0x1C, 0x0E, 0x06, 0x03,
  0x01, 0x81, 0xC0, 0x60, 0xE0, 0x38, 0x70, 0x0E, 0x38, 0x03, 0x1C, 0x00,
  0xC6, 0x00, 0x33, 0x80, 0x1D, 0xC0, 0x06, 0xF8, 0x01, 0xFE, 0x00, 0x79,
  0x80, 0x3C, 0x60, 0x0E, 0x1C, 0x03, 0x07, 0x00, 0xC0, 0xC0, 0x30, 0x30,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0x60, 0x60, 0x1C, 0x38, 0x07, 0x00,
  0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0,
  0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x00, 0x07, 0x3F, 0x07, 0xE0, 0x67,
  0xF9, 0xFE, 0x06, 0xC3, 0xB8, 0x70, 0x78, 0x1A, 0x03, 0x07, 0x01, 0xE0,
  0x30, 0xF0, 0x1C, 0x03, 0x0E, 0x01, 0xC0, 0x30, 0xE0, 0x18, 0x07, 0x0C,
  0x01, 0x80, 0x70, 0xC0, 0x38, 0x06, 0x1C, 0x03, 0x00, 0x61, 0xC0, 0x30,
  0x06, 0x18, 0x03, 0x00, 0xE1, 0x80, 0x70, 0x0C, 0x38, 0x07, 0x00, 0xC3,
  0x80, 0x60, 0x0C, 0x38, 0x06, 0x01, 0xC3, 0x00, 0x60, 0x1C, 0x30, 0x0E,
  0x01, 0x87, 0x00, 0xE0, 0x18, 0x70, 0x0C, 0x01, 0x86, 0x00, 0xC0, 0x38,
  0x60, 0x0C, 0x03, 0x8E, 0x01, 0xC0, 0x30, 0x07, 0x3F, 0x01, 0x9F, 0xE0,
  0x6C, 0x1C, 0x1E, 0x07, 0x07, 0x00, 0xC3, 0xC0, 0x30, 0xE0, 0x1C, 0x38,
  0x07, 0x0C, 0x01, 0x83, 0x00, 0x61, 0xC0, 0x18, 0x70, 0x0E, 0x18, 0x03,
  0x86, 0x00, 0xC3, 0x80, 0x30, 0xE0, 0x0C, 0x38, 0x07, 0x0C, 0x01, 0xC3,
  0x00, 0x61, 0xC0, 0x18, 0x70, 0x0E, 0x18, 0x03, 0x86, 0x00, 0xE3, 0x80,
  0x30, 0x01, 0xF8, 0x07, 0xFC, 0x0E, 0x0E, 0x1C, 0x07, 0x18, 0x07, 0x38,
  0x03, 0x30, 0x03, 0x70, 0x03, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0,
  0x1C, 0xC0, 0x1C, 0xC0, 0x38, 0xE0, 0x30, 0xF0, 0xF0, 0x7F, 0xE0, 0x3F,
  0x80, 0x01, 0xCF, 0xC0, 0x0C, 0xFF, 0x00, 0x6E, 0x1C, 0x03, 0x40, 0x60,
  0x1E, 0x03, 0x81, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80,
  0x38, 0x18, 0x01, 0xC1, 0xC0, 0x0C, 0x0E, 0x00, 0x60, 0x60, 0x03, 0x03,
  0x00, 0x38, 0x18, 0x01, 0xC1, 0xC0, 0x0C, 0x0E, 0x00, 0xE0, 0x70, 0x07,
  0x03, 0x80, 0x70, 0x3C, 0x03, 0x81, 0xE0, 0x38, 0x0D, 0x83, 0x80, 0x67,
  0xF8, 0x03, 0x3F, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x60, 0x7F, 0xD8,
  0x1E, 0x1B, 0x07, 0x01, 0xE0, 0xE0, 0x3C, 0x38, 0x03, 0x86, 0x00, 0x61,
  0xC0, 0x0C, 0x38, 0x03, 0x86, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0x86,
  0x00, 0x30, 0xC0, 0x0E, 0x18, 0x01, 0xC3, 0x00, 0x30, 0xE0, 0x0E, 0x1C,
  0x01, 0xC1, 0x80, 0x78, 0x30, 0x0F, 0x07, 0x03, 0xC0, 0xE0, 0xD8, 0x0F,
  0xF3, 0x00, 0xFC, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x06, 0x3E, 0x0C, 0xFC, 0x1B,
  0x80, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0x03, 0xFC, 0x0F, 0xFC, 0x38, 0x10, 0xE0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x10, 0x1C, 0x3F, 0xF0, 0x7F,
  0xC0, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x0F, 0xFB, 0xFF,
  0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x70, 0x07, 0xE0, 0xFC, 0x00, 0x1C, 0x01, 0x8E, 0x01, 0xC6,
  0x00, 0xE3, 0x00, 0x63, 0x80, 0x31, 0xC0, 0x18, 0xC0, 0x1C, 0x60, 0x0E,
  0x30, 0x06, 0x38, 0x03, 0x1C, 0x03, 0x8C, 0x01, 0xC6, 0x00, 0xC3, 0x00,
  0x63, 0x80, 0x31, 0xC0, 0x38, 0xC0, 0x1C, 0x60, 0x1C, 0x30, 0x0E, 0x18,
  0x0F, 0x0C, 0x05, 0x87, 0x0F, 0xC3, 0xFE, 0xC0, 0xFC, 0x60, 0xE0, 0x07,
  0x60, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x38,
  0x60, 0x30, 0x60, 0x70, 0x60, 0x60, 0x60, 0xE0, 0x60, 0xC0, 0x61, 0xC0,
  0x61, 0x80, 0x63, 0x80, 0x63, 0x00, 0x67, 0x00, 0x76, 0x00, 0x76, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0xC0, 0x38,
  0x07, 0xC0, 0x38, 0x06, 0xC0, 0x38, 0x06, 0xC0, 0x78, 0x0E, 0xC0, 0x78,
  0x0C, 0xC0, 0xD8, 0x1C, 0xC0, 0xD8, 0x18, 0xC1, 0xD8, 0x38, 0xC1, 0x98,
  0x38, 0xC1, 0x98, 0x30, 0xC3, 0x18, 0x70, 0xC3, 0x18, 0x60, 0xC6, 0x18,
  0xE0, 0xC6, 0x18, 0xC0, 0xCE, 0x18, 0xC0, 0xCC, 0x19, 0xC0, 0xCC, 0x19,
  0x80, 0xD8, 0x1B, 0x80, 0xD8, 0x1B, 0x00, 0xF0, 0x1B, 0x00, 0xF0, 0x1E,
  0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00,
  0x70, 0x30, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x18, 0x01, 0x83, 0x80, 0x18,
  0x70, 0x01, 0xC6, 0x00, 0x0C, 0xC0, 0x00, 0xDC, 0x00, 0x0D, 0x80, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xB0, 0x00,
  0x3B, 0x00, 0x07, 0x38, 0x00, 0x61, 0x80, 0x0E, 0x18, 0x01, 0xC1, 0xC0,
  0x18, 0x1C, 0x03, 0x80, 0xC0, 0x70, 0x0C, 0x0E, 0x00, 0xE0, 0x00, 0xC0,
  0x0E, 0x01, 0x80, 0x1C, 0x03, 0x00, 0x30, 0x07, 0x00, 0xE0, 0x0E, 0x01,
  0x80, 0x1C, 0x07, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x60,
  0x01, 0xC1, 0xC0, 0x01, 0x83, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x18, 0x00,
  0x0C, 0x70, 0x00, 0x18, 0xC0, 0x00, 0x33, 0x80, 0x00, 0x66, 0x00, 0x00,
  0xCC, 0x00, 0x01, 0xB0, 0x00, 0x03, 0x60, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x8E, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xFF,
  0xF0, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0xF0,
  0x3C, 0x1F, 0xFA, 0x01, 0xFC,
};

const GFXglyph NotoSans_Condensed_LightItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 32, 10, 1, -32 },
  { 41, 10, 11, 14, 5, -32 },
  { 55, 22, 32, 21, 0, -32 },
  { 143, 19, 37, 19, 0, -34 },
  { 231, 24, 34, 28, 3, -33 },
  { 333, 20, 33, 21, 0, -33 },
  { 416, 4, 11, 8, 5, -32 },
  { 422, 13, 39, 11, 1, -32 },
  { 486, 13, 39, 11, -3, -32 },
  { 550, 14, 15, 18, 5, -34 },
  { 577, 17, 21, 21, 2, -26 },
  { 622, 7, 11, 9, -2, -5 },
  { 632, 10, 2, 12, 1, -13 },
  { 635, 3, 4, 9, 1, -4 },
  { 637, 20, 32, 14, -2, -32 },
  { 717, 18, 33, 19, 1, -33 },
  { 792, 10, 32, 19, 6, -32 },
  { 832, 20, 33, 19, -1, -33 },
  { 915, 19, 33, 19, 0, -33 },
  { 994, 19, 32, 19, 0, -32 },
  { 1070, 19, 32, 19, 0, -32 },
  { 1146, 18, 33, 19, 2, -33 },
  { 1221, 18, 32, 19, 2, -32 },
  { 1293, 19, 33, 19, 0, -33 },
  { 1372, 17, 33, 19, 1, -33 },
  { 1443, 8, 24, 9, 0, -24 },
  { 1467, 10, 30, 9, -2, -24 },
  { 1505, 18, 20, 21, 2, -26 },
  { 1550, 17, 12, 21, 2, -22 },
  { 1576, 18, 20, 21, 2, -26 },
  { 1621, 15, 33, 14, 1, -33 },
  { 1683, 27, 36, 29, 1, -32 },
  { 1805, 19, 32, 19, -3, -32 },
  { 1881, 20, 32, 21, 1, -32 },
  { 1961, 20, 33, 19, 2, -33 },
  { 2044, 21, 32, 23, 1, -32 },
  { 2128, 19, 32, 18, 1, -32 },
  { 2204, 19, 32, 17, 1, -32 },
  { 2280, 23, 33, 24, 2, -33 },
  { 2375, 23, 32, 24, 1, -32 },
  { 2467, 16, 32, 11, -2, -32 },
  { 2531, 17, 40, 9, -7, -32 },
  { 2616, 22, 32, 19, 1, -32 },
  { 2704, 12, 32, 17, 1, -32 },
  { 2752, 30, 32, 31, 1, -32 },
  { 2872, 24, 32, 25, 1, -32 },
  { 2968, 21, 33, 25, 2, -33 },
  { 3055, 19, 32, 19, 1, -32 },
  { 3131, 21, 41, 25, 2, -33 },
  { 3239, 19, 32, 20, 1, -32 },
  { 3315, 20, 33, 18, -1, -33 },
  { 3398, 16, 32, 17, 4, -32 },
  { 3462, 22, 32, 23, 2, -32 },
  { 3550, 19, 32, 19, 4, -32 },
  { 3626, 30, 32, 31, 4, -32 },
  { 3746, 24, 32, 17, -3, -32 },
  { 3842, 17, 32, 17, 4, -32 },
  { 3910, 21, 32, 17, -1, -32 },
  { 3994, 17, 39, 13, -1, -32 },
  { 4077, 6, 32, 15, 5, -32 },
  { 4101, 17, 39, 13, -3, -32 },
  { 4184, 18, 17, 20, 1, -32 },
  { 4223, 15, 2, 14, -4, 4 },
  { 4227, 5, 7, 11, 7, -34 },
  { 4232, 18, 24, 20, 2, -24 },
  { 4286, 19, 34, 20, 0, -34 },
  { 4367, 14, 24, 15, 2, -24 },
  { 4409, 21, 34, 20, 1, -34 },
  { 4499, 15, 24, 18, 2, -24 },
  { 4544, 22, 45, 10, -6, -34 },
  { 4668, 20, 35, 20, 0, -24 },
  { 4756, 18, 34, 20, 0, -34 },
  { 4833, 10, 33, 9, 0, -33 },
  { 4875, 16, 44, 9, -6, -33 },
  { 4963, 18, 34, 17, 0, -34 },
  { 5040, 10, 34, 8, 0, -34 },
  { 5083, 28, 24, 30, 0, -24 },
  { 5167, 18, 24, 20, 0, -24 },
  { 5221, 16, 24, 20, 2, -24 },
  { 5269, 21, 34, 20, -2, -24 },
  { 5359, 19, 35, 20, 1, -24 },
  { 5443, 15, 24, 13, 0, -24 },
  { 5488, 15, 24, 15, 0, -24 },
  { 5533, 11, 30, 11, 1, -30 },
  { 5575, 17, 24, 20, 2, -24 },
  { 5626, 16, 24, 15, 2, -24 },
  { 5674, 24, 24, 25, 3, -24 },
  { 5746, 20, 24, 16, -2, -24 },
  { 5806, 23, 35, 16, -5, -24 },
  { 5907, 16, 24, 14, -1, -24 },
  { 5955, 16, 39, 15, 1, -32 },
  { 6033, 3, 45, 19, 8, -34 },
  { 6050, 16, 39, 15, -3, -32 },
  { 6128, 18, 4, 21, 2, -18 },
};

const GFXfont NotoSans_Condensed_LightItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC45PT7B_H_
