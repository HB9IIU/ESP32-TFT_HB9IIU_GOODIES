#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC60PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC60PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0x1C,
  0x1E, 0x78, 0x38, 0xF0, 0x71, 0xC0, 0xE3, 0x83, 0xC7, 0x07, 0x0E, 0x0E,
  0x38, 0x1C, 0x70, 0x38, 0xE0, 0xE1, 0xC1, 0xC3, 0x03, 0x86, 0x07, 0x1C,
  0x0C, 0x38, 0x18, 0x60, 0x70, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x30, 0x1C,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x18, 0x00, 0x06, 0x03, 0x80, 0x00,
  0xE0, 0x38, 0x00, 0x0E, 0x03, 0x00, 0x00, 0xC0, 0x70, 0x00, 0x1C, 0x07,
  0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0x01,
  0xC0, 0x00, 0x70, 0x18, 0x00, 0x06, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x1C, 0x06, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00,
  0x03, 0x80, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x06, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0xE0, 0x30, 0x00, 0x0C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C,
  0x06, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xC0,
  0x00, 0x30, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0xF9, 0x9F, 0x00, 0xF1, 0xC1, 0x80, 0xF0, 0xC0, 0x00, 0x70,
  0x60, 0x00, 0x70, 0x30, 0x00, 0x38, 0x18, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x0C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x83, 0x00, 0x01, 0xE1, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x3C, 0xC0, 0x00, 0x0F, 0x60, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x01, 0x87, 0x80, 0x00, 0xC1,
  0xC0, 0x00, 0x60, 0xE0, 0x00, 0x30, 0x70, 0x00, 0x38, 0x38, 0x00, 0x18,
  0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x06, 0x0F, 0x00, 0x07, 0x07, 0x02, 0x03,
  0x07, 0x81, 0x81, 0x8F, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x1C, 0x03, 0xFC, 0x00, 0x38, 0x07, 0x9E, 0x00, 0x38, 0x07, 0x0E,
  0x00, 0x70, 0x0E, 0x06, 0x00, 0x70, 0x1C, 0x06, 0x00, 0xE0, 0x1C, 0x06,
  0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x03, 0x80, 0x38, 0x06,
  0x03, 0x80, 0x30, 0x0E, 0x07, 0x00, 0x70, 0x0E, 0x07, 0x00, 0x70, 0x0E,
  0x0E, 0x00, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0x0C, 0x1C, 0x00, 0x60, 0x1C,
  0x38, 0x00, 0x60, 0x1C, 0x38, 0x00, 0x60, 0x1C, 0x70, 0x7C, 0xE0, 0x38,
  0x71, 0xFE, 0xE0, 0x38, 0xE3, 0xCF, 0x60, 0x30, 0xC7, 0x87, 0x60, 0x71,
  0xC7, 0x07, 0x70, 0xE3, 0x8E, 0x03, 0x79, 0xE3, 0x8E, 0x03, 0x3F, 0xC7,
  0x0C, 0x03, 0x1F, 0x87, 0x1C, 0x07, 0x00, 0x0E, 0x1C, 0x07, 0x00, 0x1C,
  0x18, 0x07, 0x00, 0x1C, 0x38, 0x07, 0x00, 0x38, 0x38, 0x07, 0x00, 0x38,
  0x38, 0x07, 0x00, 0x70, 0x30, 0x0E, 0x00, 0x70, 0x30, 0x0E, 0x00, 0xE0,
  0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0x70, 0x38, 0x07, 0x00, 0x70, 0x38, 0x07, 0x00,
  0x30, 0x70, 0x0E, 0x00, 0x38, 0xF0, 0x1C, 0x00, 0x3F, 0xE0, 0x1C, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E,
  0x00, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x3C, 0x78, 0x01, 0x0F, 0x0F, 0x01, 0xC1, 0xC0, 0xE0, 0x38, 0x78, 0x1E,
  0x0F, 0x1E, 0x01, 0xC1, 0xC3, 0x80, 0x3C, 0x38, 0xF0, 0x03, 0x8E, 0x1C,
  0x00, 0x71, 0xC3, 0x80, 0x0F, 0x70, 0x70, 0x00, 0xFE, 0x1E, 0x00, 0x1F,
  0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x80, 0xE0,
  0x03, 0xF0, 0x1C, 0x00, 0xFF, 0x03, 0xC0, 0x3C, 0xE0, 0x3E, 0x1F, 0x1E,
  0x03, 0xFF, 0xC1, 0xC0, 0x3F, 0xE0, 0x3C, 0x00, 0xC0, 0x00, 0x00, 0x1C,
  0x73, 0xCF, 0x38, 0xE3, 0x8C, 0x71, 0xC7, 0x18, 0x63, 0x8E, 0x30, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x80, 0xC0, 0x38, 0x18, 0x07, 0xC7, 0x00,
  0x7E, 0xE0, 0x61, 0xFB, 0xFC, 0x0F, 0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00,
  0x0E, 0xE0, 0x03, 0x8C, 0x00, 0xE1, 0xC0, 0x78, 0x38, 0x0E, 0x03, 0x80,
  0x80, 0x70, 0x00, 0x07, 0x00, 0x00, 0x80, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x80,
  0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x00, 0x7F, 0xFD,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xEF, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0x81, 0xE0, 0x1E, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0xF0, 0x07, 0x81, 0xC0, 0x07, 0x07, 0x80, 0x0E,
  0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3,
  0xC0, 0x03, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x70,
  0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x80, 0x01, 0xCE, 0x00,
  0x07, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xE0, 0x00,
  0xF3, 0xC0, 0x01, 0xE7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x1E,
  0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0x83,
  0x80, 0x0F, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0xE0, 0x1C,
  0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xF0, 0x0F, 0xC0, 0x7E,
  0x07, 0xF8, 0x3E, 0xE1, 0xE7, 0x9F, 0x1C, 0xF8, 0x71, 0x81, 0xC4, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x60,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xBF, 0x80, 0x3C, 0x01, 0xE0, 0x0C, 0x00, 0x70, 0x04, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x02, 0x00, 0x0F, 0x01, 0x80, 0x0F, 0x80, 0xF8, 0x3F,
  0x80, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x70, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x01,
  0xC0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x38,
  0x03, 0x80, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x3C,
  0x07, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xBF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x20, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x02, 0x00, 0x0F, 0x01, 0x80, 0x0F, 0x80,
  0xF8, 0x3F, 0x80, 0x7F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xEF, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x04, 0x00, 0x3C, 0x7F, 0x80, 0x39, 0xFF, 0xE0, 0x3B, 0xE3,
  0xE0, 0x3F, 0x00, 0xF0, 0x7E, 0x00, 0x70, 0x7C, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0x78, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xF0, 0x01,
  0xE0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x38, 0x0F,
  0x00, 0x3E, 0x3F, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xF3, 0xF0, 0x01, 0xE0, 0x3E, 0x00,
  0xF0, 0x07, 0x80, 0x78, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0F,
  0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00,
  0x0E, 0x01, 0xC0, 0x07, 0x80, 0x70, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0x80, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x9F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0xF0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x0F, 0x07,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x1C, 0x00,
  0x1C, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0x87, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0xFE, 0xFC, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E,
  0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x1C, 0x00, 0x3E, 0x1E, 0x00, 0x3E,
  0x0E, 0x00, 0x7C, 0x0F, 0x00, 0xFC, 0x0F, 0xC3, 0xDC, 0x07, 0xFF, 0x9C,
  0x03, 0xFE, 0x38, 0x00, 0x78, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xE1, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0xF0,
  0x7C, 0x1F, 0x07, 0x80, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x40,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x01,
  0xFF, 0xF0, 0x3F, 0xFF, 0x06, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x1C,
  0x0E, 0x00, 0x00, 0x03, 0x83, 0x80, 0x00, 0x00, 0x70, 0x70, 0x03, 0xF8,
  0x0E, 0x1C, 0x01, 0xFF, 0xC1, 0xC3, 0x80, 0x7C, 0xF0, 0x38, 0xE0, 0x1E,
  0x0E, 0x07, 0x1C, 0x07, 0x01, 0xC0, 0xE3, 0x00, 0xE0, 0x30, 0x1C, 0xE0,
  0x38, 0x0E, 0x03, 0x9C, 0x0E, 0x01, 0xC0, 0x73, 0x01, 0xC0, 0x38, 0x0E,
  0xE0, 0x30, 0x06, 0x01, 0x9C, 0x0E, 0x01, 0xC0, 0x73, 0x81, 0xC0, 0x38,
  0x0E, 0x60, 0x30, 0x07, 0x01, 0xCC, 0x0E, 0x01, 0xC0, 0x33, 0x81, 0xC0,
  0x38, 0x0E, 0x70, 0x38, 0x07, 0x01, 0xCE, 0x07, 0x01, 0xE0, 0x31, 0xC0,
  0xE0, 0x3C, 0x0E, 0x38, 0x1C, 0x0F, 0x01, 0x87, 0x03, 0x81, 0xE0, 0x70,
  0xE0, 0x70, 0x6E, 0x1C, 0x1C, 0x07, 0x1C, 0xC7, 0x03, 0x80, 0xFF, 0x1F,
  0xC0, 0x70, 0x0F, 0xC1, 0xF0, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x80, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0x70, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x38,
  0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80,
  0x38, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0xE0,
  0x38, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x00,
  0xE0, 0xF0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xE3, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x78, 0x00, 0x03, 0x9E,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x78, 0x0F, 0xC0, 0x0E, 0x00, 0x7C, 0x01,
  0xC0, 0x07, 0x80, 0x38, 0x00, 0x70, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x01,
  0xE0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x3C,
  0x00, 0x1C, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x3C,
  0x07, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1C, 0x01, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xC0, 0x3E, 0x00,
  0x70, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x78, 0x00,
  0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xE0,
  0x00, 0xF0, 0x1C, 0x00, 0x7C, 0x03, 0x80, 0x3F, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xE0,
  0x0C, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x40, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0x03, 0xF8, 0x00, 0xE0, 0x07, 0xC0, 0x0E, 0x00,
  0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0,
  0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0x70, 0x38, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x70, 0x78, 0x00, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x00,
  0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x1E,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x78, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x03,
  0x80, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x70, 0x00,
  0xF8, 0x07, 0x00, 0x1F, 0x00, 0x70, 0x03, 0xE0, 0x07, 0x01, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x00, 0x40, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0xFC, 0x3C, 0x00, 0x3F, 0xF0, 0xF0, 0x00, 0xFF,
  0xC3, 0xC0, 0x04, 0x0F, 0x0E, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0x78, 0x38,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x38, 0x07, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x1C,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xC0,
  0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x80, 0x00, 0x70, 0x0F, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x78, 0x07, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x80,
  0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x38, 0x07,
  0x80, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x08, 0x3E, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x78,
  0x03, 0x80, 0x03, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x03, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x3C, 0x01,
  0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x70, 0x1E, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x01, 0xCF, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x77, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0x38, 0x00, 0x01, 0xF1, 0xC0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x0E,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0, 0x0E, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x70,
  0x07, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x01, 0xDC, 0x00, 0x01,
  0xEE, 0x01, 0xDC, 0x00, 0x01, 0xDC, 0x01, 0xDC, 0x00, 0x03, 0xDC, 0x01,
  0xDC, 0x00, 0x03, 0x9C, 0x03, 0x8E, 0x00, 0x07, 0x9C, 0x03, 0x8E, 0x00,
  0x07, 0x3C, 0x03, 0x8E, 0x00, 0x0F, 0x38, 0x03, 0x8E, 0x00, 0x0E, 0x38,
  0x07, 0x8E, 0x00, 0x1E, 0x38, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x07, 0x0E,
  0x00, 0x3C, 0x78, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x07, 0x0E, 0x00, 0x78,
  0x70, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x0E, 0x00, 0xF0, 0xF0, 0x0E,
  0x0E, 0x00, 0xE0, 0xF0, 0x0E, 0x0E, 0x01, 0xE0, 0xE0, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x03, 0x81, 0xE0,
  0x1C, 0x07, 0x07, 0x81, 0xC0, 0x1C, 0x07, 0x07, 0x01, 0xC0, 0x3C, 0x07,
  0x0F, 0x01, 0xC0, 0x38, 0x07, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x1E, 0x03,
  0xC0, 0x38, 0x07, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x38, 0x03, 0x80, 0x70, 0x07, 0x78, 0x03, 0x80, 0x70, 0x07, 0x70,
  0x07, 0x80, 0x70, 0x03, 0xF0, 0x07, 0x00, 0x70, 0x03, 0xE0, 0x07, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0x80,
  0x3E, 0x00, 0x01, 0xC0, 0x1F, 0x00, 0x00, 0xE0, 0x0F, 0xC0, 0x00, 0x70,
  0x07, 0xE0, 0x00, 0x78, 0x03, 0xF0, 0x00, 0x38, 0x03, 0xB8, 0x00, 0x1C,
  0x01, 0xCE, 0x00, 0x0E, 0x00, 0xE7, 0x00, 0x0F, 0x00, 0x73, 0x80, 0x07,
  0x00, 0x39, 0xC0, 0x03, 0x80, 0x38, 0x70, 0x01, 0xC0, 0x1C, 0x38, 0x00,
  0xE0, 0x0E, 0x1C, 0x00, 0xF0, 0x07, 0x0E, 0x00, 0x70, 0x07, 0x87, 0x80,
  0x38, 0x03, 0x81, 0xC0, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x70,
  0x0F, 0x00, 0x70, 0x3C, 0x07, 0x00, 0x78, 0x0E, 0x03, 0x80, 0x38, 0x07,
  0x01, 0xC0, 0x1C, 0x03, 0x81, 0xE0, 0x0E, 0x01, 0xE0, 0xE0, 0x07, 0x00,
  0x70, 0x70, 0x07, 0x80, 0x38, 0x38, 0x03, 0x80, 0x1C, 0x1C, 0x01, 0xC0,
  0x0F, 0x1E, 0x00, 0xE0, 0x03, 0x8E, 0x00, 0xF0, 0x01, 0xC7, 0x00, 0x70,
  0x00, 0xE3, 0x80, 0x38, 0x00, 0x79, 0xC0, 0x1C, 0x00, 0x1D, 0xE0, 0x0E,
  0x00, 0x0E, 0xE0, 0x0F, 0x00, 0x07, 0x70, 0x07, 0x00, 0x03, 0xF8, 0x03,
  0x80, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0x7E, 0x00, 0xE0, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x70, 0x00, 0x07,
  0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x07, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x70,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x07, 0x80,
  0x07, 0x80, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xC0, 0xFC,
  0x00, 0xE0, 0x0F, 0x80, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0x38, 0x07, 0x80,
  0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x07,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38,
  0x0E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x70, 0x00,
  0xF0, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x3C, 0x03, 0xC0, 0x3E, 0x00, 0xE1,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x01,
  0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x70, 0x70, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x73,
  0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0x73, 0x80, 0x00, 0x07, 0x78, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0xCE, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x1F, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xC0, 0xFC, 0x00, 0xE0, 0x0F, 0x80, 0x38, 0x01, 0xE0, 0x0E, 0x00, 0x38,
  0x07, 0x80, 0x0E, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x1C, 0x00,
  0x3C, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38,
  0x00, 0x38, 0x0E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x03, 0xC0,
  0x70, 0x01, 0xE0, 0x1C, 0x00, 0xF8, 0x07, 0x00, 0x7C, 0x03, 0xC1, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x1C, 0x03, 0x80, 0x07,
  0x00, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00,
  0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0xE0, 0x0F,
  0x00, 0x04, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x20, 0x00, 0x7C, 0x07, 0x00, 0x1F, 0x00,
  0xFF, 0x7F, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x1E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E,
  0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x1C,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x1C,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x07, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C,
  0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x80,
  0x7C, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xDE, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF1,
  0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x07, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80,
  0x78, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x38,
  0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03,
  0xC3, 0x80, 0x01, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x39, 0xE0, 0x00,
  0x1C, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0F, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0xE0, 0x00, 0xF8, 0x00, 0x1C, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0xE0, 0x00, 0xD8, 0x00, 0x38, 0xE0, 0x01, 0xD8, 0x00, 0x78,
  0xE0, 0x01, 0xD8, 0x00, 0x70, 0xE0, 0x03, 0x98, 0x00, 0x70, 0xE0, 0x03,
  0x98, 0x00, 0xF0, 0xE0, 0x03, 0x98, 0x00, 0xE0, 0xE0, 0x07, 0x18, 0x01,
  0xE0, 0xE0, 0x07, 0x18, 0x01, 0xC0, 0xE0, 0x0E, 0x18, 0x01, 0xC0, 0xE0,
  0x0E, 0x18, 0x03, 0xC0, 0xE0, 0x1C, 0x38, 0x03, 0x80, 0xE0, 0x1C, 0x38,
  0x07, 0x80, 0xE0, 0x1C, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x38, 0x0E, 0x00, 0xE0, 0x70,
  0x38, 0x1E, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0xE0, 0xE0, 0x38, 0x3C,
  0x00, 0xE0, 0xE0, 0x38, 0x38, 0x00, 0xE1, 0xC0, 0x38, 0x38, 0x00, 0xE1,
  0xC0, 0x38, 0x78, 0x00, 0xE3, 0xC0, 0x38, 0x70, 0x00, 0xE3, 0x80, 0x38,
  0xF0, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x00, 0xE7, 0x00, 0x38, 0xE0, 0x00,
  0xE7, 0x00, 0x39, 0xC0, 0x00, 0xEE, 0x00, 0x39, 0xC0, 0x00, 0xEE, 0x00,
  0x39, 0xC0, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x00, 0xFC, 0x00, 0x3B, 0x80,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x01,
  0xC0, 0x0F, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38,
  0x1C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0xE3,
  0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x07, 0x70,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03,
  0xC0, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x78, 0x03, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x79,
  0xC0, 0x00, 0xE3, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1C,
  0x00, 0x38, 0x3C, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0x70, 0x07, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0xF0, 0x07, 0x01, 0xC0, 0x0F, 0x07,
  0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xF0, 0x00, 0x71, 0xC0,
  0x00, 0xE7, 0x80, 0x01, 0xCE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xE0, 0x70, 0x38, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x3B, 0x80, 0x00, 0x73, 0x80, 0x00, 0x71, 0xC0, 0x00, 0xE1,
  0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x1E, 0x00,
  0x38, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE1, 0xE1, 0xC3, 0xC3, 0x87, 0x07, 0x06, 0x0E, 0x0C,
  0x00, 0x3F, 0x87, 0x00, 0xFF, 0xC7, 0x01, 0xF9, 0xE7, 0x03, 0xE0, 0x66,
  0x07, 0x80, 0x3E, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x0E, 0x00, 0x1E,
  0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x3C,
  0x38, 0x00, 0x3C, 0x78, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38,
  0x70, 0x00, 0x78, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0x70,
  0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0,
  0xE0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x06, 0xE0, 0x70, 0x0F, 0xC0,
  0x78, 0x1D, 0xC0, 0x7E, 0x79, 0xC0, 0x3F, 0xF1, 0xC0, 0x1F, 0xE1, 0x80,
  0x03, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC7, 0xF8,
  0x03, 0x8F, 0xFC, 0x03, 0x9E, 0x7C, 0x03, 0xB8, 0x1E, 0x07, 0xF0, 0x0E,
  0x07, 0xE0, 0x0F, 0x07, 0xC0, 0x0F, 0x07, 0x80, 0x07, 0x07, 0x80, 0x07,
  0x0F, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x0F,
  0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x1C, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0x38, 0x00, 0x3C, 0x38, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0x7C, 0x00, 0xE0, 0x6C, 0x01, 0xE0, 0xEE, 0x03, 0xC0,
  0xE7, 0x8F, 0x80, 0xE7, 0xFF, 0x00, 0xC3, 0xFE, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFD, 0xE0, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x02,
  0x03, 0xE1, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x0F,
  0xE1, 0xC0, 0x07, 0xFE, 0x38, 0x01, 0xF9, 0xE7, 0x00, 0x7C, 0x0F, 0xE0,
  0x1E, 0x00, 0xF8, 0x03, 0x80, 0x1F, 0x00, 0xF0, 0x01, 0xE0, 0x1C, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x1C, 0x07,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x07, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x78,
  0x0E, 0x00, 0x1F, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0xF8, 0x07, 0x00,
  0x1F, 0x00, 0xF0, 0x07, 0xE0, 0x0E, 0x01, 0xDC, 0x01, 0xE0, 0x77, 0x00,
  0x3F, 0x3C, 0xE0, 0x03, 0xFF, 0x1C, 0x00, 0x3F, 0xC3, 0x80, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x7E, 0x7C, 0x07, 0x80,
  0xE0, 0x78, 0x07, 0x03, 0x80, 0x3C, 0x38, 0x01, 0xC3, 0xC0, 0x0E, 0x1C,
  0x00, 0x71, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x03, 0xC7, 0x80, 0x3C,
  0x38, 0x07, 0xC1, 0xCF, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x10, 0x1F, 0x07, 0x80, 0x7F, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3C, 0x10, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xC0, 0x0F,
  0xFC, 0x70, 0x07, 0xE7, 0x9C, 0x03, 0xE0, 0x77, 0x01, 0xE0, 0x0F, 0x80,
  0x78, 0x03, 0xE0, 0x3C, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x07, 0x80, 0x07,
  0x81, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x0E, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70,
  0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x07, 0xC0, 0xE0, 0x01,
  0xE0, 0x38, 0x00, 0xF8, 0x0E, 0x00, 0x3E, 0x03, 0xC0, 0x1F, 0x80, 0x70,
  0x0F, 0xE0, 0x1E, 0x07, 0x70, 0x07, 0xE7, 0x9C, 0x00, 0xFF, 0xC7, 0x00,
  0x1F, 0xE1, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x20, 0x03, 0xC0, 0x0C,
  0x01, 0xF0, 0x03, 0xF3, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE1, 0xFE, 0x01, 0xC7, 0xFE, 0x03,
  0xBF, 0xFC, 0x07, 0x70, 0x3C, 0x1D, 0x80, 0x38, 0x3E, 0x00, 0x70, 0x7C,
  0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xE0, 0x03, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xE0, 0x03,
  0xC3, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x78, 0x00, 0xF0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x0F,
  0x00, 0x0E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0,
  0x01, 0xC3, 0xC0, 0x07, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0x20, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x03,
  0x81, 0xC0, 0x0E, 0x03, 0x80, 0x3C, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0,
  0x38, 0x0F, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x70, 0x01, 0xC1, 0xC0, 0x07,
  0x87, 0x80, 0x0E, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x38, 0xE0, 0x00, 0x73,
  0xC0, 0x01, 0xCF, 0x80, 0x03, 0xBF, 0x00, 0x07, 0xEF, 0x00, 0x0F, 0x9E,
  0x00, 0x1E, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xE0, 0x78, 0x01, 0xC0, 0xF0,
  0x03, 0x80, 0xE0, 0x0F, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0xC0, 0x1E, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x03, 0x87, 0xF0,
  0x1F, 0xC0, 0x1C, 0xFF, 0xC3, 0xFF, 0x00, 0xEF, 0xBF, 0x3E, 0xFC, 0x06,
  0xE0, 0x7B, 0x81, 0xE0, 0x76, 0x01, 0xF8, 0x07, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x1E, 0x00, 0x7C, 0x01, 0xC0, 0xF0, 0x03, 0xC0, 0x0E, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x78, 0x00, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0x78, 0x01, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x78, 0x00, 0xE0, 0x03, 0x83, 0x80, 0x0F, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0x01, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x00,
  0x70, 0x78, 0x00, 0xE0, 0x03, 0x83, 0x80, 0x0F, 0x00, 0x1C, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0x03, 0x83, 0x80, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x70,
  0x01, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x70,
  0x01, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x00, 0xC0, 0x07, 0x0F, 0xF0, 0x0E, 0x7F, 0xF0, 0x1D, 0xFF,
  0xE0, 0x33, 0x81, 0xE0, 0xEC, 0x03, 0xC1, 0xF0, 0x03, 0x83, 0xE0, 0x07,
  0x07, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xE0,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x0F, 0x00, 0x1E, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78, 0x00,
  0xF0, 0xE0, 0x01, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x1E, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC0,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0x9F, 0x00, 0xF0, 0x1E, 0x07,
  0x80, 0x38, 0x1C, 0x00, 0xF0, 0xF0, 0x01, 0xC7, 0x80, 0x07, 0x1C, 0x00,
  0x1C, 0x70, 0x00, 0x73, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x78, 0x00, 0x1D,
  0xE0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x0F, 0x70, 0x00, 0x3F, 0xC0,
  0x00, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x7B, 0x80, 0x01,
  0xCE, 0x00, 0x0F, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x0F,
  0x00, 0x3C, 0x1C, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0xF8, 0xF8, 0x01, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00, 0x70, 0xFF, 0x00, 0x0E,
  0x3F, 0xF0, 0x01, 0xCF, 0x3E, 0x00, 0x3B, 0x81, 0xE0, 0x06, 0xE0, 0x1C,
  0x01, 0xD8, 0x03, 0xC0, 0x3E, 0x00, 0x78, 0x07, 0xC0, 0x07, 0x00, 0xF0,
  0x00, 0xE0, 0x3E, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x70,
  0x1C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1C, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0x03,
  0xC0, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x01,
  0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x3E,
  0x00, 0x70, 0x07, 0xC0, 0x1E, 0x01, 0xFC, 0x07, 0x80, 0x39, 0xE3, 0xE0,
  0x07, 0x3F, 0xF8, 0x00, 0xE1, 0xFE, 0x00, 0x1C, 0x0C, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x83, 0x00, 0xFF,
  0xC7, 0x01, 0xF9, 0xE7, 0x03, 0xC0, 0x77, 0x07, 0x80, 0x3E, 0x07, 0x00,
  0x3E, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1C, 0x00,
  0x1C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x78, 0x00,
  0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00,
  0xF0, 0xE0, 0x01, 0xF0, 0xE0, 0x01, 0xE0, 0xE0, 0x03, 0xE0, 0xE0, 0x03,
  0xE0, 0xF0, 0x07, 0xE0, 0x70, 0x0F, 0xE0, 0x78, 0x1D, 0xC0, 0x7E, 0x79,
  0xC0, 0x3F, 0xF1, 0xC0, 0x1F, 0xE3, 0xC0, 0x07, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x03, 0x87, 0xE0, 0x73, 0xFC, 0x0E, 0xFF, 0x01, 0x9C, 0x00, 0x77,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x03, 0xE1,
  0xF0, 0x78, 0x02, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x80, 0x1E, 0x0F, 0x07, 0xC0, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x07, 0xFF, 0x3F, 0xFD, 0xFF, 0xF0, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF1, 0x83, 0xFE, 0x07, 0xF8,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78,
  0x00, 0x70, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00,
  0x0E, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01,
  0xC1, 0xC0, 0x03, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0,
  0x03, 0xC1, 0xC0, 0x07, 0x83, 0x80, 0x1F, 0x07, 0x80, 0x6E, 0x0F, 0x01,
  0xD8, 0x0F, 0x9F, 0x30, 0x1F, 0xFC, 0xE0, 0x1F, 0xE1, 0xC0, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xC7,
  0x00, 0x1E, 0x38, 0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x07,
  0x83, 0x80, 0x38, 0x1C, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x38,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0xC7,
  0x00, 0x0E, 0x78, 0x00, 0x73, 0x80, 0x01, 0xBC, 0x00, 0x0D, 0xC0, 0x00,
  0x6E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x0E, 0xE0, 0x07, 0xC0,
  0x0E, 0xE0, 0x07, 0xC0, 0x1E, 0xE0, 0x0F, 0xC0, 0x1C, 0xE0, 0x0F, 0xC0,
  0x3C, 0xE0, 0x1D, 0xC0, 0x38, 0xE0, 0x1D, 0xC0, 0x38, 0xE0, 0x19, 0xC0,
  0x78, 0xE0, 0x39, 0xC0, 0x70, 0xE0, 0x39, 0xC0, 0xF0, 0xE0, 0x71, 0xC0,
  0xE0, 0xE0, 0x71, 0xC0, 0xE0, 0xE0, 0xE1, 0xC1, 0xC0, 0xE0, 0xE1, 0xC1,
  0xC0, 0xE0, 0xC1, 0xC3, 0xC0, 0xE1, 0xC1, 0xC3, 0x80, 0xE1, 0xC1, 0xC3,
  0x80, 0xE3, 0x81, 0xC7, 0x00, 0xE3, 0x81, 0xC7, 0x00, 0xE7, 0x01, 0xCE,
  0x00, 0xE7, 0x01, 0xCE, 0x00, 0xE6, 0x01, 0xCE, 0x00, 0xEE, 0x01, 0xDC,
  0x00, 0xEE, 0x01, 0xDC, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x38, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x1C, 0x00, 0x70,
  0x0E, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x78, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x1D, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x38, 0x00,
  0x0F, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x1E,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x38, 0x03, 0x80,
  0x0F, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xE0, 0x00,
  0xF0, 0x03, 0x80, 0x03, 0x80, 0x0E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x70, 0x70,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x1C, 0x78, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x23, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x02,
  0xFF, 0xE0, 0x0F, 0xEF, 0xF0, 0x3E, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xD0,
  0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_Condensed_LightItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 43, 13, 1, -43 },
  { 71, 15, 16, 19, 6, -43 },
  { 101, 28, 43, 28, 1, -43 },
  { 252, 25, 49, 25, 1, -46 },
  { 406, 32, 44, 38, 3, -43 },
  { 582, 27, 44, 28, 0, -43 },
  { 731, 6, 16, 10, 6, -43 },
  { 743, 17, 52, 15, 2, -43 },
  { 854, 17, 52, 15, -4, -43 },
  { 965, 19, 21, 24, 7, -46 },
  { 1015, 23, 28, 28, 3, -35 },
  { 1096, 10, 14, 11, -3, -6 },
  { 1114, 14, 3, 17, 1, -18 },
  { 1120, 5, 5, 12, 1, -5 },
  { 1124, 27, 43, 19, -3, -43 },
  { 1270, 23, 44, 25, 2, -43 },
  { 1397, 14, 43, 25, 7, -43 },
  { 1473, 26, 43, 25, -1, -43 },
  { 1613, 25, 44, 25, 0, -43 },
  { 1751, 26, 43, 25, -1, -43 },
  { 1891, 25, 44, 25, 0, -43 },
  { 2029, 24, 44, 25, 2, -43 },
  { 2161, 24, 43, 25, 3, -43 },
  { 2290, 26, 44, 25, 0, -43 },
  { 2433, 24, 44, 25, 1, -43 },
  { 2565, 10, 32, 12, 1, -32 },
  { 2605, 14, 40, 12, -3, -32 },
  { 2675, 23, 27, 28, 3, -35 },
  { 2753, 23, 16, 28, 3, -29 },
  { 2799, 23, 27, 28, 3, -35 },
  { 2877, 19, 43, 19, 2, -43 },
  { 2980, 35, 48, 38, 2, -43 },
  { 3190, 26, 43, 25, -4, -43 },
  { 3330, 27, 43, 28, 1, -43 },
  { 3476, 27, 45, 26, 3, -44 },
  { 3628, 28, 43, 30, 1, -43 },
  { 3779, 26, 43, 24, 1, -43 },
  { 3919, 26, 43, 23, 1, -43 },
  { 4059, 30, 45, 32, 3, -44 },
  { 4228, 31, 43, 32, 1, -43 },
  { 4395, 20, 43, 14, -2, -43 },
  { 4503, 22, 54, 12, -9, -43 },
  { 4652, 29, 43, 26, 1, -43 },
  { 4808, 17, 43, 22, 1, -43 },
  { 4900, 40, 43, 41, 1, -43 },
  { 5115, 33, 43, 33, 1, -43 },
  { 5293, 28, 44, 33, 3, -43 },
  { 5447, 26, 43, 26, 1, -43 },
  { 5587, 28, 53, 33, 3, -43 },
  { 5773, 26, 43, 26, 1, -43 },
  { 5913, 27, 44, 24, -1, -43 },
  { 6062, 22, 43, 22, 5, -43 },
  { 6181, 29, 44, 31, 3, -43 },
  { 6341, 25, 43, 26, 5, -43 },
  { 6476, 40, 43, 41, 6, -43 },
  { 6691, 31, 43, 23, -3, -43 },
  { 6858, 23, 43, 23, 5, -43 },
  { 6982, 28, 43, 23, -2, -43 },
  { 7133, 22, 53, 17, -1, -43 },
  { 7279, 9, 43, 20, 6, -43 },
  { 7328, 22, 53, 17, -4, -43 },
  { 7474, 24, 23, 27, 2, -43 },
  { 7543, 19, 3, 19, -5, 5 },
  { 7551, 7, 10, 14, 9, -46 },
  { 7560, 24, 33, 27, 2, -32 },
  { 7659, 24, 47, 27, 1, -46 },
  { 7800, 20, 33, 20, 2, -32 },
  { 7883, 27, 47, 27, 2, -46 },
  { 8042, 21, 33, 24, 2, -32 },
  { 8129, 29, 60, 14, -8, -46 },
  { 8347, 26, 46, 27, 0, -32 },
  { 8497, 23, 46, 26, 1, -46 },
  { 8630, 12, 44, 11, 1, -44 },
  { 8696, 21, 58, 12, -8, -44 },
  { 8849, 23, 46, 22, 1, -46 },
  { 8982, 13, 46, 11, 1, -46 },
  { 9057, 37, 32, 40, 1, -32 },
  { 9205, 23, 33, 26, 1, -33 },
  { 9300, 22, 33, 26, 2, -32 },
  { 9391, 27, 46, 27, -2, -32 },
  { 9547, 24, 46, 27, 2, -32 },
  { 9685, 19, 32, 18, 1, -32 },
  { 9761, 20, 33, 20, 0, -32 },
  { 9844, 14, 40, 15, 2, -39 },
  { 9914, 23, 33, 26, 2, -32 },
  { 10009, 21, 32, 21, 3, -32 },
  { 10093, 32, 32, 33, 4, -32 },
  { 10221, 26, 32, 22, -3, -32 },
  { 10325, 30, 47, 21, -6, -32 },
  { 10502, 22, 32, 19, -2, -32 },
  { 10590, 22, 52, 20, 1, -43 },
  { 10733, 3, 60, 25, 11, -46 },
  { 10756, 21, 52, 19, -3, -43 },
  { 10893, 23, 6, 28, 3, -24 },
};

const GFXfont NotoSans_Condensed_LightItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC60PT7B_H_
