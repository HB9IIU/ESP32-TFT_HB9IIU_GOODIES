#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC55PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00,
  0x38, 0x39, 0xC3, 0x9E, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x31, 0xC3, 0x8C,
  0x1C, 0xE0, 0xE7, 0x06, 0x38, 0x31, 0x81, 0x8C, 0x1C, 0x60, 0xC0, 0x00,
  0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x18,
  0x00, 0x1C, 0x0E, 0x00, 0x06, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x18, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x03, 0x80, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x0E, 0x07, 0x00,
  0x03, 0x01, 0x80, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x18, 0x0C,
  0x00, 0x06, 0x03, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x30,
  0x18, 0x00, 0x1C, 0x0E, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC0, 0x38, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x03, 0x01, 0x80,
  0x01, 0xC0, 0xE0, 0x00, 0x70, 0x30, 0x00, 0x18, 0x0C, 0x00, 0x0E, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x30, 0x38, 0x00, 0x1C,
  0x0E, 0x00, 0x06, 0x03, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x7F, 0x9F, 0x01, 0xE3, 0x06, 0x07, 0x86, 0x00, 0x0E,
  0x0C, 0x00, 0x18, 0x18, 0x00, 0x70, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC1,
  0x80, 0x03, 0x83, 0x00, 0x03, 0x8C, 0x00, 0x07, 0x18, 0x00, 0x0F, 0x30,
  0x00, 0x0F, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x37, 0x80, 0x00, 0xC7, 0x80,
  0x01, 0x87, 0x00, 0x03, 0x0E, 0x00, 0x06, 0x0C, 0x00, 0x18, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x60, 0xE0, 0x00, 0xC1, 0xC0, 0x01, 0x87, 0x02, 0x06,
  0x1E, 0x07, 0x8C, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0x01,
  0xFE, 0x00, 0x30, 0x1C, 0x38, 0x03, 0x81, 0xC1, 0xC0, 0x18, 0x0E, 0x0E,
  0x01, 0xC0, 0x60, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x0E,
  0x03, 0x80, 0xE0, 0x60, 0x1C, 0x07, 0x07, 0x00, 0xE0, 0x30, 0x30, 0x06,
  0x01, 0x83, 0x80, 0x30, 0x1C, 0x38, 0x03, 0x80, 0xE1, 0xC0, 0x1C, 0x07,
  0x1C, 0x00, 0xE0, 0x30, 0xC3, 0xE7, 0x03, 0x8E, 0x3F, 0xB8, 0x1C, 0x63,
  0xDF, 0xC1, 0xC7, 0x38, 0x7E, 0x0E, 0x71, 0x81, 0xB0, 0xE3, 0x1C, 0x0D,
  0xFE, 0x38, 0xC0, 0x67, 0xE1, 0x8E, 0x03, 0x1E, 0x1C, 0x70, 0x18, 0x01,
  0xC3, 0x00, 0xC0, 0x0E, 0x18, 0x0E, 0x00, 0xE1, 0xC0, 0x70, 0x06, 0x0E,
  0x03, 0x80, 0x70, 0x60, 0x18, 0x03, 0x03, 0x00, 0xC0, 0x38, 0x18, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x30, 0x38, 0x0C,
  0x01, 0x81, 0x80, 0xE0, 0x0C, 0x1C, 0x06, 0x00, 0x71, 0xC0, 0x70, 0x03,
  0xFC, 0x07, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x70, 0x38,
  0x00, 0x60, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38,
  0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0xE3, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0x9C, 0x00, 0x07, 0x1C, 0x07, 0x0E, 0x0E, 0x07, 0x1C, 0x0E, 0x07,
  0x3C, 0x0F, 0x0E, 0x38, 0x07, 0x0E, 0x70, 0x07, 0x1C, 0x70, 0x03, 0x9C,
  0x70, 0x03, 0xB8, 0xE0, 0x01, 0xF8, 0xE0, 0x01, 0xF0, 0xE0, 0x01, 0xF0,
  0xE0, 0x01, 0xE0, 0xF0, 0x03, 0xE0, 0x70, 0x07, 0xF0, 0x78, 0x0F, 0x70,
  0x7C, 0x3E, 0x38, 0x3F, 0xFC, 0x38, 0x1F, 0xF0, 0x3C, 0x03, 0x00, 0x00,
  0x39, 0xCE, 0xE7, 0x39, 0xCC, 0x67, 0x39, 0x8C, 0x60, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x40, 0xE0, 0x18, 0x38, 0x0F, 0x8C,
  0x01, 0xF3, 0x01, 0x0F, 0xDF, 0xC0, 0xFF, 0xF0, 0x1C, 0x00, 0x0D, 0x80,
  0x0E, 0x60, 0x07, 0x9C, 0x03, 0xC3, 0x01, 0xE0, 0xE0, 0x30, 0x18, 0x08,
  0x07, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x0F,
  0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xC0, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFC, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xE1, 0xE0, 0x1C, 0x07, 0x01, 0xE0,
  0x38, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x70, 0x01, 0xC3,
  0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x00,
  0xE7, 0x00, 0x0E, 0x38, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0,
  0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x7B, 0x80, 0x03, 0x9C, 0x00, 0x1C,
  0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00,
  0x1C, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07,
  0x00, 0x70, 0x38, 0x03, 0x81, 0xE0, 0x38, 0x07, 0x03, 0xC0, 0x3C, 0x3C,
  0x00, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x1F,
  0x03, 0xF0, 0x7E, 0x1E, 0xE3, 0xCE, 0x78, 0xEF, 0x0E, 0x41, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xF0, 0x3E, 0x00, 0xE0, 0x1E, 0x00,
  0x80, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x01, 0xE0, 0x18, 0x01, 0xC0, 0x20,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x08, 0x00, 0xF0, 0x1E, 0x07, 0xC0, 0x3F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0xEE, 0x00, 0x01, 0xCC, 0x00, 0x01, 0x9C, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0x1C, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38,
  0x00, 0x18, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x30, 0x00, 0xE0, 0x70,
  0x00, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0xE0,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0,
  0x38, 0x01, 0xC0, 0x30, 0x01, 0xC0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xBC, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x10, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x04, 0x00,
  0x78, 0x0F, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0xFF, 0x00,
  0xE7, 0xFE, 0x03, 0x38, 0x7C, 0x1D, 0x80, 0xF0, 0x7C, 0x01, 0xC1, 0xE0,
  0x03, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0xF0, 0x00, 0xE3, 0x80, 0x03,
  0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x0E,
  0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00,
  0x70, 0x1C, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xF0, 0x07, 0x81, 0xE0, 0x1E, 0x01, 0xE0, 0x38, 0x01, 0xC0,
  0x70, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x70,
  0x0E, 0x00, 0xF0, 0x38, 0x00, 0xE1, 0xE0, 0x00, 0xE7, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7C, 0xF0, 0x01, 0xE0, 0xE0,
  0x07, 0x80, 0xE0, 0x1C, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0xC3,
  0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70,
  0x00, 0x38, 0xE0, 0x00, 0x71, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80,
  0x0E, 0x03, 0x80, 0x3C, 0x07, 0xC1, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x78, 0x3C, 0x03, 0xC0, 0x78, 0x0E, 0x00, 0xE0, 0x70, 0x03, 0x83,
  0xC0, 0x0E, 0x0E, 0x00, 0x18, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00,
  0x07, 0x1C, 0x00, 0x18, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x3E, 0x1E,
  0x01, 0xF0, 0x38, 0x0F, 0xC0, 0xFF, 0xF7, 0x01, 0xFF, 0x9C, 0x01, 0xF8,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x02, 0x07, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xC0, 0xF0,
  0x3C, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x1E, 0x07, 0x83, 0xE0, 0x70, 0x00, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xF0,
  0x03, 0xFF, 0x07, 0xFF, 0xC1, 0x81, 0xE0, 0x80, 0x78, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x06, 0x03, 0x80, 0x00, 0x07, 0x07,
  0x00, 0x00, 0x07, 0x06, 0x00, 0x00, 0x07, 0x0E, 0x00, 0xFF, 0x07, 0x0C,
  0x03, 0xFF, 0x07, 0x1C, 0x07, 0x07, 0x07, 0x18, 0x0E, 0x06, 0x07, 0x38,
  0x1C, 0x06, 0x07, 0x30, 0x1C, 0x0E, 0x07, 0x30, 0x38, 0x0E, 0x07, 0x70,
  0x38, 0x0C, 0x06, 0x70, 0x70, 0x1C, 0x06, 0x60, 0x70, 0x1C, 0x06, 0x60,
  0x60, 0x1C, 0x0E, 0xE0, 0x60, 0x18, 0x0E, 0xE0, 0xE0, 0x38, 0x0C, 0xE0,
  0xE0, 0x38, 0x1C, 0xE0, 0xE0, 0x38, 0x18, 0xC0, 0xE0, 0x70, 0x18, 0xC0,
  0xE0, 0x70, 0x38, 0xC0, 0xE0, 0xF0, 0x70, 0xC0, 0xE1, 0xB8, 0x60, 0xC0,
  0x73, 0x9D, 0xE0, 0xC0, 0x7F, 0x1F, 0xC0, 0xE0, 0x1C, 0x0F, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x20, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0xC0, 0x00, 0x1D, 0x80, 0x00, 0x3B,
  0x00, 0x00, 0xE6, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x1C, 0x00, 0x0E, 0x38,
  0x00, 0x18, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80,
  0x07, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x01,
  0xC0, 0x70, 0x07, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07, 0x00, 0x38, 0x1C, 0x00,
  0x70, 0x38, 0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x03, 0x87, 0x80, 0x07,
  0x0E, 0x00, 0x06, 0x1C, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xE0, 0xFE, 0x01, 0xC0, 0x1E,
  0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x07,
  0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x38,
  0x07, 0x00, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0,
  0x0E, 0x01, 0xF0, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x38,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x70, 0x00, 0x70,
  0x70, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x70, 0x07, 0xC0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7C, 0x06, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x07, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0E, 0x3F, 0xC0, 0x07, 0x00,
  0xF8, 0x01, 0xC0, 0x0F, 0x00, 0x70, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x0E,
  0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x3C,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00,
  0x3C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xE1,
  0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x0F, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x1C,
  0x00, 0xF8, 0x07, 0x00, 0x7C, 0x01, 0xC0, 0x7E, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x01, 0xE0, 0x0F, 0x80, 0x04, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x3F, 0xF1, 0xC0, 0x07, 0xFE, 0x38, 0x00, 0xFF, 0x87, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x78,
  0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00,
  0x07, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0x3F, 0x03,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x00,
  0x03, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0,
  0x01, 0xE0, 0x1C, 0x00, 0x78, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x01, 0xE0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03,
  0xC0, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x39, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x3B,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF9, 0xC0, 0x00, 0x3E, 0x38, 0x00,
  0x07, 0x87, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00,
  0x70, 0x0E, 0x00, 0x0E, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x78, 0x00, 0xE0, 0x0E,
  0x00, 0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x06, 0xE0, 0x00, 0x1D, 0xC0, 0x77, 0x00, 0x00,
  0xFC, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0xEE,
  0x00, 0x07, 0x38, 0x07, 0x30, 0x00, 0x39, 0xC0, 0x71, 0x80, 0x03, 0x9C,
  0x03, 0x8C, 0x00, 0x1C, 0xE0, 0x1C, 0x60, 0x01, 0xC7, 0x00, 0xE3, 0x80,
  0x0E, 0x38, 0x06, 0x1C, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x07, 0x1C, 0x03,
  0x87, 0x00, 0x70, 0xE0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38,
  0x38, 0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0x70, 0x1C, 0x1C, 0x03, 0x83,
  0x80, 0xE0, 0xE0, 0x1C, 0x0C, 0x0E, 0x07, 0x00, 0xE0, 0x60, 0x70, 0x38,
  0x0E, 0x03, 0x07, 0x03, 0x80, 0x70, 0x18, 0x38, 0x1C, 0x03, 0x80, 0xE3,
  0x80, 0xE0, 0x1C, 0x07, 0x18, 0x07, 0x00, 0xC0, 0x39, 0xC0, 0x38, 0x0E,
  0x01, 0xCC, 0x03, 0x80, 0x70, 0x0E, 0xE0, 0x1C, 0x03, 0x80, 0x76, 0x00,
  0xE0, 0x1C, 0x03, 0xF0, 0x07, 0x01, 0xC0, 0x1F, 0x00, 0x70, 0x0E, 0x00,
  0xF8, 0x03, 0x80, 0x70, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x03,
  0x80, 0x7C, 0x00, 0x0E, 0x01, 0xF8, 0x00, 0x38, 0x07, 0xE0, 0x00, 0xE0,
  0x1B, 0x80, 0x07, 0x00, 0xE6, 0x00, 0x1C, 0x03, 0x9C, 0x00, 0x70, 0x0E,
  0x70, 0x01, 0xC0, 0x39, 0xC0, 0x07, 0x00, 0xE3, 0x00, 0x38, 0x07, 0x0E,
  0x00, 0xE0, 0x1C, 0x38, 0x03, 0x80, 0x70, 0xE0, 0x0E, 0x01, 0xC3, 0x80,
  0x38, 0x06, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x07, 0x00, 0xE0, 0x70, 0x1C,
  0x03, 0x81, 0xC0, 0x70, 0x0E, 0x03, 0x83, 0x80, 0x70, 0x0E, 0x0E, 0x01,
  0xC0, 0x38, 0x38, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x01, 0xC3, 0x80, 0x70,
  0x07, 0x1C, 0x03, 0x80, 0x1C, 0x70, 0x0E, 0x00, 0x71, 0xC0, 0x38, 0x00,
  0xE7, 0x00, 0xE0, 0x03, 0x9C, 0x03, 0x80, 0x0E, 0xE0, 0x1C, 0x00, 0x3B,
  0x80, 0x70, 0x00, 0x7E, 0x01, 0xC0, 0x01, 0xF8, 0x07, 0x00, 0x07, 0xC0,
  0x38, 0x00, 0x1F, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xF0, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x01, 0xE0,
  0x38, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xF1, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x07, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0,
  0x00, 0x1E, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xE0,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x01, 0xE0, 0x07,
  0x80, 0x7C, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x03, 0x8F, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x38, 0x01, 0xC0,
  0x70, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x07, 0x83, 0x80, 0x0E, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x38, 0x03,
  0xC0, 0x70, 0x1F, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xE0, 0x7C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x0E, 0x0F, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x70,
  0x00, 0x07, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3D,
  0xE0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07,
  0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x3C, 0x00,
  0x1C, 0x07, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x0F,
  0x83, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0x8F, 0xF0,
  0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x81,
  0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C,
  0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x03, 0x80,
  0x1E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x38, 0x07, 0xC0, 0x7F, 0xFF,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00,
  0x1C, 0x0E, 0x00, 0x38, 0x1E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70,
  0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0F, 0x03, 0x80, 0x0E, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x78, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0xFC, 0x0F, 0x00, 0xF0, 0x02, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xC0, 0x07, 0x80, 0xF8,
  0x3F, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C,
  0x00, 0x07, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07,
  0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0,
  0x38, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x7E, 0x1F,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xCE, 0x00,
  0x07, 0x9C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0x70, 0x07, 0x80, 0x60, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x70, 0x03, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE1,
  0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03, 0x80,
  0x03, 0xB8, 0x00, 0x3C, 0x00, 0x1D, 0xC0, 0x01, 0xE0, 0x01, 0xEE, 0x00,
  0x1F, 0x00, 0x0E, 0x70, 0x00, 0xD8, 0x00, 0x73, 0x80, 0x0E, 0xC0, 0x07,
  0x1C, 0x00, 0x76, 0x00, 0x38, 0xE0, 0x03, 0x30, 0x03, 0x87, 0x00, 0x3B,
  0x80, 0x1C, 0x38, 0x01, 0xDC, 0x00, 0xE1, 0xC0, 0x1C, 0xE0, 0x0E, 0x0E,
  0x00, 0xE7, 0x00, 0x70, 0x70, 0x06, 0x38, 0x07, 0x03, 0x80, 0x71, 0xC0,
  0x38, 0x1C, 0x03, 0x0E, 0x03, 0xC0, 0xE0, 0x38, 0x70, 0x1C, 0x07, 0x01,
  0xC3, 0x80, 0xE0, 0x38, 0x1C, 0x1C, 0x0E, 0x01, 0xC0, 0xE0, 0xE0, 0x70,
  0x0E, 0x06, 0x07, 0x07, 0x00, 0x70, 0x70, 0x38, 0x38, 0x03, 0x83, 0x81,
  0xC1, 0xC0, 0x1C, 0x38, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x70, 0xE0, 0x07,
  0x0C, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x1C, 0x70, 0x01, 0xC6, 0x00, 0xE3,
  0x80, 0x0E, 0x70, 0x07, 0x38, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x03, 0xB8,
  0x01, 0xDC, 0x00, 0x1D, 0xC0, 0x0E, 0xE0, 0x00, 0xEC, 0x00, 0x76, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x70, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x03,
  0x80, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1C, 0x0E,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x03, 0x98, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x38,
  0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x78,
  0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x7E, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0x60, 0x03, 0xC7, 0x00,
  0x38, 0x70, 0x07, 0x87, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70,
  0x1C, 0x03, 0x03, 0xC0, 0x38, 0x38, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03,
  0x8E, 0x00, 0x38, 0xE0, 0x03, 0x9C, 0x00, 0x19, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x60, 0x60, 0x70, 0x70, 0x70, 0x70, 0x70, 0x30, 0x30, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x07, 0x07, 0x07, 0x07, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xB0, 0x00, 0x0E, 0x70, 0x00, 0x18, 0xE0,
  0x00, 0x70, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0E, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x06,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0x73, 0x80,
  0x00, 0xEF, 0x00, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xE1,
  0xC1, 0xC3, 0x83, 0x07, 0x06, 0x06, 0x00, 0x1C, 0x00, 0x03, 0xFC, 0x70,
  0x1F, 0xF9, 0xC0, 0xF0, 0x66, 0x07, 0x80, 0xD8, 0x3C, 0x03, 0xE0, 0xE0,
  0x07, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x1E, 0x00, 0x1C, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x3C,
  0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xE0,
  0xE0, 0x0F, 0x83, 0x80, 0x3E, 0x07, 0x01, 0xB8, 0x1E, 0x1C, 0xC0, 0x3F,
  0xE3, 0x00, 0x7F, 0x1C, 0x00, 0x20, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x83, 0x80, 0x0E, 0x7F, 0x80, 0x73,
  0xFF, 0x01, 0xDC, 0x1E, 0x07, 0xE0, 0x38, 0x1F, 0x00, 0xF0, 0x78, 0x01,
  0xC3, 0xE0, 0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xE0, 0x01, 0xC7,
  0x80, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0xF1, 0xC0, 0x03, 0x87, 0x00,
  0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0x71, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x70, 0x78,
  0x01, 0xC1, 0xE0, 0x0E, 0x0E, 0xC0, 0x78, 0x3B, 0x87, 0xC0, 0xC7, 0xFE,
  0x03, 0x0F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xF0,
  0x1F, 0xFC, 0x0F, 0x02, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x60, 0x3F, 0xF8,
  0x07, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x07, 0xF8,
  0xE0, 0x07, 0xFE, 0x70, 0x07, 0x83, 0xB8, 0x07, 0x80, 0xF8, 0x07, 0x80,
  0x3C, 0x03, 0x80, 0x1E, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x01, 0xC0,
  0x03, 0x80, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38,
  0x00, 0x70, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07,
  0x00, 0x0F, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0xC0,
  0x70, 0x01, 0xE0, 0x38, 0x01, 0xF0, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0xF8,
  0x07, 0x00, 0xFC, 0x01, 0xC0, 0xEE, 0x00, 0xF0, 0xE6, 0x00, 0x3F, 0xE3,
  0x00, 0x0F, 0xE1, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x01, 0xE0, 0xE0, 0x78, 0x1C, 0x1E, 0x01, 0xC3, 0x80,
  0x38, 0xE0, 0x07, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0F, 0x38, 0x03,
  0xC7, 0x00, 0xF0, 0xE0, 0xFC, 0x1F, 0xFE, 0x07, 0xFF, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x08,
  0x3E, 0x06, 0x03, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x40, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x0D, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xC3, 0x00, 0x7F,
  0xE7, 0x00, 0xF0, 0x77, 0x01, 0xE0, 0x36, 0x03, 0xC0, 0x1E, 0x03, 0x80,
  0x1E, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00,
  0x1C, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x38, 0x00,
  0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x38, 0x01,
  0xF0, 0x38, 0x01, 0xE0, 0x38, 0x03, 0xE0, 0x38, 0x07, 0xE0, 0x1C, 0x0E,
  0xE0, 0x1E, 0x1C, 0xC0, 0x0F, 0xF9, 0xC0, 0x07, 0xF1, 0xC0, 0x00, 0x81,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x80, 0x3C, 0x00, 0xF8, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x38, 0x01,
  0xCF, 0xF0, 0x1C, 0xFF, 0xC0, 0xEE, 0x0F, 0x07, 0xE0, 0x38, 0x3E, 0x01,
  0xC1, 0xE0, 0x0E, 0x1E, 0x00, 0x70, 0xF0, 0x03, 0x87, 0x00, 0x1C, 0x38,
  0x01, 0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C,
  0x38, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00,
  0x1C, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87,
  0x00, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03,
  0x87, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x02, 0x7C, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x1C, 0x07,
  0x01, 0xC0, 0x38, 0x1E, 0x01, 0x81, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0xE0,
  0x07, 0x0E, 0x00, 0x38, 0xE0, 0x01, 0x8E, 0x00, 0x1C, 0xF0, 0x00, 0xEF,
  0x80, 0x07, 0x7C, 0x00, 0x37, 0xE0, 0x03, 0xF7, 0x00, 0x1F, 0x1C, 0x00,
  0xF0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x3C, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x30, 0x07, 0x03, 0x80, 0x38, 0x1C,
  0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x38, 0x01, 0x8F,
  0xF0, 0x7F, 0x81, 0xCF, 0xF8, 0xFF, 0xE0, 0xEE, 0x1E, 0xF0, 0xF0, 0x7C,
  0x07, 0x60, 0x38, 0x3C, 0x03, 0xE0, 0x1C, 0x1E, 0x01, 0xF0, 0x0E, 0x1E,
  0x00, 0xF0, 0x07, 0x0F, 0x00, 0x78, 0x03, 0x87, 0x00, 0x38, 0x01, 0xC3,
  0x80, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x00, 0x71, 0xC0, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x00, 0x38, 0x70, 0x03, 0x80, 0x1C, 0x38, 0x01, 0xC0, 0x0E,
  0x38, 0x00, 0xE0, 0x07, 0x1C, 0x00, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x03,
  0x87, 0x00, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x00,
  0x61, 0xC0, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x70, 0x03, 0x80,
  0x1C, 0x38, 0x01, 0xC0, 0x0E, 0x38, 0x01, 0xC0, 0x0E, 0x1C, 0x00, 0xE0,
  0x07, 0x0E, 0x00, 0x70, 0x03, 0x87, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x18, 0xFF, 0x01, 0xCF, 0xFC, 0x0E, 0xE0, 0xF0, 0x7E, 0x03, 0x83,
  0x60, 0x1C, 0x1E, 0x00, 0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00,
  0x38, 0x70, 0x01, 0xC7, 0x80, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E,
  0x00, 0x38, 0x70, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x3C, 0x1E, 0x07, 0x80, 0xE0, 0xF0, 0x0F, 0x0E, 0x00, 0x71, 0xC0,
  0x07, 0x1C, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x77, 0x80, 0x07, 0x70,
  0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x1C,
  0xE0, 0x03, 0xCE, 0x00, 0x38, 0xE0, 0x07, 0x0F, 0x00, 0xF0, 0x70, 0x1E,
  0x07, 0xC3, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x31, 0xFE, 0x00, 0x39, 0xFF, 0x80, 0x1D, 0xC1, 0xE0,
  0x0E, 0xC0, 0x70, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x0E, 0x03, 0xE0, 0x07,
  0x01, 0xE0, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00,
  0x70, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x07, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0xE0,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x1E,
  0x00, 0x78, 0x0F, 0x00, 0x38, 0x07, 0x80, 0x38, 0x07, 0x60, 0x3C, 0x03,
  0xB8, 0x7C, 0x01, 0xCF, 0xFC, 0x00, 0xE3, 0xF8, 0x00, 0x60, 0x20, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFC, 0x30, 0x1F, 0xF9, 0xC0, 0xF0,
  0x77, 0x07, 0x80, 0xD8, 0x3C, 0x03, 0xE0, 0xE0, 0x07, 0x87, 0x00, 0x1E,
  0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x1C, 0x70,
  0x00, 0x71, 0xC0, 0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xE0, 0x00,
  0xE3, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03, 0xC3,
  0x80, 0x0F, 0x0E, 0x00, 0x7C, 0x38, 0x01, 0xE0, 0xE0, 0x0F, 0x83, 0x80,
  0x7E, 0x0F, 0x03, 0xB8, 0x1E, 0x1C, 0xC0, 0x3F, 0xE7, 0x00, 0x7F, 0x1C,
  0x00, 0x20, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x81, 0x8F, 0xC1, 0xCF, 0xE0, 0xEF, 0x00, 0x7E, 0x00,
  0x36, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x3F, 0xFC,
  0x1E, 0x07, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x08, 0x03, 0xC3, 0x81, 0xE0, 0xFF, 0xF0, 0x1F, 0xF8,
  0x00, 0xA0, 0x00, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x0F, 0xFF, 0x7F, 0xF0, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x08, 0x3F, 0xC0,
  0xFE, 0x00, 0x80, 0x00, 0x0F, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E,
  0x1C, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80,
  0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3,
  0x80, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x03, 0xC3, 0x80, 0x1E, 0x1C, 0x01, 0xE0, 0xE0, 0x1F, 0x07, 0x01, 0xF8,
  0x3C, 0x3D, 0xC0, 0xFF, 0xCC, 0x03, 0xF8, 0x60, 0x07, 0x00, 0x00, 0xE0,
  0x01, 0xFC, 0x00, 0x3B, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x71, 0xC0,
  0x0E, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x1E, 0x1C, 0x03, 0x81, 0x80,
  0x70, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0xE0, 0x1C, 0x1C, 0x03, 0x87,
  0x00, 0x70, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x07, 0x38,
  0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x07, 0x80, 0x1F,
  0x80, 0x1E, 0x00, 0xEE, 0x00, 0xF8, 0x03, 0xB8, 0x03, 0xE0, 0x1C, 0xE0,
  0x0F, 0x80, 0x73, 0x80, 0x7E, 0x01, 0xCE, 0x01, 0xB8, 0x0E, 0x38, 0x0E,
  0xE0, 0x38, 0xE0, 0x3B, 0x81, 0xC3, 0x81, 0xCE, 0x07, 0x0E, 0x07, 0x38,
  0x1C, 0x38, 0x18, 0xE0, 0xE0, 0xE0, 0xE3, 0x83, 0x83, 0x83, 0x0E, 0x1C,
  0x0E, 0x1C, 0x38, 0x70, 0x38, 0x70, 0xE1, 0x80, 0xE3, 0x83, 0x8E, 0x03,
  0x8E, 0x0E, 0x38, 0x0E, 0x30, 0x39, 0xC0, 0x39, 0xC0, 0xE7, 0x00, 0xE6,
  0x03, 0x98, 0x03, 0xB8, 0x0E, 0xE0, 0x0E, 0xE0, 0x3B, 0x00, 0x3B, 0x00,
  0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x3E,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x0F,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x70,
  0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0x73, 0x80,
  0x00, 0x73, 0x80, 0x00, 0x77, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xEC, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x8E, 0x00,
  0x07, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x1C, 0x03, 0x00,
  0x38, 0x03, 0x80, 0x78, 0x03, 0x80, 0x70, 0x03, 0x80, 0xE0, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x38, 0x03,
  0x80, 0x03, 0x80, 0x38, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x38, 0x38, 0x00, 0x01, 0x83, 0x80, 0x00, 0x18, 0x70, 0x00,
  0x01, 0x87, 0x00, 0x00, 0x18, 0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x1D, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x04, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x7F,
  0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x07,
  0xE0, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00,
  0xFC, 0xFE, 0x1F, 0x80, 0xFF, 0xE8, 0x01, 0xFE, 0x00,
};

const GFXglyph NotoSans_Condensed_LightItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 39, 12, 1, -39 },
  { 60, 13, 14, 17, 6, -39 },
  { 83, 26, 39, 26, 1, -39 },
  { 210, 23, 45, 23, 0, -42 },
  { 340, 29, 41, 35, 3, -40 },
  { 489, 24, 41, 26, 0, -40 },
  { 612, 5, 14, 10, 6, -39 },
  { 621, 16, 48, 14, 1, -39 },
  { 717, 16, 48, 14, -4, -39 },
  { 813, 18, 19, 22, 6, -42 },
  { 856, 21, 25, 25, 3, -32 },
  { 922, 8, 13, 11, -2, -6 },
  { 935, 13, 3, 15, 1, -16 },
  { 940, 4, 5, 11, 1, -5 },
  { 943, 25, 39, 17, -3, -39 },
  { 1065, 21, 41, 23, 2, -40 },
  { 1173, 12, 39, 23, 7, -39 },
  { 1232, 24, 40, 23, -1, -40 },
  { 1352, 23, 41, 23, 0, -40 },
  { 1470, 24, 40, 23, -1, -40 },
  { 1590, 23, 40, 23, 0, -39 },
  { 1705, 22, 41, 23, 2, -40 },
  { 1818, 22, 39, 23, 3, -39 },
  { 1926, 23, 41, 23, 0, -40 },
  { 2044, 22, 41, 23, 1, -40 },
  { 2157, 10, 29, 11, 0, -29 },
  { 2194, 13, 36, 11, -3, -29 },
  { 2253, 21, 25, 25, 3, -32 },
  { 2319, 21, 14, 25, 3, -26 },
  { 2356, 21, 25, 25, 3, -32 },
  { 2422, 17, 40, 17, 2, -40 },
  { 2507, 32, 44, 35, 2, -39 },
  { 2683, 23, 39, 23, -3, -39 },
  { 2796, 24, 39, 25, 1, -39 },
  { 2913, 24, 41, 24, 3, -40 },
  { 3036, 26, 39, 28, 1, -39 },
  { 3163, 23, 39, 22, 1, -39 },
  { 3276, 23, 39, 21, 1, -39 },
  { 3389, 27, 41, 29, 3, -40 },
  { 3528, 29, 39, 29, 1, -39 },
  { 3670, 19, 39, 13, -2, -39 },
  { 3763, 20, 49, 11, -8, -39 },
  { 3886, 27, 39, 24, 1, -39 },
  { 4018, 15, 39, 20, 1, -39 },
  { 4092, 37, 39, 37, 1, -39 },
  { 4273, 30, 39, 30, 1, -39 },
  { 4420, 26, 41, 30, 3, -40 },
  { 4554, 23, 39, 24, 1, -39 },
  { 4667, 26, 49, 30, 3, -40 },
  { 4827, 23, 39, 24, 1, -39 },
  { 4940, 24, 41, 22, -1, -40 },
  { 5063, 20, 39, 20, 5, -39 },
  { 5161, 26, 40, 29, 3, -39 },
  { 5291, 23, 39, 23, 5, -39 },
  { 5404, 37, 39, 38, 5, -39 },
  { 5585, 28, 39, 21, -3, -39 },
  { 5722, 20, 39, 21, 5, -39 },
  { 5820, 26, 39, 21, -2, -39 },
  { 5947, 20, 48, 16, -1, -39 },
  { 6067, 8, 39, 18, 6, -39 },
  { 6106, 21, 48, 16, -4, -39 },
  { 6232, 23, 21, 24, 1, -39 },
  { 6293, 18, 2, 17, -5, 5 },
  { 6298, 7, 9, 13, 8, -42 },
  { 6306, 22, 31, 25, 2, -30 },
  { 6392, 22, 43, 25, 1, -42 },
  { 6511, 18, 31, 19, 2, -30 },
  { 6581, 25, 43, 25, 2, -42 },
  { 6716, 19, 31, 22, 2, -30 },
  { 6790, 27, 55, 13, -7, -42 },
  { 6976, 24, 43, 25, 0, -30 },
  { 7105, 21, 42, 24, 1, -42 },
  { 7216, 11, 40, 11, 1, -40 },
  { 7271, 19, 53, 11, -7, -40 },
  { 7397, 21, 42, 20, 1, -42 },
  { 7508, 11, 42, 10, 1, -42 },
  { 7566, 33, 30, 36, 1, -30 },
  { 7690, 21, 30, 24, 1, -30 },
  { 7769, 20, 31, 24, 2, -30 },
  { 7847, 25, 43, 25, -2, -30 },
  { 7982, 22, 43, 25, 2, -30 },
  { 8101, 17, 30, 16, 1, -30 },
  { 8165, 18, 31, 18, 0, -30 },
  { 8235, 13, 37, 13, 2, -36 },
  { 8296, 21, 30, 24, 2, -29 },
  { 8375, 19, 29, 19, 3, -29 },
  { 8444, 30, 29, 31, 3, -29 },
  { 8553, 24, 29, 20, -2, -29 },
  { 8640, 28, 42, 19, -6, -29 },
  { 8787, 20, 29, 17, -2, -29 },
  { 8860, 20, 48, 18, 1, -39 },
  { 8980, 3, 55, 23, 10, -42 },
  { 9001, 19, 48, 18, -3, -39 },
  { 9115, 21, 5, 25, 3, -22 },
};

const GFXfont NotoSans_Condensed_LightItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC55PT7B_H_
