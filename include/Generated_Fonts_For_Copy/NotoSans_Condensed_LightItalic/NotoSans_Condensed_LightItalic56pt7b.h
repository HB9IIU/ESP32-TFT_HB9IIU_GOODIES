#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC56PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0xE7, 0x07, 0x38, 0x39, 0xC1,
  0xCE, 0x0C, 0x60, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0x8C, 0x0C, 0x60, 0xE0,
  0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x30,
  0x1C, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00,
  0x60, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x01, 0x80,
  0x01, 0xC0, 0x60, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0x06, 0x03,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x18, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00,
  0x38, 0x1C, 0x00, 0x0C, 0x06, 0x00, 0x07, 0x01, 0x80, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC0, 0x18, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xC0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x06,
  0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x30, 0x1C, 0x00,
  0x0C, 0x06, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0x01, 0xF1,
  0x8E, 0x01, 0xC3, 0x02, 0x03, 0x83, 0x00, 0x03, 0x83, 0x00, 0x03, 0x03,
  0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x07, 0x06, 0x00, 0x03, 0x86,
  0x00, 0x03, 0x86, 0x00, 0x03, 0xCC, 0x00, 0x01, 0xEC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1B, 0xC0, 0x00, 0x19, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x30,
  0xF0, 0x00, 0x30, 0x70, 0x00, 0x30, 0x70, 0x00, 0x30, 0x70, 0x00, 0x60,
  0x70, 0x00, 0x60, 0x60, 0x00, 0x60, 0xE0, 0x00, 0x61, 0xE0, 0x40, 0x63,
  0xC0, 0x78, 0xCF, 0x80, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xC0,
  0x7F, 0x80, 0x0E, 0x03, 0xC7, 0x00, 0x38, 0x0E, 0x1C, 0x01, 0xC0, 0x70,
  0x30, 0x06, 0x01, 0x80, 0xC0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x38, 0x0C,
  0x07, 0x00, 0xC0, 0x30, 0x38, 0x07, 0x01, 0xC0, 0xE0, 0x1C, 0x07, 0x07,
  0x00, 0x70, 0x1C, 0x18, 0x01, 0x80, 0x60, 0xE0, 0x06, 0x01, 0x87, 0x00,
  0x38, 0x0E, 0x1C, 0x00, 0xE0, 0x38, 0xE0, 0x03, 0x80, 0xC3, 0x0F, 0xCE,
  0x07, 0x1C, 0x7F, 0xB8, 0x1C, 0x63, 0x8F, 0xE0, 0xE3, 0x8C, 0x1F, 0x83,
  0x9C, 0x70, 0x77, 0x1C, 0x71, 0x81, 0xDF, 0xE3, 0x8E, 0x07, 0x3F, 0x0C,
  0x30, 0x1C, 0x20, 0x71, 0xC0, 0x70, 0x01, 0x87, 0x01, 0xC0, 0x0E, 0x18,
  0x07, 0x00, 0x70, 0x60, 0x18, 0x01, 0xC3, 0x80, 0x60, 0x0E, 0x0E, 0x03,
  0x80, 0x30, 0x38, 0x0E, 0x01, 0xC0, 0xE0, 0x30, 0x06, 0x03, 0x81, 0xC0,
  0x38, 0x0C, 0x07, 0x01, 0xC0, 0x30, 0x18, 0x07, 0x00, 0xE0, 0xE0, 0x38,
  0x03, 0x83, 0x00, 0xC0, 0x0E, 0x1C, 0x07, 0x00, 0x1F, 0xE0, 0x38, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x83, 0x80, 0x03, 0x81,
  0xC0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x30, 0x00, 0xE0, 0x38, 0x00, 0x70,
  0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x07, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC7, 0x80, 0x00, 0x77, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x1E, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x1C, 0x07, 0x0E, 0x0E, 0x07,
  0x0E, 0x07, 0x83, 0x8E, 0x01, 0xC1, 0xC7, 0x00, 0xE1, 0xC7, 0x00, 0x38,
  0xE3, 0x80, 0x1C, 0xE1, 0xC0, 0x0F, 0x71, 0xC0, 0x03, 0xF0, 0xE0, 0x01,
  0xF0, 0x70, 0x00, 0x78, 0x38, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x07, 0x00,
  0x3F, 0x03, 0xC0, 0x7B, 0xC0, 0xF0, 0xF8, 0xE0, 0x7F, 0xF8, 0x78, 0x0F,
  0xF0, 0x1C, 0x00, 0x80, 0x00, 0x00, 0x3C, 0xE3, 0x8E, 0x71, 0xC7, 0x1C,
  0x61, 0x8E, 0x38, 0xC3, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x10, 0x18, 0x07, 0x06, 0x03, 0xF3, 0x80, 0x1F, 0xC7,
  0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x0F, 0x80, 0x07, 0x60, 0x03, 0x9C, 0x01,
  0xC3, 0x00, 0xE0, 0xE0, 0x70, 0x18, 0x0C, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x07, 0x0F,
  0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xC0, 0x7F,
  0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xF3, 0xE0, 0x1E,
  0x07, 0x00, 0xE0, 0x3C, 0x0E, 0x00, 0xE0, 0xF0, 0x07, 0x07, 0x00, 0x38,
  0x78, 0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00,
  0x1C, 0xF0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xDE,
  0x00, 0x1E, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01,
  0xDE, 0x00, 0x1E, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0,
  0x03, 0xCE, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x70,
  0xE0, 0x03, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x0F, 0x01,
  0xE0, 0x38, 0x1E, 0x01, 0xF1, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x0F, 0xE0, 0xF7, 0x0F,
  0x71, 0xF3, 0x9E, 0x1C, 0xE0, 0xE2, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0xE0, 0x1E, 0x00,
  0x40, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0x83, 0xE0, 0x1C,
  0x01, 0xE0, 0x20, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x10, 0x01, 0xF0,
  0x3C, 0x0F, 0xC0, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xCE,
  0x00, 0x01, 0x8C, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x1C,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x70, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x70,
  0x03, 0x80, 0x70, 0x03, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x80, 0x0F, 0x80, 0xF0, 0x3F, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0x02, 0x80, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0,
  0x0F, 0xC1, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x3E, 0x00, 0xE3, 0xFC, 0x03, 0xBF, 0xF8, 0x1D, 0xE0, 0xF0, 0x76, 0x01,
  0xE1, 0xF0, 0x03, 0x87, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x70, 0x00, 0xE3,
  0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80,
  0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0F,
  0x0E, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0x70, 0x07, 0x01, 0xE0, 0x38, 0x03,
  0xC3, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x78,
  0x3C, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x07, 0x03, 0xC0,
  0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80,
  0x0E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x70, 0x00, 0xF1, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xC7, 0x80, 0x0F, 0x83,
  0xC0, 0x1E, 0x01, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x78, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0xE0, 0x00,
  0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x1F, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x7C, 0x3C, 0x01, 0xC0, 0x78, 0x0E, 0x00, 0xE0,
  0x78, 0x03, 0x81, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0,
  0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01,
  0xC7, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x87,
  0x00, 0x1E, 0x1C, 0x00, 0xF8, 0x78, 0x06, 0xE0, 0xF0, 0x7B, 0x01, 0xFF,
  0xDC, 0x07, 0xFC, 0x70, 0x07, 0xC1, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x08, 0x1F, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0x20, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x07,
  0x81, 0xE0, 0xF8, 0x1C, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x80,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x03, 0xFE, 0x07, 0xFF, 0xC3, 0xE1,
  0xE0, 0x80, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xC0, 0x07,
  0x80, 0x03, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x18, 0x03, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x07, 0x01, 0x80, 0x00,
  0x01, 0x81, 0xC0, 0x00, 0x00, 0xC1, 0xC0, 0x0F, 0xC0, 0x70, 0xE0, 0x1F,
  0xF8, 0x38, 0xE0, 0x1E, 0x38, 0x1C, 0x70, 0x1C, 0x1C, 0x0E, 0x30, 0x1C,
  0x0E, 0x07, 0x38, 0x1C, 0x06, 0x03, 0x18, 0x0E, 0x03, 0x01, 0x8C, 0x0E,
  0x03, 0x80, 0xCE, 0x07, 0x01, 0xC0, 0xE7, 0x03, 0x00, 0xC0, 0x73, 0x03,
  0x80, 0x60, 0x39, 0x81, 0xC0, 0x70, 0x19, 0xC0, 0xC0, 0x38, 0x1C, 0xE0,
  0x60, 0x18, 0x0E, 0x70, 0x70, 0x1C, 0x06, 0x38, 0x38, 0x0E, 0x07, 0x1C,
  0x1C, 0x0F, 0x03, 0x8C, 0x0E, 0x07, 0x83, 0x86, 0x07, 0x06, 0xC1, 0x83,
  0x01, 0x87, 0x61, 0xC1, 0x80, 0xFF, 0x3F, 0xC0, 0xE0, 0x3F, 0x0F, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x18,
  0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xEE, 0x00, 0x00, 0xEE, 0x00,
  0x01, 0xCE, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x8E, 0x00,
  0x03, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x0E, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xC0, 0x07, 0x03,
  0x80, 0x07, 0x03, 0x80, 0x07, 0x07, 0x80, 0x07, 0x07, 0x00, 0x07, 0x0F,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x07, 0x78, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x1C, 0x03, 0xE0, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1E,
  0x03, 0x80, 0x07, 0x03, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x01,
  0xE0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x3C, 0x00, 0x78, 0x1C, 0x00,
  0x38, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x78, 0x03, 0x81, 0xF8, 0x03, 0xFF,
  0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xE0, 0x7E, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x01, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x07,
  0x00, 0x07, 0x07, 0x80, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x78, 0x00, 0x78, 0x38, 0x00, 0x38,
  0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x7C, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x07, 0xE1, 0xE0, 0x0F, 0x80, 0x10, 0x0F,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0x80, 0xF8, 0x01, 0xC0, 0x0F, 0x00,
  0x70, 0x01, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x03,
  0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80,
  0x01, 0xC1, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0F,
  0x0E, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x70, 0x00,
  0x1E, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x38, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x1E,
  0x01, 0xC0, 0x1F, 0x00, 0x70, 0x1F, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x00, 0xE0, 0x1F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xF0, 0xE0, 0x03,
  0xFF, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C,
  0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x07, 0x80, 0x03, 0x80, 0x38,
  0x00, 0x38, 0x03, 0xE0, 0x03, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xF0, 0x1C,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38,
  0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x1C,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x1E, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x38,
  0x07, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38,
  0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x07,
  0x00, 0x0E, 0x01, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x0E,
  0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x7E, 0x00, 0x00, 0xFD, 0xC0, 0x00,
  0x1F, 0x38, 0x00, 0x07, 0xC7, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x0E,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x03,
  0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xE0, 0x01, 0xC0, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x38,
  0x07, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x01, 0xDC, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x0E, 0x60, 0x00, 0x39, 0xC0,
  0x39, 0x80, 0x00, 0xEE, 0x00, 0xE6, 0x00, 0x07, 0x38, 0x03, 0x9C, 0x00,
  0x1C, 0xE0, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x03, 0x8E, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x03,
  0x87, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0x70, 0x70, 0x0E,
  0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0E, 0x0E, 0x01, 0xC0, 0xC0, 0x38,
  0x38, 0x07, 0x03, 0x01, 0xC0, 0xE0, 0x1C, 0x0C, 0x07, 0x07, 0x80, 0x70,
  0x38, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0xE0, 0x70, 0x0E, 0x03, 0x87, 0x01,
  0xC0, 0x38, 0x0E, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0xE0, 0x38, 0x03, 0x80,
  0xE3, 0x80, 0xE0, 0x0E, 0x03, 0x9C, 0x03, 0x80, 0x70, 0x0E, 0x70, 0x0E,
  0x01, 0xC0, 0x3B, 0x80, 0x38, 0x07, 0x00, 0xEE, 0x01, 0xC0, 0x1C, 0x01,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0xC0, 0x1C, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xC0, 0x3E, 0x00,
  0x07, 0x01, 0xF8, 0x00, 0x38, 0x07, 0xE0, 0x00, 0xE0, 0x1F, 0x80, 0x03,
  0x80, 0x77, 0x00, 0x0E, 0x03, 0x9C, 0x00, 0x38, 0x0E, 0x70, 0x01, 0xC0,
  0x39, 0xC0, 0x07, 0x00, 0xE3, 0x80, 0x1C, 0x03, 0x8E, 0x00, 0x70, 0x1C,
  0x38, 0x01, 0xC0, 0x70, 0xE0, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x07, 0x07,
  0x00, 0xE0, 0x1C, 0x1C, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x03, 0x80, 0xC0,
  0x70, 0x0E, 0x03, 0x81, 0xC0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0x38, 0x1C,
  0x07, 0x00, 0x60, 0xE0, 0x1C, 0x01, 0xC3, 0x80, 0x70, 0x07, 0x0E, 0x01,
  0xC0, 0x1C, 0x38, 0x0E, 0x00, 0x30, 0xE0, 0x38, 0x00, 0xE7, 0x00, 0xE0,
  0x03, 0x9C, 0x03, 0x80, 0x0E, 0x70, 0x0E, 0x00, 0x39, 0xC0, 0x70, 0x00,
  0x77, 0x01, 0xC0, 0x01, 0xF8, 0x07, 0x00, 0x07, 0xE0, 0x1C, 0x00, 0x1F,
  0x80, 0x70, 0x00, 0x3E, 0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0xC0,
  0x38, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x3C, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCF, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0xB8, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x3C, 0xE0,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x70,
  0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x03,
  0xC0, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xE0, 0x3C, 0x01, 0xC0, 0x1E,
  0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x03, 0xC0, 0x07,
  0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x0F,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x1C,
  0x07, 0x00, 0x3C, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0xF0, 0x0E, 0x07, 0xE0,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x07,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x1C, 0x78, 0x00, 0x07,
  0x1C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00,
  0x07, 0x78, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x8E, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0E, 0x0F,
  0x00, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x03, 0xF0, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xE0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xC0,
  0x0E, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x03, 0xC0, 0x07, 0x03, 0x80,
  0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x80,
  0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x3C, 0x07, 0x00,
  0x38, 0x0E, 0x00, 0xF8, 0x0E, 0x01, 0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0F,
  0x00, 0x1C, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38, 0x07,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x03,
  0xC0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x01,
  0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xE3, 0xE0, 0x0F, 0x00, 0x30, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x3E, 0x03, 0xF0, 0xFE, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x07, 0x00,
  0x01, 0xC0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC0,
  0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0x00,
  0x38, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E,
  0x00, 0x07, 0x83, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x80, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x78, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x77, 0x00, 0x01, 0xEE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38,
  0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80,
  0x07, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x18, 0x01,
  0xE0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x38, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0x80, 0x03,
  0x87, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0xEE, 0x00,
  0x07, 0x80, 0x03, 0xB8, 0x00, 0x3E, 0x00, 0x1C, 0xE0, 0x00, 0xF8, 0x00,
  0x73, 0x80, 0x07, 0xE0, 0x03, 0xCE, 0x00, 0x1F, 0x80, 0x0E, 0x38, 0x00,
  0x6E, 0x00, 0x38, 0xE0, 0x03, 0xB8, 0x01, 0xC3, 0x80, 0x0C, 0xE0, 0x07,
  0x0E, 0x00, 0x73, 0x80, 0x3C, 0x38, 0x01, 0xCE, 0x00, 0xE0, 0xE0, 0x0E,
  0x38, 0x03, 0x83, 0x80, 0x38, 0xE0, 0x1C, 0x0E, 0x00, 0xC3, 0x80, 0x70,
  0x38, 0x07, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0xE0, 0x78, 0x0E, 0x03, 0x83, 0x01, 0xC0, 0x38, 0x0C, 0x0C, 0x07, 0x00,
  0xE0, 0x70, 0x30, 0x38, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x0E, 0x0E, 0x03,
  0x07, 0x80, 0x38, 0x38, 0x0C, 0x1C, 0x00, 0xE1, 0xC0, 0x30, 0x70, 0x03,
  0x87, 0x00, 0xC3, 0x80, 0x0E, 0x18, 0x03, 0x0E, 0x00, 0x38, 0xE0, 0x0C,
  0x70, 0x00, 0xE3, 0x80, 0x31, 0xC0, 0x03, 0x9C, 0x00, 0xC7, 0x00, 0x0E,
  0x70, 0x03, 0x38, 0x00, 0x39, 0x80, 0x0C, 0xE0, 0x00, 0xEE, 0x00, 0x37,
  0x00, 0x03, 0xB8, 0x00, 0xDC, 0x00, 0x0F, 0xC0, 0x03, 0x70, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x03, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70, 0x0E,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00,
  0x03, 0x07, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x3C, 0x70,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70,
  0x07, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x00,
  0x1C, 0x38, 0x01, 0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0xF0, 0x70, 0x07, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x38, 0x03, 0x83, 0xC0, 0x1C, 0x1C,
  0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x00, 0xC7, 0x00, 0x07,
  0x70, 0x00, 0x3B, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x60, 0x60, 0x70, 0x70, 0x70, 0x70, 0x70, 0x30, 0x30, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C,
  0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x70, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xB8,
  0x00, 0x06, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0,
  0x03, 0x81, 0x80, 0x07, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x07, 0x00,
  0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0x30, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xE1, 0xC1,
  0xC3, 0x83, 0x87, 0x06, 0x06, 0x00, 0x7F, 0x0C, 0x03, 0xFE, 0x30, 0x3F,
  0x3D, 0xC1, 0xF0, 0x37, 0x07, 0x00, 0xDC, 0x3C, 0x01, 0xE1, 0xE0, 0x07,
  0x87, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1E,
  0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x0E, 0x3C, 0x00,
  0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x01, 0xE0, 0xE0,
  0x0F, 0x83, 0xC0, 0x3E, 0x07, 0x01, 0xB8, 0x1E, 0x1C, 0xE0, 0x3F, 0xE3,
  0x00, 0x7F, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x3F, 0x80, 0x39, 0xFF,
  0x01, 0xCF, 0x3E, 0x07, 0x70, 0x38, 0x1F, 0x80, 0xF0, 0x7C, 0x01, 0xC1,
  0xE0, 0x07, 0x0F, 0x80, 0x1C, 0x3C, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80,
  0x07, 0x1E, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x07,
  0x1C, 0x00, 0x3C, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x38, 0x78, 0x01,
  0xE1, 0xE0, 0x07, 0x06, 0x80, 0x3C, 0x3B, 0x01, 0xE0, 0xEE, 0x1F, 0x03,
  0x1F, 0xF8, 0x0C, 0x3F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xC0, 0x3F,
  0xF0, 0x3F, 0x1C, 0x1F, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x60, 0x3F,
  0xF8, 0x03, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x03,
  0xF8, 0x60, 0x03, 0xFE, 0x70, 0x07, 0xE7, 0xB8, 0x07, 0xC0, 0xDC, 0x03,
  0x80, 0x3E, 0x03, 0xC0, 0x1E, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x80,
  0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xE0, 0x78, 0x00, 0x70,
  0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x01,
  0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x0E, 0x00,
  0x7C, 0x07, 0x00, 0x7C, 0x03, 0xC0, 0x3E, 0x00, 0xE0, 0x37, 0x00, 0x78,
  0x73, 0x80, 0x1F, 0xF1, 0xC0, 0x07, 0xF0, 0xC0, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x0F, 0xCF, 0x03, 0xC0, 0xF0, 0x70, 0x0E,
  0x1C, 0x01, 0xC7, 0x80, 0x38, 0xE0, 0x07, 0x3C, 0x00, 0xE7, 0x00, 0x38,
  0xE0, 0x0F, 0x38, 0x03, 0xC7, 0x01, 0xF0, 0xE1, 0xFC, 0x1F, 0xFE, 0x07,
  0xFE, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x08, 0x1E, 0x07, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x01, 0x1E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xC3, 0x80, 0x1F, 0xF1, 0x80, 0x3F, 0x3D, 0xC0, 0x3E, 0x06, 0xE0,
  0x1C, 0x01, 0xF0, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0x3C,
  0x07, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x03, 0xC0, 0x03,
  0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xF0, 0x78, 0x00,
  0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x07, 0x00,
  0x0E, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x70,
  0x03, 0xE0, 0x38, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x07, 0x01, 0xB8, 0x03,
  0xC3, 0x9C, 0x00, 0xFF, 0x8E, 0x00, 0x3F, 0x8E, 0x00, 0x02, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x01, 0x00, 0x3C, 0x00, 0xF0, 0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC7, 0xF0, 0x0E, 0x7F, 0xC0, 0xE7, 0x9F, 0x07, 0x70, 0x38, 0x3E,
  0x01, 0xC1, 0xE0, 0x0E, 0x0F, 0x00, 0x70, 0xF0, 0x03, 0x87, 0x80, 0x1C,
  0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00,
  0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0x87,
  0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1C, 0x00, 0x70, 0xE0, 0x03,
  0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1C, 0x00, 0x70, 0xE0,
  0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0x00, 0x40, 0x1C, 0x07, 0x80,
  0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x47, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0xF0, 0x38, 0x07, 0x81, 0xC0, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x0E, 0x0F, 0x00, 0x38,
  0x38, 0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00, 0x0C, 0x70, 0x00, 0x73, 0xC0,
  0x01, 0xDF, 0x00, 0x07, 0x7C, 0x00, 0x1B, 0xF8, 0x00, 0xFC, 0xE0, 0x03,
  0xE3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x3C, 0x00, 0xE0, 0x70, 0x07, 0x01,
  0xC0, 0x1C, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x38, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x0F, 0xC0, 0x7F, 0x00, 0xC7, 0xFC,
  0x7F, 0xE0, 0x77, 0xDF, 0x3E, 0xF8, 0x1D, 0x81, 0xCC, 0x0F, 0x07, 0xC0,
  0x3E, 0x01, 0xC1, 0xE0, 0x0F, 0x00, 0x70, 0x78, 0x03, 0xC0, 0x1C, 0x3C,
  0x00, 0xE0, 0x07, 0x0F, 0x00, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x00, 0x70,
  0xE0, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x0E, 0x1C, 0x00, 0x70, 0x03,
  0x87, 0x00, 0x38, 0x00, 0xE1, 0xC0, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x80,
  0x1C, 0x38, 0x00, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x01, 0xC3, 0x80, 0x1C,
  0x00, 0x70, 0xE0, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x0E, 0x1C, 0x00,
  0x70, 0x03, 0x87, 0x00, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x00, 0x38, 0x70,
  0x03, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x01, 0xC3,
  0x80, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x00, 0x1C, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x03, 0x0F, 0xE0, 0x18, 0xFF, 0x81, 0xCF, 0xFE, 0x0E, 0xE0, 0x70,
  0x7C, 0x03, 0x83, 0xC0, 0x1C, 0x1E, 0x00, 0xE1, 0xE0, 0x07, 0x0F, 0x00,
  0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0x71, 0xC0, 0x07, 0x0E,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0xF1, 0xC0, 0x07,
  0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0xE1, 0xC0,
  0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x38, 0x00, 0xE1,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC0, 0x00, 0x7F, 0x80, 0x07,
  0xFE, 0x00, 0xFC, 0xF8, 0x0F, 0x01, 0xC0, 0x70, 0x07, 0x07, 0x00, 0x38,
  0x78, 0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00,
  0x1E, 0xF0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xDE,
  0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xB8, 0x00, 0x39, 0xC0, 0x01,
  0xCE, 0x00, 0x1E, 0x70, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x70, 0xE0,
  0x07, 0x87, 0x80, 0x38, 0x1C, 0x03, 0x80, 0xF8, 0x78, 0x03, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x04, 0x00, 0x00, 0x00, 0x60, 0xFC, 0x00, 0x31, 0xFF,
  0x00, 0x39, 0xE7, 0xC0, 0x1D, 0xC0, 0xE0, 0x0F, 0xC0, 0x78, 0x07, 0xC0,
  0x1C, 0x03, 0xC0, 0x0E, 0x03, 0xE0, 0x07, 0x01, 0xE0, 0x03, 0x80, 0xF0,
  0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x3C, 0x00, 0x38, 0x1C,
  0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x03,
  0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xE0,
  0x78, 0x00, 0x70, 0x3C, 0x00, 0x70, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x38,
  0x07, 0x80, 0x3C, 0x07, 0x60, 0x3C, 0x03, 0xB8, 0x7C, 0x01, 0xCF, 0xFC,
  0x00, 0xE3, 0xFC, 0x00, 0x70, 0x20, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x0E,
  0x01, 0xFF, 0x18, 0x0F, 0xCF, 0x70, 0x3C, 0x06, 0xE0, 0x70, 0x07, 0xC1,
  0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x70,
  0x00, 0xF0, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x78, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01,
  0xC3, 0x80, 0x07, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x78,
  0x38, 0x00, 0xF0, 0x70, 0x03, 0xE0, 0xE0, 0x0F, 0x81, 0xE0, 0x1F, 0x01,
  0xC0, 0x6E, 0x03, 0xC3, 0x9C, 0x03, 0xFE, 0x38, 0x03, 0xF8, 0xE0, 0x00,
  0x81, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x0F, 0xC0, 0xC7, 0xE0, 0x73, 0xF8, 0x1D, 0xC0, 0x07, 0xE0,
  0x01, 0xB0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x7F, 0xFC, 0x1F, 0x0F, 0x07, 0x80, 0x20, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC2, 0x00,
  0xF0, 0x70, 0x3C, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x03, 0xFF,
  0x7F, 0xFB, 0xFF, 0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x41, 0xFE, 0x07, 0xF0, 0x04,
  0x00, 0x07, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xE0, 0x03, 0x83, 0x80, 0x0E,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x70, 0x01, 0xC1,
  0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80,
  0x0E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xE0, 0xE0, 0x0F, 0x83, 0x80, 0x6C,
  0x0F, 0x03, 0xB0, 0x3E, 0x1D, 0xC0, 0x7F, 0xE7, 0x00, 0xFF, 0x1C, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01,
  0xEE, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E,
  0x0C, 0x01, 0xC1, 0x80, 0x70, 0x30, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x00,
  0x38, 0xE0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0xC0, 0x03, 0xB8, 0x00,
  0x77, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x1F, 0xC0, 0x0F, 0x00, 0x3B, 0x80,
  0x1E, 0x00, 0x77, 0x00, 0x3C, 0x01, 0xCE, 0x00, 0xF8, 0x03, 0x9C, 0x01,
  0xB0, 0x0E, 0x38, 0x07, 0x60, 0x1C, 0x70, 0x0E, 0xC0, 0x38, 0xE0, 0x39,
  0x80, 0xE1, 0xC0, 0x73, 0x01, 0xC3, 0x80, 0xC6, 0x07, 0x07, 0x03, 0x8C,
  0x0E, 0x0E, 0x06, 0x18, 0x38, 0x1C, 0x1C, 0x30, 0x70, 0x38, 0x38, 0x60,
  0xE0, 0x30, 0xE0, 0xC3, 0x80, 0x61, 0xC1, 0x87, 0x00, 0xC3, 0x03, 0x1C,
  0x01, 0x8E, 0x06, 0x38, 0x03, 0x18, 0x0C, 0x70, 0x06, 0x70, 0x19, 0xC0,
  0x0C, 0xE0, 0x33, 0x80, 0x1B, 0x80, 0x6E, 0x00, 0x37, 0x00, 0xDC, 0x00,
  0x6C, 0x01, 0xB0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x03,
  0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x0F, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C,
  0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xE0,
  0x00, 0x71, 0xC0, 0x00, 0x73, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x37, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xEC, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xCE, 0x00,
  0x03, 0x8E, 0x00, 0x03, 0x87, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x07, 0x00,
  0x1E, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x03, 0x80,
  0x70, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x78, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x1E,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x38, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70,
  0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x60, 0x70,
  0x00, 0x03, 0x07, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00, 0xC3, 0x80, 0x00,
  0x06, 0x1C, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x87, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xFC, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x0B, 0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xC1,
  0xFF, 0xF8, 0x03, 0xFF, 0x40, 0x07, 0xF0,
};

const GFXglyph NotoSans_Condensed_LightItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 40, 13, 1, -40 },
  { 61, 13, 14, 18, 6, -40 },
  { 84, 26, 40, 26, 1, -40 },
  { 214, 24, 46, 24, 0, -43 },
  { 352, 30, 42, 35, 3, -41 },
  { 510, 25, 42, 26, 0, -41 },
  { 642, 6, 14, 10, 6, -40 },
  { 653, 17, 49, 14, 1, -40 },
  { 758, 16, 49, 14, -4, -40 },
  { 856, 18, 20, 22, 6, -43 },
  { 901, 21, 26, 26, 3, -33 },
  { 970, 8, 13, 11, -2, -6 },
  { 983, 13, 3, 15, 1, -17 },
  { 988, 4, 5, 11, 1, -5 },
  { 991, 25, 40, 18, -3, -40 },
  { 1116, 21, 42, 24, 2, -41 },
  { 1227, 13, 40, 24, 7, -40 },
  { 1292, 24, 41, 24, -1, -41 },
  { 1415, 23, 42, 24, 0, -41 },
  { 1536, 24, 40, 24, -1, -40 },
  { 1656, 24, 41, 24, 0, -40 },
  { 1779, 22, 42, 24, 2, -41 },
  { 1895, 22, 40, 24, 3, -40 },
  { 2005, 24, 42, 24, 0, -41 },
  { 2131, 22, 42, 24, 1, -41 },
  { 2247, 10, 30, 11, 0, -30 },
  { 2285, 13, 37, 11, -3, -30 },
  { 2346, 21, 24, 26, 3, -32 },
  { 2409, 21, 15, 26, 3, -27 },
  { 2449, 21, 24, 26, 3, -32 },
  { 2512, 17, 41, 17, 2, -41 },
  { 2600, 33, 45, 36, 2, -40 },
  { 2786, 24, 40, 24, -4, -40 },
  { 2906, 25, 40, 26, 1, -40 },
  { 3031, 25, 42, 24, 3, -41 },
  { 3163, 26, 40, 28, 1, -40 },
  { 3293, 24, 40, 23, 1, -40 },
  { 3413, 24, 40, 21, 1, -40 },
  { 3533, 28, 42, 30, 3, -41 },
  { 3680, 29, 40, 30, 1, -40 },
  { 3825, 19, 40, 13, -2, -40 },
  { 3920, 20, 50, 11, -8, -40 },
  { 4045, 27, 40, 24, 1, -40 },
  { 4180, 16, 40, 21, 1, -40 },
  { 4260, 38, 40, 38, 1, -40 },
  { 4450, 30, 40, 31, 1, -40 },
  { 4600, 26, 42, 31, 3, -41 },
  { 4737, 24, 40, 24, 1, -40 },
  { 4857, 26, 51, 31, 3, -41 },
  { 5023, 24, 40, 25, 1, -40 },
  { 5143, 25, 42, 22, -1, -41 },
  { 5275, 20, 40, 21, 5, -40 },
  { 5375, 27, 41, 29, 3, -40 },
  { 5514, 23, 40, 24, 5, -40 },
  { 5629, 38, 40, 39, 5, -40 },
  { 5819, 29, 40, 22, -3, -40 },
  { 5964, 21, 40, 21, 5, -40 },
  { 6069, 27, 40, 22, -2, -40 },
  { 6204, 21, 49, 16, -1, -40 },
  { 6333, 8, 40, 18, 6, -40 },
  { 6373, 21, 49, 16, -4, -40 },
  { 6502, 23, 22, 25, 1, -40 },
  { 6566, 18, 3, 17, -5, 5 },
  { 6573, 7, 9, 13, 8, -43 },
  { 6581, 22, 31, 25, 2, -30 },
  { 6667, 22, 44, 25, 1, -43 },
  { 6788, 18, 31, 19, 2, -30 },
  { 6858, 25, 44, 25, 2, -43 },
  { 6996, 19, 31, 22, 2, -30 },
  { 7070, 27, 56, 13, -7, -43 },
  { 7259, 25, 43, 25, 0, -30 },
  { 7394, 21, 43, 25, 1, -43 },
  { 7507, 11, 41, 11, 1, -41 },
  { 7564, 19, 54, 11, -7, -41 },
  { 7693, 22, 43, 21, 1, -43 },
  { 7812, 12, 43, 11, 1, -43 },
  { 7877, 34, 30, 37, 1, -30 },
  { 8005, 21, 30, 25, 1, -30 },
  { 8084, 21, 31, 24, 2, -30 },
  { 8166, 25, 43, 25, -2, -30 },
  { 8301, 23, 43, 25, 2, -30 },
  { 8425, 18, 30, 16, 1, -30 },
  { 8493, 19, 31, 19, 0, -30 },
  { 8567, 13, 38, 14, 2, -37 },
  { 8629, 22, 31, 25, 2, -30 },
  { 8715, 19, 30, 19, 3, -30 },
  { 8787, 31, 30, 31, 3, -30 },
  { 8904, 24, 30, 20, -2, -30 },
  { 8994, 29, 44, 20, -6, -30 },
  { 9154, 21, 30, 17, -2, -30 },
  { 9233, 21, 49, 18, 1, -40 },
  { 9362, 3, 57, 23, 10, -43 },
  { 9384, 20, 49, 18, -3, -40 },
  { 9507, 21, 6, 26, 3, -23 },
};

const GFXfont NotoSans_Condensed_LightItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC56PT7B_H_
