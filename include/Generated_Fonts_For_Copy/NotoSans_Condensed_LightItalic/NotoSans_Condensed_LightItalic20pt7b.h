#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC20PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0x84, 0x23, 0x10, 0x84, 0x22, 0x00, 0x04, 0x60, 0x4A, 0xA5,
  0x29, 0x00, 0x04, 0x82, 0x20, 0x90, 0x24, 0x3F, 0xC4, 0x81, 0x20, 0x48,
  0x22, 0x3F, 0xC2, 0x41, 0x10, 0x48, 0x12, 0x00, 0x02, 0x03, 0x07, 0x64,
  0x82, 0x41, 0x40, 0xE0, 0x30, 0x0C, 0x05, 0x04, 0x82, 0x49, 0x67, 0xC0,
  0x40, 0x40, 0x38, 0x49, 0x11, 0x24, 0x44, 0x88, 0xA1, 0x15, 0xA5, 0x4F,
  0xA9, 0x0A, 0x22, 0x44, 0x49, 0x11, 0x22, 0x24, 0x87, 0x00, 0x0E, 0x08,
  0x84, 0x42, 0x41, 0x20, 0xE0, 0x60, 0x50, 0x4D, 0xE2, 0xA1, 0xD0, 0x48,
  0x63, 0xC8, 0x5A, 0x80, 0x08, 0x88, 0x44, 0x22, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0xC0, 0x18, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x21, 0x10,
  0x88, 0x80, 0x11, 0x21, 0xC8, 0xE3, 0x09, 0x02, 0x00, 0x10, 0x10, 0x10,
  0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x2D, 0x28, 0xF8, 0x70, 0x01,
  0x80, 0x80, 0x80, 0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x08, 0x08, 0x08,
  0x04, 0x04, 0x00, 0x1E, 0x45, 0x8A, 0x14, 0x30, 0x60, 0xC1, 0x87, 0x0A,
  0x14, 0x48, 0x9E, 0x00, 0x19, 0x74, 0x21, 0x08, 0xC4, 0x21, 0x08, 0xC4,
  0x20, 0x3F, 0x01, 0x01, 0x01, 0x01, 0x02, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x80, 0xFC, 0x3F, 0x21, 0x01, 0x01, 0x01, 0x02, 0x1C, 0x04, 0x02,
  0x02, 0x02, 0x02, 0x84, 0xF8, 0x03, 0x03, 0x05, 0x0A, 0x0A, 0x12, 0x22,
  0x22, 0x44, 0x84, 0xFF, 0x04, 0x04, 0x08, 0x1F, 0x10, 0x10, 0x20, 0x20,
  0x38, 0x26, 0x02, 0x02, 0x02, 0x02, 0x02, 0x84, 0xF8, 0x1F, 0x30, 0x20,
  0x40, 0x40, 0xD8, 0xE4, 0x86, 0x82, 0x86, 0x84, 0x84, 0x88, 0x70, 0x7F,
  0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x40,
  0x80, 0x1F, 0x08, 0x88, 0x64, 0x23, 0x10, 0xB0, 0x20, 0x68, 0x42, 0x41,
  0x20, 0x90, 0x4C, 0x63, 0xE0, 0x1F, 0x31, 0x21, 0x21, 0x41, 0x41, 0x63,
  0x25, 0x1A, 0x02, 0x02, 0x04, 0x08, 0xF0, 0x33, 0x00, 0x00, 0x00, 0x04,
  0xC0, 0x08, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x18, 0x84, 0x40, 0x01, 0x03,
  0x0C, 0x30, 0xC0, 0x40, 0x30, 0x0C, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x06, 0x18, 0x60, 0x80, 0x7C, 0x10,
  0x41, 0x08, 0x42, 0x18, 0x41, 0x08, 0x00, 0x82, 0x00, 0x0F, 0xC2, 0x04,
  0x80, 0xA0, 0x14, 0x7B, 0x12, 0x64, 0x4C, 0x89, 0x92, 0x32, 0x4A, 0x59,
  0x4C, 0xC8, 0x01, 0x00, 0x10, 0x81, 0xE0, 0x03, 0x05, 0x05, 0x05, 0x09,
  0x09, 0x11, 0x11, 0x3F, 0x21, 0x61, 0x41, 0xC1, 0x81, 0x1F, 0x08, 0x44,
  0x22, 0x12, 0x09, 0x08, 0xF8, 0x46, 0x61, 0x20, 0x90, 0x48, 0x64, 0x67,
  0xE0, 0x02, 0x07, 0xC4, 0x04, 0x06, 0x02, 0x01, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x02, 0x01, 0xF0, 0x1F, 0x04, 0x21, 0x0C, 0x41, 0x20,
  0x48, 0x12, 0x0C, 0x82, 0x60, 0x90, 0x64, 0x11, 0x0C, 0x46, 0x3E, 0x00,
  0x1F, 0x88, 0x04, 0x02, 0x02, 0x01, 0x00, 0xF8, 0x40, 0x60, 0x20, 0x10,
  0x08, 0x04, 0x07, 0xE0, 0x1F, 0x88, 0x04, 0x02, 0x02, 0x01, 0x00, 0x80,
  0x7C, 0x60, 0x20, 0x10, 0x08, 0x04, 0x04, 0x00, 0x02, 0x03, 0xF1, 0x00,
  0x80, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x87, 0xA0, 0x48, 0x12, 0x04, 0x81,
  0x10, 0xC3, 0xE0, 0x10, 0x22, 0x08, 0x41, 0x08, 0x22, 0x04, 0x41, 0x8F,
  0xE1, 0x04, 0x60, 0x88, 0x11, 0x06, 0x20, 0x84, 0x11, 0x02, 0x00, 0x1E,
  0x10, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x81, 0x02, 0x1E, 0x00,
  0x02, 0x04, 0x08, 0x10, 0x40, 0x81, 0x02, 0x0C, 0x10, 0x20, 0x40, 0x83,
  0x04, 0x08, 0xB1, 0x80, 0x10, 0xC4, 0x61, 0x10, 0x48, 0x24, 0x0A, 0x03,
  0x80, 0xA0, 0x64, 0x11, 0x04, 0x41, 0x18, 0x42, 0x20, 0x80, 0x10, 0x41,
  0x04, 0x20, 0x82, 0x08, 0x61, 0x04, 0x10, 0x43, 0xF0, 0x18, 0x0C, 0x60,
  0x61, 0x81, 0x86, 0x0A, 0x28, 0x28, 0xA1, 0x22, 0x85, 0x0A, 0x24, 0x64,
  0x91, 0x14, 0x44, 0x53, 0x11, 0x88, 0x46, 0x22, 0x10, 0x80, 0x18, 0x23,
  0x04, 0x60, 0x8C, 0x22, 0x44, 0x48, 0x89, 0x11, 0x26, 0x62, 0x88, 0x51,
  0x0A, 0x21, 0x44, 0x19, 0x02, 0x00, 0x1F, 0x18, 0x48, 0x28, 0x14, 0x0A,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0xA0, 0x50, 0x6C, 0x63, 0xE0, 0x1F, 0x08,
  0xC4, 0x22, 0x12, 0x09, 0x08, 0x8C, 0x7C, 0x60, 0x20, 0x10, 0x08, 0x04,
  0x04, 0x00, 0x1F, 0x18, 0x48, 0x28, 0x14, 0x0A, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xA0, 0x50, 0x6C, 0x63, 0xE0, 0x20, 0x10, 0x04, 0x00, 0x1F, 0x08,
  0xC4, 0x22, 0x12, 0x09, 0x08, 0x8C, 0x78, 0x64, 0x22, 0x11, 0x08, 0xC4,
  0x24, 0x10, 0x1F, 0x90, 0x08, 0x04, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04,
  0x01, 0x00, 0x80, 0xC8, 0x47, 0xC0, 0xFE, 0x20, 0x81, 0x02, 0x04, 0x18,
  0x20, 0x40, 0x81, 0x06, 0x08, 0x10, 0x00, 0x20, 0xC8, 0x22, 0x09, 0x02,
  0x40, 0x90, 0x44, 0x11, 0x04, 0x81, 0x20, 0x48, 0x22, 0x08, 0xC4, 0x1F,
  0x00, 0x81, 0x82, 0x82, 0x84, 0x84, 0x88, 0x88, 0x98, 0x90, 0x90, 0xA0,
  0xA0, 0xC0, 0xC0, 0x82, 0x0C, 0x30, 0xE1, 0x85, 0x0C, 0x28, 0xA2, 0x45,
  0x12, 0x49, 0x12, 0x48, 0xA2, 0x45, 0x14, 0x28, 0xA1, 0x86, 0x0C, 0x30,
  0x41, 0x80, 0x18, 0x42, 0x20, 0x90, 0x24, 0x0A, 0x03, 0x80, 0x40, 0x30,
  0x14, 0x05, 0x02, 0x21, 0x88, 0x42, 0x20, 0x80, 0x83, 0x0A, 0x34, 0x4D,
  0x0A, 0x18, 0x30, 0x40, 0x81, 0x06, 0x08, 0x10, 0x00, 0x1F, 0xC0, 0x20,
  0x10, 0x04, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x3F, 0x80, 0x1E, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x40, 0x81,
  0x02, 0x04, 0x10, 0x20, 0x40, 0xE0, 0x92, 0x24, 0x92, 0x48, 0x92, 0x40,
  0x1E, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02,
  0x04, 0x08, 0xE0, 0x18, 0x18, 0x24, 0x24, 0x44, 0x42, 0x83, 0xFE, 0x94,
  0x19, 0x26, 0x42, 0x42, 0x82, 0x82, 0x84, 0x84, 0x84, 0x8C, 0xF4, 0x18,
  0x10, 0x10, 0x10, 0x36, 0x29, 0x31, 0x21, 0x21, 0x41, 0x41, 0x43, 0x42,
  0x46, 0xBC, 0x1C, 0x84, 0x10, 0x82, 0x08, 0x20, 0x82, 0x07, 0x00, 0x00,
  0x80, 0x80, 0x40, 0x21, 0x91, 0x39, 0x08, 0x84, 0x82, 0x41, 0x21, 0x10,
  0x88, 0xC4, 0x63, 0xD0, 0x1C, 0x49, 0x1A, 0x28, 0xDE, 0x20, 0x40, 0x81,
  0x01, 0xE0, 0x01, 0xC0, 0x80, 0x20, 0x08, 0x0F, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x80, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04,
  0x02, 0x03, 0x80, 0x0C, 0x89, 0x48, 0x44, 0x24, 0x12, 0x09, 0x08, 0x84,
  0x46, 0x23, 0x1E, 0x80, 0x80, 0x40, 0x22, 0x20, 0xE0, 0x18, 0x10, 0x10,
  0x10, 0x26, 0x29, 0x31, 0x21, 0x21, 0x42, 0x42, 0x42, 0x42, 0x42, 0x84,
  0x11, 0x00, 0x32, 0x22, 0x24, 0x44, 0x44, 0x80, 0x02, 0x04, 0x00, 0x00,
  0x60, 0x81, 0x02, 0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20,
  0x87, 0x00, 0x18, 0x10, 0x10, 0x10, 0x31, 0x22, 0x24, 0x2C, 0x28, 0x58,
  0x68, 0x48, 0x4C, 0x44, 0x84, 0x18, 0x84, 0x23, 0x10, 0x84, 0x22, 0x10,
  0x84, 0x22, 0x00, 0x2E, 0x71, 0x9C, 0x88, 0x46, 0x42, 0x22, 0x21, 0x21,
  0x09, 0x08, 0x48, 0x46, 0x42, 0x22, 0x21, 0x21, 0x08, 0x26, 0x29, 0x31,
  0x21, 0x21, 0x42, 0x42, 0x42, 0x42, 0x42, 0x84, 0x1C, 0x4D, 0x0A, 0x18,
  0x30, 0x60, 0xC2, 0x85, 0x11, 0xC0, 0x13, 0x0A, 0x46, 0x22, 0x11, 0x09,
  0x04, 0x82, 0x43, 0x21, 0x11, 0x97, 0x88, 0x04, 0x02, 0x01, 0x01, 0x00,
  0x19, 0x25, 0x42, 0x42, 0x82, 0x82, 0x84, 0x84, 0x8C, 0x8C, 0xF4, 0x08,
  0x08, 0x08, 0x08, 0x18, 0x26, 0x50, 0xC1, 0x02, 0x08, 0x10, 0x20, 0x40,
  0x82, 0x00, 0x1C, 0x45, 0x02, 0x02, 0x06, 0x02, 0x04, 0x08, 0x13, 0xC0,
  0x22, 0xF4, 0x44, 0x48, 0x88, 0x88, 0xE0, 0x42, 0x85, 0x0A, 0x14, 0x30,
  0xA1, 0x42, 0x8D, 0x1B, 0xE0, 0x83, 0x0A, 0x14, 0x48, 0x92, 0x24, 0x50,
  0xA1, 0x41, 0x00, 0x84, 0x30, 0x8E, 0x31, 0x46, 0x29, 0x49, 0x29, 0x29,
  0x45, 0x28, 0xA5, 0x18, 0xC3, 0x18, 0x00, 0x10, 0x88, 0x84, 0x82, 0x40,
  0xC0, 0x40, 0x60, 0x28, 0x24, 0x22, 0x31, 0x80, 0x10, 0x44, 0x31, 0x08,
  0x66, 0x09, 0x02, 0x40, 0xA0, 0x28, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x10,
  0x04, 0x02, 0x03, 0x00, 0x1F, 0x02, 0x06, 0x04, 0x08, 0x08, 0x10, 0x20,
  0x20, 0x40, 0xFC, 0x07, 0x08, 0x08, 0x08, 0x08, 0x10, 0x10, 0x30, 0xC0,
  0x20, 0x20, 0x20, 0x20, 0x20, 0x40, 0x60, 0x30, 0xFF, 0xFF, 0xF0, 0x1C,
  0x08, 0x10, 0x20, 0x41, 0x02, 0x04, 0x06, 0x10, 0x40, 0x81, 0x02, 0x0C,
  0x10, 0xC0, 0xF1, 0x8E,
};

const GFXglyph NotoSans_Condensed_LightItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 14, 4, 0, -14 },
  { 10, 5, 5, 6, 2, -14 },
  { 14, 10, 14, 9, 0, -14 },
  { 32, 9, 16, 8, 0, -15 },
  { 50, 11, 14, 13, 1, -14 },
  { 70, 9, 14, 9, 0, -14 },
  { 86, 2, 5, 3, 2, -14 },
  { 88, 5, 17, 5, 1, -14 },
  { 99, 5, 17, 5, -1, -14 },
  { 110, 7, 7, 8, 2, -15 },
  { 117, 8, 10, 9, 1, -12 },
  { 127, 3, 5, 4, -1, -2 },
  { 129, 5, 1, 6, 0, -6 },
  { 130, 2, 2, 4, 0, -2 },
  { 131, 9, 14, 6, -1, -14 },
  { 147, 7, 14, 8, 1, -14 },
  { 160, 5, 14, 8, 2, -14 },
  { 169, 8, 14, 8, 0, -14 },
  { 183, 8, 14, 8, 0, -14 },
  { 197, 8, 14, 8, 0, -14 },
  { 211, 8, 14, 8, 0, -14 },
  { 225, 8, 14, 8, 1, -14 },
  { 239, 8, 14, 8, 1, -14 },
  { 253, 9, 14, 8, 0, -14 },
  { 269, 8, 14, 8, 0, -14 },
  { 283, 4, 11, 4, 0, -11 },
  { 289, 5, 14, 4, -1, -11 },
  { 298, 8, 9, 9, 1, -12 },
  { 307, 8, 6, 9, 1, -10 },
  { 313, 8, 9, 9, 1, -12 },
  { 322, 6, 14, 6, 1, -14 },
  { 333, 11, 16, 13, 1, -14 },
  { 355, 8, 14, 8, -1, -14 },
  { 369, 9, 14, 9, 0, -14 },
  { 385, 9, 15, 9, 1, -15 },
  { 402, 10, 14, 10, 0, -14 },
  { 420, 9, 14, 8, 0, -14 },
  { 436, 9, 14, 8, 0, -14 },
  { 452, 10, 15, 11, 1, -15 },
  { 471, 11, 14, 11, 0, -14 },
  { 491, 7, 14, 5, -1, -14 },
  { 504, 7, 18, 4, -3, -14 },
  { 520, 10, 14, 9, 0, -14 },
  { 538, 6, 14, 7, 0, -14 },
  { 549, 14, 14, 14, 0, -14 },
  { 574, 11, 14, 11, 0, -14 },
  { 594, 9, 14, 11, 1, -14 },
  { 610, 9, 14, 9, 0, -14 },
  { 626, 9, 17, 11, 1, -14 },
  { 646, 9, 14, 9, 0, -14 },
  { 662, 9, 14, 8, 0, -14 },
  { 678, 7, 14, 7, 2, -14 },
  { 691, 10, 14, 10, 1, -14 },
  { 709, 8, 14, 9, 2, -14 },
  { 723, 13, 14, 14, 2, -14 },
  { 746, 10, 14, 8, -1, -14 },
  { 764, 7, 14, 8, 2, -14 },
  { 777, 10, 14, 8, -1, -14 },
  { 795, 7, 17, 6, 0, -14 },
  { 810, 3, 14, 7, 2, -14 },
  { 816, 7, 17, 6, -1, -14 },
  { 831, 8, 7, 9, 1, -14 },
  { 838, 7, 1, 6, -2, 2 },
  { 839, 2, 3, 5, 3, -15 },
  { 840, 8, 11, 9, 1, -11 },
  { 851, 8, 15, 9, 0, -15 },
  { 866, 6, 11, 7, 1, -11 },
  { 875, 9, 15, 9, 1, -15 },
  { 892, 7, 11, 8, 1, -11 },
  { 902, 10, 20, 5, -3, -15 },
  { 927, 9, 16, 9, 0, -11 },
  { 945, 8, 15, 9, 0, -15 },
  { 960, 4, 15, 4, 0, -15 },
  { 968, 7, 20, 4, -3, -15 },
  { 986, 8, 15, 7, 0, -15 },
  { 1001, 5, 15, 4, 0, -15 },
  { 1011, 13, 11, 13, 0, -11 },
  { 1029, 8, 11, 9, 0, -11 },
  { 1040, 7, 11, 9, 1, -11 },
  { 1050, 9, 16, 9, -1, -11 },
  { 1068, 8, 16, 9, 1, -11 },
  { 1084, 7, 11, 6, 0, -11 },
  { 1094, 7, 11, 7, 0, -11 },
  { 1104, 4, 13, 5, 1, -13 },
  { 1111, 7, 11, 9, 1, -11 },
  { 1121, 7, 11, 7, 1, -11 },
  { 1131, 11, 11, 11, 1, -11 },
  { 1147, 9, 11, 7, -1, -11 },
  { 1160, 10, 16, 7, -2, -11 },
  { 1180, 8, 11, 6, -1, -11 },
  { 1191, 8, 17, 7, 0, -14 },
  { 1208, 1, 20, 8, 4, -15 },
  { 1211, 7, 17, 6, -1, -14 },
  { 1226, 8, 2, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_LightItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC20PT7B_H_
