#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC39PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x20, 0x00, 0x00,
  0x00, 0x40, 0xE0, 0xE0, 0xC0, 0x31, 0xB8, 0xD8, 0x6C, 0x36, 0x33, 0x19,
  0x0D, 0x86, 0xC2, 0x63, 0x00, 0x00, 0x20, 0xC0, 0x0C, 0x10, 0x01, 0x86,
  0x00, 0x20, 0xC0, 0x0C, 0x10, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x0C, 0x18,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x04, 0x18, 0x01, 0x82, 0x00, 0x30, 0xC0,
  0x04, 0x18, 0x01, 0x82, 0x00, 0x30, 0xC0, 0x04, 0x18, 0x01, 0x83, 0x03,
  0xFF, 0xFC, 0x06, 0x18, 0x00, 0x83, 0x00, 0x30, 0x40, 0x06, 0x18, 0x00,
  0x83, 0x00, 0x30, 0x40, 0x06, 0x18, 0x00, 0x83, 0x00, 0x30, 0x60, 0x00,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x02, 0x00, 0x1F, 0xF0, 0x1F,
  0xFC, 0x18, 0x84, 0x18, 0x40, 0x0C, 0x20, 0x06, 0x30, 0x03, 0x18, 0x01,
  0x88, 0x00, 0xC4, 0x00, 0x32, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x6E, 0x00, 0x33, 0x00, 0x10, 0xC0, 0x08, 0x60, 0x04,
  0x30, 0x06, 0x30, 0x03, 0x18, 0x41, 0x18, 0x3F, 0xF8, 0x0F, 0xF8, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08, 0x00, 0x07, 0x80, 0x70, 0xEE,
  0x03, 0x06, 0x30, 0x30, 0x61, 0x81, 0x83, 0x0C, 0x18, 0x30, 0x60, 0x81,
  0x83, 0x0C, 0x0C, 0x18, 0xC0, 0x40, 0xC6, 0x06, 0x04, 0x60, 0x30, 0x63,
  0x01, 0x83, 0x31, 0xEC, 0x11, 0x1F, 0x61, 0x99, 0x8F, 0x19, 0x98, 0x6D,
  0xCC, 0xC3, 0x7C, 0xCC, 0x18, 0x06, 0x60, 0xC0, 0x63, 0x06, 0x02, 0x10,
  0x30, 0x31, 0x83, 0x03, 0x0C, 0x18, 0x18, 0x60, 0xC1, 0x83, 0x04, 0x0C,
  0x18, 0x60, 0xC0, 0xC2, 0x0C, 0x03, 0x70, 0x60, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x61, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x1C,
  0x18, 0x0C, 0x18, 0x03, 0x0C, 0x01, 0x8C, 0x00, 0xCC, 0x00, 0x6C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x39, 0x83, 0x38, 0xE1, 0x98, 0x30,
  0xD8, 0x18, 0xCC, 0x06, 0x6E, 0x03, 0x66, 0x01, 0xF3, 0x00, 0x71, 0x80,
  0x38, 0xE0, 0x3C, 0x30, 0x36, 0x1F, 0xF1, 0x87, 0xF0, 0xC0, 0x37, 0x66,
  0x66, 0x4C, 0xCC, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x30, 0x0E, 0x00, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x86, 0x0E,
  0x30, 0x3D, 0x04, 0x3F, 0xE0, 0xF8, 0x0F, 0x00, 0xC8, 0x0C, 0x60, 0xC1,
  0x02, 0x0C, 0x00, 0x40, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x71, 0x86, 0x30, 0xC2, 0x18, 0xC0, 0xFF, 0xFF, 0xC0,
  0x5F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xF8, 0x07, 0xF8, 0x0C, 0x38, 0x30, 0x30, 0xC0, 0x61,
  0x80, 0xC6, 0x01, 0x8C, 0x03, 0x38, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80,
  0x37, 0x00, 0x6C, 0x01, 0xD8, 0x03, 0x30, 0x06, 0x60, 0x0D, 0xC0, 0x3B,
  0x80, 0x66, 0x00, 0xCC, 0x03, 0x98, 0x06, 0x30, 0x0C, 0x70, 0x30, 0x60,
  0xE0, 0xC1, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0x83, 0x83, 0xC7, 0x67,
  0x37, 0x3A, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70,
  0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30,
  0x18, 0x0C, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x80, 0xC0, 0xC0, 0x40, 0x70,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x3F, 0xFE,
  0x1F, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xFE, 0x0E, 0x07, 0x04, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x80, 0x70, 0xFF, 0xE0, 0xFF, 0x80, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1A, 0x00, 0x16, 0x00, 0x36, 0x00,
  0x66, 0x00, 0xC6, 0x00, 0xCC, 0x01, 0x8C, 0x03, 0x0C, 0x03, 0x0C, 0x06,
  0x0C, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x18, 0x30, 0x38, 0x60,
  0x30, 0xC0, 0x30, 0xFF, 0xFE, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x03, 0xFF, 0x81, 0xFF, 0x80,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x78, 0x01, 0xFF, 0x00, 0x41,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30,
  0x40, 0x38, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x33, 0xF0, 0x37, 0xF8, 0x68, 0x18, 0x70,
  0x1C, 0x70, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0,
  0x18, 0xE0, 0x18, 0xE0, 0x18, 0x60, 0x30, 0x60, 0x70, 0x70, 0x60, 0x3F,
  0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0x3F, 0xFE, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x00,
  0xFC, 0x01, 0xFF, 0x01, 0xC1, 0xC0, 0xC0, 0x60, 0x60, 0x38, 0x60, 0x1C,
  0x30, 0x0E, 0x18, 0x06, 0x0C, 0x03, 0x03, 0x03, 0x01, 0x83, 0x80, 0x63,
  0x00, 0x1F, 0x00, 0x0E, 0x00, 0x1D, 0x80, 0x3C, 0x60, 0x38, 0x18, 0x18,
  0x0E, 0x18, 0x03, 0x0C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31,
  0xC0, 0x38, 0x60, 0x18, 0x38, 0x1C, 0x0F, 0x7C, 0x03, 0xF8, 0x00, 0x00,
  0xF8, 0x03, 0xFE, 0x07, 0x06, 0x06, 0x07, 0x0C, 0x03, 0x0C, 0x03, 0x18,
  0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x07, 0x18, 0x07, 0x18,
  0x06, 0x18, 0x0E, 0x1C, 0x1E, 0x0F, 0x76, 0x07, 0xE6, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x01, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x06, 0x1C, 0x38, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x41, 0x87,
  0x0E, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x07, 0x03,
  0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x00, 0x00, 0x02, 0x00, 0x0C,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x06, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x00, 0xC0, 0x01, 0x00, 0x00, 0x0F,
  0xC0, 0xFF, 0x84, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01,
  0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xE0, 0x03, 0x80, 0xE0, 0x0C, 0x00, 0x60, 0x30, 0x00, 0xC0,
  0xC0, 0x00, 0xC3, 0x00, 0x01, 0x86, 0x00, 0x03, 0x18, 0x1F, 0xC6, 0x30,
  0x73, 0x0C, 0xC1, 0x86, 0x19, 0x86, 0x0C, 0x32, 0x0C, 0x18, 0x6C, 0x30,
  0x60, 0xD8, 0x60, 0xC1, 0xB0, 0xC1, 0x82, 0x43, 0x03, 0x0C, 0x86, 0x0C,
  0x1B, 0x0C, 0x18, 0x26, 0x18, 0x70, 0xCC, 0x30, 0xE3, 0x18, 0x63, 0x46,
  0x30, 0x7C, 0xF8, 0x60, 0x60, 0xC0, 0x40, 0x00, 0x00, 0xC0, 0x00, 0x01,
  0x80, 0x00, 0x01, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC1, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x36, 0x00, 0x36, 0x00, 0x66, 0x00, 0x66, 0x00, 0xE6, 0x00, 0xC6, 0x00,
  0xC6, 0x01, 0x86, 0x01, 0x86, 0x03, 0x06, 0x03, 0x06, 0x07, 0x07, 0x07,
  0xFF, 0x0F, 0xFF, 0x0C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x30,
  0x03, 0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0x07,
  0xF8, 0x03, 0xFF, 0x01, 0x81, 0xC0, 0xC0, 0x70, 0x60, 0x18, 0x60, 0x0C,
  0x30, 0x06, 0x18, 0x03, 0x0C, 0x03, 0x8E, 0x01, 0x86, 0x01, 0xC3, 0x01,
  0xC1, 0xFF, 0xC0, 0xFF, 0x00, 0xE1, 0xE0, 0x60, 0x38, 0x30, 0x0C, 0x18,
  0x07, 0x0C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0x71, 0x80, 0x30,
  0xC0, 0x38, 0xC0, 0x38, 0x60, 0x38, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0xFF, 0xC0, 0xE0, 0x20, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x01, 0xFF, 0x80, 0x60, 0xF0, 0x18, 0x0E, 0x06, 0x01, 0x83, 0x00,
  0x70, 0xC0, 0x1C, 0x30, 0x03, 0x0C, 0x00, 0xC7, 0x00, 0x31, 0x80, 0x0C,
  0x60, 0x03, 0x18, 0x01, 0xC6, 0x00, 0x73, 0x80, 0x18, 0xC0, 0x06, 0x30,
  0x01, 0x8C, 0x00, 0xE3, 0x00, 0x31, 0x80, 0x1C, 0x60, 0x06, 0x18, 0x03,
  0x86, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x78, 0x30, 0x3C, 0x0F, 0xFC, 0x03,
  0xFC, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x07, 0xFF,
  0x07, 0xFF, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F,
  0x01, 0x83, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x0F, 0xE6, 0x01, 0xFC, 0xC0, 0x03, 0x98, 0x00,
  0x63, 0x00, 0x0C, 0x60, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0C, 0x38, 0x01,
  0x83, 0x00, 0x30, 0x70, 0x06, 0x07, 0x01, 0xC0, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0x07, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x70, 0x60, 0x06, 0x06,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0E, 0x0C, 0x00, 0xC1,
  0xC0, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x1F, 0xFF, 0x81, 0xFF, 0xF8,
  0x38, 0x01, 0x83, 0x00, 0x18, 0x30, 0x03, 0x83, 0x00, 0x30, 0x30, 0x03,
  0x07, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00, 0x70, 0x60, 0x06, 0x0E, 0x00,
  0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0x03,
  0xFC, 0x0F, 0xE0, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x03, 0xE0, 0x3F, 0xC0,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0xC0, 0x38, 0x18,
  0x0E, 0x03, 0x01, 0x80, 0x60, 0x60, 0x18, 0x18, 0x03, 0x07, 0x00, 0x61,
  0xC0, 0x0C, 0x70, 0x03, 0x8C, 0x00, 0x63, 0x00, 0x0C, 0xE0, 0x01, 0xB8,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xEE, 0x00, 0x38, 0xC0, 0x06, 0x18,
  0x00, 0xC3, 0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x1C,
  0x07, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x07, 0x03, 0x00, 0x60, 0x60, 0x0C,
  0x00, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x38, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x83, 0x60, 0x03, 0x60,
  0xD8, 0x00, 0xD8, 0x36, 0x00, 0x6C, 0x0D, 0x80, 0x1B, 0x07, 0x60, 0x0C,
  0xC1, 0x98, 0x03, 0x30, 0x66, 0x01, 0x9C, 0x19, 0x80, 0x66, 0x06, 0x20,
  0x31, 0x83, 0x0C, 0x0C, 0x60, 0xC3, 0x06, 0x18, 0x30, 0xC1, 0x8E, 0x0C,
  0x30, 0xC3, 0x03, 0x0C, 0x30, 0xC1, 0x83, 0x18, 0x30, 0x60, 0xC6, 0x0C,
  0x18, 0x33, 0x06, 0x06, 0x0C, 0xC1, 0x83, 0x83, 0x60, 0x60, 0xC0, 0xD8,
  0x18, 0x30, 0x3C, 0x0E, 0x0C, 0x07, 0x03, 0x03, 0x01, 0x80, 0xC0, 0x07,
  0x00, 0x18, 0x38, 0x00, 0xC1, 0xC0, 0x0C, 0x0F, 0x00, 0x60, 0x58, 0x03,
  0x06, 0xC0, 0x18, 0x36, 0x01, 0xC1, 0x98, 0x0C, 0x0C, 0xC0, 0x60, 0xE6,
  0x03, 0x06, 0x30, 0x18, 0x30, 0xC1, 0x81, 0x86, 0x0C, 0x0C, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x06, 0x18, 0x30, 0x31, 0x81, 0x81, 0x8C, 0x0C, 0x0C,
  0x60, 0xC0, 0x33, 0x06, 0x01, 0xB8, 0x30, 0x0D, 0x81, 0x80, 0x6C, 0x1C,
  0x01, 0xE0, 0xC0, 0x0F, 0x06, 0x00, 0x70, 0x30, 0x03, 0x81, 0x80, 0x1C,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x38, 0x38, 0x18, 0x07, 0x0C, 0x00,
  0xC7, 0x00, 0x31, 0x80, 0x0C, 0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x37,
  0x00, 0x0D, 0x80, 0x03, 0x60, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x3B, 0x00, 0x0C, 0xC0, 0x03,
  0x30, 0x01, 0xCC, 0x00, 0x63, 0x80, 0x30, 0x60, 0x1C, 0x1C, 0x0E, 0x03,
  0xFF, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x06, 0x0E, 0x06, 0x07,
  0x06, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x1C, 0x03,
  0x18, 0x07, 0x18, 0x06, 0x18, 0x0E, 0x18, 0x1C, 0x38, 0x78, 0x3F, 0xE0,
  0x3F, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x38, 0x38, 0x18, 0x07, 0x0C, 0x00, 0xC7,
  0x00, 0x31, 0x80, 0x0C, 0xE0, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x37, 0x00,
  0x0D, 0x80, 0x03, 0x60, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x06,
  0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x3B, 0x00, 0x0C, 0xC0, 0x03, 0x30,
  0x01, 0x8C, 0x00, 0x63, 0x80, 0x30, 0x60, 0x1C, 0x1C, 0x0E, 0x03, 0xFF,
  0x00, 0x7F, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x06,
  0x0E, 0x06, 0x07, 0x06, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C,
  0x03, 0x1C, 0x03, 0x18, 0x07, 0x18, 0x06, 0x18, 0x0E, 0x18, 0x3C, 0x3F,
  0xF8, 0x3F, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0x60, 0x70, 0x60, 0x60,
  0x60, 0x60, 0x60, 0x60, 0x70, 0x60, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0xC0,
  0x38, 0xC0, 0x18, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x38, 0x08, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x10,
  0x0E, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x61, 0x80, 0x1C, 0x30, 0x03, 0x06, 0x00, 0x61, 0x80, 0x0C, 0x30,
  0x01, 0x86, 0x00, 0x70, 0xC0, 0x0C, 0x38, 0x01, 0x86, 0x00, 0x30, 0xC0,
  0x06, 0x18, 0x01, 0x83, 0x00, 0x30, 0xE0, 0x06, 0x18, 0x00, 0xC3, 0x00,
  0x38, 0x60, 0x06, 0x0C, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03, 0x0C, 0x00,
  0xC1, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0xC0, 0xE0, 0x38, 0x0C, 0x0E,
  0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x00, 0xE0, 0x03, 0xB0, 0x01, 0x98, 0x01,
  0xCC, 0x00, 0xC6, 0x00, 0xE3, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x30, 0x60,
  0x18, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x03, 0x07, 0x01,
  0x83, 0x00, 0xC3, 0x80, 0x61, 0x80, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0x60,
  0x06, 0x60, 0x03, 0x30, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x0C, 0x01, 0xF0, 0x07, 0x00,
  0x6C, 0x01, 0xC0, 0x1B, 0x00, 0xF0, 0x0C, 0xC0, 0x3C, 0x03, 0x30, 0x0B,
  0x01, 0xCC, 0x06, 0xC0, 0x63, 0x01, 0xB0, 0x18, 0xC0, 0xCC, 0x0C, 0x30,
  0x33, 0x03, 0x0C, 0x18, 0xC1, 0xC3, 0x06, 0x30, 0x60, 0xC1, 0x8C, 0x18,
  0x30, 0xC3, 0x0C, 0x0C, 0x30, 0xC3, 0x03, 0x18, 0x31, 0x80, 0xC6, 0x0C,
  0x60, 0x31, 0x83, 0x38, 0x0C, 0xC0, 0xCC, 0x03, 0x30, 0x33, 0x00, 0xD8,
  0x0D, 0x80, 0x36, 0x03, 0x60, 0x0D, 0x00, 0xD8, 0x03, 0xC0, 0x3C, 0x00,
  0xF0, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x00, 0x30,
  0x00, 0x03, 0x80, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x18, 0x0C, 0x01,
  0x81, 0x80, 0x0C, 0x38, 0x00, 0xC3, 0x00, 0x0C, 0x60, 0x00, 0xC6, 0x00,
  0x0C, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xB0, 0x00, 0x3B, 0x00, 0x03, 0x38,
  0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0xC1, 0x80, 0x1C, 0x18, 0x01, 0x81,
  0x80, 0x30, 0x0C, 0x07, 0x00, 0xC0, 0x60, 0x0C, 0x0C, 0x00, 0xC0, 0xE0,
  0x0E, 0xC0, 0x19, 0x80, 0x73, 0x00, 0xC6, 0x03, 0x8C, 0x06, 0x18, 0x18,
  0x18, 0x30, 0x30, 0xC0, 0x63, 0x80, 0xC6, 0x01, 0x98, 0x03, 0x30, 0x06,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xC3,
  0x0C, 0x30, 0x61, 0x86, 0x18, 0x61, 0x86, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC1, 0x86, 0x18, 0x61, 0x86, 0x18, 0x30, 0xC3, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x7F, 0x01, 0xFE, 0x00,
  0x00, 0xC0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0x30, 0x03, 0x30,
  0x06, 0x30, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x0C,
  0x30, 0x06, 0x60, 0x06, 0xE0, 0x07, 0xFF, 0xF0, 0xCC, 0x66, 0x31, 0x01,
  0xE3, 0x07, 0xF3, 0x0E, 0x1B, 0x1C, 0x0E, 0x18, 0x0E, 0x38, 0x0E, 0x30,
  0x0E, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0xE0,
  0x18, 0xE0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xE0, 0x38, 0x60, 0x70, 0x60,
  0xF0, 0x7B, 0xB0, 0x3F, 0x30, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x7C, 0x06, 0xFE, 0x0D, 0x87, 0x0F, 0x03, 0x0E, 0x03, 0x0E, 0x03, 0x1C,
  0x03, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x30, 0x07, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x0E, 0x30, 0x0C, 0x70, 0x1C, 0x70, 0x18, 0x78,
  0x38, 0x6E, 0xF0, 0xC7, 0xC0, 0x01, 0xF8, 0x3F, 0xC3, 0x80, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x7B, 0x81, 0xFC, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x78, 0xC0, 0x7F, 0xB0, 0x38, 0x6C, 0x1C, 0x0E, 0x06, 0x03, 0x83,
  0x80, 0x60, 0xC0, 0x38, 0x30, 0x0E, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80,
  0x30, 0x60, 0x0C, 0x38, 0x07, 0x0E, 0x01, 0x83, 0x00, 0xE0, 0xC0, 0x38,
  0x38, 0x1E, 0x0E, 0x05, 0x01, 0x83, 0xC0, 0x7B, 0xB0, 0x0F, 0xCC, 0x00,
  0x01, 0xF0, 0x1F, 0xE0, 0xE1, 0x87, 0x03, 0x18, 0x0C, 0xE0, 0x63, 0x01,
  0x9C, 0x0E, 0x60, 0x71, 0x8F, 0x87, 0xF8, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x02, 0x0F, 0x78, 0x1F,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0F,
  0xE0, 0x07, 0xF8, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF9,
  0x81, 0xFE, 0xC1, 0xC3, 0x61, 0xC0, 0xA0, 0xC0, 0x70, 0xE0, 0x38, 0x60,
  0x1C, 0x30, 0x0E, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0x61, 0x80, 0x70, 0xC0, 0x38, 0x70, 0x3C, 0x38, 0x14,
  0x0C, 0x1E, 0x07, 0xBB, 0x01, 0xF9, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x10, 0x18, 0x0F, 0x7C, 0x07,
  0xF8, 0x00, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x7C, 0x06, 0xFE,
  0x0D, 0x86, 0x0F, 0x07, 0x0E, 0x03, 0x0C, 0x07, 0x1C, 0x06, 0x1C, 0x06,
  0x18, 0x06, 0x18, 0x06, 0x18, 0x0E, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x0C,
  0x30, 0x0C, 0x30, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18,
  0xE0, 0x30, 0x03, 0x81, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x06,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x3E,
  0x00, 0xF0, 0x00, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x07, 0x06,
  0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x0C, 0x30, 0x0C, 0x70, 0x1C, 0xE0, 0x18,
  0xC0, 0x19, 0x80, 0x1B, 0x80, 0x1F, 0x80, 0x3D, 0xC0, 0x38, 0xC0, 0x30,
  0xC0, 0x30, 0xC0, 0x30, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60, 0x60,
  0x70, 0xE0, 0x30, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C,
  0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06,
  0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x07,
  0x00, 0x06, 0x7C, 0x3E, 0x04, 0xFE, 0x7F, 0x0D, 0x8E, 0xC3, 0x0E, 0x07,
  0x83, 0x0E, 0x07, 0x03, 0x0C, 0x06, 0x03, 0x1C, 0x06, 0x03, 0x1C, 0x06,
  0x03, 0x18, 0x0C, 0x03, 0x18, 0x0C, 0x06, 0x18, 0x0C, 0x06, 0x38, 0x0C,
  0x06, 0x30, 0x0C, 0x06, 0x30, 0x18, 0x06, 0x30, 0x18, 0x0C, 0x30, 0x18,
  0x0C, 0x60, 0x18, 0x0C, 0x60, 0x38, 0x0C, 0x60, 0x30, 0x1C, 0x60, 0x30,
  0x18, 0xE0, 0x30, 0x18, 0x06, 0x7C, 0x04, 0xFE, 0x0D, 0x86, 0x0F, 0x07,
  0x0E, 0x07, 0x0C, 0x07, 0x1C, 0x06, 0x1C, 0x06, 0x18, 0x06, 0x18, 0x06,
  0x18, 0x0E, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x18,
  0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x38, 0xE0, 0x30, 0x01, 0xF0,
  0x0F, 0xF0, 0x38, 0x70, 0xE0, 0x61, 0x80, 0xE7, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x60, 0x0E, 0xC0, 0x1D, 0x80, 0x33, 0x00, 0x6E, 0x00, 0xD8, 0x03,
  0xB0, 0x06, 0x60, 0x0C, 0xE0, 0x30, 0xC0, 0xE1, 0x83, 0x81, 0xFE, 0x01,
  0xF8, 0x00, 0x03, 0x3E, 0x01, 0x3F, 0x81, 0xB0, 0xE0, 0xF0, 0x30, 0x70,
  0x18, 0x38, 0x0C, 0x18, 0x06, 0x1C, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC3,
  0x00, 0x63, 0x80, 0x71, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x1C, 0x30, 0x0C,
  0x38, 0x0E, 0x1C, 0x06, 0x0F, 0x07, 0x06, 0xEF, 0x03, 0x3E, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF3, 0x07, 0xFB, 0x0E, 0x1B,
  0x1C, 0x0E, 0x18, 0x0E, 0x38, 0x0E, 0x30, 0x0E, 0x30, 0x0E, 0x70, 0x0C,
  0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x1C, 0xE0, 0x18, 0xC0, 0x38,
  0xC0, 0x38, 0xE0, 0x78, 0xE0, 0x70, 0x60, 0xF0, 0x7B, 0xB0, 0x3F, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x04, 0x78, 0x27, 0xC3, 0x60, 0x1E,
  0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0xC7, 0x04, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x20, 0x71,
  0xFF, 0x0F, 0xF0, 0x00, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0xFD, 0xFE,
  0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x60, 0x30,
  0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xFC, 0x3E, 0x00, 0x0C, 0x07,
  0x1C, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x0C, 0x30, 0x0C,
  0x30, 0x0C, 0x30, 0x0C, 0x30, 0x1C, 0x70, 0x18, 0x60, 0x18, 0x60, 0x18,
  0x60, 0x18, 0x60, 0x38, 0xE0, 0x30, 0xC0, 0x70, 0xC0, 0x70, 0xE0, 0xB0,
  0x7F, 0x20, 0x3E, 0x60, 0xC0, 0x1E, 0x00, 0xF0, 0x0D, 0x80, 0x6C, 0x06,
  0x60, 0x33, 0x03, 0x1C, 0x18, 0x61, 0x83, 0x0C, 0x18, 0xE0, 0xC6, 0x06,
  0x70, 0x33, 0x01, 0xB8, 0x0D, 0x80, 0x6C, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x00, 0xC0, 0x30, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x0F, 0x81,
  0xE0, 0x6C, 0x0F, 0x03, 0x60, 0x58, 0x33, 0x06, 0xC1, 0x98, 0x36, 0x18,
  0xC3, 0x30, 0xC6, 0x19, 0x8E, 0x31, 0x8C, 0x61, 0x8C, 0x63, 0x0C, 0x43,
  0x30, 0x66, 0x19, 0x83, 0x30, 0xD8, 0x1B, 0x06, 0xC0, 0xD8, 0x36, 0x06,
  0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0x00, 0x06,
  0x01, 0x83, 0x81, 0x80, 0xC1, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x0C, 0xE0,
  0x06, 0x60, 0x03, 0x60, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x36, 0x00, 0x1B, 0x00, 0x19, 0x80, 0x18, 0x60, 0x1C, 0x30, 0x0C,
  0x18, 0x0C, 0x0C, 0x0E, 0x03, 0x0E, 0x01, 0x80, 0x01, 0x80, 0x70, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x01, 0x80, 0xC0, 0x18, 0x18, 0x01,
  0x81, 0x80, 0x18, 0x30, 0x01, 0x83, 0x00, 0x18, 0x60, 0x01, 0x86, 0x00,
  0x18, 0xC0, 0x01, 0x8C, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x1B, 0x80,
  0x00, 0xB0, 0x00, 0x0B, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0xBC, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xFC, 0x3F, 0xF0, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x00, 0x1C, 0x01, 0xF0, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x07, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80,
  0x0F, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x7C, 0x01, 0xE0, 0x0E, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x03,
  0xFE, 0x07, 0x0F, 0xFC, 0x07, 0xE0,
};

const GFXglyph NotoSans_Condensed_LightItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 28, 9, 1, -28 },
  { 29, 9, 10, 12, 4, -28 },
  { 41, 19, 28, 18, 0, -28 },
  { 108, 17, 32, 16, 0, -30 },
  { 176, 21, 28, 25, 2, -28 },
  { 250, 17, 28, 18, 0, -28 },
  { 310, 4, 10, 7, 4, -28 },
  { 315, 11, 34, 10, 1, -28 },
  { 362, 12, 34, 10, -3, -28 },
  { 413, 13, 14, 16, 4, -30 },
  { 436, 15, 18, 18, 2, -23 },
  { 470, 6, 9, 7, -2, -4 },
  { 477, 9, 2, 11, 1, -12 },
  { 480, 3, 4, 8, 1, -4 },
  { 482, 17, 28, 12, -2, -28 },
  { 542, 15, 28, 16, 1, -28 },
  { 595, 9, 28, 16, 5, -28 },
  { 627, 17, 28, 16, -1, -28 },
  { 687, 16, 28, 16, 0, -28 },
  { 743, 16, 28, 16, 0, -28 },
  { 799, 17, 28, 16, 0, -28 },
  { 859, 16, 28, 16, 1, -28 },
  { 915, 16, 28, 16, 2, -28 },
  { 971, 17, 28, 16, 0, -28 },
  { 1031, 16, 28, 16, 0, -28 },
  { 1087, 7, 21, 8, 0, -21 },
  { 1106, 9, 26, 8, -2, -21 },
  { 1136, 15, 18, 18, 2, -23 },
  { 1170, 15, 10, 18, 2, -19 },
  { 1189, 15, 18, 18, 2, -23 },
  { 1223, 13, 28, 12, 1, -28 },
  { 1269, 23, 31, 25, 1, -28 },
  { 1359, 16, 28, 16, -2, -28 },
  { 1415, 17, 28, 18, 1, -28 },
  { 1475, 17, 28, 17, 2, -28 },
  { 1535, 18, 28, 20, 1, -28 },
  { 1598, 16, 28, 16, 1, -28 },
  { 1654, 16, 28, 15, 1, -28 },
  { 1710, 19, 28, 21, 2, -28 },
  { 1777, 20, 28, 21, 1, -28 },
  { 1847, 14, 28, 9, -2, -28 },
  { 1896, 15, 35, 8, -6, -28 },
  { 1962, 19, 28, 17, 1, -28 },
  { 2029, 11, 28, 14, 1, -28 },
  { 2068, 26, 28, 26, 1, -28 },
  { 2159, 21, 28, 21, 1, -28 },
  { 2233, 18, 28, 21, 2, -28 },
  { 2296, 16, 28, 17, 1, -28 },
  { 2352, 18, 35, 21, 2, -28 },
  { 2431, 16, 28, 17, 1, -28 },
  { 2487, 18, 28, 16, -1, -28 },
  { 2550, 15, 28, 14, 3, -28 },
  { 2603, 19, 28, 20, 2, -28 },
  { 2670, 17, 28, 17, 3, -28 },
  { 2730, 26, 28, 27, 4, -28 },
  { 2821, 20, 28, 15, -2, -28 },
  { 2891, 15, 28, 15, 3, -28 },
  { 2944, 18, 28, 15, -1, -28 },
  { 3007, 15, 34, 11, -1, -28 },
  { 3071, 6, 28, 13, 4, -28 },
  { 3092, 15, 34, 11, -3, -28 },
  { 3156, 16, 15, 17, 1, -28 },
  { 3186, 12, 1, 12, -3, 4 },
  { 3188, 4, 6, 9, 6, -30 },
  { 3191, 16, 21, 17, 1, -21 },
  { 3233, 16, 30, 17, 0, -30 },
  { 3293, 13, 21, 13, 1, -21 },
  { 3328, 18, 30, 18, 1, -30 },
  { 3396, 14, 21, 15, 1, -21 },
  { 3433, 19, 39, 9, -5, -30 },
  { 3526, 17, 30, 18, 0, -21 },
  { 3590, 16, 30, 17, 0, -30 },
  { 3650, 9, 28, 7, 0, -28 },
  { 3682, 14, 37, 8, -5, -28 },
  { 3747, 16, 30, 14, 0, -30 },
  { 3807, 9, 30, 7, 0, -30 },
  { 3841, 24, 21, 26, 0, -21 },
  { 3904, 16, 21, 17, 0, -21 },
  { 3946, 15, 21, 17, 1, -21 },
  { 3986, 17, 30, 18, -1, -21 },
  { 4050, 16, 30, 18, 1, -21 },
  { 4110, 13, 21, 11, 0, -21 },
  { 4145, 13, 21, 13, 0, -21 },
  { 4180, 9, 26, 9, 1, -26 },
  { 4210, 16, 21, 17, 1, -21 },
  { 4252, 13, 21, 13, 2, -21 },
  { 4287, 21, 21, 22, 2, -21 },
  { 4343, 17, 21, 14, -2, -21 },
  { 4388, 20, 30, 14, -4, -21 },
  { 4463, 14, 21, 12, -1, -21 },
  { 4500, 14, 34, 13, 1, -28 },
  { 4560, 2, 39, 16, 7, -30 },
  { 4570, 14, 34, 13, -2, -28 },
  { 4630, 15, 4, 18, 2, -16 },
};

const GFXfont NotoSans_Condensed_LightItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC39PT7B_H_
