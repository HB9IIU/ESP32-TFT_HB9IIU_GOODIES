#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC43PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0E, 0x07, 0x03, 0x80,
  0x38, 0xE6, 0x1C, 0xC3, 0x18, 0x63, 0x0C, 0xC3, 0x98, 0x63, 0x0C, 0x61,
  0x88, 0x23, 0x0C, 0x00, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x08,
  0x10, 0x00, 0xC1, 0x80, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x03, 0x06, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06,
  0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x46,
  0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x18, 0x30, 0x00, 0xC1, 0x80,
  0x06, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0x83,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x20, 0x00,
  0x7F, 0x00, 0x7F, 0xF0, 0x39, 0x8C, 0x1C, 0x40, 0x06, 0x10, 0x03, 0x8C,
  0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0E, 0x20, 0x03, 0x88, 0x00, 0x76, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0x70, 0x00,
  0xCC, 0x00, 0x33, 0x80, 0x08, 0x60, 0x02, 0x18, 0x01, 0x86, 0x00, 0x61,
  0x80, 0x10, 0xE2, 0x04, 0x30, 0xE3, 0x38, 0x3F, 0xFC, 0x03, 0xFC, 0x00,
  0x08, 0x00, 0x02, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07,
  0xC0, 0x0C, 0x1F, 0xC0, 0x30, 0x31, 0x80, 0xE0, 0xC3, 0x01, 0x83, 0x86,
  0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0x61,
  0x80, 0xC0, 0xC7, 0x01, 0x83, 0x8C, 0x03, 0x06, 0x30, 0x06, 0x0C, 0x63,
  0x98, 0x19, 0x8F, 0xB0, 0x67, 0x31, 0xB0, 0xCC, 0xC3, 0x63, 0x31, 0x86,
  0xFC, 0x66, 0x0C, 0xF1, 0x8C, 0x18, 0x03, 0x18, 0x30, 0x0C, 0x60, 0x60,
  0x38, 0xC0, 0xC0, 0x61, 0x81, 0x81, 0x83, 0x06, 0x03, 0x06, 0x0C, 0x0C,
  0x08, 0x18, 0x18, 0x10, 0x60, 0x60, 0x30, 0xC1, 0xC0, 0x63, 0x03, 0x00,
  0xEE, 0x0C, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x07, 0x0C,
  0x00, 0xC1, 0x80, 0x38, 0x38, 0x06, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18,
  0x03, 0x07, 0x00, 0x60, 0xC0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x1B, 0x80,
  0x03, 0xE0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0E, 0xE0, 0x03, 0x8C, 0x0C,
  0x61, 0xC3, 0x98, 0x18, 0x67, 0x03, 0x8C, 0xC0, 0x33, 0x18, 0x06, 0x67,
  0x00, 0xF8, 0xE0, 0x0F, 0x1C, 0x01, 0xC3, 0x80, 0x78, 0x70, 0x1F, 0x87,
  0x07, 0x70, 0xFF, 0xC6, 0x07, 0xF0, 0xE0, 0x39, 0xCC, 0x63, 0x39, 0x8C,
  0x63, 0x30, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0x01, 0x00, 0x06, 0x00, 0x30, 0x00, 0xC0, 0xC3, 0x03, 0xCC, 0x03,
  0xF3, 0xC3, 0xFF, 0x07, 0x00, 0x34, 0x01, 0x98, 0x1C, 0x60, 0xE0, 0xC1,
  0x03, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0E,
  0x1C, 0x30, 0xE1, 0x87, 0x0C, 0x18, 0x60, 0xC3, 0x00, 0xFF, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x71, 0xC0, 0x60,
  0x60, 0x70, 0x38, 0x70, 0x1C, 0x30, 0x0E, 0x18, 0x07, 0x1C, 0x03, 0x8C,
  0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x00, 0x31, 0x80, 0x19, 0xC0, 0x0C,
  0xE0, 0x06, 0x60, 0x07, 0x30, 0x03, 0x98, 0x01, 0x8C, 0x00, 0xC6, 0x00,
  0xE7, 0x00, 0x73, 0x80, 0x31, 0xC0, 0x38, 0xE0, 0x18, 0x30, 0x1C, 0x18,
  0x0C, 0x0C, 0x0E, 0x07, 0x0E, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xC0,
  0xF0, 0x7C, 0x3E, 0x3D, 0x9C, 0x6E, 0x39, 0x0E, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x07, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0x0F, 0x00, 0x80, 0x60, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFC,
  0x3F, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0x78, 0x38, 0x08, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x80, 0x78, 0x3F, 0xFC, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0D,
  0x80, 0x06, 0x60, 0x01, 0xB8, 0x00, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x0C, 0x70, 0x06, 0x18, 0x03, 0x86, 0x00, 0xC1, 0x80, 0x60, 0x60, 0x38,
  0x38, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x80, 0xC0, 0xC0, 0x70, 0x60, 0x1C,
  0x38, 0x06, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0xFF, 0xC0, 0x7F, 0xF0, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x80, 0x78, 0x3F, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x3E,
  0x03, 0x3F, 0xC1, 0xB0, 0xE1, 0xF0, 0x38, 0xF0, 0x0C, 0x70, 0x06, 0x38,
  0x03, 0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80, 0x38,
  0xC0, 0x18, 0x60, 0x0C, 0x30, 0x0E, 0x1C, 0x0E, 0x06, 0x0E, 0x03, 0xFE,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xC8, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0xE0, 0x3C, 0x38, 0x0C, 0x07, 0x07, 0x00, 0xC1, 0x80, 0x30, 0x60,
  0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x70, 0x70, 0x38, 0x0C, 0x0C,
  0x03, 0x8E, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x07, 0x38, 0x03,
  0x87, 0x01, 0x80, 0xC0, 0xC0, 0x38, 0x70, 0x06, 0x18, 0x01, 0x8E, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x06, 0x38, 0x01, 0x8E, 0x00, 0xE1, 0xC0, 0x30,
  0x70, 0x1C, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0x01,
  0xC1, 0x81, 0xC0, 0xE0, 0xC0, 0x30, 0xE0, 0x18, 0x60, 0x0E, 0x30, 0x07,
  0x38, 0x03, 0x9C, 0x01, 0xCC, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x31, 0x80,
  0x38, 0xC0, 0x1C, 0x70, 0x1E, 0x1C, 0x1F, 0x0F, 0xFB, 0x03, 0xF9, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x07, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0x07, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x70, 0xF0, 0x60,
  0x01, 0xC0, 0x70, 0x1C, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x30, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x07,
  0xE0, 0x7F, 0xE1, 0xC3, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03, 0x00, 0xE0,
  0x00, 0x60, 0x30, 0x00, 0x18, 0x18, 0x00, 0x06, 0x0C, 0x00, 0x01, 0x83,
  0x01, 0xF8, 0x31, 0x81, 0xFE, 0x0C, 0x60, 0xE1, 0x83, 0x30, 0x30, 0x60,
  0xCC, 0x18, 0x30, 0x63, 0x0E, 0x0C, 0x19, 0x83, 0x03, 0x06, 0x60, 0xC0,
  0xC1, 0x98, 0x60, 0x60, 0x66, 0x18, 0x18, 0x31, 0x86, 0x06, 0x0C, 0x61,
  0x83, 0x83, 0x30, 0x60, 0xE1, 0x8C, 0x18, 0x78, 0x63, 0x06, 0x16, 0x30,
  0xC1, 0xFD, 0xF8, 0x30, 0x3E, 0x3C, 0x06, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x0E, 0x03, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0x60, 0x00, 0xD8, 0x00, 0x67, 0x00, 0x19, 0xC0, 0x0C, 0x70, 0x03,
  0x1C, 0x01, 0xC7, 0x00, 0x60, 0xC0, 0x38, 0x30, 0x0C, 0x0C, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0xE0, 0x30, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0x00, 0xC1,
  0x80, 0x30, 0xE0, 0x0C, 0x30, 0x03, 0x1C, 0x00, 0xC6, 0x00, 0x33, 0x80,
  0x0C, 0xC0, 0x03, 0x70, 0x00, 0xDC, 0x00, 0x3E, 0x00, 0x0C, 0x03, 0xFC,
  0x00, 0x7F, 0xF0, 0x0C, 0x3F, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x0C, 0x01,
  0xC1, 0x80, 0x38, 0x30, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x18, 0x30, 0x07,
  0x06, 0x00, 0xC0, 0xC0, 0x38, 0x38, 0x1E, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x18, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x06, 0x1C, 0x00, 0xC3, 0x80, 0x18, 0x60, 0x07, 0x0C, 0x00, 0xE1,
  0x80, 0x38, 0x70, 0x0E, 0x0E, 0x07, 0x81, 0xFF, 0xE0, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x0F, 0xFC, 0x07, 0x81, 0x81, 0xE0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x80, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x03, 0x1F, 0x80, 0x70, 0x1C,
  0x07, 0x00, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0x60, 0x60, 0x07, 0x0E, 0x00,
  0x70, 0xE0, 0x07, 0x0C, 0x00, 0x70, 0xC0, 0x07, 0x0C, 0x00, 0x71, 0xC0,
  0x07, 0x18, 0x00, 0x71, 0x80, 0x06, 0x18, 0x00, 0x63, 0x80, 0x0E, 0x38,
  0x00, 0xE3, 0x00, 0x0C, 0x30, 0x01, 0xC3, 0x00, 0x1C, 0x70, 0x03, 0x87,
  0x00, 0x38, 0x60, 0x07, 0x06, 0x00, 0xE0, 0x60, 0x1E, 0x0E, 0x03, 0xC0,
  0xC0, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xE0, 0x7F, 0xF0, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0x80, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x7C, 0x0E,
  0x07, 0x80, 0x10, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x01, 0xFC, 0xE0, 0x1F,
  0xE7, 0x00, 0x07, 0x38, 0x00, 0x31, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x70,
  0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x30, 0xE0, 0x01, 0x83, 0x00, 0x0C,
  0x1C, 0x00, 0xE0, 0xE0, 0x06, 0x03, 0xC0, 0x30, 0x0F, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x01, 0xC1, 0xC0,
  0x07, 0x07, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x0E,
  0x0E, 0x00, 0x30, 0x38, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x1C, 0x0C,
  0x00, 0x70, 0x70, 0x01, 0x81, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x18, 0x00,
  0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0,
  0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80,
  0x06, 0x06, 0x00, 0x38, 0x38, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00, 0x0C,
  0x0C, 0x00, 0x70, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x0F, 0xE0,
  0x3F, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03,
  0x00, 0x07, 0x00, 0x9E, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x38,
  0x18, 0x03, 0x80, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x18, 0x03, 0x01,
  0xC0, 0x18, 0x1C, 0x00, 0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x03,
  0x0E, 0x00, 0x18, 0xE0, 0x00, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0x6F, 0x00,
  0x03, 0x78, 0x00, 0x1E, 0xE0, 0x01, 0xE7, 0x00, 0x0E, 0x18, 0x00, 0x60,
  0xC0, 0x03, 0x07, 0x00, 0x18, 0x38, 0x01, 0xC0, 0xC0, 0x0E, 0x07, 0x00,
  0x60, 0x38, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x60, 0x06, 0x03, 0x00, 0x38, 0x00, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x6C, 0x00, 0x1B,
  0x03, 0x60, 0x00, 0xF8, 0x1B, 0x00, 0x0D, 0x80, 0xD8, 0x00, 0x6C, 0x0E,
  0xC0, 0x06, 0x60, 0x66, 0x00, 0x37, 0x03, 0x30, 0x03, 0x38, 0x19, 0x80,
  0x19, 0x80, 0xCC, 0x01, 0x8C, 0x0E, 0x60, 0x0C, 0x60, 0x63, 0x80, 0xC7,
  0x03, 0x1C, 0x06, 0x38, 0x18, 0x60, 0x61, 0x81, 0xC3, 0x03, 0x0C, 0x0E,
  0x18, 0x30, 0x60, 0x60, 0xC1, 0x87, 0x03, 0x06, 0x18, 0x30, 0x18, 0x30,
  0xC1, 0x81, 0xC1, 0x8C, 0x0C, 0x0C, 0x0C, 0x60, 0xE0, 0x60, 0x66, 0x07,
  0x03, 0x03, 0x30, 0x30, 0x18, 0x1B, 0x01, 0x81, 0xC0, 0xF8, 0x0C, 0x0C,
  0x07, 0x80, 0xE0, 0x60, 0x1C, 0x07, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x03,
  0x80, 0x06, 0x07, 0x00, 0x0C, 0x0E, 0x00, 0x38, 0x3E, 0x00, 0x60, 0x6C,
  0x00, 0xC0, 0xD8, 0x01, 0x81, 0xB0, 0x03, 0x03, 0x70, 0x0E, 0x0E, 0x60,
  0x18, 0x18, 0xC0, 0x30, 0x31, 0x80, 0x60, 0x63, 0x81, 0xC0, 0xC3, 0x03,
  0x83, 0x86, 0x06, 0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x38, 0x70,
  0x70, 0x30, 0xC0, 0xE0, 0x61, 0x81, 0x80, 0xC3, 0x03, 0x01, 0xC6, 0x06,
  0x01, 0x9C, 0x1C, 0x03, 0x30, 0x30, 0x06, 0x60, 0x60, 0x0E, 0xC0, 0xC0,
  0x0D, 0x81, 0x80, 0x1F, 0x07, 0x00, 0x3C, 0x0C, 0x00, 0x78, 0x18, 0x00,
  0x70, 0x30, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFC, 0x01, 0xC1,
  0xE0, 0x38, 0x0E, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x0C, 0x00, 0x31, 0xC0,
  0x03, 0x18, 0x00, 0x33, 0x80, 0x03, 0x30, 0x00, 0x33, 0x00, 0x03, 0x70,
  0x00, 0x37, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00, 0xEC, 0x00, 0x0C,
  0xC0, 0x01, 0xCE, 0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00, 0x30, 0x60, 0x07,
  0x07, 0x00, 0xE0, 0x38, 0x1C, 0x03, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0xFF, 0xC0, 0x31, 0xF8, 0x1C, 0x0E, 0x07, 0x01, 0xC1, 0x80,
  0x70, 0x60, 0x0C, 0x18, 0x03, 0x0E, 0x00, 0xC3, 0x80, 0x70, 0xC0, 0x1C,
  0x30, 0x07, 0x0C, 0x01, 0x87, 0x00, 0xE1, 0x80, 0x70, 0x60, 0x38, 0x1F,
  0xFC, 0x0F, 0xFC, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x0F, 0xFC, 0x01, 0xC1, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0x70, 0xE0, 0x07,
  0x0C, 0x00, 0x31, 0xC0, 0x03, 0x18, 0x00, 0x33, 0x80, 0x03, 0x30, 0x00,
  0x33, 0x00, 0x03, 0x70, 0x00, 0x37, 0x00, 0x03, 0x60, 0x00, 0x36, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0,
  0x00, 0xEC, 0x00, 0x0C, 0xC0, 0x01, 0xCE, 0x00, 0x18, 0xE0, 0x03, 0x8E,
  0x00, 0x30, 0x60, 0x07, 0x07, 0x00, 0xE0, 0x38, 0x1C, 0x03, 0xFF, 0x80,
  0x0F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x03, 0xF0, 0x00, 0xFF,
  0xC0, 0x31, 0xF8, 0x1C, 0x0E, 0x07, 0x01, 0xC1, 0x80, 0x70, 0x60, 0x0C,
  0x18, 0x03, 0x0E, 0x00, 0xC3, 0x80, 0x70, 0xC0, 0x1C, 0x30, 0x06, 0x0C,
  0x03, 0x87, 0x00, 0xC1, 0x80, 0xF0, 0x60, 0xF8, 0x1F, 0xF8, 0x0F, 0xF8,
  0x03, 0x86, 0x00, 0xC1, 0xC0, 0x30, 0x70, 0x0C, 0x0C, 0x07, 0x03, 0x01,
  0xC0, 0xE0, 0x60, 0x38, 0x18, 0x06, 0x06, 0x01, 0x83, 0x80, 0x70, 0xE0,
  0x1C, 0x30, 0x03, 0x0C, 0x00, 0xC0, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x07,
  0x83, 0x81, 0xC0, 0x10, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x04, 0x03, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x18, 0x30, 0x01,
  0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18, 0x30,
  0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00, 0x18,
  0x70, 0x01, 0xC3, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06, 0x00,
  0x38, 0x70, 0x01, 0xC3, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x03, 0x06,
  0x00, 0x38, 0x70, 0x01, 0x83, 0x80, 0x0C, 0x18, 0x00, 0x60, 0xC0, 0x07,
  0x06, 0x00, 0x30, 0x38, 0x03, 0x81, 0xC0, 0x38, 0x07, 0x03, 0x80, 0x1F,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00, 0x3B,
  0x00, 0x0C, 0xC0, 0x07, 0x30, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x30, 0xC0,
  0x1C, 0x30, 0x07, 0x0C, 0x01, 0x83, 0x80, 0xE0, 0xE0, 0x30, 0x38, 0x1C,
  0x0E, 0x06, 0x03, 0x83, 0x80, 0xE0, 0xC0, 0x38, 0x70, 0x06, 0x18, 0x01,
  0x86, 0x00, 0x63, 0x00, 0x18, 0xC0, 0x06, 0x70, 0x01, 0x98, 0x00, 0x6E,
  0x00, 0x1B, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x07, 0x00, 0x3E, 0x00, 0x38, 0x01, 0xB0, 0x03,
  0xC0, 0x0D, 0x80, 0x1E, 0x00, 0xEC, 0x00, 0xF0, 0x06, 0x60, 0x0D, 0x80,
  0x73, 0x00, 0x6C, 0x03, 0x18, 0x07, 0x60, 0x38, 0xC0, 0x33, 0x01, 0xC6,
  0x01, 0x98, 0x0C, 0x30, 0x18, 0xC0, 0xE1, 0x80, 0xC6, 0x06, 0x0C, 0x0C,
  0x30, 0x70, 0x60, 0x61, 0x83, 0x03, 0x07, 0x0C, 0x18, 0x18, 0x30, 0x61,
  0xC0, 0xC1, 0x83, 0x0C, 0x06, 0x18, 0x18, 0xE0, 0x30, 0xC0, 0xC6, 0x01,
  0x8E, 0x0E, 0x30, 0x0C, 0x60, 0x73, 0x80, 0x63, 0x03, 0x98, 0x03, 0x30,
  0x1D, 0xC0, 0x19, 0x80, 0xCC, 0x00, 0xD8, 0x06, 0x60, 0x06, 0xC0, 0x36,
  0x00, 0x36, 0x01, 0xB0, 0x01, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x78, 0x00,
  0x70, 0x03, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xC0, 0x0E, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x60, 0x03, 0x01, 0xC0, 0x06, 0x03, 0x00, 0x0C,
  0x0E, 0x00, 0x18, 0x38, 0x00, 0x38, 0x60, 0x00, 0x31, 0xC0, 0x00, 0x63,
  0x00, 0x00, 0xCC, 0x00, 0x01, 0xB8, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xB0, 0x00, 0x06, 0x60, 0x00, 0x1C, 0xE0, 0x00, 0x31, 0xC0, 0x00,
  0xC1, 0x80, 0x03, 0x83, 0x00, 0x06, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x70,
  0x1C, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x0E, 0x00, 0x60, 0x38, 0x00,
  0xE0, 0x00, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0E, 0xE0, 0x1C, 0xE0, 0x18,
  0x60, 0x38, 0x60, 0x30, 0x60, 0x70, 0x60, 0x60, 0x60, 0xE0, 0x70, 0xC0,
  0x71, 0x80, 0x33, 0x80, 0x33, 0x00, 0x37, 0x00, 0x36, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xE0, 0xC1, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x60,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x0C,
  0x70, 0x0E, 0x18, 0x06, 0x0C, 0x07, 0x07, 0x03, 0x01, 0x83, 0x00, 0xC1,
  0x80, 0x31, 0x80, 0x19, 0xC0, 0x0E, 0xC0, 0x03, 0xE0, 0x01, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0xE3, 0x1C, 0x63, 0x8C, 0x20, 0x01, 0xF8, 0xC0, 0xFF,
  0x60, 0x70, 0xD8, 0x38, 0x1E, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x30,
  0xE0, 0x0C, 0x30, 0x03, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0x80, 0x18, 0x60,
  0x06, 0x18, 0x01, 0x86, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1C, 0x38, 0x07,
  0x06, 0x03, 0xC1, 0x80, 0xB0, 0x70, 0x58, 0x0F, 0xF6, 0x01, 0xF1, 0x80,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x73,
  0xF0, 0x19, 0xFE, 0x06, 0xC3, 0x81, 0xE0, 0x60, 0xF0, 0x1C, 0x38, 0x07,
  0x0E, 0x00, 0xC3, 0x00, 0x70, 0xC0, 0x1C, 0x70, 0x07, 0x18, 0x01, 0xC6,
  0x00, 0x61, 0x80, 0x18, 0xE0, 0x0E, 0x38, 0x03, 0x8C, 0x00, 0xC3, 0x00,
  0x70, 0xC0, 0x18, 0x78, 0x0E, 0x1E, 0x03, 0x06, 0xC1, 0xC1, 0xBF, 0xE0,
  0xC7, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x1C, 0x10, 0x70, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x07, 0x02, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x01, 0xF9, 0xC0, 0x3F, 0xDC, 0x07, 0x05, 0x80, 0xE0, 0x78, 0x1C, 0x03,
  0x81, 0xC0, 0x38, 0x38, 0x03, 0x03, 0x80, 0x30, 0x30, 0x03, 0x07, 0x00,
  0x30, 0x70, 0x07, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0xE0,
  0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0x60, 0x3C, 0x06,
  0x06, 0xC0, 0x70, 0xFC, 0x03, 0xFD, 0x80, 0x1F, 0x18, 0x00, 0x01, 0xF8,
  0x07, 0xF8, 0x1C, 0x38, 0x70, 0x31, 0xC0, 0x63, 0x00, 0xCE, 0x03, 0x98,
  0x06, 0x30, 0x1C, 0xE0, 0xF1, 0xBF, 0xC3, 0xFE, 0x06, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07,
  0x01, 0x07, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0x10, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x60, 0x3F, 0xCC, 0x0E,
  0x0B, 0x03, 0x81, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x87, 0x00, 0x70, 0xE0,
  0x0C, 0x18, 0x01, 0x87, 0x00, 0x30, 0xE0, 0x0E, 0x18, 0x01, 0x83, 0x00,
  0x30, 0x60, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0E, 0x0E, 0x01,
  0xC0, 0xC0, 0x78, 0x18, 0x1B, 0x03, 0x87, 0xE0, 0x3F, 0xD8, 0x03, 0xE3,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x20, 0x38, 0x07, 0xFE, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x8F,
  0xC0, 0xCF, 0xF0, 0x6C, 0x38, 0x3C, 0x0C, 0x3C, 0x06, 0x1C, 0x03, 0x0E,
  0x01, 0x86, 0x00, 0xC3, 0x00, 0xE3, 0x80, 0x61, 0x80, 0x30, 0xC0, 0x18,
  0x60, 0x1C, 0x70, 0x0E, 0x38, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x61, 0x80, 0x30, 0xC0, 0x18, 0xE0, 0x1C, 0x00,
  0x01, 0x81, 0xC0, 0xE0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x81,
  0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x80, 0x00,
  0x06, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x18, 0x0C,
  0x06, 0x07, 0x01, 0x83, 0x80, 0xE1, 0xC0, 0x30, 0xE0, 0x0C, 0x30, 0x03,
  0x18, 0x00, 0xCE, 0x00, 0x77, 0x00, 0x1B, 0xC0, 0x07, 0xF0, 0x01, 0xEE,
  0x00, 0xF3, 0x80, 0x38, 0x60, 0x0C, 0x18, 0x03, 0x07, 0x00, 0xC1, 0xC0,
  0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x81, 0x80, 0xE0, 0xE0, 0x18, 0x00,
  0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x70,
  0x1C, 0x06, 0x01, 0x80, 0xE0, 0x00, 0x06, 0x3E, 0x0F, 0x80, 0xDF, 0xE7,
  0xF8, 0x1B, 0x0D, 0xC3, 0x83, 0x81, 0xE0, 0x70, 0xF0, 0x3C, 0x06, 0x1C,
  0x07, 0x01, 0xC3, 0x80, 0xE0, 0x38, 0x60, 0x18, 0x06, 0x0C, 0x03, 0x00,
  0xC3, 0x80, 0x60, 0x18, 0x60, 0x1C, 0x03, 0x0C, 0x03, 0x00, 0xE1, 0x80,
  0x60, 0x18, 0x70, 0x0C, 0x03, 0x0E, 0x01, 0x80, 0x61, 0x80, 0x70, 0x1C,
  0x30, 0x0C, 0x03, 0x86, 0x01, 0x80, 0x61, 0xC0, 0x30, 0x0C, 0x38, 0x0E,
  0x01, 0x86, 0x01, 0xC0, 0x70, 0xC0, 0x30, 0x0E, 0x38, 0x06, 0x01, 0x80,
  0x06, 0x3F, 0x03, 0x3F, 0xC1, 0xB0, 0xE0, 0xF0, 0x30, 0xF0, 0x18, 0x70,
  0x0C, 0x38, 0x06, 0x18, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0x86, 0x00, 0xC3,
  0x00, 0x61, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x18, 0x60, 0x0C, 0x30, 0x06,
  0x18, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x80,
  0x70, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0x0E, 0x0E, 0x07, 0x1C, 0x03, 0x18,
  0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x03, 0x70, 0x03, 0x70, 0x03, 0x60,
  0x03, 0x60, 0x07, 0x60, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0x60,
  0x0C, 0x60, 0x1C, 0x60, 0x38, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0xC0, 0x01,
  0x8F, 0xC0, 0x19, 0xFE, 0x01, 0xB0, 0xE0, 0x1E, 0x07, 0x03, 0xC0, 0x70,
  0x3C, 0x07, 0x03, 0x80, 0x30, 0x38, 0x03, 0x03, 0x00, 0x70, 0x70, 0x07,
  0x07, 0x00, 0x70, 0x60, 0x06, 0x06, 0x00, 0x60, 0xE0, 0x06, 0x0E, 0x00,
  0xE0, 0xE0, 0x0C, 0x0C, 0x01, 0xC0, 0xC0, 0x18, 0x1E, 0x03, 0x81, 0xE0,
  0x30, 0x1B, 0x07, 0x01, 0xBF, 0xE0, 0x19, 0xF8, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0xC0, 0xFF, 0x30, 0x70, 0x58, 0x38, 0x1E, 0x1C, 0x03, 0x87, 0x00, 0xE3,
  0x80, 0x38, 0xE0, 0x0C, 0x30, 0x03, 0x1C, 0x00, 0xC7, 0x00, 0x71, 0x80,
  0x18, 0x60, 0x06, 0x18, 0x01, 0x86, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1C,
  0x38, 0x07, 0x06, 0x03, 0xC1, 0x81, 0xB0, 0x70, 0xFC, 0x0F, 0xF6, 0x03,
  0xF1, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x06, 0x3C, 0x1B, 0xF0, 0x6C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xF0, 0xC0, 0xC7,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x06, 0x00, 0x18, 0x80, 0xE3, 0xFF, 0x0F, 0xF8, 0x00, 0x03,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x7F, 0xDF, 0xF0, 0x60, 0x1C, 0x03,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xF8,
  0x3F, 0x00, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xE3, 0x80, 0x71, 0xC0,
  0x30, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x0E, 0x38, 0x07, 0x18, 0x03, 0x0C,
  0x01, 0x86, 0x00, 0xC3, 0x00, 0xE3, 0x80, 0x61, 0x80, 0x30, 0xC0, 0x38,
  0x60, 0x1C, 0x30, 0x0E, 0x38, 0x0E, 0x1C, 0x0F, 0x06, 0x0D, 0x83, 0xFC,
  0xC0, 0xFC, 0x60, 0xE0, 0x0F, 0xC0, 0x1B, 0x80, 0x73, 0x00, 0xC6, 0x03,
  0x8C, 0x06, 0x18, 0x0C, 0x30, 0x30, 0x60, 0x60, 0xC1, 0xC1, 0x83, 0x03,
  0x0E, 0x06, 0x18, 0x0C, 0x70, 0x18, 0xC0, 0x33, 0x80, 0x66, 0x00, 0xDC,
  0x01, 0xB0, 0x03, 0x60, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x30, 0x0F, 0x80, 0xE0, 0x1B, 0x01, 0xE0, 0x76, 0x03, 0xC0, 0xCC, 0x0D,
  0x81, 0x98, 0x1B, 0x07, 0x30, 0x66, 0x0C, 0x60, 0xCC, 0x38, 0xC3, 0x18,
  0x61, 0x86, 0x30, 0xC3, 0x0C, 0x63, 0x06, 0x30, 0xC6, 0x0C, 0x61, 0x9C,
  0x19, 0x83, 0x30, 0x33, 0x06, 0x60, 0x6E, 0x0D, 0x80, 0xD8, 0x1B, 0x01,
  0xB0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x06, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x60, 0x38, 0x0C,
  0x06, 0x01, 0xC1, 0xC0, 0x18, 0x70, 0x03, 0x0C, 0x00, 0x63, 0x00, 0x0E,
  0xE0, 0x00, 0xD8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0xEC, 0x00, 0x39, 0x80, 0x06, 0x30, 0x01, 0xC7,
  0x00, 0x70, 0x60, 0x0C, 0x0C, 0x03, 0x01, 0xC0, 0xE0, 0x18, 0x38, 0x03,
  0x00, 0x01, 0x80, 0x18, 0x0C, 0x01, 0xC0, 0x60, 0x0C, 0x03, 0x00, 0xE0,
  0x18, 0x06, 0x00, 0xC0, 0x70, 0x06, 0x03, 0x00, 0x30, 0x18, 0x01, 0x81,
  0x80, 0x0E, 0x0C, 0x00, 0x70, 0xC0, 0x03, 0x86, 0x00, 0x0C, 0x70, 0x00,
  0x63, 0x00, 0x03, 0x38, 0x00, 0x19, 0x80, 0x00, 0xDC, 0x00, 0x06, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1F, 0xFC, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0,
  0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x80,
  0x1C, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xE1, 0xF0, 0x7F, 0xD0, 0x07, 0xC0,
};

const GFXglyph NotoSans_Condensed_LightItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 31, 10, 1, -31 },
  { 36, 11, 11, 14, 4, -31 },
  { 52, 21, 31, 20, 0, -31 },
  { 134, 18, 36, 18, 0, -33 },
  { 215, 23, 31, 27, 2, -31 },
  { 305, 19, 31, 20, 0, -31 },
  { 379, 5, 11, 7, 4, -31 },
  { 386, 13, 38, 11, 1, -31 },
  { 448, 12, 38, 11, -3, -31 },
  { 505, 14, 15, 17, 5, -33 },
  { 532, 17, 20, 20, 2, -25 },
  { 575, 7, 11, 8, -2, -5 },
  { 585, 10, 2, 12, 1, -13 },
  { 588, 3, 4, 8, 1, -4 },
  { 590, 19, 31, 14, -2, -31 },
  { 664, 17, 31, 18, 1, -31 },
  { 730, 10, 31, 18, 5, -31 },
  { 769, 19, 31, 18, -1, -31 },
  { 843, 18, 31, 18, 0, -31 },
  { 913, 18, 31, 18, 0, -31 },
  { 983, 18, 31, 18, 0, -31 },
  { 1053, 17, 31, 18, 2, -31 },
  { 1119, 17, 31, 18, 2, -31 },
  { 1185, 18, 31, 18, 0, -31 },
  { 1255, 17, 31, 18, 1, -31 },
  { 1321, 8, 23, 8, 0, -23 },
  { 1344, 10, 29, 8, -2, -23 },
  { 1381, 17, 19, 20, 2, -25 },
  { 1422, 17, 11, 20, 2, -21 },
  { 1446, 17, 19, 20, 2, -25 },
  { 1487, 14, 31, 13, 1, -31 },
  { 1542, 26, 35, 27, 1, -31 },
  { 1656, 18, 31, 18, -3, -31 },
  { 1726, 19, 31, 20, 1, -31 },
  { 1800, 19, 31, 18, 2, -31 },
  { 1874, 20, 31, 22, 1, -31 },
  { 1952, 18, 31, 17, 1, -31 },
  { 2022, 18, 31, 16, 1, -31 },
  { 2092, 21, 31, 23, 2, -31 },
  { 2174, 22, 31, 23, 1, -31 },
  { 2260, 15, 31, 10, -2, -31 },
  { 2319, 16, 39, 9, -6, -31 },
  { 2397, 21, 31, 18, 1, -31 },
  { 2479, 12, 31, 16, 1, -31 },
  { 2526, 29, 31, 29, 1, -31 },
  { 2639, 23, 31, 24, 1, -31 },
  { 2729, 20, 31, 23, 2, -31 },
  { 2807, 18, 31, 19, 1, -31 },
  { 2877, 20, 38, 23, 2, -31 },
  { 2972, 18, 31, 19, 1, -31 },
  { 3042, 19, 31, 17, -1, -31 },
  { 3116, 15, 31, 16, 4, -31 },
  { 3175, 21, 31, 22, 2, -31 },
  { 3257, 18, 31, 18, 4, -31 },
  { 3327, 29, 31, 30, 4, -31 },
  { 3440, 23, 31, 17, -3, -31 },
  { 3530, 16, 31, 16, 4, -31 },
  { 3592, 20, 31, 17, -1, -31 },
  { 3670, 16, 38, 12, -1, -31 },
  { 3746, 7, 31, 14, 4, -31 },
  { 3774, 16, 38, 12, -3, -31 },
  { 3850, 17, 17, 19, 1, -31 },
  { 3887, 14, 2, 13, -4, 4 },
  { 3891, 5, 7, 10, 6, -33 },
  { 3896, 18, 23, 19, 1, -23 },
  { 3948, 18, 33, 19, 0, -33 },
  { 4023, 15, 23, 15, 1, -23 },
  { 4067, 20, 33, 19, 1, -33 },
  { 4150, 15, 23, 17, 1, -23 },
  { 4194, 20, 43, 10, -5, -33 },
  { 4302, 19, 33, 19, 0, -23 },
  { 4381, 17, 33, 19, 0, -33 },
  { 4452, 9, 31, 8, 0, -31 },
  { 4487, 16, 41, 8, -6, -31 },
  { 4569, 18, 33, 16, 0, -33 },
  { 4644, 10, 33, 8, 0, -33 },
  { 4686, 27, 23, 29, 0, -23 },
  { 4764, 17, 23, 19, 0, -23 },
  { 4813, 16, 23, 19, 1, -23 },
  { 4859, 20, 33, 19, -2, -23 },
  { 4942, 18, 33, 19, 1, -23 },
  { 5017, 14, 23, 13, 0, -23 },
  { 5058, 14, 23, 14, 0, -23 },
  { 5099, 11, 28, 10, 1, -28 },
  { 5138, 17, 23, 19, 1, -23 },
  { 5187, 15, 23, 15, 2, -23 },
  { 5231, 23, 23, 24, 3, -23 },
  { 5298, 19, 23, 15, -2, -23 },
  { 5353, 21, 33, 15, -4, -23 },
  { 5440, 15, 23, 13, -1, -23 },
  { 5484, 16, 38, 14, 1, -31 },
  { 5560, 2, 43, 18, 8, -33 },
  { 5571, 15, 38, 14, -2, -31 },
  { 5643, 17, 4, 20, 2, -17 },
};

const GFXfont NotoSans_Condensed_LightItalic43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC43PT7B_H_
