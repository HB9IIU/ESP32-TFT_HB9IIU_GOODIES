#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC47PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic47pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x03, 0xC0, 0xE0, 0x38, 0x00, 0x38, 0xE6, 0x1D, 0xC3,
  0xB8, 0x67, 0x0C, 0xC3, 0x98, 0x73, 0x0C, 0xE1, 0x98, 0x33, 0x06, 0x61,
  0x8C, 0x30, 0x00, 0x18, 0x30, 0x00, 0xE0, 0xC0, 0x03, 0x03, 0x00, 0x0C,
  0x1C, 0x00, 0x70, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x30,
  0x00, 0xC0, 0xC0, 0x03, 0x03, 0x01, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x01,
  0x81, 0x80, 0x06, 0x0E, 0x00, 0x38, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x07,
  0x00, 0x0C, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80, 0x06, 0x0C, 0x03,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x03, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x60,
  0x60, 0x01, 0x83, 0x80, 0x0E, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC1, 0xC0,
  0x03, 0x06, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x83, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1F,
  0x80, 0x0F, 0xFE, 0x01, 0xFD, 0xF0, 0x38, 0xC2, 0x07, 0x0C, 0x00, 0x60,
  0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x06, 0x18, 0x00, 0x61, 0x80, 0x07,
  0x10, 0x00, 0x73, 0x00, 0x03, 0xB0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x06, 0xE0, 0x00, 0x67, 0x00, 0x04, 0x30,
  0x00, 0xC3, 0x80, 0x0C, 0x38, 0x00, 0xC3, 0x80, 0x0C, 0x30, 0x00, 0x83,
  0x00, 0x18, 0x70, 0x41, 0x8E, 0x0F, 0x9F, 0xC0, 0xFF, 0xF8, 0x00, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x20, 0x00, 0x06,
  0x00, 0x00, 0x07, 0xC0, 0x06, 0x07, 0xF0, 0x06, 0x07, 0x18, 0x03, 0x03,
  0x0C, 0x03, 0x03, 0x06, 0x03, 0x81, 0x83, 0x01, 0x81, 0x81, 0x81, 0xC0,
  0xC0, 0xC0, 0xC0, 0x60, 0x60, 0xC0, 0x70, 0x30, 0xE0, 0x30, 0x18, 0x60,
  0x18, 0x0C, 0x70, 0x0C, 0x0C, 0x30, 0x06, 0x06, 0x30, 0x43, 0x03, 0x18,
  0xF9, 0x83, 0x98, 0xEE, 0xC1, 0x9C, 0xE3, 0x61, 0xCC, 0x61, 0xF9, 0xCE,
  0x60, 0x6F, 0xC6, 0x30, 0x73, 0xC6, 0x30, 0x38, 0x03, 0x18, 0x18, 0x03,
  0x0C, 0x0C, 0x03, 0x8E, 0x06, 0x01, 0x86, 0x03, 0x01, 0xC3, 0x01, 0x80,
  0xC1, 0x81, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x30, 0x60,
  0x70, 0x18, 0x30, 0x30, 0x0C, 0x30, 0x38, 0x03, 0xF8, 0x38, 0x01, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x3C, 0xF0,
  0x01, 0x83, 0x80, 0x1C, 0x0C, 0x00, 0xC0, 0x60, 0x06, 0x07, 0x00, 0x30,
  0x38, 0x01, 0x81, 0x80, 0x0C, 0x1C, 0x00, 0x60, 0xE0, 0x03, 0x0E, 0x00,
  0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0x60, 0x71, 0xC3, 0x83, 0x1C,
  0x0C, 0x39, 0xC0, 0x71, 0x8E, 0x03, 0x8C, 0x60, 0x0E, 0xE7, 0x00, 0x7E,
  0x38, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x07, 0xC1, 0xC0,
  0x7E, 0x0E, 0x07, 0x38, 0x3F, 0xF1, 0xC0, 0xFE, 0x07, 0x00, 0x39, 0x8C,
  0xE7, 0x31, 0x8C, 0xE6, 0x31, 0x8C, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x80, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x04, 0x18, 0x1E,
  0x30, 0x1F, 0x60, 0x87, 0xFF, 0x03, 0xFE, 0x0F, 0x00, 0x3B, 0x00, 0xE6,
  0x03, 0x8E, 0x0E, 0x0C, 0x08, 0x1C, 0x00, 0x18, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x1C,
  0x30, 0xE1, 0x87, 0x0E, 0x18, 0x60, 0xC3, 0x00, 0xFF, 0xFF, 0xF8, 0x6F,
  0xEE, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x1C, 0xF0, 0x0E, 0x0E, 0x07,
  0x03, 0x83, 0x80, 0x60, 0xE0, 0x18, 0x70, 0x06, 0x1C, 0x01, 0xC6, 0x00,
  0x63, 0x80, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x9C, 0x00, 0x67, 0x00, 0x39,
  0x80, 0x0E, 0x60, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x33, 0x80, 0x1C, 0xC0,
  0x07, 0x30, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x38, 0xC0, 0x0E, 0x30, 0x03,
  0x0C, 0x01, 0xC3, 0x00, 0x60, 0xC0, 0x38, 0x30, 0x0C, 0x0E, 0x07, 0x01,
  0xC3, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0xC0, 0x70, 0x7C, 0x3F,
  0x1D, 0xCE, 0x6F, 0x1B, 0x0E, 0x43, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0,
  0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70,
  0x18, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x01, 0xF1, 0xE0, 0x18, 0x07,
  0x01, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x07, 0xE3, 0xC0, 0x30,
  0x0E, 0x02, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x80, 0x1C, 0x0C, 0x07, 0xC0, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x36, 0x00, 0x07, 0xE0, 0x00, 0x6C, 0x00, 0x0C, 0xC0, 0x01, 0xCC,
  0x00, 0x19, 0xC0, 0x03, 0x1C, 0x00, 0x71, 0x80, 0x06, 0x18, 0x00, 0xC3,
  0x80, 0x1C, 0x38, 0x01, 0x83, 0x80, 0x30, 0x30, 0x07, 0x03, 0x00, 0xE0,
  0x70, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x06, 0x03, 0x00, 0x60, 0x60,
  0x0E, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01, 0xFF,
  0xE0, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x08, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x80, 0x1C, 0x0C, 0x07,
  0xC0, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F,
  0x84, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x3C, 0x07, 0x3F, 0xC1, 0xDC, 0xF8, 0x6C, 0x0E, 0x1E, 0x01, 0xCF, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCC, 0x00, 0x73, 0x00, 0x1C,
  0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x38, 0xC0, 0x1C, 0x38,
  0x07, 0x0E, 0x03, 0x81, 0xC1, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xFC, 0x01, 0xE1, 0xE0, 0x3C, 0x0E, 0x03, 0x80, 0x70, 0x30, 0x07, 0x07,
  0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x60,
  0x30, 0x0E, 0x03, 0x81, 0xC0, 0x18, 0x38, 0x01, 0xCF, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0x9E, 0x00, 0xE0, 0xE0, 0x1C, 0x07,
  0x03, 0x80, 0x30, 0x70, 0x03, 0x86, 0x00, 0x38, 0x60, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x86, 0x00, 0x70, 0x70,
  0x07, 0x03, 0x81, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x7F, 0xC0, 0x3C, 0x78, 0x1C, 0x0E, 0x06, 0x01, 0xC3, 0x80, 0x70, 0xC0,
  0x0C, 0x70, 0x03, 0x18, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x0C, 0xE0, 0x03,
  0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F, 0x38, 0x07, 0x87,
  0x01, 0xE1, 0xE1, 0xD8, 0x3F, 0xEE, 0x07, 0xE3, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x0E, 0x02, 0x07, 0x80, 0xFF, 0x80, 0x3F,
  0xC0, 0x00, 0x03, 0x03, 0xC1, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x81, 0xC1, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x30, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0xE1,
  0xE7, 0x84, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x18, 0x03, 0x00, 0x01, 0x80, 0xC0, 0x00, 0x30, 0x30, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x61, 0x80, 0x00, 0x0C, 0x60, 0x1F, 0xC1, 0x8C, 0x07, 0xF8,
  0x33, 0x01, 0x83, 0x06, 0x60, 0x60, 0xE0, 0xDC, 0x1C, 0x18, 0x1B, 0x03,
  0x03, 0x03, 0x60, 0xC0, 0x60, 0xEC, 0x18, 0x1C, 0x1B, 0x87, 0x03, 0x03,
  0x60, 0xC0, 0x60, 0x6C, 0x18, 0x1C, 0x1D, 0x83, 0x03, 0x83, 0x30, 0x60,
  0x60, 0x66, 0x0C, 0x1C, 0x18, 0xC1, 0x83, 0x83, 0x18, 0x30, 0xF0, 0xC3,
  0x07, 0x33, 0x38, 0x60, 0x7C, 0x7E, 0x0C, 0x07, 0x07, 0x01, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x6E, 0x00, 0x06, 0xE0, 0x00,
  0xE6, 0x00, 0x0C, 0x60, 0x01, 0xC6, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00,
  0x30, 0x60, 0x07, 0x06, 0x00, 0x70, 0x60, 0x06, 0x06, 0x00, 0xE0, 0x60,
  0x0C, 0x06, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0xFF, 0xE0, 0x3F, 0xFE,
  0x07, 0x00, 0x60, 0x70, 0x06, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00,
  0x71, 0xC0, 0x07, 0x18, 0x00, 0x73, 0x80, 0x07, 0x30, 0x00, 0x77, 0x00,
  0x07, 0x70, 0x00, 0x7E, 0x00, 0x07, 0x01, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0x80, 0x1C, 0x0C, 0x00,
  0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x30, 0x01, 0x81, 0x80, 0x1C, 0x1C,
  0x00, 0xE0, 0xE0, 0x0E, 0x07, 0x00, 0xF0, 0x30, 0x0F, 0x01, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0x01, 0xE0, 0x30, 0x07, 0x01, 0x80,
  0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x30, 0x01, 0xC3,
  0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x06, 0x00, 0x38, 0x30, 0x03,
  0x83, 0x80, 0x3C, 0x1C, 0x0F, 0xC0, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0x1E, 0x03, 0xC0, 0x10, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x80,
  0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0xE0, 0x7C, 0x03, 0x80, 0x70, 0x0C, 0x00, 0xE0, 0x30,
  0x03, 0x81, 0xC0, 0x06, 0x07, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x60, 0x01,
  0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xC0, 0x01, 0xC3,
  0x00, 0x07, 0x1C, 0x00, 0x18, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x86, 0x00,
  0x0E, 0x18, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0C, 0x00, 0x18,
  0x30, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0xE0, 0x60,
  0x07, 0x81, 0x80, 0x3C, 0x0E, 0x03, 0xE0, 0x38, 0x7E, 0x00, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xE0,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xF0, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF,
  0xE0, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x7E, 0x3F, 0x01, 0xF0, 0x06, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x07, 0xF8,
  0x60, 0x07, 0xF8, 0xE0, 0x08, 0x30, 0xE0, 0x00, 0x30, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x60, 0xE0, 0x00, 0x60,
  0x60, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x78, 0x00, 0xC0,
  0x38, 0x00, 0xC0, 0x1E, 0x01, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x01, 0x80, 0x03, 0x01, 0x80, 0x03, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07,
  0x03, 0x80, 0x07, 0x03, 0x00, 0x06, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x0E, 0x00, 0x1C,
  0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0C, 0x00, 0x18, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x30,
  0x18, 0x00, 0x30, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x30, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0,
  0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0,
  0xE0, 0x01, 0xC0, 0xC0, 0x01, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x08, 0x00, 0x00, 0x01, 0x80,
  0x0E, 0x03, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x1C, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x00,
  0x0C, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0x80, 0x01,
  0xCE, 0x00, 0x03, 0x38, 0x00, 0x06, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x3E,
  0xC0, 0x00, 0x79, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0x83, 0x00, 0x07, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x18, 0x1C, 0x00, 0x30, 0x18, 0x00, 0xE0, 0x38,
  0x01, 0xC0, 0x70, 0x03, 0x80, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0x70, 0x03, 0x00, 0xE0, 0x07, 0x01, 0x80, 0x0E, 0x00,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0,
  0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xD8, 0x00, 0x1B, 0x03,
  0xB0, 0x00, 0x7E, 0x07, 0x60, 0x00, 0xDC, 0x0C, 0xC0, 0x03, 0xB8, 0x19,
  0x80, 0x06, 0x60, 0x73, 0x00, 0x1C, 0xC0, 0xE6, 0x00, 0x33, 0x81, 0xCC,
  0x00, 0xE7, 0x03, 0x18, 0x01, 0x8E, 0x06, 0x38, 0x07, 0x18, 0x1C, 0x70,
  0x0C, 0x30, 0x38, 0xE0, 0x38, 0xE0, 0x61, 0xC0, 0x61, 0xC0, 0xC1, 0x81,
  0xC3, 0x01, 0x83, 0x03, 0x06, 0x07, 0x06, 0x0E, 0x1C, 0x0E, 0x0C, 0x18,
  0x38, 0x18, 0x18, 0x70, 0x70, 0x30, 0x30, 0xC0, 0xC0, 0xE0, 0x63, 0x81,
  0x81, 0xC0, 0xC6, 0x07, 0x03, 0x81, 0x9C, 0x0E, 0x06, 0x03, 0xB0, 0x1C,
  0x0C, 0x07, 0xE0, 0x30, 0x38, 0x0F, 0x80, 0x60, 0x70, 0x1F, 0x01, 0xC0,
  0xC0, 0x1C, 0x03, 0x81, 0x80, 0x38, 0x06, 0x00, 0x01, 0xC0, 0x01, 0x80,
  0xE0, 0x00, 0xC0, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x3E, 0x00, 0x38,
  0x1F, 0x00, 0x18, 0x1D, 0x80, 0x0C, 0x0E, 0xC0, 0x0E, 0x07, 0x70, 0x07,
  0x03, 0x38, 0x03, 0x01, 0x8C, 0x01, 0x81, 0xC6, 0x01, 0xC0, 0xE3, 0x80,
  0xE0, 0x61, 0xC0, 0x70, 0x30, 0x60, 0x30, 0x18, 0x30, 0x18, 0x1C, 0x1C,
  0x1C, 0x0E, 0x0E, 0x0E, 0x06, 0x03, 0x07, 0x03, 0x01, 0x83, 0x01, 0x80,
  0xE1, 0x81, 0xC0, 0x71, 0xC0, 0xE0, 0x18, 0xE0, 0x60, 0x0C, 0x60, 0x30,
  0x07, 0x30, 0x38, 0x03, 0x98, 0x1C, 0x00, 0xDC, 0x0E, 0x00, 0x6E, 0x06,
  0x00, 0x3E, 0x03, 0x00, 0x1F, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x03, 0xC0,
  0xC0, 0x01, 0xE0, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xC0, 0x03, 0xE3, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0xE0, 0x03,
  0x81, 0xC0, 0x07, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x0C, 0x38, 0x00, 0x1C,
  0x60, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xC6, 0x00, 0x01, 0x9C,
  0x00, 0x03, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0x80,
  0x00, 0x77, 0x00, 0x00, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00,
  0x0E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0xC3, 0x80, 0x03,
  0x83, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x70, 0x1E, 0x01, 0xC0,
  0x1E, 0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x38, 0x1E, 0x03, 0x80, 0xE0, 0x30, 0x07,
  0x03, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x60, 0x07, 0x06, 0x00,
  0x70, 0xE0, 0x07, 0x0E, 0x00, 0x60, 0xE0, 0x0E, 0x0C, 0x00, 0xC0, 0xC0,
  0x1C, 0x1C, 0x03, 0x81, 0xC0, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xE3, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x01,
  0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x00, 0x06, 0x0C, 0x00, 0x0C,
  0x38, 0x00, 0x1C, 0x60, 0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xC6,
  0x00, 0x01, 0x9C, 0x00, 0x03, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xE0,
  0x00, 0x39, 0x80, 0x00, 0x77, 0x00, 0x00, 0xCE, 0x00, 0x03, 0x9C, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0x71, 0xC0, 0x00,
  0xC3, 0x80, 0x03, 0x83, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x70,
  0x0E, 0x01, 0xC0, 0x1E, 0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x38, 0x1E, 0x03, 0x80, 0xE0,
  0x30, 0x07, 0x03, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x70, 0x60, 0x07,
  0x06, 0x00, 0x70, 0xE0, 0x06, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0C, 0x01,
  0xC0, 0xC0, 0x3C, 0x1C, 0x07, 0x81, 0xFF, 0xF0, 0x1F, 0xFC, 0x01, 0x83,
  0x00, 0x18, 0x38, 0x03, 0x83, 0x80, 0x38, 0x38, 0x03, 0x81, 0x80, 0x30,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x60, 0x0E, 0x06,
  0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0x60, 0xE0, 0x07, 0x0C, 0x00, 0x70,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x3F, 0x7E, 0x03, 0x80, 0x20, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x82, 0x00, 0x38, 0x1C, 0x07, 0xC0,
  0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x06, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x70, 0x60, 0x00, 0xC1, 0xC0, 0x01,
  0x83, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0C, 0x00, 0x18, 0x18, 0x00, 0x30,
  0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x06, 0x06,
  0x00, 0x0C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x60, 0x00, 0xE0, 0xC0,
  0x01, 0x83, 0x80, 0x03, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x18, 0x00,
  0x30, 0x30, 0x00, 0x60, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x06,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x1C, 0x03, 0xC0,
  0x3C, 0x0F, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xE0, 0x00, 0x7E,
  0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xCE, 0x00, 0x18,
  0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x07, 0x06, 0x00, 0x70, 0x60, 0x0E,
  0x06, 0x00, 0xE0, 0x60, 0x0C, 0x06, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03,
  0x80, 0x60, 0x30, 0x06, 0x07, 0x00, 0x60, 0x60, 0x06, 0x0E, 0x00, 0x60,
  0xE0, 0x06, 0x1C, 0x00, 0x61, 0xC0, 0x06, 0x18, 0x00, 0x63, 0x80, 0x06,
  0x30, 0x00, 0x77, 0x00, 0x07, 0x60, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x6C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0xE0, 0x01, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x0E, 0xE0, 0x03,
  0x80, 0x0E, 0xE0, 0x07, 0x80, 0x0C, 0xE0, 0x07, 0x80, 0x1C, 0xE0, 0x0F,
  0x80, 0x18, 0xE0, 0x0D, 0x80, 0x38, 0xE0, 0x0D, 0x80, 0x38, 0xE0, 0x1D,
  0x80, 0x30, 0xE0, 0x19, 0x80, 0x70, 0xE0, 0x39, 0x80, 0x60, 0xE0, 0x31,
  0x80, 0xE0, 0xE0, 0x31, 0x80, 0xE0, 0xE0, 0x71, 0x81, 0xC0, 0xE0, 0x61,
  0x81, 0xC0, 0xE0, 0xE1, 0x81, 0x80, 0xE0, 0xC1, 0x83, 0x80, 0xE1, 0xC1,
  0x83, 0x00, 0xE1, 0x81, 0x87, 0x00, 0xE1, 0x81, 0x87, 0x00, 0xE3, 0x81,
  0x86, 0x00, 0xE3, 0x01, 0x8E, 0x00, 0xE7, 0x01, 0x8C, 0x00, 0xE6, 0x01,
  0x9C, 0x00, 0xE6, 0x01, 0x9C, 0x00, 0xEE, 0x01, 0x98, 0x00, 0xEC, 0x01,
  0xB8, 0x00, 0xFC, 0x01, 0xB0, 0x00, 0xF8, 0x01, 0xB0, 0x00, 0xF8, 0x01,
  0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x0E, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x00, 0xC0, 0xE0,
  0x00, 0x60, 0x60, 0x00, 0x30, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x30,
  0x00, 0x03, 0x38, 0x00, 0x01, 0xB8, 0x00, 0x00, 0xDC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x06, 0xC0, 0x00, 0x07, 0x60, 0x00, 0x07, 0x30, 0x00, 0x03,
  0x1C, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x83, 0x00, 0x01, 0x81, 0x80, 0x01,
  0xC0, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x70, 0x01, 0xC0, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x39, 0x80, 0x1C, 0x60, 0x06,
  0x18, 0x03, 0x87, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0x38, 0x1C, 0x0E, 0x03,
  0x07, 0x00, 0xC1, 0x80, 0x30, 0xE0, 0x0E, 0x30, 0x03, 0x9C, 0x00, 0xEE,
  0x00, 0x1B, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF8, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0xC1, 0x83, 0x07, 0x0E, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0xC3, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x70, 0xE0, 0xC1, 0x83,
  0x06, 0x0C, 0x1C, 0x38, 0x30, 0x60, 0xC1, 0x83, 0x07, 0x0E, 0x0C, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0x98, 0x00, 0x63, 0x80, 0x0C, 0x30, 0x03, 0x06,
  0x00, 0xE0, 0xE0, 0x18, 0x0C, 0x07, 0x01, 0xC0, 0xC0, 0x38, 0x38, 0x03,
  0x06, 0x00, 0x71, 0x80, 0x06, 0x70, 0x00, 0xCC, 0x00, 0x1F, 0x80, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xE3, 0x87, 0x1C, 0x30, 0x61, 0x83, 0x01,
  0xF8, 0xC1, 0xFF, 0x30, 0xF0, 0x6C, 0x38, 0x1F, 0x1C, 0x03, 0xCE, 0x00,
  0xE3, 0x80, 0x38, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00, 0xC6, 0x00, 0x33,
  0x80, 0x0C, 0xE0, 0x07, 0x38, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x18, 0xC0,
  0x0E, 0x30, 0x03, 0x8C, 0x01, 0xE3, 0x00, 0x70, 0xC0, 0x3C, 0x38, 0x1B,
  0x0F, 0x0C, 0xC1, 0xFE, 0x70, 0x3F, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x1F,
  0x80, 0xE7, 0xF8, 0x1D, 0x87, 0x83, 0x60, 0x70, 0x78, 0x06, 0x0E, 0x00,
  0xC3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x61, 0xC0, 0x0C, 0x30, 0x01,
  0x8E, 0x00, 0x31, 0xC0, 0x0E, 0x30, 0x01, 0xC6, 0x00, 0x38, 0xC0, 0x06,
  0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x70,
  0xF8, 0x1C, 0x1B, 0x07, 0x83, 0x3F, 0xE0, 0x63, 0xF0, 0x00, 0x01, 0xFE,
  0x07, 0xFC, 0x1C, 0x08, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x1C, 0x08, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x03, 0xF1, 0x80, 0x7F, 0xCC, 0x07, 0x83, 0x60, 0x38, 0x0F,
  0x03, 0x80, 0x78, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0C, 0x00, 0xE0, 0xE0,
  0x07, 0x07, 0x00, 0x38, 0x30, 0x01, 0x83, 0x80, 0x0C, 0x1C, 0x00, 0xE0,
  0xE0, 0x07, 0x06, 0x00, 0x38, 0x30, 0x03, 0x81, 0x80, 0x1C, 0x0C, 0x00,
  0xE0, 0x60, 0x0F, 0x03, 0x00, 0x78, 0x18, 0x07, 0x80, 0xE0, 0x6C, 0x07,
  0x86, 0x60, 0x1F, 0xF7, 0x00, 0x7E, 0x30, 0x00, 0x01, 0xFC, 0x03, 0xFE,
  0x07, 0x0E, 0x0E, 0x07, 0x1C, 0x07, 0x38, 0x07, 0x38, 0x06, 0x70, 0x0E,
  0x70, 0x0E, 0x60, 0x1C, 0xE0, 0x78, 0xFF, 0xF0, 0xFF, 0x80, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x10, 0x7F, 0xF0, 0x1F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x10, 0x00, 0x1C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x38, 0x07, 0xF9, 0x80, 0xF0, 0x6C, 0x07, 0x01,
  0x60, 0x70, 0x0F, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0x80, 0x1C, 0x1C,
  0x00, 0xE0, 0xE0, 0x07, 0x06, 0x00, 0x30, 0x70, 0x01, 0x83, 0x80, 0x1C,
  0x1C, 0x00, 0xE0, 0xC0, 0x07, 0x06, 0x00, 0x70, 0x30, 0x03, 0x81, 0x80,
  0x1C, 0x0C, 0x01, 0xE0, 0x60, 0x0F, 0x03, 0x00, 0xF0, 0x1C, 0x0D, 0x80,
  0xF0, 0xFC, 0x03, 0xFE, 0xE0, 0x0F, 0xC6, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x00, 0x80, 0x38, 0x06, 0x07, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0xFC, 0x0E, 0xFF, 0x83, 0xF0, 0xF0, 0xD8, 0x1C, 0x3C,
  0x07, 0x0E, 0x01, 0xC7, 0x80, 0x71, 0xC0, 0x18, 0x70, 0x06, 0x18, 0x01,
  0x86, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xC3,
  0x00, 0x71, 0xC0, 0x1C, 0x70, 0x06, 0x18, 0x01, 0x86, 0x00, 0xE3, 0x80,
  0x38, 0xE0, 0x0E, 0x38, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x70, 0x01, 0x81,
  0xC0, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x01, 0x81, 0xC0,
  0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60,
  0x00, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x07, 0x0E, 0x03,
  0x83, 0x81, 0xC0, 0xE0, 0xE0, 0x30, 0x30, 0x0C, 0x1C, 0x07, 0x0E, 0x01,
  0xC7, 0x00, 0x73, 0x80, 0x19, 0xC0, 0x06, 0x70, 0x03, 0xBC, 0x00, 0xFB,
  0x00, 0x3C, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x01, 0xC1, 0x80, 0x70, 0x70,
  0x18, 0x1C, 0x06, 0x07, 0x03, 0x80, 0xC0, 0xE0, 0x38, 0x38, 0x0E, 0x0C,
  0x01, 0x83, 0x00, 0x70, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x30,
  0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0x06, 0x7F, 0x0F, 0xE0, 0xEF, 0xF9, 0xFF, 0x0D, 0xC3, 0xB8, 0x70,
  0xD0, 0x1E, 0x03, 0x0F, 0x01, 0xE0, 0x30, 0xE0, 0x1C, 0x03, 0x1C, 0x01,
  0x80, 0x31, 0xC0, 0x38, 0x03, 0x1C, 0x03, 0x80, 0x71, 0x80, 0x38, 0x07,
  0x18, 0x03, 0x00, 0x63, 0x80, 0x30, 0x06, 0x38, 0x07, 0x00, 0xE3, 0x00,
  0x70, 0x0E, 0x30, 0x06, 0x00, 0xE3, 0x00, 0x60, 0x0C, 0x70, 0x06, 0x00,
  0xC7, 0x00, 0xE0, 0x1C, 0x60, 0x0E, 0x01, 0xC6, 0x00, 0xC0, 0x1C, 0xE0,
  0x0C, 0x01, 0x8E, 0x01, 0xC0, 0x18, 0xE0, 0x1C, 0x03, 0x8C, 0x01, 0xC0,
  0x38, 0xC0, 0x18, 0x03, 0x00, 0x03, 0x1F, 0x80, 0xEF, 0xF8, 0x1B, 0x87,
  0x83, 0x60, 0x70, 0x78, 0x0E, 0x0E, 0x01, 0xC3, 0xC0, 0x38, 0x70, 0x07,
  0x0E, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x18,
  0x30, 0x03, 0x06, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x87, 0x00, 0x60,
  0xC0, 0x0C, 0x18, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0x83,
  0x00, 0x30, 0xE0, 0x0E, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xC1, 0xC1,
  0xC0, 0x61, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03,
  0xB0, 0x01, 0xD8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1B, 0x00,
  0x1D, 0x80, 0x0E, 0xC0, 0x06, 0x60, 0x07, 0x30, 0x03, 0x98, 0x03, 0x8E,
  0x01, 0xC7, 0x01, 0xC1, 0xC1, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x00,
  0xC7, 0xE0, 0x07, 0x3F, 0xC0, 0x1D, 0x83, 0x80, 0x6C, 0x0E, 0x01, 0xE0,
  0x18, 0x07, 0x00, 0x60, 0x3C, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x18,
  0x0E, 0x00, 0x60, 0x30, 0x01, 0x81, 0xC0, 0x06, 0x07, 0x00, 0x38, 0x1C,
  0x00, 0xE0, 0x60, 0x03, 0x81, 0x80, 0x0C, 0x0E, 0x00, 0x70, 0x38, 0x01,
  0xC0, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x1E, 0x01, 0xC0, 0x7C, 0x0E, 0x01,
  0xF0, 0x78, 0x06, 0x7F, 0xC0, 0x18, 0xFC, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xF8, 0xE0, 0xFF, 0x98, 0x3C, 0x1B, 0x07, 0x01, 0x61,
  0xC0, 0x3C, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0x80, 0x1C, 0x70, 0x03, 0x8E,
  0x00, 0x71, 0x80, 0x0C, 0x70, 0x01, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x30,
  0x01, 0xC6, 0x00, 0x30, 0xC0, 0x0E, 0x18, 0x01, 0xC3, 0x00, 0x78, 0x60,
  0x0E, 0x0C, 0x03, 0xC1, 0xC0, 0xD8, 0x3C, 0x37, 0x03, 0xFE, 0xE0, 0x3F,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x06, 0x3E, 0x1D, 0xF8, 0x37, 0x00, 0x6C, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0x0E, 0x06, 0x1C, 0x00, 0x1C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x80,
  0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x60, 0x3F, 0xF3, 0xFE, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x07, 0xE0, 0x7E, 0x00, 0x0C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x18, 0x60,
  0x06, 0x18, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0C, 0x30, 0x03,
  0x0C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x06, 0x18, 0x01, 0x86,
  0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0C, 0x30, 0x07, 0x0C, 0x01, 0xC3, 0x00,
  0xF0, 0xC0, 0x3C, 0x30, 0x1E, 0x0E, 0x0D, 0x83, 0xFE, 0x60, 0x7F, 0x18,
  0x00, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0,
  0x38, 0xC0, 0x30, 0xC0, 0x70, 0xC0, 0x70, 0xC0, 0xE0, 0xC0, 0xE0, 0xE1,
  0xC0, 0xE1, 0xC0, 0xE1, 0x80, 0xE3, 0x80, 0xE3, 0x00, 0xE7, 0x00, 0xE6,
  0x00, 0xEE, 0x00, 0x6C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xC0, 0x1C, 0x03, 0xE0, 0x0E, 0x01, 0xF0, 0x0F, 0x00,
  0xD8, 0x07, 0x80, 0xEC, 0x06, 0xC0, 0x66, 0x03, 0x60, 0x73, 0x03, 0xB0,
  0x39, 0x81, 0x98, 0x18, 0xC0, 0xCC, 0x1C, 0x60, 0xC6, 0x0C, 0x30, 0x63,
  0x0E, 0x18, 0x71, 0x86, 0x0C, 0x30, 0xC3, 0x06, 0x38, 0x63, 0x83, 0x18,
  0x31, 0x81, 0x8C, 0x19, 0xC0, 0xCC, 0x0C, 0xC0, 0x66, 0x06, 0x60, 0x37,
  0x03, 0x60, 0x1B, 0x01, 0xB0, 0x0D, 0x80, 0xF8, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x03, 0x00,
  0x70, 0x38, 0x06, 0x03, 0x80, 0xE0, 0x18, 0x1C, 0x01, 0x81, 0x80, 0x1C,
  0x38, 0x01, 0xC7, 0x00, 0x0C, 0x60, 0x00, 0xCE, 0x00, 0x0F, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1B, 0x80, 0x03, 0x98, 0x00, 0x71, 0x80, 0x06, 0x1C, 0x00, 0xE1, 0xC0,
  0x1C, 0x0C, 0x03, 0x80, 0xC0, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0xE0, 0x06,
  0x00, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x18, 0x00, 0xE0, 0x38, 0x00, 0x60,
  0x30, 0x00, 0x60, 0x70, 0x00, 0x60, 0x70, 0x00, 0x60, 0xE0, 0x00, 0x60,
  0xE0, 0x00, 0x60, 0xC0, 0x00, 0x61, 0xC0, 0x00, 0x61, 0x80, 0x00, 0x63,
  0x80, 0x00, 0x63, 0x00, 0x00, 0x67, 0x00, 0x00, 0x66, 0x00, 0x00, 0x6E,
  0x00, 0x00, 0x6C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0x80, 0x07, 0xC0,
  0x0F, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x03,
  0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x40, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x01, 0xFC, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x5F, 0xF0, 0x1E, 0x1F, 0x9F, 0x01, 0xFF,
  0x80, 0x1F, 0x00,
};

const GFXglyph NotoSans_Condensed_LightItalic47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 10, 34, 11, 1, -34 },
  { 44, 11, 13, 15, 5, -34 },
  { 62, 22, 34, 22, 1, -34 },
  { 156, 20, 39, 20, 0, -36 },
  { 254, 25, 35, 30, 3, -34 },
  { 364, 21, 34, 22, 0, -34 },
  { 454, 5, 13, 8, 5, -34 },
  { 463, 14, 41, 12, 1, -34 },
  { 535, 13, 41, 12, -3, -34 },
  { 602, 15, 16, 19, 5, -36 },
  { 632, 18, 22, 22, 2, -28 },
  { 682, 7, 11, 9, -2, -5 },
  { 692, 11, 2, 13, 1, -14 },
  { 695, 4, 4, 9, 1, -4 },
  { 697, 20, 34, 15, -2, -34 },
  { 782, 18, 34, 20, 2, -34 },
  { 859, 10, 34, 20, 6, -34 },
  { 902, 20, 34, 20, -1, -34 },
  { 987, 20, 34, 20, 0, -34 },
  { 1072, 20, 34, 20, 0, -34 },
  { 1157, 20, 34, 20, 0, -34 },
  { 1242, 18, 34, 20, 2, -34 },
  { 1319, 19, 34, 20, 2, -34 },
  { 1400, 20, 34, 20, 0, -34 },
  { 1485, 18, 34, 20, 1, -34 },
  { 1562, 9, 25, 9, 0, -25 },
  { 1591, 11, 31, 9, -2, -25 },
  { 1634, 18, 21, 22, 2, -27 },
  { 1682, 18, 13, 22, 2, -23 },
  { 1712, 18, 21, 22, 2, -27 },
  { 1760, 14, 34, 15, 2, -34 },
  { 1820, 27, 38, 30, 2, -34 },
  { 1949, 20, 34, 20, -3, -34 },
  { 2034, 21, 34, 22, 1, -34 },
  { 2124, 21, 34, 20, 2, -34 },
  { 2214, 22, 34, 24, 1, -34 },
  { 2308, 20, 34, 19, 1, -34 },
  { 2393, 20, 34, 18, 1, -34 },
  { 2478, 24, 34, 25, 2, -34 },
  { 2580, 24, 34, 25, 1, -34 },
  { 2682, 16, 34, 11, -2, -34 },
  { 2750, 17, 43, 9, -7, -34 },
  { 2842, 23, 34, 20, 1, -34 },
  { 2940, 13, 34, 17, 1, -34 },
  { 2996, 31, 34, 32, 1, -34 },
  { 3128, 25, 34, 26, 1, -34 },
  { 3235, 23, 34, 26, 2, -34 },
  { 3333, 20, 34, 20, 1, -34 },
  { 3418, 23, 42, 26, 2, -34 },
  { 3539, 20, 34, 21, 1, -34 },
  { 3624, 21, 34, 19, -1, -34 },
  { 3714, 17, 34, 17, 4, -34 },
  { 3787, 23, 34, 24, 2, -34 },
  { 3885, 20, 34, 20, 4, -34 },
  { 3970, 32, 34, 32, 4, -34 },
  { 4106, 25, 34, 18, -3, -34 },
  { 4213, 18, 34, 18, 4, -34 },
  { 4290, 23, 34, 18, -2, -34 },
  { 4388, 18, 41, 13, -1, -34 },
  { 4481, 7, 34, 16, 5, -34 },
  { 4511, 17, 41, 13, -3, -34 },
  { 4599, 19, 19, 21, 1, -34 },
  { 4645, 15, 2, 15, -4, 4 },
  { 4649, 6, 8, 11, 7, -36 },
  { 4655, 18, 25, 21, 2, -25 },
  { 4712, 19, 36, 21, 1, -36 },
  { 4798, 15, 25, 16, 2, -25 },
  { 4845, 21, 36, 21, 2, -36 },
  { 4940, 16, 25, 19, 2, -25 },
  { 4990, 23, 47, 11, -6, -36 },
  { 5126, 21, 36, 21, 0, -25 },
  { 5221, 18, 36, 21, 1, -36 },
  { 5302, 9, 34, 9, 1, -34 },
  { 5341, 16, 45, 9, -6, -34 },
  { 5431, 18, 36, 17, 1, -36 },
  { 5512, 10, 36, 9, 1, -36 },
  { 5557, 28, 25, 31, 1, -25 },
  { 5645, 19, 25, 21, 0, -25 },
  { 5705, 17, 25, 21, 2, -25 },
  { 5759, 22, 36, 21, -2, -25 },
  { 5858, 19, 36, 21, 2, -25 },
  { 5944, 15, 25, 14, 1, -25 },
  { 5991, 16, 25, 16, 0, -25 },
  { 6041, 12, 31, 11, 1, -31 },
  { 6088, 18, 25, 21, 2, -25 },
  { 6145, 16, 25, 16, 3, -25 },
  { 6195, 25, 25, 26, 3, -25 },
  { 6274, 20, 25, 17, -2, -25 },
  { 6337, 24, 36, 17, -5, -25 },
  { 6445, 17, 25, 15, -1, -25 },
  { 6499, 17, 41, 15, 1, -34 },
  { 6587, 2, 47, 19, 9, -36 },
  { 6599, 17, 41, 15, -3, -34 },
  { 6687, 18, 5, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_LightItalic47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC47PT7B_H_
