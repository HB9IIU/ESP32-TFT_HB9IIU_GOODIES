#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC36PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC36PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1,
  0x82, 0x0C, 0x18, 0x30, 0x41, 0x80, 0x00, 0x00, 0x00, 0x60, 0xC1, 0x80,
  0x63, 0x63, 0x63, 0x63, 0xC2, 0xC6, 0xC6, 0xC6, 0x84, 0x84, 0x00, 0x61,
  0x00, 0x21, 0x80, 0x30, 0xC0, 0x18, 0x40, 0x08, 0x20, 0x0C, 0x30, 0x06,
  0x18, 0x02, 0x08, 0x1F, 0xFF, 0x81, 0x86, 0x00, 0x82, 0x00, 0x43, 0x00,
  0x61, 0x80, 0x30, 0x80, 0x10, 0x40, 0x18, 0x60, 0x7F, 0xFE, 0x7F, 0xFF,
  0x06, 0x18, 0x03, 0x0C, 0x01, 0x04, 0x00, 0x86, 0x00, 0xC3, 0x00, 0x61,
  0x00, 0x21, 0x80, 0x30, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x40, 0x00, 0x80,
  0x0F, 0xF0, 0x7E, 0xE1, 0xC8, 0x43, 0x10, 0x04, 0x20, 0x18, 0x40, 0x11,
  0x80, 0x32, 0x00, 0x74, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xB0,
  0x01, 0x30, 0x02, 0x70, 0x0C, 0x60, 0x18, 0xC0, 0x21, 0x80, 0x46, 0x20,
  0x8C, 0x7B, 0xF0, 0x7F, 0x80, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0x0F, 0x00, 0xC3, 0xF0, 0x30, 0xC6, 0x06, 0x18, 0xC1, 0x86, 0x18,
  0x30, 0xC3, 0x0C, 0x10, 0x61, 0x02, 0x0C, 0x60, 0xC1, 0x98, 0x18, 0x23,
  0x03, 0x0C, 0xC6, 0x61, 0x93, 0xFC, 0x26, 0x67, 0x8C, 0x98, 0xDF, 0x32,
  0x0B, 0xCC, 0xC3, 0x01, 0x98, 0x60, 0x62, 0x0C, 0x08, 0x41, 0x83, 0x18,
  0x20, 0xC3, 0x04, 0x18, 0x61, 0x86, 0x0C, 0x30, 0xC1, 0x8C, 0x30, 0x33,
  0x0C, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xF8, 0x03, 0x0C, 0x02, 0x0C, 0x06,
  0x0C, 0x06, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x06, 0x30, 0x06, 0x70, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x19, 0x83, 0x30, 0xC3, 0x70,
  0xC6, 0x60, 0x66, 0x60, 0x6C, 0xC0, 0x6C, 0xC0, 0x38, 0xC0, 0x30, 0xC0,
  0x78, 0x60, 0xF8, 0x7B, 0xCC, 0x3F, 0x0C, 0x6D, 0xB5, 0xB6, 0x90, 0x00,
  0xC0, 0x20, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x03,
  0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18,
  0x02, 0x00, 0xC0, 0x01, 0x80, 0x10, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x03,
  0x00, 0x20, 0x86, 0x0E, 0x60, 0x76, 0x21, 0xFF, 0x0E, 0x01, 0xA0, 0x33,
  0x06, 0x10, 0x41, 0x80, 0x18, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x71, 0x86, 0x30, 0xC6, 0x18, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x01, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x61, 0x83, 0x03, 0x0C, 0x0C, 0x60, 0x31,
  0x80, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x36, 0x00, 0xD8, 0x07, 0x60, 0x19,
  0x80, 0x66, 0x01, 0xB0, 0x06, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x18,
  0xC0, 0x63, 0x01, 0x8C, 0x0C, 0x18, 0x60, 0x77, 0x80, 0xF8, 0x00, 0x01,
  0x83, 0x83, 0xC3, 0x67, 0x37, 0x19, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x30, 0x00, 0x00, 0xF8, 0x03, 0xFE, 0x07, 0x06, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0x01, 0xF8, 0x0F,
  0xF8, 0x38, 0x30, 0x40, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x7C, 0x00, 0xFC, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x40, 0x70, 0xF3, 0xC1, 0xFF, 0x00, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x02, 0xC0, 0x0D, 0x80, 0x33, 0x00,
  0xC4, 0x01, 0x98, 0x06, 0x30, 0x18, 0x60, 0x30, 0xC0, 0xC3, 0x03, 0x06,
  0x06, 0x0C, 0x18, 0x18, 0x60, 0x30, 0x80, 0xC3, 0xFF, 0xF7, 0xFF, 0xE0,
  0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0xFE, 0x07, 0xFC, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x64, 0x00, 0xFF, 0x01, 0x87, 0x00,
  0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x40, 0x70, 0xF3, 0xC1, 0xFE, 0x00,
  0x00, 0x7E, 0x03, 0xF8, 0x0E, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xCF, 0x03, 0x7F, 0x87, 0x83,
  0x0E, 0x06, 0x18, 0x06, 0x30, 0x0C, 0xE0, 0x19, 0x80, 0x33, 0x00, 0xC6,
  0x01, 0x8C, 0x03, 0x18, 0x0E, 0x18, 0x18, 0x30, 0x60, 0x7B, 0xC0, 0x7E,
  0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xF8, 0x18, 0x38, 0x70, 0x30, 0xC0, 0x61, 0x80, 0xC3, 0x01,
  0x86, 0x03, 0x0C, 0x0C, 0x0C, 0x38, 0x18, 0xE0, 0x1F, 0x80, 0x3C, 0x00,
  0xFC, 0x07, 0x18, 0x1C, 0x18, 0x70, 0x38, 0xC0, 0x33, 0x00, 0x66, 0x00,
  0xCC, 0x01, 0x98, 0x03, 0x38, 0x0C, 0x30, 0x38, 0x38, 0xE0, 0x3F, 0x80,
  0x01, 0xF0, 0x07, 0xF0, 0x18, 0x30, 0x60, 0x60, 0xC0, 0x63, 0x00, 0xC6,
  0x01, 0x8C, 0x03, 0x10, 0x06, 0x60, 0x0C, 0xC0, 0x31, 0x80, 0x61, 0x81,
  0xC3, 0x07, 0x87, 0xFB, 0x07, 0xE4, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xC7, 0x01, 0xFC,
  0x00, 0x0E, 0x18, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x61, 0xC3, 0x80, 0x03, 0x81, 0xC0, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x18, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x01, 0x80, 0x00, 0x04, 0x00,
  0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x20, 0x00, 0x0F, 0x87, 0xFC,
  0x41, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xFE, 0x00, 0x70, 0x18, 0x06, 0x00, 0x60, 0x60, 0x01, 0x06, 0x00,
  0x0C, 0x30, 0x00, 0x63, 0x01, 0x81, 0x10, 0x3F, 0x09, 0x83, 0x18, 0x4C,
  0x30, 0x82, 0xC3, 0x04, 0x36, 0x18, 0x61, 0xB1, 0x83, 0x0D, 0x0C, 0x10,
  0x68, 0x61, 0x82, 0xC2, 0x0C, 0x36, 0x10, 0x61, 0x30, 0x87, 0x19, 0x84,
  0x38, 0x8C, 0x3E, 0x7C, 0x60, 0xE3, 0x83, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x02, 0xC0,
  0x0D, 0x80, 0x1B, 0x00, 0x66, 0x00, 0xCC, 0x03, 0x18, 0x06, 0x30, 0x18,
  0x60, 0x30, 0x40, 0xC0, 0x81, 0x81, 0x03, 0xFF, 0x0F, 0xFE, 0x18, 0x0C,
  0x60, 0x18, 0xC0, 0x33, 0x00, 0x66, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0xE0,
  0x07, 0x80, 0x0C, 0x07, 0xF0, 0x07, 0xFC, 0x0C, 0x0E, 0x0C, 0x06, 0x0C,
  0x07, 0x0C, 0x07, 0x0C, 0x07, 0x18, 0x06, 0x18, 0x06, 0x18, 0x0E, 0x18,
  0x1C, 0x18, 0x78, 0x3F, 0xC0, 0x30, 0xF0, 0x30, 0x18, 0x30, 0x18, 0x30,
  0x1C, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x18, 0xC0, 0x18, 0xC0,
  0x30, 0xC0, 0xF0, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0xFE, 0x01, 0xFF, 0x07,
  0x02, 0x0E, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x3D, 0xE0, 0x1F, 0xE0, 0x07,
  0xE0, 0x03, 0xFE, 0x03, 0x07, 0x81, 0x80, 0xC0, 0xC0, 0x30, 0x60, 0x18,
  0x30, 0x0C, 0x30, 0x06, 0x18, 0x03, 0x8C, 0x01, 0x86, 0x00, 0xC3, 0x00,
  0x63, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x0E, 0x20, 0x06, 0x30,
  0x03, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x01, 0x86, 0x01, 0xC3, 0x01, 0xC1,
  0x83, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x03,
  0xFF, 0x03, 0xFF, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x18, 0x00, 0x10, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x78, 0x18, 0x38, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x1F, 0xCC, 0x07,
  0xE3, 0x00, 0x18, 0xC0, 0x06, 0x30, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x0C, 0x30, 0x03, 0x06, 0x00, 0xC1, 0xC0, 0x60, 0x3E, 0xF8, 0x07,
  0xFC, 0x00, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30,
  0x60, 0x06, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x60, 0x06, 0x0C, 0x00, 0xC1,
  0x80, 0x30, 0x30, 0x06, 0x06, 0x00, 0xC1, 0xFF, 0xF8, 0x30, 0x03, 0x06,
  0x00, 0xC0, 0xC0, 0x18, 0x18, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18,
  0x03, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x30, 0x60,
  0x0C, 0x1C, 0x01, 0x80, 0x07, 0xF0, 0x7F, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x38, 0x0F, 0xE0, 0x00, 0x18, 0x00, 0xC0, 0x04,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x02, 0x70, 0x1F, 0x00, 0x40,
  0x00, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x1C, 0x06, 0x06,
  0x01, 0x83, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x0C, 0x70, 0x03, 0x38, 0x00,
  0xCC, 0x00, 0x36, 0x00, 0x1B, 0x80, 0x07, 0xF0, 0x01, 0xCC, 0x00, 0x63,
  0x00, 0x10, 0xC0, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x70,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x38, 0x06, 0x00,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0x80, 0x03, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xC0, 0xF0, 0x01,
  0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0xD8, 0x1E, 0x00, 0x6C, 0x1B, 0x00,
  0x6C, 0x0C, 0x80, 0x36, 0x06, 0x40, 0x33, 0x03, 0x30, 0x19, 0x81, 0x18,
  0x18, 0xC1, 0x8C, 0x0C, 0xC0, 0xC6, 0x0C, 0x60, 0x63, 0x06, 0x30, 0x31,
  0x86, 0x18, 0x10, 0xC3, 0x18, 0x18, 0x63, 0x0C, 0x0C, 0x31, 0x86, 0x06,
  0x19, 0x83, 0x03, 0x04, 0xC1, 0x83, 0x02, 0xC1, 0x81, 0x81, 0x60, 0xC0,
  0xC0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x70, 0x30, 0x38, 0x00, 0x03, 0x00,
  0x30, 0x30, 0x03, 0x07, 0x80, 0x30, 0x78, 0x03, 0x07, 0x80, 0x60, 0x68,
  0x06, 0x06, 0xC0, 0x60, 0xCC, 0x06, 0x0C, 0xC0, 0x40, 0xC4, 0x0C, 0x0C,
  0x60, 0xC0, 0xC6, 0x0C, 0x18, 0x60, 0xC1, 0x82, 0x18, 0x18, 0x31, 0x81,
  0x83, 0x18, 0x10, 0x31, 0x83, 0x03, 0x18, 0x30, 0x1B, 0x03, 0x01, 0xB0,
  0x30, 0x1B, 0x06, 0x01, 0xB0, 0x60, 0x0E, 0x06, 0x00, 0xE0, 0x60, 0x0E,
  0x0E, 0x00, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0x01, 0xC1, 0xC1, 0x80, 0x61,
  0xC0, 0x30, 0xC0, 0x0C, 0xC0, 0x06, 0x60, 0x03, 0x70, 0x01, 0xB0, 0x00,
  0xD8, 0x00, 0x6C, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x06, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0x8C, 0x00, 0xC6,
  0x00, 0xC3, 0x80, 0xE0, 0xC0, 0xE0, 0x7D, 0xE0, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x0F, 0xF0, 0x30, 0x70, 0x60, 0x70, 0xC0, 0x61, 0x80, 0xC3, 0x01,
  0x8C, 0x03, 0x18, 0x06, 0x30, 0x1C, 0x60, 0x30, 0xC0, 0xE3, 0x03, 0x86,
  0x1E, 0x0F, 0xF0, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00,
  0x00, 0xF8, 0x01, 0xFF, 0x01, 0xC1, 0xC1, 0x80, 0x61, 0xC0, 0x30, 0xC0,
  0x0C, 0xC0, 0x06, 0x60, 0x03, 0x70, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C,
  0x00, 0x7C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x06,
  0x60, 0x03, 0x30, 0x01, 0x98, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0xC3, 0x80,
  0xE0, 0xC0, 0xE0, 0x7D, 0xE0, 0x0F, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x07, 0xC0, 0x0F, 0xF0,
  0x30, 0x70, 0x60, 0x70, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x8C, 0x03, 0x18,
  0x06, 0x30, 0x18, 0x60, 0x30, 0xC0, 0xC3, 0x03, 0x87, 0xFC, 0x0F, 0xE0,
  0x18, 0xC0, 0x30, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x06, 0x06, 0x18,
  0x0C, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x71, 0x80, 0x60, 0x01, 0xFC, 0x07,
  0xFC, 0x18, 0x18, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x1C, 0x40, 0x70, 0xF7, 0xC1, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x00, 0x0C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03,
  0x18, 0x03, 0x0C, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x61, 0x80,
  0x30, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x06, 0x18, 0x03, 0x0C,
  0x01, 0x86, 0x01, 0x83, 0x00, 0xC1, 0xC0, 0xC0, 0x7B, 0xC0, 0x1F, 0xC0,
  0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x36, 0x00, 0x6C, 0x01, 0x98, 0x03,
  0x30, 0x0C, 0x60, 0x18, 0x40, 0x60, 0x80, 0xC1, 0x03, 0x83, 0x06, 0x06,
  0x0C, 0x0C, 0x30, 0x18, 0x60, 0x31, 0x80, 0x63, 0x00, 0xCC, 0x01, 0x98,
  0x03, 0x60, 0x06, 0xC0, 0x0D, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0xC0, 0x18, 0x03, 0xE0, 0x0C, 0x01, 0xB0, 0x06, 0x00, 0xD8,
  0x07, 0x00, 0xCC, 0x03, 0x80, 0x66, 0x03, 0x40, 0x63, 0x01, 0xA0, 0x31,
  0x80, 0x90, 0x18, 0xC0, 0xC8, 0x18, 0x60, 0x64, 0x0C, 0x30, 0x62, 0x0C,
  0x18, 0x31, 0x06, 0x0C, 0x30, 0x87, 0x06, 0x18, 0x43, 0x03, 0x08, 0x21,
  0x81, 0x8C, 0x11, 0x80, 0xC6, 0x08, 0xC0, 0x66, 0x04, 0xC0, 0x33, 0x02,
  0x60, 0x19, 0x01, 0x30, 0x0D, 0x80, 0xB0, 0x06, 0xC0, 0x58, 0x03, 0xC0,
  0x28, 0x01, 0xE0, 0x1C, 0x00, 0xE0, 0x0C, 0x00, 0x70, 0x06, 0x00, 0x00,
  0x03, 0x00, 0xE0, 0x60, 0x18, 0x04, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x30,
  0x03, 0x0C, 0x00, 0x61, 0x80, 0x04, 0x60, 0x00, 0xD8, 0x00, 0x1B, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0x30, 0x00, 0xC6, 0x00, 0x18, 0xC0, 0x06, 0x18, 0x01,
  0xC3, 0x00, 0x30, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x18, 0x18,
  0x03, 0x00, 0xC0, 0x1F, 0x00, 0x6C, 0x03, 0x18, 0x0C, 0x60, 0x61, 0x81,
  0x86, 0x0C, 0x18, 0x70, 0x61, 0x80, 0x8C, 0x03, 0x30, 0x0D, 0x80, 0x36,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x00,
  0x03, 0xFF, 0x83, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xE0,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x08, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x07, 0xE0, 0x3F, 0x80, 0x86, 0x31, 0x8C, 0x61, 0x08, 0x63, 0x18, 0xC6,
  0x10, 0xC6, 0x31, 0x8C, 0x61, 0x0C, 0x63, 0x18, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xD0, 0x06, 0x60, 0x19, 0x80,
  0xC3, 0x03, 0x0C, 0x18, 0x30, 0x60, 0x63, 0x01, 0x98, 0x02, 0x60, 0x0F,
  0x00, 0x30, 0xFF, 0xFF, 0xFC, 0xC3, 0x18, 0x63, 0x0C, 0x07, 0xE6, 0x1C,
  0x68, 0x70, 0x70, 0xC0, 0xE3, 0x01, 0xC6, 0x03, 0x98, 0x06, 0x30, 0x0C,
  0x60, 0x18, 0xC0, 0x33, 0x00, 0xC6, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x30,
  0x1C, 0x60, 0x70, 0x61, 0xE0, 0xE6, 0xC0, 0xF9, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0xF8, 0x1B, 0x38, 0x3C, 0x38, 0x70, 0x31, 0xC0, 0x63, 0x80, 0xC6,
  0x01, 0x8C, 0x03, 0x18, 0x06, 0x60, 0x1C, 0xC0, 0x31, 0x80, 0x63, 0x00,
  0xC6, 0x03, 0x1C, 0x06, 0x38, 0x18, 0x70, 0x70, 0xB9, 0xC3, 0x3F, 0x00,
  0x03, 0xF0, 0xE3, 0x1C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x07, 0x98, 0x3F, 0x80, 0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x20, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x07, 0xE6,
  0x07, 0x1A, 0x07, 0x07, 0x03, 0x03, 0x83, 0x01, 0xC1, 0x80, 0xE1, 0x80,
  0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0C, 0x30, 0x0E, 0x18, 0x06, 0x0C,
  0x03, 0x06, 0x03, 0x83, 0x01, 0xC1, 0x81, 0xC0, 0x61, 0xA0, 0x39, 0xB0,
  0x0F, 0x98, 0x00, 0x07, 0xE0, 0x71, 0x87, 0x0C, 0x30, 0x33, 0x03, 0x18,
  0x19, 0x81, 0xCC, 0x1C, 0x6F, 0xC7, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0xCE, 0x0F, 0xE0, 0x00, 0x01,
  0x00, 0x03, 0xF0, 0x00, 0xC4, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x03, 0xF3,
  0x07, 0x1A, 0x0E, 0x0E, 0x0C, 0x0E, 0x18, 0x0E, 0x18, 0x0E, 0x30, 0x0C,
  0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x18,
  0x60, 0x38, 0x60, 0x38, 0x60, 0x70, 0x30, 0xF0, 0x39, 0xB0, 0x1F, 0x30,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0xC3, 0x80, 0xFF, 0x00, 0x18, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0xF8, 0x36, 0x70,
  0xE0, 0xC3, 0x83, 0x1C, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x0C,
  0xC0, 0x63, 0x01, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x66, 0x03, 0x18, 0x0C,
  0x60, 0x31, 0x80, 0xCC, 0x06, 0x00, 0x03, 0x07, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30,
  0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x07, 0xC0, 0x18, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x0E, 0x18, 0x30,
  0x30, 0xE0, 0x63, 0x81, 0x86, 0x03, 0x18, 0x06, 0x60, 0x0D, 0x80, 0x17,
  0x00, 0x7B, 0x00, 0xE6, 0x01, 0x8C, 0x03, 0x18, 0x04, 0x18, 0x18, 0x30,
  0x30, 0x60, 0x60, 0xC0, 0xC0, 0xC3, 0x01, 0x80, 0x03, 0x03, 0x03, 0x06,
  0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x0C,
  0xF8, 0xFC, 0x1B, 0x3B, 0x38, 0x38, 0x3C, 0x30, 0x60, 0x70, 0x31, 0xC0,
  0xC0, 0xC3, 0x01, 0x81, 0x86, 0x03, 0x03, 0x0C, 0x0C, 0x06, 0x18, 0x18,
  0x0C, 0x60, 0x30, 0x30, 0xC0, 0x60, 0x61, 0x80, 0x80, 0xC3, 0x03, 0x01,
  0x84, 0x06, 0x03, 0x18, 0x0C, 0x0C, 0x30, 0x18, 0x18, 0x60, 0x60, 0x30,
  0xC0, 0xC0, 0x63, 0x01, 0x81, 0xC0, 0x00, 0x20, 0x33, 0xF0, 0xD9, 0xC3,
  0x83, 0x0E, 0x0C, 0x70, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x33,
  0x01, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x98, 0x0C, 0x60, 0x31,
  0x80, 0xC6, 0x03, 0x30, 0x18, 0x07, 0xF0, 0x38, 0xE1, 0xC1, 0x86, 0x06,
  0x30, 0x18, 0xC0, 0x36, 0x00, 0xD8, 0x06, 0x60, 0x19, 0x80, 0x6C, 0x01,
  0xB0, 0x06, 0xC0, 0x33, 0x00, 0xCC, 0x07, 0x30, 0x18, 0x60, 0xC1, 0xEF,
  0x03, 0xF0, 0x00, 0x06, 0x7C, 0x06, 0xCE, 0x07, 0x87, 0x07, 0x03, 0x0E,
  0x03, 0x0E, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x18,
  0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x0C, 0x38, 0x0C, 0x38, 0x18, 0x38,
  0x38, 0x3E, 0x70, 0x27, 0xE0, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x07, 0xE6, 0x1C,
  0x68, 0x70, 0x70, 0xC0, 0xE3, 0x01, 0xC6, 0x03, 0x98, 0x06, 0x30, 0x0C,
  0x60, 0x18, 0xC0, 0x33, 0x00, 0x66, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x30,
  0x1C, 0x60, 0x70, 0x61, 0xE0, 0xE6, 0xC0, 0xF9, 0x80, 0x03, 0x00, 0x04,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x0C, 0xF0, 0xDD, 0x0F, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x00, 0x0F, 0xF1, 0xC3, 0x18, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x81, 0x8E, 0x78, 0xFE, 0x00,
  0x04, 0x06, 0x03, 0x01, 0x81, 0x83, 0xFD, 0xFC, 0x30, 0x18, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0xA0, 0xF0, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x30, 0x18,
  0xC0, 0x63, 0x01, 0x8C, 0x06, 0x60, 0x11, 0x80, 0xC6, 0x03, 0x18, 0x0C,
  0x60, 0x33, 0x01, 0x8C, 0x06, 0x30, 0x38, 0xC1, 0xE1, 0xDD, 0x87, 0xE4,
  0x00, 0xC0, 0x3C, 0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1, 0x8C,
  0x18, 0xC3, 0x0C, 0x30, 0xC6, 0x04, 0x60, 0x4C, 0x04, 0xC0, 0x58, 0x05,
  0x80, 0x70, 0x07, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x7C, 0x0E, 0x06, 0xC0,
  0xE0, 0x6C, 0x1E, 0x0C, 0xC1, 0xE0, 0xCC, 0x36, 0x18, 0xC3, 0x61, 0x8C,
  0x26, 0x30, 0xC6, 0x63, 0x0C, 0x66, 0x30, 0xCC, 0x66, 0x0C, 0xC6, 0x60,
  0xD8, 0x6C, 0x0D, 0x86, 0xC0, 0xD0, 0x68, 0x0F, 0x07, 0x80, 0xF0, 0x78,
  0x0E, 0x07, 0x00, 0xE0, 0x70, 0x00, 0x06, 0x07, 0x06, 0x06, 0x03, 0x0C,
  0x03, 0x1C, 0x03, 0x18, 0x03, 0x30, 0x01, 0xF0, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06, 0x40, 0x0C, 0x60, 0x0C, 0x60,
  0x18, 0x60, 0x30, 0x30, 0x30, 0x30, 0xE0, 0x30, 0x03, 0x00, 0xE0, 0x60,
  0x18, 0x04, 0x06, 0x00, 0x80, 0xC0, 0x10, 0x30, 0x03, 0x06, 0x00, 0x61,
  0x80, 0x0C, 0x30, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x06, 0x30, 0x00, 0xCC,
  0x00, 0x19, 0x80, 0x03, 0x60, 0x00, 0x6C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0x80, 0x03, 0xE0, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0x38,
  0x07, 0xC0, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x1E, 0x00,
  0xF0, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xF0,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x03, 0xE0, 0x10, 0x00, 0x18,
  0x03, 0xF8, 0x1C, 0x7F, 0xE0, 0x7C,
};

const GFXglyph NotoSans_Condensed_LightItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 26, 8, 1, -26 },
  { 24, 8, 10, 11, 4, -26 },
  { 34, 17, 26, 17, 0, -26 },
  { 90, 15, 29, 15, 0, -27 },
  { 145, 19, 26, 23, 2, -26 },
  { 207, 16, 26, 17, 0, -26 },
  { 259, 3, 10, 6, 4, -26 },
  { 263, 10, 32, 9, 1, -26 },
  { 303, 11, 32, 9, -3, -26 },
  { 347, 12, 12, 14, 4, -27 },
  { 365, 14, 17, 17, 2, -21 },
  { 395, 6, 9, 7, -2, -4 },
  { 402, 8, 2, 10, 1, -11 },
  { 404, 2, 3, 7, 1, -3 },
  { 405, 16, 26, 11, -2, -26 },
  { 457, 14, 26, 15, 1, -26 },
  { 503, 9, 26, 15, 4, -26 },
  { 533, 16, 26, 15, -1, -26 },
  { 585, 15, 26, 15, 0, -26 },
  { 634, 15, 26, 15, 0, -26 },
  { 683, 15, 26, 15, 0, -26 },
  { 732, 15, 26, 15, 1, -26 },
  { 781, 14, 26, 15, 2, -26 },
  { 827, 15, 26, 15, 0, -26 },
  { 876, 15, 26, 15, 0, -26 },
  { 925, 7, 19, 7, 0, -19 },
  { 942, 9, 24, 7, -2, -19 },
  { 969, 14, 16, 17, 2, -21 },
  { 997, 14, 9, 17, 2, -17 },
  { 1013, 14, 16, 17, 2, -21 },
  { 1041, 11, 26, 11, 1, -26 },
  { 1077, 21, 29, 23, 1, -26 },
  { 1154, 15, 26, 15, -2, -26 },
  { 1203, 16, 26, 17, 1, -26 },
  { 1255, 16, 26, 15, 2, -26 },
  { 1307, 17, 26, 18, 1, -26 },
  { 1363, 16, 26, 15, 0, -26 },
  { 1415, 16, 26, 14, 0, -26 },
  { 1467, 18, 26, 19, 2, -26 },
  { 1526, 19, 26, 19, 0, -26 },
  { 1588, 12, 26, 9, -1, -26 },
  { 1627, 13, 33, 7, -5, -26 },
  { 1681, 18, 26, 15, 0, -26 },
  { 1740, 11, 26, 13, 0, -26 },
  { 1776, 25, 26, 24, 0, -26 },
  { 1858, 20, 26, 20, 0, -26 },
  { 1923, 17, 26, 20, 2, -26 },
  { 1979, 15, 26, 16, 1, -26 },
  { 2028, 17, 32, 20, 2, -26 },
  { 2096, 15, 26, 16, 1, -26 },
  { 2145, 15, 26, 14, 0, -26 },
  { 2194, 13, 26, 13, 3, -26 },
  { 2237, 17, 26, 19, 2, -26 },
  { 2293, 15, 26, 15, 3, -26 },
  { 2342, 25, 26, 25, 3, -26 },
  { 2424, 19, 26, 14, -2, -26 },
  { 2486, 14, 26, 14, 3, -26 },
  { 2532, 17, 26, 14, -1, -26 },
  { 2588, 14, 32, 10, -1, -26 },
  { 2644, 5, 26, 12, 4, -26 },
  { 2661, 13, 32, 10, -2, -26 },
  { 2713, 14, 14, 16, 1, -26 },
  { 2738, 11, 2, 11, -3, 3 },
  { 2741, 5, 6, 8, 5, -28 },
  { 2745, 15, 19, 16, 1, -19 },
  { 2781, 15, 27, 16, 0, -27 },
  { 2832, 12, 19, 12, 1, -19 },
  { 2861, 17, 27, 16, 1, -27 },
  { 2919, 13, 19, 14, 1, -19 },
  { 2950, 18, 37, 8, -5, -28 },
  { 3034, 16, 28, 16, 0, -19 },
  { 3090, 14, 27, 16, 0, -27 },
  { 3138, 8, 26, 7, 0, -26 },
  { 3164, 13, 35, 7, -5, -26 },
  { 3221, 15, 27, 13, 0, -27 },
  { 3272, 8, 27, 7, 0, -27 },
  { 3299, 23, 19, 24, 0, -19 },
  { 3354, 14, 20, 16, 0, -20 },
  { 3389, 14, 19, 16, 1, -19 },
  { 3423, 16, 27, 16, -1, -19 },
  { 3477, 15, 28, 16, 1, -19 },
  { 3530, 12, 19, 11, 0, -19 },
  { 3559, 12, 19, 12, 0, -19 },
  { 3588, 9, 24, 9, 1, -24 },
  { 3615, 14, 19, 16, 1, -19 },
  { 3649, 12, 19, 12, 2, -19 },
  { 3678, 20, 19, 20, 2, -19 },
  { 3726, 16, 19, 13, -2, -19 },
  { 3764, 19, 28, 13, -4, -19 },
  { 3831, 13, 19, 11, -1, -19 },
  { 3862, 13, 32, 12, 1, -26 },
  { 3914, 1, 36, 15, 7, -27 },
  { 3919, 13, 32, 12, -2, -26 },
  { 3971, 14, 4, 17, 2, -15 },
};

const GFXfont NotoSans_Condensed_LightItalic36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC36PT7B_H_
