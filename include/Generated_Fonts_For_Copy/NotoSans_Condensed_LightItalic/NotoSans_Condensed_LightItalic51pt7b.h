#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC51PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x70, 0x00, 0x38, 0x79, 0xC3, 0x8E, 0x1C, 0x60, 0xE3, 0x06, 0x38,
  0x71, 0xC3, 0x8C, 0x1C, 0x60, 0xC3, 0x06, 0x18, 0x31, 0x83, 0x8C, 0x18,
  0x00, 0x00, 0x1C, 0x0C, 0x00, 0x18, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x38,
  0x18, 0x00, 0x38, 0x18, 0x00, 0x30, 0x30, 0x00, 0x30, 0x30, 0x00, 0x70,
  0x30, 0x00, 0x60, 0x70, 0x00, 0x60, 0x60, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFE, 0x00, 0xC0, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0x81, 0xC0, 0x01, 0x81,
  0x80, 0x01, 0x81, 0x80, 0x03, 0x81, 0x80, 0x03, 0x03, 0x80, 0x03, 0x03,
  0x00, 0x07, 0x03, 0x00, 0x06, 0x07, 0x00, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF0, 0x0C, 0x0C, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x1C,
  0x00, 0x18, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x30, 0x38,
  0x00, 0x30, 0x30, 0x00, 0x70, 0x30, 0x00, 0x60, 0x70, 0x00, 0x60, 0x60,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x04, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x79, 0x8E, 0x03,
  0x86, 0x08, 0x0C, 0x18, 0x00, 0x70, 0x40, 0x01, 0xC3, 0x00, 0x07, 0x0C,
  0x00, 0x1C, 0x30, 0x00, 0x70, 0xC0, 0x01, 0xC2, 0x00, 0x03, 0x98, 0x00,
  0x0F, 0x60, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0D, 0xE0, 0x00, 0x23, 0x80, 0x01, 0x87,
  0x00, 0x06, 0x1C, 0x00, 0x18, 0x70, 0x00, 0x61, 0xC0, 0x01, 0x07, 0x00,
  0x0C, 0x1C, 0x00, 0x30, 0xE0, 0x80, 0xC3, 0x81, 0x83, 0x3C, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x70, 0x39, 0xC0, 0x0C, 0x0E, 0x18, 0x03, 0x81, 0x83,
  0x80, 0xE0, 0x70, 0x70, 0x18, 0x0C, 0x0E, 0x07, 0x01, 0x81, 0xC0, 0xC0,
  0x70, 0x38, 0x38, 0x0C, 0x06, 0x06, 0x01, 0x80, 0xC1, 0xC0, 0x70, 0x18,
  0x70, 0x0E, 0x03, 0x0C, 0x01, 0xC0, 0xE3, 0x80, 0x30, 0x18, 0x60, 0x06,
  0x03, 0x1C, 0x7C, 0xC0, 0xE3, 0x1F, 0xD8, 0x18, 0xC7, 0x1F, 0x07, 0x39,
  0xC3, 0xF0, 0xC6, 0x30, 0x37, 0x79, 0xCE, 0x06, 0xFE, 0x31, 0x80, 0xCF,
  0x0E, 0x30, 0x18, 0x01, 0x8E, 0x07, 0x00, 0x61, 0xC0, 0xE0, 0x1C, 0x30,
  0x1C, 0x03, 0x06, 0x03, 0x00, 0xE0, 0xC0, 0x60, 0x18, 0x38, 0x1C, 0x07,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x1C, 0x1C, 0x0E, 0x03, 0x83,
  0x01, 0x80, 0x70, 0xE0, 0x70, 0x06, 0x18, 0x0C, 0x00, 0xFF, 0x03, 0x80,
  0x0F, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x80,
  0x01, 0xF7, 0x80, 0x03, 0x87, 0x00, 0x0E, 0x07, 0x00, 0x18, 0x0E, 0x00,
  0x70, 0x1C, 0x00, 0xE0, 0x30, 0x01, 0xC0, 0x60, 0x03, 0x81, 0xC0, 0x07,
  0x03, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x18, 0xF0, 0x00, 0x3B,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1D, 0xC0, 0x00, 0x73, 0x80, 0x21, 0xC3, 0x81, 0x87, 0x07, 0x07,
  0x1C, 0x06, 0x0E, 0x30, 0x0E, 0x38, 0xE0, 0x1C, 0x71, 0xC0, 0x1D, 0xC3,
  0x00, 0x3B, 0x8E, 0x00, 0x3E, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xF0, 0x70,
  0x01, 0xE0, 0xE0, 0x07, 0xC0, 0xE0, 0x1D, 0xC1, 0xE0, 0xF3, 0x81, 0xFF,
  0xC3, 0x81, 0xFE, 0x07, 0x00, 0x60, 0x00, 0x00, 0x3C, 0xE3, 0x8E, 0x31,
  0xC7, 0x18, 0x61, 0x86, 0x30, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xC0, 0x07, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0,
  0x81, 0xC0, 0xE1, 0x80, 0xF9, 0x80, 0x3D, 0x8F, 0x0F, 0xFF, 0x03, 0xFC,
  0x07, 0x80, 0x0E, 0xC0, 0x1C, 0xC0, 0x38, 0x60, 0xF0, 0x60, 0x60, 0x70,
  0x00, 0x38, 0x00, 0x20, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x0F, 0x0E, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x30,
  0x70, 0x60, 0xE0, 0xC0, 0x7F, 0xFF, 0xFE, 0xFF, 0xE0, 0x2F, 0xFF, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xE0,
  0xE0, 0x38, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x70, 0x07, 0x0E, 0x00,
  0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01,
  0xCC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x19, 0xC0, 0x07,
  0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xE7, 0x00, 0x1C,
  0xE0, 0x03, 0x98, 0x00, 0x73, 0x00, 0x1C, 0x60, 0x03, 0x8C, 0x00, 0xE1,
  0xC0, 0x1C, 0x38, 0x03, 0x07, 0x00, 0xE0, 0xE0, 0x38, 0x1C, 0x0F, 0x01,
  0xC3, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0,
  0x1E, 0x03, 0xE0, 0xFE, 0x1E, 0xE3, 0x8E, 0xF0, 0xC6, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x78, 0x1E, 0x00, 0x80, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0x80, 0xE0, 0x10, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x04, 0x00, 0x70, 0x38, 0x0F, 0x81, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x1B, 0x80, 0x00, 0xCE,
  0x00, 0x07, 0x30, 0x00, 0x18, 0xC0, 0x00, 0xC7, 0x00, 0x07, 0x1C, 0x00,
  0x38, 0x70, 0x00, 0xC1, 0x80, 0x07, 0x06, 0x00, 0x38, 0x38, 0x00, 0xC0,
  0xE0, 0x07, 0x03, 0x80, 0x38, 0x0C, 0x00, 0xC0, 0x70, 0x07, 0x01, 0xC0,
  0x38, 0x07, 0x01, 0xC0, 0x1C, 0x06, 0x00, 0x60, 0x38, 0x03, 0x81, 0xC0,
  0x0E, 0x07, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x80, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xBF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x80, 0x0E, 0x03, 0x80, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x30, 0x03, 0x1F, 0xE0, 0x73, 0xFF, 0x07, 0x60, 0x70, 0x7C,
  0x03, 0x87, 0x80, 0x38, 0x70, 0x03, 0x8F, 0x00, 0x18, 0xE0, 0x01, 0x8E,
  0x00, 0x18, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38,
  0xE0, 0x03, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x0E,
  0x07, 0x01, 0xC0, 0x78, 0x78, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x30,
  0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0x80, 0x0F, 0xDF, 0x00, 0x78, 0x1E, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x70,
  0x38, 0x01, 0xC0, 0xC0, 0x07, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x60, 0x30,
  0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0x1C, 0x1E,
  0x00, 0x38, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0x80, 0x07, 0x87, 0x00, 0x38, 0x1E, 0x01, 0xC0, 0x38, 0x0E, 0x00,
  0x70, 0x70, 0x01, 0xC1, 0xC0, 0x03, 0x06, 0x00, 0x0C, 0x38, 0x00, 0x38,
  0xE0, 0x00, 0xC3, 0x80, 0x03, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x70, 0x70,
  0x03, 0x81, 0xE0, 0x1E, 0x03, 0xC0, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0,
  0x3C, 0x1E, 0x07, 0x80, 0xE0, 0x70, 0x06, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x1C, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0x80, 0x07, 0x18, 0x00,
  0x73, 0x80, 0x07, 0x38, 0x00, 0x73, 0x80, 0x0E, 0x38, 0x00, 0xE1, 0x80,
  0x1E, 0x1C, 0x03, 0xE1, 0xC0, 0x7E, 0x0F, 0x1E, 0xC0, 0xFF, 0xCC, 0x03,
  0xF1, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x81, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x80, 0x00, 0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x20, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x80, 0xE0, 0x78, 0x78, 0x1C, 0x00, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0xF0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x03, 0xF0,
  0x0F, 0xFC, 0x1F, 0xFE, 0x18, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x1C,
  0x00, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x18, 0x18, 0x00,
  0x00, 0x60, 0xE0, 0x00, 0x01, 0x83, 0x00, 0xFF, 0x06, 0x1C, 0x07, 0xFC,
  0x1C, 0x60, 0x38, 0x70, 0x73, 0x81, 0xC1, 0x81, 0x8C, 0x0E, 0x06, 0x06,
  0x30, 0x30, 0x18, 0x19, 0xC1, 0xC0, 0xE0, 0x66, 0x06, 0x03, 0x01, 0x98,
  0x38, 0x0C, 0x0E, 0xE0, 0xC0, 0x30, 0x3B, 0x83, 0x01, 0xC0, 0xCC, 0x0C,
  0x06, 0x03, 0x30, 0x70, 0x18, 0x1C, 0xC1, 0xC0, 0xE0, 0x63, 0x07, 0x03,
  0x83, 0x8C, 0x1C, 0x1E, 0x0C, 0x30, 0x70, 0x58, 0x70, 0xC0, 0xC3, 0x63,
  0x83, 0x03, 0xF9, 0xFC, 0x0C, 0x07, 0xC3, 0xE0, 0x30, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x0C, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1B, 0x00,
  0x01, 0xD8, 0x00, 0x0C, 0xC0, 0x00, 0xE6, 0x00, 0x06, 0x30, 0x00, 0x71,
  0x80, 0x03, 0x8C, 0x00, 0x38, 0x60, 0x01, 0xC3, 0x00, 0x0C, 0x18, 0x00,
  0xE0, 0xC0, 0x06, 0x06, 0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFF, 0x03, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0x70,
  0xE0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00,
  0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0x80,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0x01, 0xE0, 0x0C, 0x01, 0xE0,
  0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x06, 0x03,
  0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x70,
  0x03, 0x80, 0xC0, 0x0E, 0x03, 0x80, 0x3C, 0x07, 0x03, 0xE0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x70, 0x1F, 0x00, 0xE0, 0x0F, 0x01, 0xC0, 0x0E,
  0x03, 0x80, 0x1C, 0x06, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0xE0, 0x01, 0x81, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x3C, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x0F, 0x81, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xC0, 0x20, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x0C,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x01, 0xC0, 0xF8, 0x01, 0x80, 0x3C, 0x03, 0x80,
  0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0x80, 0x0E, 0x03, 0x00,
  0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x07, 0x06, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E, 0x00,
  0x0E, 0x0C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x1C, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x30, 0x00, 0xF0, 0x70, 0x00,
  0xE0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x60, 0x07, 0x80, 0xE0, 0x1F,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x60, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x01, 0xF0, 0x0E, 0x00, 0xF0, 0x00, 0x80, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x3F, 0xE1, 0xC0, 0x0F, 0xF8, 0x70, 0x03, 0xFE,
  0x1C, 0x00, 0x07, 0x06, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x1C, 0x38, 0x00, 0x06, 0x06, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x01, 0xE0, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x0F, 0x00, 0x1C, 0x01, 0xF0, 0x1F, 0x00, 0x3F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00, 0xC0, 0x00, 0xE0, 0x38, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x03,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x60, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03,
  0x80, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03, 0x80, 0x01, 0x80, 0x70,
  0x00, 0x70, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38,
  0x0E, 0x00, 0x0E, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x06, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0xE0, 0x18, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C,
  0x00, 0x0C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x00, 0x01, 0xFF,
  0x80, 0x3F, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x3F, 0xF0,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x01, 0x1E, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x80,
  0x30, 0x07, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x0E, 0x03, 0x80,
  0x07, 0x03, 0x80, 0x03, 0x03, 0xC0, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0,
  0x00, 0xE1, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x39, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x06, 0xF8, 0x00, 0x07, 0xEE,
  0x00, 0x03, 0xE7, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xE0, 0xC0, 0x00, 0x60,
  0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x0E,
  0x03, 0x80, 0x06, 0x01, 0xC0, 0x07, 0x00, 0x60, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0D, 0x80, 0xFC, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x01, 0xB8, 0x0D, 0xC0, 0x00, 0xEE, 0x03, 0x30, 0x00, 0x33,
  0x01, 0xCC, 0x00, 0x1D, 0xC0, 0x73, 0x00, 0x06, 0x70, 0x1C, 0xC0, 0x03,
  0x9C, 0x06, 0x30, 0x00, 0xC7, 0x03, 0x8C, 0x00, 0x71, 0x80, 0xE3, 0x80,
  0x18, 0xE0, 0x38, 0xE0, 0x0E, 0x38, 0x0E, 0x38, 0x03, 0x0E, 0x03, 0x0E,
  0x01, 0xC3, 0x01, 0xC3, 0x80, 0x61, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C,
  0x38, 0x0C, 0x1C, 0x07, 0x06, 0x07, 0x07, 0x01, 0x81, 0x81, 0x81, 0x80,
  0xE0, 0x60, 0xE0, 0xE0, 0x38, 0x18, 0x30, 0x38, 0x0E, 0x06, 0x1C, 0x0E,
  0x03, 0x01, 0x86, 0x03, 0x80, 0xC0, 0x73, 0x80, 0xC0, 0x70, 0x1C, 0xC0,
  0x70, 0x1C, 0x07, 0x70, 0x1C, 0x07, 0x01, 0xD8, 0x07, 0x01, 0x80, 0x7E,
  0x01, 0xC0, 0xE0, 0x1F, 0x00, 0x60, 0x38, 0x07, 0xC0, 0x38, 0x0E, 0x00,
  0xE0, 0x0E, 0x03, 0x80, 0x38, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x1E,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0xE0, 0x1F, 0x00, 0x0E, 0x03, 0xF0, 0x00,
  0xE0, 0x3F, 0x00, 0x0C, 0x03, 0xB0, 0x01, 0xC0, 0x33, 0x80, 0x1C, 0x03,
  0x38, 0x01, 0xC0, 0x73, 0x80, 0x1C, 0x07, 0x18, 0x01, 0x80, 0x71, 0xC0,
  0x38, 0x06, 0x1C, 0x03, 0x80, 0xE1, 0xC0, 0x38, 0x0E, 0x0C, 0x03, 0x00,
  0xE0, 0xC0, 0x30, 0x0E, 0x0E, 0x07, 0x00, 0xC0, 0xE0, 0x70, 0x1C, 0x06,
  0x07, 0x01, 0xC0, 0x60, 0x60, 0x1C, 0x07, 0x0E, 0x01, 0xC0, 0x70, 0xE0,
  0x18, 0x03, 0x0E, 0x03, 0x80, 0x30, 0xE0, 0x38, 0x03, 0x8C, 0x03, 0x80,
  0x39, 0xC0, 0x30, 0x03, 0x9C, 0x03, 0x00, 0x19, 0xC0, 0x70, 0x01, 0xD8,
  0x07, 0x00, 0x1D, 0x80, 0x70, 0x01, 0xF8, 0x06, 0x00, 0x0F, 0x80, 0xE0,
  0x00, 0xF8, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1E,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x1C, 0x0E,
  0x00, 0x0E, 0x0F, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE3,
  0x80, 0x00, 0x71, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0C,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x71, 0x80, 0x00,
  0x38, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x07, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0,
  0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x07,
  0x83, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x06, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1C, 0x1F, 0x00, 0x60, 0x1E, 0x03,
  0x80, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0x81, 0xC0, 0x0E, 0x06, 0x00, 0x38,
  0x18, 0x00, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x3C, 0x0E, 0x01, 0xE0, 0x30,
  0x0F, 0x01, 0xC3, 0xF8, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x70, 0x00,
  0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x1E, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x1E, 0x00, 0x38, 0x0E, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0x07, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x0C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x71,
  0x80, 0x00, 0x38, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x06, 0x00, 0x03, 0x83, 0x80, 0x03,
  0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0x1E, 0x01,
  0xE0, 0x07, 0x83, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1C, 0x1F, 0x00,
  0x60, 0x1E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0,
  0x07, 0x03, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70, 0x03, 0x81, 0xC0, 0x0E,
  0x07, 0x00, 0x38, 0x18, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0x80, 0x38, 0x0E,
  0x01, 0xE0, 0x30, 0x1F, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x0E, 0x00,
  0xE0, 0x38, 0x03, 0x80, 0xE0, 0x0C, 0x03, 0x80, 0x70, 0x07, 0x01, 0xC0,
  0x1C, 0x07, 0x00, 0x70, 0x18, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x0E,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xF8, 0x07, 0x80, 0x60, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x81, 0x00, 0x0F, 0x03, 0xC0, 0xFC, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80,
  0x03, 0x81, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E,
  0x00, 0x06, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0x80, 0x01, 0xC1,
  0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x60, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38,
  0x18, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x03, 0x80, 0x03, 0x81, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xC0, 0xE0, 0x00,
  0xE0, 0x70, 0x00, 0x70, 0x30, 0x00, 0x38, 0x18, 0x00, 0x18, 0x1C, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x01, 0xC0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xB0,
  0x00, 0x39, 0x80, 0x01, 0xCC, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x07,
  0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0,
  0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x0E,
  0x00, 0x70, 0x70, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0x80, 0x03,
  0x1C, 0x00, 0x18, 0xC0, 0x00, 0xCE, 0x00, 0x06, 0x70, 0x00, 0x37, 0x00,
  0x01, 0xB8, 0x00, 0x0D, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0x70,
  0x00, 0xEE, 0x00, 0x3C, 0x00, 0x3B, 0x80, 0x0F, 0x00, 0x1C, 0xE0, 0x03,
  0xC0, 0x07, 0x38, 0x01, 0xF0, 0x01, 0xCE, 0x00, 0x6C, 0x00, 0xE3, 0x80,
  0x3B, 0x00, 0x38, 0xE0, 0x0C, 0xC0, 0x1C, 0x38, 0x03, 0x30, 0x07, 0x0E,
  0x01, 0xCC, 0x01, 0xC3, 0x80, 0x63, 0x00, 0xE0, 0xE0, 0x38, 0xC0, 0x38,
  0x38, 0x0C, 0x30, 0x1C, 0x0E, 0x07, 0x0C, 0x07, 0x03, 0x81, 0xC3, 0x01,
  0x80, 0xE0, 0x60, 0xC0, 0xE0, 0x38, 0x38, 0x30, 0x38, 0x0C, 0x0C, 0x0C,
  0x1C, 0x03, 0x07, 0x03, 0x07, 0x00, 0xC1, 0x80, 0xC1, 0x80, 0x30, 0x60,
  0x30, 0xE0, 0x0C, 0x38, 0x0C, 0x38, 0x03, 0x0C, 0x03, 0x1C, 0x00, 0xC7,
  0x00, 0xC7, 0x00, 0x31, 0x80, 0x31, 0x80, 0x0C, 0xE0, 0x0C, 0xE0, 0x03,
  0x38, 0x03, 0x30, 0x00, 0xCC, 0x00, 0xDC, 0x00, 0x37, 0x00, 0x37, 0x00,
  0x0D, 0x80, 0x0D, 0x80, 0x03, 0x60, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x18, 0x03, 0x80, 0x03, 0x80, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x18, 0x38, 0x00, 0x03, 0x0E, 0x00,
  0x00, 0x71, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xCC, 0x00, 0x00, 0x1B,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xE6, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x06, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0xE0,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xF7, 0x00, 0x1C, 0x70, 0x01, 0xC7,
  0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x70, 0x70, 0x07, 0x03, 0x00, 0xE0,
  0x30, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x70,
  0x01, 0x87, 0x00, 0x18, 0xE0, 0x01, 0x8C, 0x00, 0x1D, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0xE0, 0xE0, 0x60,
  0x60, 0x60, 0x70, 0x70, 0x70, 0x70, 0x30, 0x30, 0x30, 0x38, 0x38, 0x38,
  0x38, 0x18, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0E,
  0x0E, 0x0E, 0x06, 0x06, 0x06, 0x06, 0x07, 0x07, 0x07, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x06, 0x60, 0x00, 0x73, 0x80, 0x03, 0x1C, 0x00, 0x38, 0x60,
  0x03, 0x83, 0x80, 0x1C, 0x0C, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0,
  0x0C, 0x06, 0x00, 0x70, 0x70, 0x03, 0x87, 0x00, 0x0C, 0x38, 0x00, 0x73,
  0x80, 0x01, 0xBC, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC1,
  0xC1, 0x83, 0x83, 0x03, 0x00, 0x18, 0x00, 0x1F, 0xE3, 0x03, 0xFF, 0x30,
  0x78, 0x37, 0x0F, 0x01, 0x60, 0xE0, 0x1E, 0x1C, 0x01, 0xE1, 0xC0, 0x0E,
  0x38, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01,
  0xCE, 0x00, 0x1C, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0,
  0x0F, 0x0E, 0x01, 0xE0, 0xE0, 0x36, 0x07, 0x06, 0x60, 0x7F, 0xCE, 0x03,
  0xF8, 0xE0, 0x04, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x60, 0x07,
  0x1F, 0xC0, 0x77, 0xFE, 0x06, 0xE0, 0xE0, 0xEC, 0x07, 0x0F, 0x80, 0x70,
  0xF0, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x1E, 0x00, 0x71, 0xC0, 0x07,
  0x1C, 0x00, 0x71, 0xC0, 0x07, 0x18, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00,
  0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x00, 0x0E, 0x70, 0x01, 0xC7, 0x00,
  0x1C, 0x70, 0x03, 0x87, 0x00, 0x38, 0xF8, 0x07, 0x0F, 0x80, 0xF0, 0xCC,
  0x1E, 0x0C, 0xFF, 0xC0, 0xC7, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x18, 0x00,
  0x7F, 0xC0, 0xFF, 0xC0, 0xF0, 0x20, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x18, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0xC1, 0x80, 0x1F, 0xE3,
  0x00, 0x7F, 0xEE, 0x01, 0xE0, 0xDC, 0x07, 0x80, 0xF8, 0x0E, 0x01, 0xE0,
  0x38, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0,
  0x03, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00,
  0xF0, 0x30, 0x01, 0xC0, 0x60, 0x03, 0x80, 0xE0, 0x0F, 0x01, 0xC0, 0x3E,
  0x03, 0x80, 0x7C, 0x07, 0x01, 0xB0, 0x07, 0x06, 0x60, 0x0F, 0xF8, 0xC0,
  0x0F, 0xE3, 0x80, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x00, 0xFF,
  0xC0, 0xF0, 0x70, 0xF0, 0x38, 0x70, 0x1C, 0x70, 0x0E, 0x70, 0x07, 0x38,
  0x03, 0x98, 0x03, 0x9C, 0x01, 0xCE, 0x03, 0xC6, 0x07, 0xC7, 0xFF, 0x83,
  0xFF, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x0C, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0xF2, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x06, 0x00, 0x00, 0x9E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xFE, 0x30, 0x0F,
  0xFC, 0xC0, 0x78, 0x37, 0x03, 0xC0, 0x7C, 0x0E, 0x01, 0xE0, 0x70, 0x03,
  0x81, 0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x07,
  0x00, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x06, 0x0E, 0x00,
  0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x0C, 0x00, 0x70,
  0x30, 0x03, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x7C, 0x0E, 0x01, 0xF0, 0x38,
  0x0D, 0x80, 0x70, 0x66, 0x01, 0xFF, 0x38, 0x03, 0xF8, 0xE0, 0x01, 0x03,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x80, 0x3C, 0x03, 0x83,
  0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x83, 0x00,
  0x73, 0xFC, 0x0E, 0xFF, 0xC1, 0xB8, 0x38, 0x3E, 0x07, 0x0F, 0x80, 0x61,
  0xE0, 0x0C, 0x38, 0x01, 0x87, 0x00, 0x71, 0xE0, 0x0E, 0x38, 0x01, 0xC7,
  0x00, 0x38, 0xE0, 0x06, 0x18, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x18, 0x60, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70,
  0x03, 0x0C, 0x00, 0x61, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0,
  0x0C, 0x30, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x3C, 0x07, 0x01, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x08, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0xF0, 0x70, 0x1E, 0x06, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x07,
  0x00, 0xE0, 0xE0, 0x0E, 0x1C, 0x00, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC7,
  0x00, 0x1C, 0xE0, 0x01, 0x9E, 0x00, 0x1B, 0xE0, 0x03, 0xFE, 0x00, 0x3E,
  0x70, 0x03, 0xC7, 0x00, 0x38, 0x70, 0x03, 0x07, 0x00, 0x70, 0x38, 0x07,
  0x03, 0x80, 0x70, 0x38, 0x06, 0x03, 0x80, 0x60, 0x1C, 0x0E, 0x01, 0xC0,
  0xE0, 0x1C, 0x0E, 0x00, 0xC0, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x30, 0x00, 0x01, 0x06, 0x00, 0x40, 0x0C, 0x7F, 0x07, 0xF0, 0x19, 0xFF,
  0x1F, 0xF0, 0x37, 0x0E, 0x70, 0xF0, 0x78, 0x0F, 0x80, 0xE1, 0xE0, 0x1E,
  0x01, 0xC3, 0xC0, 0x3C, 0x03, 0x87, 0x00, 0x70, 0x07, 0x0E, 0x00, 0xE0,
  0x0E, 0x38, 0x01, 0x80, 0x18, 0x70, 0x07, 0x00, 0x70, 0xE0, 0x0E, 0x00,
  0xE1, 0xC0, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0x03, 0x8E, 0x00, 0x60, 0x06,
  0x1C, 0x01, 0xC0, 0x1C, 0x38, 0x03, 0x80, 0x38, 0x70, 0x07, 0x00, 0x70,
  0xC0, 0x0C, 0x00, 0xE3, 0x80, 0x18, 0x01, 0x87, 0x00, 0x70, 0x07, 0x0E,
  0x00, 0xE0, 0x0E, 0x18, 0x01, 0xC0, 0x1C, 0x70, 0x03, 0x00, 0x30, 0xE0,
  0x0E, 0x00, 0x61, 0xC0, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x03, 0x86, 0x00,
  0x70, 0x07, 0x00, 0x01, 0x07, 0x00, 0xC7, 0xF8, 0x19, 0xFF, 0x83, 0x70,
  0x70, 0xFC, 0x0E, 0x1F, 0x00, 0xC3, 0xC0, 0x18, 0x70, 0x03, 0x0E, 0x00,
  0xE3, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x30, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x30, 0xC0, 0x0E,
  0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x06, 0x18, 0x01, 0xC7, 0x00, 0x38,
  0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x18, 0x60, 0x07, 0x00, 0x00, 0x30,
  0x00, 0x1F, 0xC0, 0x0F, 0xFE, 0x03, 0xC1, 0xC0, 0xF0, 0x1C, 0x1C, 0x03,
  0x87, 0x00, 0x31, 0xC0, 0x06, 0x38, 0x00, 0xE7, 0x00, 0x1D, 0xC0, 0x03,
  0xB8, 0x00, 0x67, 0x00, 0x0D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E,
  0xE0, 0x01, 0xDC, 0x00, 0x73, 0x80, 0x0E, 0x60, 0x01, 0xCC, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x03, 0x87, 0x00, 0x70, 0x70, 0x1C, 0x0F, 0x0F, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xC7,
  0xF0, 0x03, 0x3F, 0xF0, 0x06, 0xE0, 0xE0, 0x0D, 0x80, 0xE0, 0x3E, 0x01,
  0xC0, 0x78, 0x03, 0x80, 0xF0, 0x07, 0x01, 0xC0, 0x0E, 0x07, 0x80, 0x1C,
  0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x60, 0x01, 0xC1,
  0xC0, 0x03, 0x83, 0x80, 0x06, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x18,
  0x00, 0x70, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x0E, 0x03, 0x80,
  0x1C, 0x07, 0x80, 0x70, 0x1F, 0x01, 0xE0, 0x3B, 0x07, 0x80, 0x77, 0xFE,
  0x00, 0xC7, 0xF0, 0x03, 0x81, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xE3, 0x03, 0xFF, 0x30, 0x78, 0x37,
  0x0F, 0x01, 0xF0, 0xE0, 0x1E, 0x1C, 0x01, 0xE1, 0xC0, 0x0E, 0x38, 0x00,
  0xE3, 0x80, 0x0E, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x01, 0xCE, 0x00,
  0x1C, 0xE0, 0x01, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0,
  0x07, 0x8C, 0x00, 0x70, 0xC0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x1F, 0x0E,
  0x01, 0xF0, 0xE0, 0x36, 0x07, 0x06, 0xE0, 0x7F, 0xCE, 0x03, 0xF8, 0xE0,
  0x04, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x06, 0x06, 0x3F, 0x06, 0x7F,
  0x06, 0xE0, 0x06, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x38, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xE0, 0x60, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x80, 0x38, 0x60, 0x78, 0x3F, 0xFC, 0x1F,
  0xF8, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00,
  0x60, 0x0E, 0x07, 0xFF, 0x7F, 0xE0, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0E, 0x00, 0xFE, 0x07, 0xE0, 0x10, 0x00, 0x0E, 0x00, 0x70,
  0xE0, 0x06, 0x0C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0C,
  0x18, 0x01, 0xC1, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01,
  0x83, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00,
  0x30, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0,
  0x0E, 0x0E, 0x01, 0xE0, 0xE0, 0x3E, 0x0E, 0x03, 0xE0, 0xF0, 0xEC, 0x07,
  0xFC, 0xC0, 0x3F, 0x8C, 0x00, 0xC0, 0x00, 0xE0, 0x03, 0xF0, 0x03, 0xB8,
  0x01, 0xDC, 0x00, 0xCE, 0x00, 0xE7, 0x00, 0x63, 0x80, 0x71, 0xC0, 0x30,
  0xE0, 0x38, 0x70, 0x1C, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x07, 0x07,
  0x01, 0x87, 0x00, 0xC3, 0x80, 0x63, 0x80, 0x31, 0xC0, 0x19, 0xC0, 0x0C,
  0xE0, 0x06, 0x60, 0x03, 0x70, 0x01, 0xB0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0xE0, 0x0E,
  0xE0, 0x1E, 0x00, 0xEE, 0x01, 0xE0, 0x1C, 0xE0, 0x3E, 0x01, 0xCE, 0x03,
  0x60, 0x18, 0xE0, 0x36, 0x03, 0x8E, 0x07, 0x60, 0x30, 0xE0, 0x66, 0x07,
  0x0E, 0x0E, 0x60, 0x70, 0xE0, 0xC6, 0x0E, 0x0E, 0x1C, 0x60, 0xE0, 0xE1,
  0x86, 0x0C, 0x0E, 0x18, 0x61, 0xC0, 0xE3, 0x86, 0x18, 0x0E, 0x30, 0x63,
  0x80, 0xE7, 0x07, 0x38, 0x0E, 0x60, 0x73, 0x00, 0xEE, 0x07, 0x70, 0x0E,
  0xE0, 0x66, 0x00, 0xEC, 0x06, 0xE0, 0x0F, 0xC0, 0x6E, 0x00, 0xF8, 0x06,
  0xC0, 0x0F, 0x80, 0x7C, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00,
  0xF0, 0x07, 0x00, 0x00, 0x03, 0x80, 0x3C, 0x0E, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x07, 0x00, 0x0E, 0x38, 0x00,
  0x38, 0xE0, 0x00, 0xE7, 0x00, 0x01, 0xB8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xDC, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xC0, 0x01, 0xC3, 0x00, 0x0E,
  0x0E, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x38,
  0x00, 0xE0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0x60, 0x06, 0x00,
  0x18, 0x03, 0x80, 0x06, 0x00, 0xC0, 0x01, 0x80, 0x70, 0x00, 0x60, 0x1C,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x71, 0xC0, 0x00, 0x1C, 0x60, 0x00, 0x07, 0x38, 0x00, 0x00, 0xCC, 0x00,
  0x00, 0x37, 0x00, 0x00, 0x0D, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x8F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x40, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0xFE,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0F, 0xC0, 0x0F,
  0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x13, 0xFC, 0x01, 0x7F, 0xF0, 0x3E,
  0x07, 0xFF, 0x80, 0x1F, 0xE8, 0x00, 0x38,
};

const GFXglyph NotoSans_Condensed_LightItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 36, 11, 1, -36 },
  { 51, 13, 13, 16, 5, -36 },
  { 73, 24, 36, 24, 1, -36 },
  { 181, 22, 42, 21, 0, -39 },
  { 297, 27, 38, 32, 3, -37 },
  { 426, 23, 38, 24, 0, -37 },
  { 536, 6, 13, 9, 5, -36 },
  { 546, 15, 44, 13, 1, -36 },
  { 629, 15, 44, 13, -4, -36 },
  { 712, 16, 18, 20, 6, -39 },
  { 748, 20, 24, 24, 2, -30 },
  { 808, 8, 12, 10, -2, -5 },
  { 820, 12, 3, 14, 1, -15 },
  { 825, 4, 5, 10, 1, -5 },
  { 828, 22, 36, 16, -2, -36 },
  { 927, 19, 38, 22, 2, -37 },
  { 1018, 12, 36, 22, 6, -36 },
  { 1072, 22, 37, 22, -1, -37 },
  { 1174, 21, 38, 22, 0, -37 },
  { 1274, 22, 37, 22, -1, -37 },
  { 1376, 22, 37, 22, 0, -36 },
  { 1478, 20, 38, 22, 2, -37 },
  { 1573, 20, 36, 22, 3, -36 },
  { 1663, 22, 38, 22, 0, -37 },
  { 1768, 20, 38, 22, 1, -37 },
  { 1863, 9, 27, 10, 0, -27 },
  { 1894, 11, 34, 10, -2, -27 },
  { 1941, 20, 22, 24, 2, -29 },
  { 1996, 20, 14, 24, 2, -25 },
  { 2031, 20, 22, 24, 2, -29 },
  { 2086, 16, 37, 16, 2, -37 },
  { 2160, 30, 41, 32, 2, -37 },
  { 2314, 21, 37, 22, -3, -37 },
  { 2412, 23, 36, 24, 1, -36 },
  { 2516, 23, 38, 22, 2, -37 },
  { 2626, 24, 36, 26, 1, -36 },
  { 2734, 22, 36, 21, 1, -36 },
  { 2833, 22, 36, 19, 1, -36 },
  { 2932, 26, 38, 27, 2, -37 },
  { 3056, 27, 36, 27, 1, -36 },
  { 3178, 17, 36, 12, -2, -36 },
  { 3255, 19, 45, 10, -8, -36 },
  { 3362, 25, 36, 22, 1, -36 },
  { 3475, 14, 36, 19, 1, -36 },
  { 3538, 34, 36, 35, 1, -36 },
  { 3691, 28, 36, 28, 1, -36 },
  { 3817, 25, 38, 28, 2, -37 },
  { 3936, 22, 36, 22, 1, -36 },
  { 4035, 25, 46, 28, 2, -37 },
  { 4179, 22, 36, 22, 1, -36 },
  { 4278, 23, 38, 20, -1, -37 },
  { 4388, 19, 36, 19, 4, -36 },
  { 4474, 25, 37, 26, 2, -36 },
  { 4590, 21, 36, 22, 5, -36 },
  { 4685, 34, 36, 35, 5, -36 },
  { 4838, 27, 36, 20, -3, -36 },
  { 4960, 20, 36, 19, 4, -36 },
  { 5050, 24, 36, 20, -2, -36 },
  { 5158, 19, 45, 14, -1, -37 },
  { 5265, 8, 36, 17, 5, -36 },
  { 5301, 18, 45, 14, -3, -37 },
  { 5403, 21, 19, 23, 1, -36 },
  { 5453, 16, 2, 16, -4, 5 },
  { 5457, 7, 8, 12, 7, -39 },
  { 5464, 20, 29, 23, 2, -28 },
  { 5537, 20, 40, 23, 1, -39 },
  { 5637, 17, 29, 17, 2, -28 },
  { 5699, 23, 40, 23, 2, -39 },
  { 5814, 17, 29, 20, 2, -28 },
  { 5876, 24, 51, 12, -6, -39 },
  { 6029, 22, 40, 23, 0, -28 },
  { 6139, 19, 39, 22, 1, -39 },
  { 6232, 10, 37, 10, 1, -37 },
  { 6279, 18, 49, 10, -7, -37 },
  { 6390, 20, 39, 19, 1, -39 },
  { 6488, 11, 39, 10, 1, -39 },
  { 6542, 31, 28, 34, 1, -28 },
  { 6651, 19, 28, 22, 1, -28 },
  { 6718, 19, 29, 22, 2, -28 },
  { 6787, 23, 40, 23, -2, -28 },
  { 6902, 20, 40, 23, 2, -28 },
  { 7002, 16, 28, 15, 1, -28 },
  { 7058, 17, 29, 17, 0, -28 },
  { 7120, 12, 35, 12, 2, -34 },
  { 7173, 20, 28, 22, 2, -27 },
  { 7243, 17, 27, 18, 3, -27 },
  { 7301, 28, 27, 28, 3, -27 },
  { 7396, 22, 27, 18, -2, -27 },
  { 7471, 26, 39, 18, -5, -27 },
  { 7598, 18, 27, 16, -1, -27 },
  { 7659, 19, 44, 17, 1, -36 },
  { 7764, 2, 51, 21, 10, -39 },
  { 7777, 18, 44, 17, -3, -36 },
  { 7876, 20, 6, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_LightItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC51PT7B_H_
