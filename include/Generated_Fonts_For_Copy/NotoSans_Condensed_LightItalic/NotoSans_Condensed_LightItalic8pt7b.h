#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC8PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0xA0, 0xE0, 0x35, 0x66, 0xAC, 0x29, 0x17, 0x80, 0x4D, 0xAA,
  0xF6, 0xB8, 0x26, 0x4D, 0xAE, 0xC0, 0x2A, 0x49, 0x20, 0x24, 0x92, 0xB0,
  0x74, 0x4B, 0xA0, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x2E, 0xDB, 0x80,
  0x76, 0xA0, 0x64, 0x95, 0xC0, 0x64, 0xB3, 0xC0, 0x25, 0xDE, 0x80, 0x6B,
  0x13, 0xC0, 0x2B, 0xDB, 0xC0, 0x72, 0x24, 0x48, 0x6D, 0xDB, 0xC0, 0x76,
  0xB3, 0x80, 0x10, 0x18, 0x2B, 0x10, 0xFC, 0x8C, 0xE0, 0x65, 0x29, 0x00,
  0x32, 0x6F, 0xBF, 0xC1, 0x80, 0x11, 0x37, 0x59, 0x65, 0x5A, 0xAE, 0x34,
  0x88, 0x86, 0x65, 0x59, 0x9E, 0x74, 0x4A, 0x8C, 0x74, 0x4A, 0x88, 0x34,
  0x8B, 0x97, 0x55, 0x5B, 0x9A, 0x56, 0xA0, 0x24, 0xA4, 0xB0, 0x56, 0x4C,
  0xAA, 0x56, 0xB0, 0x45, 0x25, 0xB6, 0xAA, 0xA0, 0x55, 0x5B, 0xB9, 0x35,
  0x99, 0x9E, 0x65, 0x56, 0x88, 0x35, 0x99, 0x9E, 0x20, 0x65, 0x56, 0xAA,
  0x71, 0x13, 0xC0, 0xF2, 0x49, 0x00, 0x55, 0x59, 0x9E, 0xB7, 0x69, 0x00,
  0xAD, 0x7D, 0x6A, 0x50, 0x56, 0x44, 0xAA, 0xBA, 0x49, 0x00, 0x72, 0x24,
  0x8C, 0x69, 0x49, 0x20, 0xFC, 0x24, 0x92, 0x70, 0x2E, 0x80, 0xE0, 0x80,
  0x76, 0xF0, 0x49, 0xDB, 0xC0, 0x72, 0x70, 0x13, 0x5A, 0xAE, 0x7E, 0x70,
  0x36, 0x24, 0x44, 0x48, 0x7A, 0xAE, 0x2C, 0x49, 0xDB, 0x40, 0x46, 0xA0,
  0x20, 0xA4, 0x94, 0x49, 0xAD, 0x40, 0x56, 0xA0, 0x7D, 0x6B, 0x50, 0x76,
  0xD0, 0x76, 0xF0, 0x76, 0xF9, 0x00, 0x7A, 0xAE, 0x22, 0x72, 0x40, 0xF1,
  0x60, 0xDA, 0x80, 0x76, 0xF0, 0xB5, 0x40, 0xAF, 0x95, 0x40, 0x69, 0x60,
  0x55, 0x22, 0x48, 0x6A, 0x60, 0x29, 0x65, 0x30, 0xFF, 0x55, 0x68, 0xE0,
};

const GFXglyph NotoSans_Condensed_LightItalic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 6, 2, 0, -6 },
  { 3, 2, 2, 3, 1, -6 },
  { 4, 4, 6, 4, 0, -6 },
  { 7, 3, 6, 3, 0, -6 },
  { 10, 5, 6, 5, 0, -6 },
  { 14, 4, 6, 4, 0, -6 },
  { 17, 1, 2, 1, 1, -6 },
  { 18, 3, 7, 2, 0, -6 },
  { 21, 3, 7, 2, -1, -6 },
  { 24, 2, 3, 3, 1, -6 },
  { 25, 3, 4, 4, 0, -5 },
  { 27, 1, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -3 },
  { 29, 1, 1, 2, 0, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 3, 6, 3, 0, -6 },
  { 36, 2, 6, 3, 1, -6 },
  { 38, 3, 6, 3, 0, -6 },
  { 41, 3, 6, 3, 0, -6 },
  { 44, 3, 6, 3, 0, -6 },
  { 47, 3, 6, 3, 0, -6 },
  { 50, 3, 6, 3, 0, -6 },
  { 53, 4, 6, 3, 0, -6 },
  { 56, 3, 6, 3, 0, -6 },
  { 59, 3, 6, 3, 0, -6 },
  { 62, 1, 4, 2, 0, -4 },
  { 63, 1, 5, 2, 0, -4 },
  { 64, 3, 4, 4, 0, -5 },
  { 66, 3, 2, 4, 0, -4 },
  { 67, 3, 4, 4, 0, -5 },
  { 69, 3, 6, 2, 0, -6 },
  { 72, 5, 7, 5, 0, -6 },
  { 77, 4, 6, 3, -1, -6 },
  { 80, 4, 6, 4, 0, -6 },
  { 83, 4, 6, 3, 0, -6 },
  { 86, 4, 6, 4, 0, -6 },
  { 89, 4, 6, 3, 0, -6 },
  { 92, 4, 6, 3, 0, -6 },
  { 95, 4, 6, 4, 0, -6 },
  { 98, 4, 6, 4, 0, -6 },
  { 101, 2, 6, 2, 0, -6 },
  { 103, 3, 7, 2, -1, -6 },
  { 106, 4, 6, 3, 0, -6 },
  { 109, 2, 6, 3, 0, -6 },
  { 111, 6, 6, 5, 0, -6 },
  { 116, 4, 6, 4, 0, -6 },
  { 119, 4, 6, 4, 0, -6 },
  { 122, 4, 6, 3, 0, -6 },
  { 125, 4, 7, 4, 0, -6 },
  { 129, 4, 6, 4, 0, -6 },
  { 132, 3, 6, 3, 0, -6 },
  { 135, 3, 6, 3, 1, -6 },
  { 138, 4, 6, 4, 0, -6 },
  { 141, 3, 6, 3, 1, -6 },
  { 144, 5, 6, 6, 1, -6 },
  { 148, 4, 6, 3, 0, -6 },
  { 151, 3, 6, 3, 1, -6 },
  { 154, 4, 6, 3, 0, -6 },
  { 157, 3, 7, 2, 0, -6 },
  { 160, 1, 6, 3, 1, -6 },
  { 161, 3, 7, 2, -1, -6 },
  { 164, 3, 3, 4, 0, -6 },
  { 166, 3, 1, 3, -1, 0 },
  { 167, 1, 1, 2, 1, -6 },
  { 168, 3, 4, 4, 0, -4 },
  { 170, 3, 6, 4, 0, -6 },
  { 173, 3, 4, 3, 0, -4 },
  { 175, 4, 6, 4, 0, -6 },
  { 178, 3, 4, 3, 0, -4 },
  { 180, 4, 8, 2, -1, -6 },
  { 184, 4, 6, 4, 0, -4 },
  { 187, 3, 6, 4, 0, -6 },
  { 190, 2, 6, 2, 0, -6 },
  { 192, 3, 8, 2, -1, -6 },
  { 195, 3, 6, 3, 0, -6 },
  { 198, 2, 6, 2, 0, -6 },
  { 200, 5, 4, 5, 0, -4 },
  { 203, 3, 4, 4, 0, -4 },
  { 205, 3, 4, 4, 0, -4 },
  { 207, 3, 6, 4, 0, -4 },
  { 210, 4, 6, 4, 0, -4 },
  { 213, 3, 4, 2, 0, -4 },
  { 215, 3, 4, 3, 0, -4 },
  { 217, 2, 5, 2, 0, -5 },
  { 219, 3, 4, 4, 0, -4 },
  { 221, 3, 4, 3, 0, -4 },
  { 223, 5, 4, 4, 0, -4 },
  { 226, 3, 4, 3, 0, -4 },
  { 228, 4, 6, 3, -1, -4 },
  { 231, 3, 4, 3, 0, -4 },
  { 233, 3, 7, 3, 0, -6 },
  { 236, 1, 8, 3, 1, -6 },
  { 237, 2, 7, 3, 0, -6 },
  { 239, 3, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_LightItalic8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC8PT7B_H_
