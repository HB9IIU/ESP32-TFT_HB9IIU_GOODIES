#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC66PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC66PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic66pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x00,
  0x3C, 0x0F, 0x3C, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x1C,
  0x78, 0x1C, 0x78, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38,
  0xE0, 0x38, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x70, 0xC0, 0x70, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0,
  0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x38,
  0x00, 0x03, 0x80, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C,
  0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03,
  0x80, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0x18, 0x38, 0x07,
  0x83, 0x01, 0x01, 0xE0, 0x60, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03, 0x80,
  0x00, 0xE0, 0x60, 0x00, 0x3C, 0x0C, 0x00, 0x07, 0x81, 0x80, 0x00, 0xF0,
  0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0x80, 0x00, 0x3C, 0x30, 0x00,
  0x03, 0xC6, 0x00, 0x00, 0x7D, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x19, 0xE0, 0x00, 0x03, 0x1E, 0x00, 0x00, 0xE1,
  0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x03, 0x80, 0x00, 0x60, 0x70, 0x00,
  0x0C, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x60, 0x38, 0x00, 0x0C, 0x07,
  0x00, 0x01, 0x81, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x0E, 0x0F, 0x03, 0x01,
  0x87, 0xC0, 0x7C, 0x33, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x3F, 0x80, 0x00,
  0xE0, 0x0F, 0xF8, 0x00, 0x3C, 0x03, 0xC7, 0x80, 0x07, 0x00, 0xF0, 0x70,
  0x01, 0xC0, 0x1C, 0x0E, 0x00, 0x38, 0x07, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x38, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x70, 0x1C,
  0x00, 0xE0, 0x0E, 0x07, 0x00, 0x1C, 0x01, 0xC1, 0xE0, 0x07, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0x0E, 0x0F, 0x00, 0x1C, 0x01, 0xC1, 0xC0, 0x03, 0x80,
  0x38, 0x70, 0x00, 0x70, 0x0E, 0x0E, 0x0F, 0x0E, 0x01, 0xC3, 0x87, 0xF9,
  0xC0, 0x38, 0xF1, 0xFF, 0xB8, 0x0E, 0x1C, 0x78, 0x77, 0x01, 0xC7, 0x0E,
  0x0F, 0xE0, 0x70, 0xE3, 0x80, 0xFC, 0x1E, 0x38, 0x70, 0x1F, 0xC7, 0x87,
  0x1C, 0x03, 0xBF, 0xE1, 0xC3, 0x80, 0x73, 0xF8, 0x78, 0xF0, 0x0E, 0x1C,
  0x0E, 0x1C, 0x01, 0xC0, 0x03, 0x83, 0x80, 0x38, 0x00, 0x70, 0x70, 0x0E,
  0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x07, 0x83, 0x80, 0x38, 0x00, 0xE0, 0x70,
  0x07, 0x00, 0x3C, 0x0E, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x38, 0x01, 0xC0,
  0x78, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x38,
  0x03, 0x80, 0x1E, 0x07, 0x00, 0xE0, 0x01, 0xC1, 0xC0, 0x1C, 0x00, 0x3C,
  0x78, 0x07, 0x00, 0x03, 0xFE, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x03, 0x80,
  0x03, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xBC,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x70, 0xF0, 0x3C, 0x07,
  0x8F, 0x01, 0xE0, 0x38, 0x78, 0x07, 0x83, 0xC7, 0x80, 0x3C, 0x1E, 0x38,
  0x00, 0xF0, 0xE3, 0xC0, 0x07, 0x8F, 0x1E, 0x00, 0x1C, 0x70, 0xE0, 0x00,
  0xF7, 0x87, 0x00, 0x07, 0xF8, 0x78, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0xFC,
  0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3E, 0x03, 0x80, 0x03, 0xF0, 0x1E,
  0x00, 0x3F, 0xC0, 0xF0, 0x03, 0xDE, 0x07, 0xC0, 0x3C, 0x78, 0x1F, 0xFF,
  0xC3, 0xC0, 0x7F, 0xFC, 0x0F, 0x01, 0xFF, 0x80, 0x78, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x78, 0xF1, 0xE3, 0x87, 0x0E, 0x3C, 0x70, 0xE1, 0xC3, 0x8E,
  0x1C, 0x38, 0x70, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x01, 0x00, 0xE0, 0x07,
  0x03, 0x80, 0x3F, 0x0E, 0x00, 0x3F, 0x30, 0x04, 0x3F, 0xC7, 0xE0, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xF0, 0x00, 0x07, 0x60, 0x00, 0x39, 0xC0,
  0x01, 0xC7, 0x00, 0x1E, 0x0E, 0x00, 0xF0, 0x38, 0x07, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x10, 0x07, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3B, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x07, 0xC0, 0xF0, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x0F,
  0x01, 0xC0, 0x03, 0x81, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xF0, 0x00,
  0x70, 0x70, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x1C, 0x00,
  0x07, 0x1E, 0x00, 0x03, 0x8F, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCE,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79,
  0xE0, 0x00, 0x38, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x01, 0xC0, 0xF0, 0x01, 0xE0, 0x38, 0x01, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x7C, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xF7, 0x87, 0xCF, 0x1F, 0x1E,
  0x7C, 0x39, 0xE0, 0xF1, 0x81, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFD, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0x00, 0x1F, 0x00,
  0x20, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x0F, 0xFB, 0xFC, 0x00, 0xF8, 0x07, 0xC0, 0x0E, 0x00, 0x1E, 0x00,
  0x40, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x08, 0x00, 0x1F, 0x00,
  0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x1D, 0xE0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x70, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1E, 0x00,
  0xF0, 0x01, 0xC0, 0x1E, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x02,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x80, 0x01, 0xF0,
  0x0E, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF8, 0xE0, 0x01, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x0F,
  0xE0, 0x01, 0xC7, 0xFF, 0x00, 0x79, 0xFF, 0xF0, 0x0F, 0x78, 0x1F, 0x01,
  0xDC, 0x01, 0xE0, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xC1, 0xF0, 0x00,
  0x78, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x07, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x78,
  0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x3C, 0x03,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x01, 0xE0,
  0x0E, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0x9F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x80, 0x3C,
  0x01, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x07,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x03, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xFE, 0xFF, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x34, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFC, 0xFC,
  0x00, 0xF8, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x38, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1C,
  0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x3C,
  0x38, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00,
  0x3C, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0xE0,
  0x00, 0xF8, 0x3C, 0x00, 0x7E, 0x0F, 0x00, 0x3F, 0x83, 0xE0, 0x1D, 0xC0,
  0x7C, 0x1F, 0x70, 0x0F, 0xFF, 0x9C, 0x01, 0xFF, 0x8F, 0x00, 0x3F, 0x83,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x80, 0x3E,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xDF, 0xE0, 0x60, 0x1F, 0x02, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x01, 0xFE, 0x01, 0xC1,
  0xC0, 0x0F, 0xFE, 0x03, 0x83, 0x80, 0x3F, 0xFC, 0x07, 0x0E, 0x00, 0xF0,
  0x38, 0x0E, 0x1C, 0x03, 0xC0, 0xE0, 0x1C, 0x70, 0x0F, 0x01, 0xC0, 0x38,
  0xE0, 0x1C, 0x03, 0x80, 0x71, 0xC0, 0x70, 0x07, 0x01, 0xC7, 0x00, 0xE0,
  0x1C, 0x03, 0x8E, 0x03, 0x80, 0x38, 0x07, 0x1C, 0x07, 0x00, 0x70, 0x0E,
  0x70, 0x1E, 0x00, 0xE0, 0x1C, 0xE0, 0x38, 0x03, 0x80, 0x39, 0xC0, 0x70,
  0x07, 0x00, 0xE3, 0x80, 0xE0, 0x0E, 0x01, 0xC7, 0x03, 0x80, 0x3C, 0x03,
  0x8E, 0x07, 0x00, 0x70, 0x0E, 0x38, 0x0E, 0x00, 0xE0, 0x1C, 0x70, 0x1C,
  0x03, 0xC0, 0x78, 0xE0, 0x38, 0x07, 0x80, 0xE1, 0xC0, 0x70, 0x1F, 0x03,
  0xC3, 0x80, 0xE0, 0x3E, 0x07, 0x07, 0x01, 0xE0, 0xCC, 0x1C, 0x0E, 0x01,
  0xE3, 0x9C, 0x78, 0x1C, 0x03, 0xFE, 0x3F, 0xE0, 0x38, 0x03, 0xF8, 0x3F,
  0x00, 0x78, 0x00, 0x80, 0x18, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01,
  0x00, 0x00, 0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x1E, 0x00, 0x3C,
  0x01, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xE0, 0x00, 0xE0, 0x1E,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0xE0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x0E, 0x0F,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xF0, 0x0F, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x38, 0x00, 0x7C, 0x01, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x38, 0x07, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x1F, 0x00, 0x38, 0x07, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0x00,
  0x3E, 0x00, 0x38, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E, 0x07, 0x00,
  0x00, 0xF0, 0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x03,
  0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x3F, 0x00, 0xE0, 0x0F, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFE,
  0xFE, 0x00, 0x1F, 0x80, 0x10, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x30, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xC0, 0x7F, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x0E, 0x00,
  0x1F, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x7C, 0x07, 0x80, 0x01, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x7E, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xE0,
  0x03, 0x81, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x02, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xBF, 0xF0, 0x01, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x18,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x3F, 0xF8, 0x38, 0x00, 0x1F, 0xFC, 0x1C, 0x00,
  0x1F, 0xFE, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x07, 0x80,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0xE0, 0x03, 0xE0, 0x00, 0x70,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x00, 0x38, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x78, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x0F, 0x00,
  0x00, 0x38, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x87, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x07, 0x80, 0x01, 0xC0,
  0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78,
  0x07, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x07, 0x03, 0xE0, 0x00, 0x03,
  0x83, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x71, 0xF0, 0x00, 0x00, 0x39, 0xF0, 0x00, 0x00,
  0x3C, 0xF8, 0x00, 0x00, 0x1E, 0xFC, 0x00, 0x00, 0x0F, 0xEE, 0x00, 0x00,
  0x07, 0xE7, 0x80, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x01, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0x78, 0x07, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xE0, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x01, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x1F, 0xE0, 0x00, 0x03, 0xDC,
  0x00, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x07, 0x78, 0x00, 0x01, 0xEF, 0x00,
  0x39, 0xC0, 0x00, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x1E,
  0x70, 0x00, 0x07, 0x3C, 0x00, 0xF3, 0x80, 0x00, 0x79, 0xE0, 0x07, 0x1C,
  0x00, 0x03, 0x8F, 0x00, 0x38, 0xE0, 0x00, 0x3C, 0x70, 0x03, 0xC7, 0x00,
  0x01, 0xC3, 0x80, 0x1E, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0xE1, 0xC0, 0x00,
  0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x38, 0x78, 0x00, 0x70,
  0x70, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x38, 0x3C,
  0x00, 0xE0, 0x70, 0x03, 0xC1, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00,
  0x78, 0x1C, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0xE0, 0x0E, 0x07, 0x80, 0x1E,
  0x07, 0x00, 0xF0, 0x3C, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x07, 0x01,
  0xC0, 0x78, 0x0E, 0x00, 0x78, 0x0E, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x70,
  0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC1, 0xC0, 0x3C, 0x00, 0xE0, 0x1E, 0x1E,
  0x01, 0xE0, 0x07, 0x00, 0xF0, 0xE0, 0x0E, 0x00, 0x78, 0x07, 0x8F, 0x00,
  0x70, 0x03, 0xC0, 0x1C, 0x70, 0x07, 0x80, 0x1C, 0x00, 0xE7, 0x80, 0x3C,
  0x00, 0xE0, 0x07, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x3B, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xDC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x7E, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x0F, 0x00,
  0x1F, 0x00, 0x0E, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x7E,
  0x00, 0x00, 0xE0, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x01, 0xE0,
  0x0F, 0xF0, 0x00, 0x1C, 0x00, 0xE7, 0x00, 0x01, 0xC0, 0x0E, 0x70, 0x00,
  0x3C, 0x00, 0xE7, 0x80, 0x03, 0xC0, 0x1E, 0x78, 0x00, 0x3C, 0x01, 0xE3,
  0x80, 0x03, 0x80, 0x1E, 0x38, 0x00, 0x38, 0x01, 0xC3, 0xC0, 0x07, 0x80,
  0x1C, 0x3C, 0x00, 0x78, 0x03, 0xC1, 0xC0, 0x07, 0x80, 0x3C, 0x1C, 0x00,
  0x70, 0x03, 0x81, 0xE0, 0x07, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x03, 0x80,
  0xE0, 0x0F, 0x00, 0x78, 0x0E, 0x00, 0xE0, 0x07, 0x80, 0xF0, 0x0E, 0x00,
  0x70, 0x0F, 0x01, 0xE0, 0x07, 0x00, 0x70, 0x1E, 0x00, 0xF0, 0x07, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x07, 0x81, 0xC0, 0x0E, 0x00,
  0x38, 0x3C, 0x00, 0xE0, 0x03, 0x83, 0xC0, 0x1E, 0x00, 0x38, 0x3C, 0x01,
  0xE0, 0x03, 0xC3, 0x80, 0x1E, 0x00, 0x1C, 0x38, 0x01, 0xC0, 0x01, 0xC7,
  0x80, 0x1C, 0x00, 0x1C, 0x78, 0x03, 0xC0, 0x01, 0xE7, 0x00, 0x3C, 0x00,
  0x1E, 0x70, 0x03, 0x80, 0x00, 0xE7, 0x00, 0x38, 0x00, 0x0E, 0xF0, 0x03,
  0x80, 0x00, 0xFF, 0x00, 0x78, 0x00, 0x0F, 0xE0, 0x07, 0x80, 0x00, 0x7E,
  0x00, 0x70, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x00,
  0x07, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0x7F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x3E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x00, 0xE1, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0x80, 0xFC,
  0x00, 0x78, 0x03, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xF0, 0x0F,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x70, 0x1E, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xC0,
  0x78, 0x00, 0x78, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x03,
  0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00,
  0x0E, 0x3C, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x79,
  0xC0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x0F,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0x80, 0xFC, 0x00, 0x78,
  0x03, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x1E,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0xF0, 0x1C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x1E, 0x03,
  0xC0, 0x03, 0xE0, 0x38, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x80, 0x78, 0x00,
  0xF8, 0x07, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00,
  0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x78,
  0x03, 0x80, 0x07, 0x80, 0x78, 0x00, 0x78, 0x07, 0x80, 0x03, 0x80, 0x78,
  0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0x00,
  0x3E, 0x00, 0x08, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x01, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x3F, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78,
  0x0E, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x78, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x78, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0x80, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x1C,
  0x01, 0xC0, 0x07, 0x80, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x01, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x0F, 0x00,
  0x0E, 0x01, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0xE0, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0xF0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x80, 0x01,
  0xE3, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0xE0, 0x00, 0x70,
  0xF0, 0x00, 0x77, 0x00, 0x07, 0x87, 0x80, 0x03, 0xB8, 0x00, 0x3C, 0x3C,
  0x00, 0x3D, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xCE, 0x00, 0x1E, 0x0F, 0x00,
  0x1E, 0x70, 0x00, 0xE0, 0x78, 0x00, 0xE3, 0x80, 0x0F, 0x03, 0xC0, 0x07,
  0x1C, 0x00, 0x70, 0x1E, 0x00, 0x70, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0x87,
  0x00, 0x3C, 0x07, 0x80, 0x3C, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC1, 0xC0,
  0x1E, 0x01, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x70, 0x0F,
  0x00, 0x78, 0x07, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x78, 0x1C, 0x07, 0x80,
  0x1E, 0x03, 0x80, 0xE0, 0x3C, 0x00, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x07,
  0x81, 0xC0, 0x38, 0x1E, 0x00, 0x3C, 0x0E, 0x01, 0xC0, 0xE0, 0x01, 0xE0,
  0xF0, 0x0E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x70, 0x78, 0x00, 0x78, 0x78,
  0x03, 0x83, 0x80, 0x03, 0xC3, 0x80, 0x1C, 0x3C, 0x00, 0x1E, 0x1C, 0x00,
  0xE1, 0xC0, 0x00, 0xF1, 0xC0, 0x07, 0x1E, 0x00, 0x07, 0x8E, 0x00, 0x38,
  0xF0, 0x00, 0x3C, 0xF0, 0x01, 0xC7, 0x00, 0x01, 0xE7, 0x00, 0x0E, 0x78,
  0x00, 0x0F, 0x38, 0x00, 0x73, 0x80, 0x00, 0x7B, 0x80, 0x03, 0xBC, 0x00,
  0x03, 0xDC, 0x00, 0x1D, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xEE, 0x00, 0x00,
  0xEE, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1C, 0xE0, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x1C, 0x00,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0x70, 0x00, 0x78, 0x70, 0x00, 0x78, 0x70, 0x00, 0xF0,
  0x78, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xC0, 0x38, 0x03, 0xC0,
  0x38, 0x07, 0x80, 0x38, 0x07, 0x80, 0x38, 0x0F, 0x00, 0x3C, 0x0E, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x3C, 0x00, 0x1C, 0x78, 0x00,
  0x1C, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1E, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0x78, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x0F, 0x00, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0x78, 0x07, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0x80, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x07, 0x8E, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x39, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xF0, 0xF0, 0x78, 0x78, 0x38, 0x3C, 0x1C,
  0x0E, 0x0E, 0x07, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFC, 0x1C, 0x01, 0xFF,
  0xC7, 0x00, 0x7F, 0x7C, 0xE0, 0x1F, 0x01, 0xDC, 0x07, 0xC0, 0x1B, 0x80,
  0xF0, 0x03, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x78,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0E,
  0x0F, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x7C, 0x0F, 0x00, 0x0F, 0x80, 0xE0, 0x03, 0xF0, 0x1E, 0x00, 0xFE, 0x03,
  0xC0, 0x3B, 0x80, 0x7C, 0x0E, 0x70, 0x07, 0xEF, 0x8E, 0x00, 0x7F, 0xE1,
  0xC0, 0x07, 0xF8, 0x70, 0x00, 0x18, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x8F, 0xF8,
  0x01, 0xC7, 0xFF, 0x00, 0x73, 0xEF, 0xE0, 0x3D, 0xC0, 0x78, 0x0F, 0xE0,
  0x0F, 0x03, 0xB0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x7E, 0x00, 0x1C, 0x1F,
  0x00, 0x07, 0x07, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C,
  0x3C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xE0, 0x00,
  0x3C, 0x38, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xE1, 0xC0,
  0x00, 0x78, 0x70, 0x00, 0x1E, 0x1C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x07,
  0x87, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x1D, 0x80,
  0x3C, 0x0F, 0x70, 0x1F, 0x03, 0x9F, 0xBF, 0x80, 0xE3, 0xFF, 0xC0, 0x38,
  0x7F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xC0, 0x3F, 0x9E, 0x01, 0xF0, 0x08, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x01,
  0x00, 0xFF, 0x7C, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x07, 0xF8, 0x78,
  0x00, 0x7F, 0xF9, 0xE0, 0x03, 0xFB, 0xE7, 0x00, 0x1F, 0x01, 0xDC, 0x00,
  0xF8, 0x03, 0x70, 0x03, 0xC0, 0x0F, 0xC0, 0x1E, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x70, 0x0F, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x78, 0x07, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x03,
  0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xF8,
  0x01, 0xE0, 0x1D, 0xC0, 0x07, 0xC0, 0xE7, 0x00, 0x0F, 0xDF, 0x9C, 0x00,
  0x1F, 0xFC, 0x70, 0x00, 0x3F, 0xC1, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xE7, 0xE0,
  0x1F, 0x03, 0xC0, 0x78, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x70, 0xF0, 0x01, 0xE3, 0xC0,
  0x03, 0x87, 0x80, 0x0F, 0x0E, 0x00, 0x7C, 0x3C, 0x03, 0xF0, 0x78, 0x3F,
  0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xC0, 0x3F,
  0x1F, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x27,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xE1, 0xC0, 0x07,
  0xFF, 0x8E, 0x00, 0x7F, 0x7C, 0xE0, 0x07, 0xC0, 0x77, 0x00, 0x7C, 0x01,
  0xB8, 0x03, 0xC0, 0x0F, 0xC0, 0x3C, 0x00, 0x3E, 0x03, 0xC0, 0x01, 0xE0,
  0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xE0,
  0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0xF8, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0,
  0x1E, 0x00, 0x3F, 0x00, 0x70, 0x03, 0xF8, 0x03, 0xC0, 0x3B, 0x80, 0x1F,
  0x03, 0xDC, 0x00, 0x7F, 0xFC, 0xE0, 0x01, 0xFF, 0xCF, 0x00, 0x07, 0xF8,
  0x78, 0x00, 0x07, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x02, 0x00, 0x0F, 0x00, 0x18, 0x01, 0xF0, 0x00, 0xF8, 0x3F, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x03,
  0xC7, 0xFC, 0x01, 0xC7, 0xFF, 0x00, 0xE7, 0xFF, 0xC0, 0xF7, 0x01, 0xE0,
  0x7F, 0x00, 0xF0, 0x3F, 0x00, 0x38, 0x1F, 0x00, 0x1C, 0x0F, 0x00, 0x0E,
  0x0F, 0x80, 0x07, 0x07, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x38, 0x38, 0x00,
  0x3C, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x07, 0x80,
  0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xF0,
  0x00, 0x70, 0x78, 0x00, 0x38, 0x38, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x1E,
  0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x07, 0x83, 0x80, 0x03, 0xC3,
  0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x8F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x01,
  0xC0, 0x07, 0x80, 0x70, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x03, 0x80, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x0F, 0x00, 0x1E, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x3C,
  0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xE7, 0xC0, 0x00,
  0x3B, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF7, 0x80, 0x01, 0xF8, 0xE0,
  0x00, 0x7C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0,
  0x70, 0x00, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x07,
  0x80, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0xC0, 0x1C, 0x00, 0x70,
  0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x38, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xC3, 0xFC, 0x07, 0xFC, 0x01, 0xCF, 0xFE, 0x0F, 0xFE, 0x01, 0xDF, 0xFF,
  0x1F, 0x7F, 0x03, 0x9C, 0x0F, 0x38, 0x0F, 0x03, 0xB0, 0x07, 0x70, 0x0F,
  0x03, 0xF0, 0x07, 0xE0, 0x07, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x38, 0x00, 0x78, 0x00, 0x78, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x78, 0x00, 0x78, 0x00, 0x70, 0x78, 0x00, 0x70, 0x00, 0xF0,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xE1, 0xFF,
  0x00, 0x71, 0xFF, 0xC0, 0x39, 0xFF, 0xF0, 0x39, 0xC0, 0x78, 0x1D, 0xC0,
  0x3C, 0x0F, 0xC0, 0x0E, 0x07, 0xC0, 0x07, 0x07, 0xC0, 0x03, 0x83, 0xE0,
  0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x07,
  0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0,
  0xE0, 0x00, 0xF0, 0x70, 0x00, 0x78, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x1C,
  0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03,
  0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x1C, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xDF, 0x80,
  0x1F, 0x01, 0xE0, 0x1F, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x0E,
  0x0F, 0x00, 0x07, 0x07, 0x80, 0x03, 0x87, 0x80, 0x01, 0xE3, 0xC0, 0x00,
  0xF1, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x78, 0x00, 0x07, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCE, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x79, 0xE0,
  0x00, 0x3C, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0x83, 0x80, 0x07, 0x81, 0xE0, 0x07, 0x80,
  0xF0, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01,
  0xC3, 0xFE, 0x00, 0x0E, 0x3F, 0xF8, 0x00, 0x73, 0xE7, 0xE0, 0x07, 0xB8,
  0x0F, 0x00, 0x3B, 0x80, 0x3C, 0x01, 0xD8, 0x01, 0xE0, 0x0F, 0xC0, 0x07,
  0x00, 0x7C, 0x00, 0x38, 0x07, 0xC0, 0x01, 0xC0, 0x3E, 0x00, 0x0E, 0x01,
  0xE0, 0x00, 0x70, 0x0F, 0x00, 0x03, 0x80, 0x78, 0x00, 0x1C, 0x07, 0x80,
  0x00, 0xE0, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x07, 0x80,
  0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x3C, 0x01,
  0xD8, 0x03, 0xC0, 0x0E, 0xE0, 0x3E, 0x00, 0xF3, 0xFF, 0xE0, 0x07, 0x9F,
  0xFE, 0x00, 0x38, 0x7F, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xFC, 0x1C, 0x01, 0xFF, 0xE3, 0x80, 0x7F,
  0x7C, 0xE0, 0x1F, 0x01, 0xDC, 0x07, 0xC0, 0x1B, 0x80, 0xF0, 0x03, 0xF0,
  0x3C, 0x00, 0x7E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0F,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C,
  0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x0F, 0x00,
  0x0F, 0x81, 0xE0, 0x03, 0xF0, 0x1C, 0x00, 0xFE, 0x03, 0xC0, 0x3B, 0x80,
  0x7C, 0x0E, 0x70, 0x07, 0xFF, 0xCE, 0x00, 0x7F, 0xF3, 0xC0, 0x07, 0xF8,
  0x78, 0x00, 0x18, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x0E,
  0x1F, 0xC0, 0x71, 0xFE, 0x03, 0x9F, 0xE0, 0x39, 0xE0, 0x01, 0xDC, 0x00,
  0x0E, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0xFE, 0x3F, 0x07, 0xC0, 0x18, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x20, 0x01, 0xE0, 0xC0,
  0x1F, 0x03, 0xF3, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFD, 0xC0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x01,
  0xE0, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x03, 0x80,
  0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x07,
  0x80, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x78, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xF0, 0x38, 0x00,
  0x3C, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x70,
  0x00, 0x78, 0x1C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0xC0,
  0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xDC, 0x0F, 0x00, 0x7F, 0x01, 0xE0, 0x3B,
  0x80, 0x7F, 0xFC, 0xE0, 0x0F, 0xFE, 0x38, 0x01, 0xFE, 0x0E, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00,
  0x1C, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0x70,
  0xE0, 0x03, 0xC3, 0x80, 0x0E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0,
  0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x03, 0xC0, 0xF0, 0x07, 0x03, 0x80, 0x1C, 0x1E, 0x00, 0x70, 0x70, 0x01,
  0xC3, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xC0, 0x01, 0xCF,
  0x00, 0x07, 0x38, 0x00, 0x1D, 0xE0, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x1E,
  0xE0, 0x01, 0xF0, 0x01, 0xEE, 0x00, 0x3F, 0x00, 0x1C, 0xE0, 0x03, 0xF0,
  0x03, 0xCE, 0x00, 0x3F, 0x00, 0x38, 0xE0, 0x07, 0x70, 0x07, 0x8E, 0x00,
  0x77, 0x00, 0x70, 0xE0, 0x0E, 0x70, 0x0F, 0x0E, 0x00, 0xE7, 0x00, 0xF0,
  0xE0, 0x1E, 0x70, 0x0E, 0x0E, 0x01, 0xC7, 0x01, 0xE0, 0xE0, 0x1C, 0x70,
  0x1C, 0x0E, 0x03, 0x87, 0x03, 0xC0, 0xE0, 0x38, 0x70, 0x38, 0x0E, 0x07,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x70, 0x78, 0x0E, 0x0F, 0x07, 0x07, 0x00,
  0xE0, 0xE0, 0x70, 0xF0, 0x0E, 0x0E, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x70,
  0xE0, 0x0E, 0x1C, 0x07, 0x1E, 0x00, 0xE3, 0xC0, 0x71, 0xC0, 0x0E, 0x38,
  0x07, 0x3C, 0x00, 0xE7, 0x80, 0x73, 0x80, 0x0E, 0x70, 0x07, 0x38, 0x00,
  0xE7, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x7F,
  0x00, 0x0E, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0x80, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C,
  0x1E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78,
  0x07, 0x00, 0x07, 0x80, 0x38, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xC0, 0x3E, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x07, 0x80, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x38, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x3C, 0x1C,
  0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x71,
  0xE0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x01,
  0xCF, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x02, 0x1F, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x4F, 0xFC, 0x00,
  0x17, 0xFF, 0xC0, 0x0F, 0xE3, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0xB0, 0x01,
  0xFF, 0xC8, 0x00, 0x1F, 0xC0,
};

const GFXglyph NotoSans_Condensed_LightItalic66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 47, 15, 1, -47 },
  { 84, 16, 17, 21, 7, -47 },
  { 118, 31, 47, 31, 1, -47 },
  { 301, 27, 54, 28, 1, -50 },
  { 484, 35, 49, 42, 4, -48 },
  { 699, 29, 49, 31, 0, -48 },
  { 877, 7, 17, 11, 7, -47 },
  { 892, 19, 57, 17, 2, -47 },
  { 1028, 20, 57, 17, -5, -47 },
  { 1171, 22, 22, 26, 7, -50 },
  { 1232, 26, 31, 30, 3, -39 },
  { 1333, 10, 16, 13, -3, -7 },
  { 1353, 14, 4, 18, 2, -20 },
  { 1360, 5, 6, 13, 1, -6 },
  { 1364, 29, 47, 21, -3, -47 },
  { 1535, 25, 49, 28, 2, -48 },
  { 1689, 15, 47, 28, 8, -47 },
  { 1778, 28, 48, 28, -1, -48 },
  { 1946, 28, 49, 28, 0, -48 },
  { 2118, 28, 48, 28, -1, -48 },
  { 2286, 28, 48, 28, 0, -47 },
  { 2454, 27, 49, 28, 2, -48 },
  { 2620, 27, 47, 28, 3, -47 },
  { 2779, 28, 49, 28, 0, -48 },
  { 2951, 26, 49, 28, 1, -48 },
  { 3111, 11, 35, 13, 1, -35 },
  { 3160, 15, 44, 13, -3, -35 },
  { 3243, 26, 29, 30, 3, -38 },
  { 3338, 26, 17, 30, 3, -32 },
  { 3394, 26, 29, 30, 3, -38 },
  { 3489, 21, 48, 20, 2, -48 },
  { 3615, 39, 53, 42, 2, -47 },
  { 3874, 28, 47, 28, -4, -47 },
  { 4039, 29, 47, 30, 1, -47 },
  { 4210, 30, 49, 28, 3, -48 },
  { 4394, 31, 47, 34, 1, -47 },
  { 4577, 28, 47, 27, 1, -47 },
  { 4742, 28, 47, 25, 1, -47 },
  { 4907, 33, 49, 35, 3, -48 },
  { 5110, 35, 47, 35, 1, -47 },
  { 5316, 23, 47, 16, -3, -47 },
  { 5452, 25, 59, 13, -10, -47 },
  { 5637, 33, 47, 28, 1, -47 },
  { 5831, 19, 47, 24, 1, -47 },
  { 5943, 45, 47, 45, 1, -47 },
  { 6208, 36, 47, 36, 1, -47 },
  { 6420, 31, 49, 36, 3, -48 },
  { 6610, 28, 47, 29, 1, -47 },
  { 6775, 31, 59, 36, 3, -48 },
  { 7004, 28, 47, 29, 1, -47 },
  { 7169, 29, 49, 26, -1, -48 },
  { 7347, 24, 47, 24, 6, -47 },
  { 7488, 32, 48, 34, 3, -47 },
  { 7680, 27, 47, 28, 6, -47 },
  { 7839, 45, 47, 46, 6, -47 },
  { 8104, 34, 47, 26, -4, -47 },
  { 8304, 24, 47, 25, 6, -47 },
  { 8445, 31, 47, 25, -2, -47 },
  { 8628, 24, 58, 19, -1, -47 },
  { 8802, 10, 47, 22, 7, -47 },
  { 8861, 24, 58, 19, -4, -47 },
  { 9035, 26, 25, 29, 2, -47 },
  { 9117, 21, 3, 21, -5, 6 },
  { 9125, 8, 10, 15, 10, -50 },
  { 9135, 27, 37, 30, 2, -36 },
  { 9260, 26, 51, 30, 1, -50 },
  { 9426, 22, 37, 23, 2, -36 },
  { 9528, 30, 51, 30, 2, -50 },
  { 9720, 23, 37, 26, 2, -36 },
  { 9827, 31, 66, 15, -8, -50 },
  { 10083, 29, 52, 30, 0, -36 },
  { 10272, 25, 50, 29, 1, -50 },
  { 10429, 13, 48, 13, 1, -48 },
  { 10507, 24, 64, 13, -9, -48 },
  { 10699, 26, 50, 24, 1, -50 },
  { 10862, 14, 50, 12, 1, -50 },
  { 10950, 40, 36, 44, 1, -36 },
  { 11130, 25, 36, 29, 1, -36 },
  { 11243, 25, 37, 29, 2, -36 },
  { 11359, 29, 51, 30, -2, -36 },
  { 11544, 27, 52, 30, 2, -36 },
  { 11720, 21, 36, 19, 1, -36 },
  { 11815, 22, 37, 22, 0, -36 },
  { 11917, 16, 44, 16, 2, -43 },
  { 12005, 26, 36, 29, 2, -35 },
  { 12122, 22, 35, 23, 4, -35 },
  { 12219, 36, 35, 37, 4, -35 },
  { 12377, 29, 35, 24, -3, -35 },
  { 12504, 34, 51, 23, -7, -35 },
  { 12721, 24, 35, 21, -2, -35 },
  { 12826, 23, 57, 21, 2, -47 },
  { 12990, 4, 66, 27, 12, -50 },
  { 13023, 24, 57, 21, -4, -47 },
  { 13194, 26, 7, 30, 3, -27 },
};

const GFXfont NotoSans_Condensed_LightItalic66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic66pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC66PT7B_H_
