#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC49PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x00, 0x38, 0x73, 0x86,
  0x30, 0x63, 0x0E, 0x70, 0xE7, 0x0C, 0x60, 0xC6, 0x0C, 0x61, 0xCE, 0x18,
  0xC1, 0x8C, 0x18, 0xC1, 0x80, 0x00, 0x18, 0x18, 0x00, 0x30, 0x30, 0x00,
  0xE0, 0xE0, 0x01, 0x81, 0x80, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x18,
  0x18, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60, 0x01, 0xC1, 0x80, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE0, 0x1C, 0x1C, 0x00, 0x30, 0x30, 0x00, 0x60, 0x60,
  0x01, 0xC1, 0xC0, 0x03, 0x03, 0x00, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00,
  0x30, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0, 0x3F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF0, 0x0C, 0x0C, 0x00, 0x38, 0x38, 0x00, 0x60, 0x60, 0x00, 0xC0,
  0xC0, 0x01, 0x83, 0x80, 0x06, 0x06, 0x00, 0x0C, 0x0C, 0x00, 0x18, 0x18,
  0x00, 0x70, 0x70, 0x00, 0xC0, 0xC0, 0x01, 0x83, 0x80, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x0C, 0x00, 0x03, 0xFE, 0x00,
  0x7F, 0xFC, 0x07, 0x99, 0xC0, 0x70, 0x82, 0x07, 0x0C, 0x00, 0x38, 0x60,
  0x01, 0x83, 0x00, 0x0C, 0x10, 0x00, 0x61, 0x80, 0x03, 0x0C, 0x00, 0x1C,
  0x60, 0x00, 0xF3, 0x00, 0x03, 0x90, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x17, 0x80, 0x01, 0x9C, 0x00, 0x0C,
  0x70, 0x00, 0x63, 0x80, 0x02, 0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00,
  0x0C, 0x18, 0x00, 0x61, 0xC0, 0x02, 0x1C, 0x08, 0x31, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x07, 0x03, 0xF8,
  0x01, 0x81, 0xC7, 0x00, 0xE0, 0x60, 0xC0, 0x30, 0x38, 0x30, 0x1C, 0x0C,
  0x0C, 0x06, 0x07, 0x03, 0x03, 0x01, 0x80, 0xC1, 0xC0, 0x60, 0x30, 0x60,
  0x18, 0x1C, 0x38, 0x0E, 0x07, 0x0C, 0x03, 0x01, 0x86, 0x00, 0xC0, 0x61,
  0x80, 0x30, 0x38, 0xC0, 0x0C, 0x0C, 0x71, 0xF3, 0x03, 0x18, 0xFE, 0xC1,
  0xCE, 0x71, 0xF0, 0x63, 0x38, 0x7E, 0x39, 0x8C, 0x0D, 0xFC, 0xE3, 0x03,
  0x7E, 0x31, 0x81, 0xC0, 0x1C, 0x60, 0x70, 0x06, 0x18, 0x1C, 0x03, 0x8E,
  0x06, 0x00, 0xC3, 0x01, 0x80, 0x60, 0xC0, 0x60, 0x38, 0x30, 0x38, 0x0C,
  0x0C, 0x0E, 0x07, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0xE0, 0x30, 0x60,
  0x30, 0x0C, 0x18, 0x18, 0x03, 0x0C, 0x0E, 0x00, 0xFF, 0x03, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00,
  0x60, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x70,
  0xE0, 0x01, 0xC7, 0x00, 0x03, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x73, 0x00, 0x03, 0x8E, 0x07, 0x1C,
  0x38, 0x18, 0xE0, 0x70, 0xE3, 0x81, 0xC3, 0x9C, 0x03, 0x9C, 0x70, 0x0E,
  0x71, 0x80, 0x1B, 0x8E, 0x00, 0x7E, 0x38, 0x01, 0xF0, 0xE0, 0x03, 0x83,
  0x80, 0x1E, 0x0E, 0x00, 0xF8, 0x1C, 0x07, 0x70, 0x78, 0x3D, 0xC0, 0xFF,
  0xC3, 0x81, 0xFE, 0x0E, 0x00, 0x39, 0xCC, 0x67, 0x39, 0x8C, 0x63, 0x31,
  0x8C, 0x00, 0x00, 0x0E, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x60,
  0xC0, 0xF8, 0xC0, 0x3E, 0x83, 0x0F, 0xFF, 0x01, 0xFF, 0x03, 0xC0, 0x06,
  0xC0, 0x1C, 0x60, 0x38, 0x60, 0x70, 0x70, 0x30, 0x30, 0x00, 0x38, 0x00,
  0x20, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30,
  0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x0E, 0x1C, 0x38, 0xE1,
  0xC7, 0x0E, 0x18, 0x70, 0xC3, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03,
  0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0xE0, 0x1C, 0x38, 0x0E, 0x07, 0x07, 0x01, 0xC1, 0x80, 0x70, 0xE0,
  0x0C, 0x30, 0x03, 0x1C, 0x00, 0xC6, 0x00, 0x33, 0x80, 0x0C, 0xE0, 0x07,
  0x30, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0x60, 0x01, 0xD8,
  0x00, 0x6E, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xCC, 0x00,
  0x73, 0x00, 0x1C, 0xC0, 0x07, 0x30, 0x03, 0x8C, 0x00, 0xE3, 0x00, 0x30,
  0xC0, 0x1C, 0x30, 0x06, 0x0E, 0x03, 0x83, 0x81, 0xC0, 0x70, 0xE0, 0x1F,
  0xF0, 0x03, 0xF8, 0x00, 0x00, 0xE0, 0x3C, 0x1F, 0x87, 0xE1, 0xEC, 0x73,
  0xBC, 0x73, 0x0E, 0x41, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x78,
  0x3C, 0x01, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x87, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x03, 0xC0, 0xE0, 0x30, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x30,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x08, 0x01, 0xE0, 0xC0, 0x3C, 0x0F,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0x60, 0x00, 0x76, 0x00, 0x0E, 0xE0, 0x00,
  0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x8C, 0x00, 0x30, 0xC0, 0x07, 0x1C, 0x00,
  0xE1, 0xC0, 0x0C, 0x18, 0x01, 0x81, 0x80, 0x38, 0x38, 0x03, 0x03, 0x80,
  0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x30, 0x18, 0x07, 0x03, 0x80, 0x70,
  0x70, 0x07, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0x80, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18, 0x00, 0x00, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xC0, 0x0E, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x10, 0x03, 0xC0, 0xC0, 0x3C, 0x07,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x60, 0xE0, 0x0C, 0xFF, 0x03, 0xBF, 0xF0, 0x7E, 0x0F, 0x0F, 0x00, 0xE1,
  0xC0, 0x0C, 0x78, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7,
  0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x00, 0x1C, 0x60, 0x03, 0x8E,
  0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x03, 0x81, 0xE0, 0x70, 0x78, 0x07,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0x78,
  0x3C, 0x03, 0x80, 0xE0, 0x38, 0x03, 0x81, 0x80, 0x1C, 0x1C, 0x00, 0xE0,
  0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0x80, 0xC0, 0x1C, 0x06, 0x00,
  0xC0, 0x38, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x9E, 0x00, 0x1F, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0xE0, 0x01, 0xF7, 0x80, 0x1E, 0x1E, 0x01, 0xC0, 0x70,
  0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x38, 0x60, 0x01, 0xC3, 0x00,
  0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x18, 0x70, 0x01, 0xC1,
  0xC0, 0x0E, 0x0E, 0x00, 0xE0, 0x3C, 0x0E, 0x00, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x0F, 0x0F, 0x03, 0x80, 0xE0, 0x70,
  0x0E, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x00,
  0x1C, 0x60, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00,
  0x79, 0xC0, 0x0E, 0x38, 0x03, 0xC3, 0x80, 0xF8, 0x70, 0x3F, 0x07, 0xFE,
  0xE0, 0x7F, 0x98, 0x03, 0x87, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x81, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0xE0, 0xF0, 0x38, 0x00, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0C,
  0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x60, 0x70, 0x80, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0xE0, 0x1C, 0x00, 0x06, 0x03, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03,
  0x06, 0x00, 0x00, 0x30, 0xC0, 0x00, 0x03, 0x1C, 0x03, 0xF8, 0x31, 0x80,
  0xFF, 0x83, 0x38, 0x1C, 0x38, 0x33, 0x03, 0x83, 0x83, 0x30, 0x30, 0x30,
  0x37, 0x07, 0x03, 0x03, 0x60, 0x60, 0x70, 0x36, 0x0E, 0x07, 0x07, 0x60,
  0xC0, 0x60, 0x6E, 0x0C, 0x06, 0x06, 0xC1, 0xC0, 0xE0, 0x6C, 0x18, 0x0C,
  0x0E, 0xC1, 0x80, 0xC0, 0xCC, 0x18, 0x1C, 0x0C, 0xC1, 0x81, 0xC1, 0x8C,
  0x18, 0x3C, 0x18, 0xC1, 0xC2, 0xC3, 0x0C, 0x0E, 0xEF, 0xE0, 0xC0, 0xFC,
  0x7C, 0x0C, 0x02, 0x01, 0x00, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x1E, 0x01, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x36, 0x00, 0x03, 0xB0, 0x00, 0x19, 0x80, 0x00, 0xCE, 0x00, 0x0E,
  0x70, 0x00, 0x63, 0x80, 0x07, 0x1C, 0x00, 0x30, 0xE0, 0x03, 0x87, 0x00,
  0x18, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xE0, 0x06, 0x07, 0x00, 0x30, 0x70, 0x01, 0x83, 0x80, 0x0C,
  0x38, 0x00, 0x61, 0xC0, 0x03, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xC6, 0x00,
  0x06, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xF8, 0x00, 0x0E, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x80, 0x18, 0x3F, 0x00, 0xE0, 0x1E, 0x03, 0x80, 0x38, 0x0E,
  0x00, 0x60, 0x30, 0x01, 0xC0, 0xC0, 0x07, 0x07, 0x00, 0x18, 0x1C, 0x00,
  0xE0, 0x70, 0x03, 0x81, 0x80, 0x0E, 0x0E, 0x00, 0x70, 0x38, 0x03, 0xC0,
  0xE0, 0x1E, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xC0,
  0x78, 0x07, 0x00, 0x70, 0x18, 0x01, 0xC0, 0x60, 0x03, 0x83, 0x80, 0x0E,
  0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x00, 0x0E, 0x1C,
  0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x0E, 0x06, 0x00, 0x78, 0x38, 0x03,
  0xC0, 0xE0, 0xFE, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xC0, 0x1E, 0x06, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x18, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x06, 0x1F, 0xC0, 0x1C, 0x03,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x03, 0x80, 0xC0, 0x07, 0x01, 0x80, 0x06,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x30, 0x00, 0x70,
  0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0C,
  0x00, 0x0C, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0x80,
  0x01, 0xC3, 0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0x60, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x80, 0x0E, 0x07, 0x00, 0x3C,
  0x0E, 0x00, 0xF0, 0x18, 0x03, 0xC0, 0x70, 0x0F, 0x00, 0xE3, 0xFC, 0x01,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0x81, 0xE0, 0x0F,
  0x00, 0x10, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0x0E, 0x00, 0xFF,
  0x86, 0x00, 0x7F, 0xC3, 0x00, 0x00, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00,
  0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x18, 0x38, 0x00, 0x0C, 0x0C, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0x80, 0x70,
  0x01, 0xC0, 0x3C, 0x00, 0xE0, 0x0F, 0x80, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00,
  0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x0C, 0x00,
  0x1C, 0x06, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x01, 0xC0,
  0x01, 0x80, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38,
  0x00, 0x30, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x01, 0xC0,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0x60, 0x38, 0x00, 0x30, 0x18, 0x00, 0x38,
  0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x03, 0x80, 0x07,
  0x01, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00,
  0x60, 0x30, 0x00, 0x70, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0x01,
  0xC0, 0x0F, 0x01, 0x80, 0x0E, 0x01, 0x80, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x70, 0x03, 0x80, 0xE0, 0x03, 0x01, 0xE0, 0x03, 0x01, 0xC0, 0x07,
  0x03, 0x80, 0x07, 0x07, 0x00, 0x07, 0x0E, 0x00, 0x06, 0x1E, 0x00, 0x0E,
  0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0D,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x70, 0x00, 0x1E, 0x30, 0x00, 0x1C,
  0x38, 0x00, 0x18, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x38,
  0x1C, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x0C, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x0E, 0x00, 0x60, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0,
  0x07, 0x00, 0xE0, 0x03, 0x80, 0xC0, 0x03, 0x80, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x07, 0xFF, 0xEF, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1B, 0x00, 0x01, 0xF8, 0x0D,
  0x80, 0x00, 0xD8, 0x06, 0xC0, 0x00, 0xEC, 0x07, 0x70, 0x00, 0x6E, 0x03,
  0xB8, 0x00, 0x77, 0x01, 0x9C, 0x00, 0x33, 0x80, 0xCE, 0x00, 0x39, 0x80,
  0xE7, 0x00, 0x18, 0xC0, 0x73, 0x80, 0x1C, 0xE0, 0x38, 0xC0, 0x0C, 0x70,
  0x18, 0x60, 0x0E, 0x38, 0x0C, 0x30, 0x06, 0x18, 0x0E, 0x18, 0x07, 0x0C,
  0x07, 0x0C, 0x03, 0x0E, 0x03, 0x86, 0x03, 0x87, 0x01, 0x83, 0x01, 0x83,
  0x80, 0xC1, 0xC1, 0xC1, 0x80, 0xE0, 0xE0, 0xC1, 0xC0, 0x70, 0x70, 0xE0,
  0xE0, 0x38, 0x38, 0x60, 0x70, 0x18, 0x1C, 0x70, 0x30, 0x1C, 0x06, 0x30,
  0x18, 0x0E, 0x03, 0x38, 0x1C, 0x07, 0x01, 0x98, 0x0E, 0x03, 0x00, 0xDC,
  0x07, 0x01, 0x80, 0x6C, 0x03, 0x01, 0xC0, 0x3E, 0x01, 0x80, 0xE0, 0x1E,
  0x01, 0xC0, 0x70, 0x0F, 0x00, 0xE0, 0x30, 0x07, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0xC0, 0x70, 0x00, 0x30, 0x1E, 0x00, 0x1C, 0x0F, 0x80, 0x07,
  0x03, 0xE0, 0x01, 0xC0, 0xD8, 0x00, 0x60, 0x37, 0x00, 0x38, 0x0D, 0xC0,
  0x0E, 0x07, 0x30, 0x03, 0x81, 0xCC, 0x00, 0xC0, 0x63, 0x80, 0x30, 0x18,
  0xE0, 0x1C, 0x0E, 0x18, 0x07, 0x03, 0x86, 0x01, 0xC0, 0xE1, 0xC0, 0x60,
  0x30, 0x70, 0x18, 0x0C, 0x0C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0,
  0xE0, 0x70, 0x38, 0x30, 0x18, 0x06, 0x0C, 0x06, 0x01, 0x87, 0x03, 0x80,
  0x71, 0xC0, 0xE0, 0x1C, 0x70, 0x38, 0x03, 0x18, 0x0C, 0x00, 0xCE, 0x07,
  0x00, 0x3B, 0x81, 0xC0, 0x0E, 0xE0, 0x70, 0x01, 0xB0, 0x18, 0x00, 0x6C,
  0x06, 0x00, 0x1F, 0x03, 0x80, 0x07, 0xC0, 0xE0, 0x01, 0xF0, 0x38, 0x00,
  0x38, 0x0C, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x0E, 0x07, 0x80, 0x0E, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0E, 0x00, 0x06, 0x1C, 0x00, 0x07, 0x1C,
  0x00, 0x07, 0x18, 0x00, 0x07, 0x38, 0x00, 0x07, 0x38, 0x00, 0x06, 0x30,
  0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x70, 0x60, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0x70,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x61, 0xF8, 0x07, 0x01,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x1C, 0x0C, 0x00, 0xE0, 0x60, 0x07, 0x07,
  0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0C, 0x00, 0x60, 0xE0, 0x07,
  0x07, 0x00, 0x38, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0C, 0x01, 0xC0, 0xE0,
  0x3C, 0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x0C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x1C, 0x03, 0x80,
  0x0E, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x06, 0x0E, 0x00,
  0x06, 0x1C, 0x00, 0x07, 0x1C, 0x00, 0x07, 0x18, 0x00, 0x07, 0x38, 0x00,
  0x06, 0x38, 0x00, 0x06, 0x30, 0x00, 0x06, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x60, 0x00, 0x0C, 0x60, 0x00,
  0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x38, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0x60, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x3E, 0x0F,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x61, 0xF8, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x1C, 0x0C,
  0x00, 0xE0, 0x60, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E,
  0x0C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x03, 0x81, 0xC0,
  0x3C, 0x0C, 0x03, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01,
  0x83, 0x80, 0x0C, 0x0C, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x38, 0x1C,
  0x01, 0x80, 0x60, 0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38,
  0x07, 0x01, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38,
  0x30, 0x00, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0x03, 0x80,
  0x70, 0x02, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x78, 0x20, 0x03, 0xC0, 0xF0, 0x3E, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x03,
  0x80, 0x03, 0x03, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07, 0x00, 0x07, 0x07,
  0x00, 0x06, 0x06, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E,
  0x00, 0x0C, 0x0E, 0x00, 0x0C, 0x0C, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x38, 0x18, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x30, 0x30, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x60, 0x70, 0x00, 0x60, 0x60,
  0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xC0, 0xE0, 0x01, 0xC0, 0xE0,
  0x01, 0xC0, 0xE0, 0x03, 0x80, 0x70, 0x03, 0x80, 0x70, 0x07, 0x00, 0x3C,
  0x1E, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xC6, 0x00, 0x0E, 0x30, 0x00, 0xE1,
  0x80, 0x07, 0x0C, 0x00, 0x30, 0x60, 0x03, 0x83, 0x00, 0x18, 0x18, 0x01,
  0xC0, 0xC0, 0x0E, 0x06, 0x00, 0xE0, 0x30, 0x07, 0x01, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0C, 0x00, 0xE0, 0xE0,
  0x07, 0x06, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x00, 0x0E, 0x38, 0x00, 0x71,
  0xC0, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00,
  0x3B, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x03,
  0xB0, 0x00, 0xE0, 0x01, 0xD8, 0x00, 0xF0, 0x01, 0xCC, 0x00, 0x78, 0x00,
  0xE6, 0x00, 0x3C, 0x00, 0xE3, 0x00, 0x36, 0x00, 0x71, 0x80, 0x1B, 0x00,
  0x30, 0xC0, 0x1D, 0x80, 0x38, 0x60, 0x0C, 0xC0, 0x1C, 0x30, 0x0E, 0x60,
  0x1C, 0x18, 0x06, 0x30, 0x0E, 0x0C, 0x03, 0x18, 0x06, 0x06, 0x03, 0x8C,
  0x07, 0x03, 0x01, 0x86, 0x03, 0x81, 0x81, 0xC3, 0x03, 0x80, 0xC0, 0xC1,
  0x81, 0xC0, 0x60, 0x60, 0xC0, 0xC0, 0x30, 0x70, 0x60, 0xE0, 0x18, 0x30,
  0x30, 0x60, 0x0C, 0x38, 0x18, 0x70, 0x06, 0x18, 0x0C, 0x38, 0x03, 0x1C,
  0x06, 0x38, 0x01, 0x8E, 0x03, 0x1C, 0x00, 0xC6, 0x01, 0x8C, 0x00, 0x67,
  0x00, 0xCE, 0x00, 0x33, 0x00, 0x66, 0x00, 0x1B, 0x80, 0x37, 0x00, 0x0D,
  0x80, 0x1B, 0x80, 0x06, 0xC0, 0x0D, 0x80, 0x03, 0xE0, 0x07, 0xC0, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x01, 0xC0, 0x18, 0x00, 0x70, 0x0E, 0x00, 0x0C, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x06,
  0x1C, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x63, 0x00, 0x00, 0x1D, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0x30, 0x00, 0x07, 0x0C, 0x00, 0x01,
  0xC3, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x30, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x0E, 0x01, 0x80, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0x01, 0xFC, 0x00, 0x39, 0x80, 0x0E, 0x30, 0x01, 0xC7, 0x00, 0x70, 0xE0,
  0x0C, 0x1C, 0x03, 0x83, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x07, 0x00, 0xC0,
  0xE0, 0x1C, 0x38, 0x03, 0x86, 0x00, 0x71, 0xC0, 0x0E, 0x30, 0x00, 0xCE,
  0x00, 0x1B, 0x80, 0x03, 0x70, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x40,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x60,
  0x70, 0x70, 0x70, 0x30, 0x30, 0x30, 0x30, 0x38, 0x38, 0x38, 0x18, 0x18,
  0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E,
  0x06, 0x06, 0x06, 0x07, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x01, 0xC6, 0x00, 0x18,
  0x70, 0x03, 0x83, 0x00, 0x30, 0x30, 0x07, 0x03, 0x80, 0xE0, 0x18, 0x0E,
  0x01, 0xC1, 0xC0, 0x1C, 0x18, 0x00, 0xC3, 0x80, 0x0E, 0x30, 0x00, 0x67,
  0x00, 0x06, 0xE0, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xE1,
  0xC7, 0x0E, 0x18, 0x60, 0xC0, 0x00, 0x20, 0x00, 0x3F, 0x8C, 0x0F, 0xF9,
  0x83, 0xC3, 0x70, 0xE0, 0x3E, 0x38, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x0E,
  0x38, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x06, 0x38, 0x01, 0xC6, 0x00, 0x39,
  0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x18, 0xE0, 0x07, 0x18, 0x00, 0xE3,
  0x00, 0x1C, 0x60, 0x07, 0x0C, 0x00, 0xE1, 0x80, 0x3C, 0x38, 0x0F, 0x87,
  0x01, 0xF0, 0x70, 0xEC, 0x0F, 0xF9, 0x80, 0xFE, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x10,
  0x03, 0x9F, 0xC0, 0x67, 0xFC, 0x1D, 0xC3, 0x83, 0xE0, 0x38, 0x7C, 0x07,
  0x0F, 0x00, 0x61, 0xC0, 0x0C, 0x78, 0x01, 0x8E, 0x00, 0x31, 0xC0, 0x0E,
  0x38, 0x01, 0xC6, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x18,
  0xC0, 0x07, 0x18, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x07, 0x1C, 0x00, 0xE3,
  0x80, 0x38, 0xF0, 0x07, 0x1F, 0x01, 0xC3, 0x70, 0x70, 0x67, 0xFC, 0x0C,
  0x7F, 0x00, 0x00, 0x10, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0x82, 0x0E, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x78, 0x20, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x02, 0x07, 0x00, 0x7F, 0x18, 0x03, 0xFE, 0x60, 0x1E, 0x1F, 0x80, 0xE0,
  0x3E, 0x07, 0x00, 0x78, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C,
  0x1C, 0x00, 0x70, 0x70, 0x01, 0x81, 0xC0, 0x06, 0x06, 0x00, 0x38, 0x38,
  0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0C, 0x0E, 0x00, 0x70, 0x30, 0x01,
  0xC0, 0xC0, 0x07, 0x03, 0x00, 0x3C, 0x0C, 0x00, 0xE0, 0x30, 0x07, 0x80,
  0xE0, 0x3E, 0x03, 0x80, 0xF8, 0x07, 0x0E, 0xE0, 0x1F, 0xF3, 0x00, 0x3F,
  0x8C, 0x00, 0x00, 0x10, 0x01, 0xFE, 0x03, 0xFF, 0x07, 0x07, 0x0E, 0x03,
  0x1C, 0x03, 0x1C, 0x03, 0x38, 0x03, 0x30, 0x07, 0x70, 0x06, 0x70, 0x0E,
  0x60, 0x3C, 0xE1, 0xF8, 0xFF, 0xE0, 0xFF, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x78, 0x18, 0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x18, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03, 0xF8, 0xC0, 0x3F,
  0xE6, 0x03, 0xC3, 0xB0, 0x38, 0x0F, 0x83, 0x80, 0x3C, 0x1C, 0x01, 0xC1,
  0xC0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x18, 0x38, 0x00,
  0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x18, 0x38,
  0x01, 0xC1, 0x80, 0x0E, 0x0C, 0x00, 0x70, 0x60, 0x07, 0x83, 0x00, 0x38,
  0x18, 0x03, 0xC0, 0xE0, 0x3E, 0x07, 0x03, 0xF0, 0x3C, 0x3B, 0x80, 0xFF,
  0x98, 0x03, 0xF8, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x01, 0x00, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x10, 0x03, 0x9F, 0xC0, 0x67, 0xFC, 0x1D, 0x83, 0x83, 0xE0, 0x38,
  0x78, 0x07, 0x0F, 0x00, 0xE1, 0xC0, 0x18, 0x70, 0x03, 0x0E, 0x00, 0x61,
  0xC0, 0x1C, 0x30, 0x03, 0x86, 0x00, 0x71, 0xC0, 0x0C, 0x38, 0x03, 0x87,
  0x00, 0x70, 0xC0, 0x0E, 0x18, 0x01, 0x87, 0x00, 0x30, 0xE0, 0x0E, 0x1C,
  0x01, 0xC3, 0x00, 0x38, 0xE0, 0x06, 0x1C, 0x00, 0xC3, 0x80, 0x38, 0x70,
  0x07, 0x0C, 0x00, 0xE0, 0x00, 0x80, 0x70, 0x3C, 0x0E, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38,
  0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C,
  0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x70,
  0x60, 0x1C, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x0C, 0x1C, 0x01,
  0x83, 0x80, 0x70, 0xE0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x33, 0x80, 0x06,
  0xF0, 0x01, 0xDF, 0x00, 0x3E, 0xE0, 0x07, 0x9C, 0x00, 0xE1, 0x80, 0x18,
  0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x0C, 0x03, 0x01, 0xC0, 0xE0,
  0x38, 0x1C, 0x07, 0x03, 0x80, 0x60, 0x60, 0x0E, 0x0C, 0x01, 0xC0, 0x01,
  0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0,
  0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x80, 0x18, 0xFC, 0x1F, 0xC0, 0x67, 0xF8, 0xFF, 0x83, 0xB0, 0xF7,
  0x0E, 0x0F, 0x81, 0xF0, 0x1C, 0x3C, 0x07, 0x80, 0x70, 0xE0, 0x1E, 0x01,
  0xC3, 0x80, 0x70, 0x06, 0x1C, 0x01, 0xC0, 0x18, 0x70, 0x07, 0x00, 0x61,
  0xC0, 0x18, 0x03, 0x86, 0x00, 0x60, 0x0E, 0x18, 0x03, 0x80, 0x30, 0xE0,
  0x0E, 0x00, 0xC3, 0x80, 0x30, 0x07, 0x0E, 0x00, 0xC0, 0x1C, 0x30, 0x07,
  0x00, 0x70, 0xC0, 0x1C, 0x01, 0x87, 0x00, 0x70, 0x06, 0x1C, 0x01, 0x80,
  0x38, 0x70, 0x06, 0x00, 0xE1, 0x80, 0x38, 0x03, 0x8E, 0x00, 0xE0, 0x0C,
  0x38, 0x03, 0x80, 0x30, 0xE0, 0x0C, 0x01, 0xC3, 0x00, 0x30, 0x07, 0x0C,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x31, 0xFC, 0x03, 0x3F, 0xE0,
  0x77, 0x0E, 0x07, 0xC0, 0x70, 0x78, 0x07, 0x07, 0x80, 0x70, 0x70, 0x06,
  0x0F, 0x00, 0x60, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xC0, 0x0E, 0x0C, 0x00,
  0xE1, 0xC0, 0x0C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x18, 0x01, 0xC3, 0x80,
  0x18, 0x38, 0x01, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x00, 0x38, 0x70,
  0x03, 0x07, 0x00, 0x30, 0x70, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x07, 0x00,
  0x00, 0x10, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1C, 0x1E, 0x0E, 0x03, 0x87,
  0x00, 0x61, 0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xDC, 0x00, 0x77, 0x00,
  0x1D, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x6E, 0x00, 0x3B, 0x80, 0x0E,
  0xC0, 0x03, 0xB0, 0x00, 0xCC, 0x00, 0x73, 0x00, 0x1C, 0xC0, 0x0E, 0x38,
  0x03, 0x8E, 0x01, 0xC3, 0x80, 0xF0, 0x70, 0x78, 0x0F, 0xFC, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x80, 0x03, 0x1F, 0xC0, 0x0C, 0xFF, 0x80, 0x37, 0x0F,
  0x01, 0xF0, 0x1C, 0x07, 0xC0, 0x70, 0x1E, 0x00, 0xC0, 0x70, 0x03, 0x03,
  0xC0, 0x0C, 0x0E, 0x00, 0x30, 0x38, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00,
  0x1C, 0x1C, 0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x06, 0x06, 0x00, 0x38,
  0x18, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38,
  0x03, 0x80, 0xE0, 0x0E, 0x07, 0xC0, 0x70, 0x1F, 0x87, 0x80, 0x67, 0xFC,
  0x01, 0x8F, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x3F, 0x8C, 0x0F, 0xF9, 0x83, 0xC3, 0xB0, 0xE0, 0x3E, 0x38, 0x03,
  0xC7, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x06,
  0x38, 0x00, 0xC6, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x18,
  0xE0, 0x07, 0x18, 0x00, 0xE3, 0x00, 0x1C, 0x60, 0x07, 0x8C, 0x00, 0xE1,
  0x80, 0x3C, 0x38, 0x0F, 0x87, 0x01, 0xF0, 0xF0, 0xEE, 0x0F, 0xF9, 0x80,
  0xFE, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x04, 0x0C, 0x7C, 0x19,
  0xF8, 0x77, 0x00, 0xF8, 0x01, 0xA0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x00, 0x00, 0x20,
  0x03, 0xFE, 0x07, 0xFF, 0x0F, 0x03, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x80, 0x78, 0xC0, 0xF0,
  0xFF, 0xE0, 0xFF, 0xC0, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x70, 0x3F, 0xF3, 0xFF, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x7F, 0x03, 0xF0, 0x0E, 0x00, 0xE1, 0x80, 0x18, 0x70, 0x03, 0x0E,
  0x00, 0xE1, 0xC0, 0x1C, 0x30, 0x03, 0x8E, 0x00, 0x61, 0xC0, 0x0C, 0x38,
  0x03, 0x87, 0x00, 0x70, 0xC0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x70, 0xE0,
  0x0E, 0x18, 0x01, 0xC3, 0x00, 0x38, 0xE0, 0x06, 0x1C, 0x01, 0xC3, 0x80,
  0x38, 0x60, 0x0F, 0x0C, 0x01, 0xC1, 0x80, 0x78, 0x38, 0x1B, 0x07, 0x06,
  0x60, 0xFF, 0xDC, 0x0F, 0xE3, 0x00, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0E,
  0xC0, 0x0E, 0xC0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x30,
  0xE0, 0x70, 0xE0, 0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0xE1, 0xC0, 0xE1, 0x80,
  0xE3, 0x80, 0xE3, 0x00, 0x67, 0x00, 0x66, 0x00, 0x6E, 0x00, 0x6E, 0x00,
  0x6C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xC0, 0x0E,
  0x01, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x1B, 0x00, 0xF8, 0x0E, 0xC0,
  0x36, 0x03, 0xB0, 0x1F, 0x81, 0xCC, 0x06, 0xE0, 0x73, 0x01, 0xB8, 0x18,
  0xC0, 0xEE, 0x0E, 0x30, 0x33, 0x83, 0x0C, 0x1C, 0xE1, 0xC3, 0x06, 0x38,
  0x70, 0xC3, 0x8E, 0x18, 0x30, 0xC3, 0x8E, 0x0C, 0x30, 0x63, 0x03, 0x1C,
  0x19, 0xC0, 0xC6, 0x06, 0x60, 0x33, 0x81, 0x98, 0x0E, 0xC0, 0x6E, 0x03,
  0x70, 0x1B, 0x00, 0xD8, 0x07, 0xC0, 0x36, 0x01, 0xE0, 0x0F, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x38, 0x1C, 0x03, 0x80, 0x60, 0x18, 0x03, 0x01, 0xC0, 0x1C, 0x1C,
  0x00, 0xE0, 0xC0, 0x03, 0x0E, 0x00, 0x1C, 0xE0, 0x00, 0xE6, 0x00, 0x07,
  0x70, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x3B, 0x00, 0x03, 0x98, 0x00, 0x1C, 0xE0, 0x01, 0xC7,
  0x00, 0x1C, 0x18, 0x00, 0xE0, 0xC0, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xC0, 0x70, 0x07, 0x07, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x03, 0x80,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x03, 0x00, 0xE0, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x30, 0x00, 0x60, 0x38,
  0x00, 0x30, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x0C, 0x0C, 0x00, 0x06, 0x0E,
  0x00, 0x03, 0x06, 0x00, 0x01, 0x87, 0x00, 0x00, 0xE3, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x39, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07,
  0x60, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x10, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x01,
  0xE0, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x00,
  0x1F, 0x00, 0x2F, 0xF8, 0x07, 0xCF, 0xC3, 0xE0, 0x3F, 0xF8, 0x01, 0xF8,
};

const GFXglyph NotoSans_Condensed_LightItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 35, 11, 1, -35 },
  { 45, 12, 13, 15, 5, -35 },
  { 65, 23, 35, 23, 1, -35 },
  { 166, 21, 40, 21, 0, -37 },
  { 271, 26, 36, 31, 3, -35 },
  { 388, 22, 35, 23, 0, -35 },
  { 485, 5, 13, 9, 5, -35 },
  { 494, 15, 43, 12, 1, -35 },
  { 575, 14, 43, 12, -3, -35 },
  { 651, 16, 17, 20, 5, -37 },
  { 685, 19, 23, 23, 2, -29 },
  { 740, 7, 11, 9, -2, -5 },
  { 750, 11, 3, 14, 1, -15 },
  { 755, 4, 4, 10, 1, -4 },
  { 757, 21, 35, 16, -2, -35 },
  { 849, 18, 35, 21, 2, -35 },
  { 928, 11, 35, 21, 6, -35 },
  { 977, 21, 35, 21, -1, -35 },
  { 1069, 20, 35, 21, 0, -35 },
  { 1157, 20, 35, 21, 0, -35 },
  { 1245, 21, 35, 21, 0, -35 },
  { 1337, 19, 35, 21, 2, -35 },
  { 1421, 19, 35, 21, 3, -35 },
  { 1505, 21, 35, 21, 0, -35 },
  { 1597, 19, 35, 21, 1, -35 },
  { 1681, 9, 26, 10, 0, -26 },
  { 1711, 11, 32, 10, -2, -26 },
  { 1755, 19, 21, 23, 2, -28 },
  { 1805, 19, 13, 23, 2, -24 },
  { 1836, 19, 21, 23, 2, -28 },
  { 1886, 15, 35, 15, 2, -35 },
  { 1952, 28, 39, 31, 2, -35 },
  { 2089, 21, 35, 21, -3, -35 },
  { 2181, 22, 35, 23, 1, -35 },
  { 2278, 22, 36, 21, 2, -36 },
  { 2377, 23, 35, 25, 1, -35 },
  { 2478, 21, 35, 20, 1, -35 },
  { 2570, 21, 35, 18, 1, -35 },
  { 2662, 25, 36, 26, 2, -36 },
  { 2775, 25, 35, 26, 1, -35 },
  { 2885, 17, 35, 12, -2, -35 },
  { 2960, 18, 44, 10, -7, -35 },
  { 3059, 24, 35, 21, 1, -35 },
  { 3164, 14, 35, 18, 1, -35 },
  { 3226, 33, 35, 33, 1, -35 },
  { 3371, 26, 35, 27, 1, -35 },
  { 3485, 24, 35, 27, 2, -35 },
  { 3590, 21, 35, 21, 1, -35 },
  { 3682, 24, 43, 27, 2, -35 },
  { 3811, 21, 35, 22, 1, -35 },
  { 3903, 22, 35, 20, -1, -35 },
  { 4000, 18, 35, 18, 4, -35 },
  { 4079, 24, 35, 25, 2, -35 },
  { 4184, 21, 35, 21, 4, -35 },
  { 4276, 33, 35, 34, 5, -35 },
  { 4421, 26, 35, 19, -3, -35 },
  { 4535, 19, 35, 18, 4, -35 },
  { 4619, 23, 35, 19, -2, -35 },
  { 4720, 18, 43, 14, -1, -35 },
  { 4817, 8, 35, 16, 5, -35 },
  { 4852, 18, 43, 14, -3, -35 },
  { 4949, 20, 19, 22, 1, -35 },
  { 4997, 16, 3, 15, -4, 4 },
  { 5003, 6, 7, 11, 7, -37 },
  { 5009, 19, 27, 22, 2, -27 },
  { 5074, 19, 37, 22, 1, -37 },
  { 5162, 16, 27, 17, 2, -27 },
  { 5216, 22, 37, 22, 2, -37 },
  { 5318, 16, 27, 19, 2, -27 },
  { 5372, 23, 49, 11, -6, -37 },
  { 5513, 21, 39, 22, 0, -27 },
  { 5616, 19, 37, 22, 1, -37 },
  { 5704, 10, 36, 9, 1, -36 },
  { 5749, 17, 48, 10, -6, -36 },
  { 5851, 19, 37, 18, 1, -37 },
  { 5939, 10, 37, 9, 1, -37 },
  { 5986, 30, 27, 32, 1, -27 },
  { 6088, 20, 27, 22, 0, -27 },
  { 6156, 18, 27, 21, 2, -27 },
  { 6217, 22, 38, 22, -2, -27 },
  { 6322, 19, 39, 22, 2, -27 },
  { 6415, 15, 27, 14, 1, -27 },
  { 6466, 16, 27, 16, 0, -27 },
  { 6520, 12, 32, 12, 1, -32 },
  { 6568, 19, 26, 22, 2, -26 },
  { 6630, 16, 26, 17, 3, -26 },
  { 6682, 26, 26, 27, 3, -26 },
  { 6767, 21, 26, 18, -2, -26 },
  { 6836, 25, 38, 17, -5, -26 },
  { 6955, 17, 26, 15, -1, -26 },
  { 7011, 18, 43, 16, 1, -35 },
  { 7108, 3, 49, 20, 9, -37 },
  { 7127, 18, 43, 16, -3, -35 },
  { 7224, 19, 5, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_LightItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC49PT7B_H_
