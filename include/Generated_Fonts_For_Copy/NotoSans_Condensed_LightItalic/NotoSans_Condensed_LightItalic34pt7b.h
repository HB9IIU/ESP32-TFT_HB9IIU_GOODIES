#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC34PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x1C, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x41, 0x83,
  0x06, 0x08, 0x10, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x60, 0x31, 0x91,
  0x98, 0xCC, 0x66, 0x32, 0x11, 0x18, 0x8C, 0xC4, 0x00, 0x00, 0xC3, 0x00,
  0x86, 0x00, 0x86, 0x01, 0x84, 0x01, 0x84, 0x01, 0x0C, 0x03, 0x08, 0x1F,
  0xFF, 0x02, 0x18, 0x02, 0x18, 0x06, 0x10, 0x04, 0x30, 0x04, 0x30, 0x0C,
  0x20, 0x0C, 0x20, 0xFF, 0xFC, 0x18, 0x40, 0x18, 0x40, 0x10, 0xC0, 0x30,
  0xC0, 0x30, 0x80, 0x21, 0x80, 0x21, 0x80, 0x61, 0x00, 0x00, 0x20, 0x00,
  0x80, 0x06, 0x00, 0x7E, 0x07, 0xFC, 0x31, 0x10, 0xC4, 0x06, 0x30, 0x18,
  0x80, 0x62, 0x00, 0x88, 0x03, 0x60, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x58, 0x03, 0x30, 0x08, 0xC0, 0x23, 0x00, 0x8C, 0x02, 0x30, 0x19, 0x8E,
  0x4C, 0x3F, 0xE0, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x06, 0x00,
  0x87, 0xC0, 0x43, 0x10, 0x30, 0x84, 0x08, 0x61, 0x06, 0x18, 0x43, 0x04,
  0x10, 0x83, 0x04, 0x60, 0xC3, 0x10, 0x30, 0xCC, 0x0C, 0x22, 0x3B, 0x19,
  0xBF, 0xC6, 0xC8, 0xF3, 0x26, 0x37, 0x99, 0x0C, 0x84, 0xC3, 0x03, 0x30,
  0xC1, 0x88, 0x30, 0x62, 0x08, 0x30, 0x82, 0x08, 0x61, 0x86, 0x18, 0x41,
  0x02, 0x30, 0xC0, 0xC8, 0x60, 0x3E, 0x00, 0x00, 0x40, 0x03, 0xE0, 0x0C,
  0x60, 0x30, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x18, 0x06, 0x30,
  0x0C, 0xC0, 0x1B, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xB0, 0x06, 0x61, 0x98,
  0xC3, 0x60, 0xCC, 0xC1, 0x9B, 0x01, 0xE6, 0x03, 0xCC, 0x03, 0x18, 0x0E,
  0x38, 0x3C, 0x39, 0xCC, 0x3F, 0x1C, 0x33, 0x66, 0x66, 0x44, 0xC0, 0x01,
  0xC0, 0x40, 0x30, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x06,
  0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x20, 0x00,
  0x03, 0x00, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60,
  0x30, 0x30, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x00, 0x06, 0x00, 0xC0,
  0x18, 0x62, 0x0E, 0x40, 0x7F, 0xC3, 0x00, 0xE0, 0x32, 0x1C, 0x61, 0x0C,
  0x00, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x1F, 0xFF, 0xFF, 0xF8, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x19, 0x8C, 0x66, 0x33, 0x18, 0xFF, 0xFC, 0xFC,
  0x00, 0x06, 0x00, 0x08, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10,
  0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x80, 0x1F,
  0x81, 0x8C, 0x18, 0x30, 0xC1, 0x8C, 0x0C, 0x40, 0x66, 0x03, 0x30, 0x19,
  0x00, 0xD8, 0x06, 0xC0, 0x36, 0x01, 0xB0, 0x1B, 0x00, 0xD8, 0x06, 0xC0,
  0x36, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0x61, 0x86, 0x0E, 0xE0,
  0x3E, 0x00, 0x07, 0x0F, 0x1A, 0x76, 0xE6, 0x46, 0x04, 0x0C, 0x0C, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x60,
  0x60, 0x60, 0x00, 0x60, 0x07, 0xF8, 0x1C, 0x30, 0x10, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0xFF,
  0xF0, 0x00, 0xE0, 0x1F, 0xE0, 0xE1, 0xC2, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60, 0x03, 0x00, 0x78, 0x0F, 0x80,
  0x07, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x60, 0x01, 0x88, 0x0C, 0x39, 0xF0, 0xFF, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x02, 0xC0, 0x1A, 0x00, 0xD8, 0x02, 0x60, 0x19, 0x80, 0xC4, 0x02,
  0x30, 0x18, 0xC0, 0xC3, 0x02, 0x0C, 0x18, 0x20, 0xC1, 0x82, 0x06, 0x18,
  0x18, 0xC0, 0x63, 0xFF, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x07, 0xFC, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x6E, 0x01, 0xFE, 0x04, 0x18,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x62, 0x03, 0x0E, 0x3C, 0x3F, 0xC0, 0x00, 0x38, 0x07,
  0xF0, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x04, 0x00, 0x30,
  0x00, 0xC0, 0x02, 0x7C, 0x1B, 0xF8, 0x70, 0x61, 0xC0, 0xC6, 0x03, 0x38,
  0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x06,
  0x0C, 0x1C, 0xE0, 0x3F, 0x00, 0x3F, 0xFA, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0x00, 0xE0, 0x0F, 0xE0,
  0x61, 0xC3, 0x03, 0x0C, 0x04, 0x30, 0x10, 0xC0, 0xC3, 0x03, 0x0C, 0x0C,
  0x30, 0x60, 0x67, 0x00, 0xF0, 0x03, 0x80, 0x3B, 0x01, 0x86, 0x0C, 0x0C,
  0x60, 0x31, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xC6, 0x06,
  0x1E, 0x70, 0x3F, 0x80, 0x00, 0x40, 0x0F, 0xC0, 0x61, 0x83, 0x02, 0x0C,
  0x0C, 0x60, 0x31, 0x80, 0xC4, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0xCC,
  0x07, 0x30, 0x38, 0x61, 0xE1, 0xFD, 0x81, 0xC6, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x18, 0x31, 0xC0, 0xFE, 0x00,
  0x0C, 0x70, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0xE3, 0x80, 0x03, 0x03, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x20, 0x60, 0xC0,
  0x00, 0x08, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x60, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x06, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x02, 0x00, 0x00, 0x02, 0x07, 0xF8, 0xC3, 0x00, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0x80, 0x30, 0x04, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x07, 0x00,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x1C, 0x1C, 0x03, 0x00, 0x60, 0x60, 0x02,
  0x0C, 0x00, 0x30, 0x80, 0x03, 0x18, 0x18, 0x33, 0x07, 0xE3, 0x30, 0xC6,
  0x32, 0x18, 0x63, 0x61, 0x04, 0x36, 0x30, 0xC3, 0x42, 0x0C, 0x24, 0x20,
  0xC2, 0xC6, 0x08, 0x6C, 0x61, 0x86, 0xC6, 0x18, 0x4C, 0x62, 0x8C, 0xC6,
  0x69, 0x8C, 0x3C, 0xF0, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0xEF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0xE0, 0x02, 0x80, 0x1A, 0x00, 0x68, 0x03, 0x20, 0x0C, 0xC0, 0x63,
  0x01, 0x8C, 0x04, 0x30, 0x30, 0xC0, 0x83, 0x06, 0x0C, 0x18, 0x30, 0xFF,
  0xC3, 0x03, 0x18, 0x0C, 0x60, 0x33, 0x00, 0xCC, 0x03, 0x60, 0x0D, 0x80,
  0x36, 0x00, 0xF0, 0x03, 0x0F, 0xF8, 0x18, 0x78, 0x30, 0x30, 0x60, 0x30,
  0xC0, 0x63, 0x00, 0xC6, 0x03, 0x0C, 0x06, 0x18, 0x1C, 0x20, 0x70, 0xFF,
  0xC1, 0xFE, 0x03, 0x07, 0x06, 0x06, 0x08, 0x06, 0x30, 0x0C, 0x60, 0x18,
  0xC0, 0x31, 0x80, 0xC6, 0x01, 0x8C, 0x07, 0x18, 0x1C, 0x3F, 0xF0, 0x7F,
  0x80, 0x00, 0x38, 0x03, 0xFC, 0x1E, 0x10, 0x70, 0x01, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x3E, 0xE0, 0x1F, 0xC0,
  0x0F, 0xF0, 0x0C, 0x7C, 0x0C, 0x0C, 0x0C, 0x06, 0x0C, 0x06, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x03, 0x18, 0x03, 0x10, 0x06, 0x30, 0x06, 0x30, 0x06,
  0x30, 0x06, 0x30, 0x06, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x18,
  0x60, 0x38, 0xC0, 0x30, 0xC0, 0x60, 0xC1, 0xC0, 0xFF, 0x80, 0xFE, 0x00,
  0x07, 0xFE, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x7F, 0xC0, 0xFF, 0x81, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0x03, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xC1, 0xE0,
  0xC1, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x26, 0x03, 0xE3,
  0x02, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x02, 0x18, 0x03,
  0x0C, 0x01, 0x87, 0x00, 0xC1, 0x80, 0x60, 0x79, 0xE0, 0x1F, 0xF0, 0x00,
  0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x01, 0x83,
  0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x02, 0x00, 0xC1, 0xFF,
  0xF0, 0x7F, 0xFC, 0x18, 0x03, 0x06, 0x00, 0x83, 0x00, 0x60, 0xC0, 0x18,
  0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x41, 0x80, 0x30, 0x60, 0x0C, 0x18,
  0x03, 0x06, 0x00, 0xC3, 0x00, 0x60, 0x07, 0xE0, 0x30, 0x04, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x60,
  0x0C, 0x07, 0xE0, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18,
  0x0F, 0xC0, 0x7C, 0x00, 0x06, 0x03, 0x83, 0x01, 0x81, 0x81, 0x80, 0xC1,
  0x80, 0x41, 0x80, 0x61, 0xC0, 0x31, 0xC0, 0x18, 0xC0, 0x0C, 0xC0, 0x04,
  0xC0, 0x06, 0xE0, 0x03, 0xF0, 0x01, 0xD8, 0x00, 0xCC, 0x00, 0xC3, 0x00,
  0x61, 0x80, 0x30, 0xC0, 0x18, 0x30, 0x0C, 0x18, 0x0C, 0x0C, 0x06, 0x06,
  0x03, 0x01, 0x81, 0x80, 0xC1, 0x80, 0x60, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x07, 0xFF,
  0xFF, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1E, 0x07, 0x80,
  0x1E, 0x05, 0x80, 0x34, 0x0D, 0x80, 0x3C, 0x0D, 0x80, 0x6C, 0x0D, 0x80,
  0x6C, 0x0D, 0x80, 0xCC, 0x09, 0x80, 0xC8, 0x19, 0x81, 0x98, 0x19, 0x81,
  0x98, 0x18, 0x83, 0x18, 0x18, 0x83, 0x18, 0x30, 0x86, 0x10, 0x30, 0x86,
  0x30, 0x30, 0xCC, 0x30, 0x30, 0xCC, 0x30, 0x20, 0xD8, 0x30, 0x60, 0xD8,
  0x60, 0x60, 0xF0, 0x60, 0x60, 0xF0, 0x60, 0x60, 0xE0, 0x60, 0xC0, 0xE0,
  0x40, 0x07, 0x00, 0x60, 0xE0, 0x0C, 0x1C, 0x01, 0x03, 0xC0, 0x60, 0x58,
  0x0C, 0x1B, 0x01, 0x83, 0x20, 0x30, 0x66, 0x04, 0x0C, 0xC1, 0x81, 0x18,
  0x30, 0x61, 0x06, 0x0C, 0x30, 0xC1, 0x86, 0x10, 0x30, 0xC6, 0x0C, 0x08,
  0xC1, 0x81, 0x98, 0x30, 0x33, 0x06, 0x06, 0x40, 0x80, 0x58, 0x30, 0x0F,
  0x06, 0x01, 0xE0, 0xC0, 0x38, 0x18, 0x07, 0x06, 0x00, 0x60, 0x00, 0x40,
  0x03, 0xF8, 0x07, 0x0C, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x03, 0x30, 0x03,
  0x30, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x02, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x30, 0x60, 0x60, 0x79, 0xC0, 0x3F, 0x80,
  0x0F, 0xF0, 0x31, 0xE0, 0xC1, 0xC3, 0x03, 0x0C, 0x0C, 0x60, 0x31, 0x80,
  0xC6, 0x03, 0x18, 0x0C, 0x40, 0x63, 0x01, 0x8C, 0x1C, 0x3F, 0xE0, 0xFE,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x00, 0x40, 0x03, 0xF8, 0x07, 0x0C,
  0x0C, 0x06, 0x18, 0x06, 0x18, 0x03, 0x30, 0x03, 0x30, 0x03, 0x60, 0x03,
  0x60, 0x03, 0x60, 0x03, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x38,
  0xC0, 0x30, 0x60, 0x60, 0x79, 0xC0, 0x3F, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x0F, 0xF0, 0x31, 0xE0,
  0xC1, 0xC3, 0x03, 0x0C, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x0C,
  0x40, 0x63, 0x03, 0x8C, 0x3C, 0x3F, 0xC0, 0xFE, 0x02, 0x18, 0x18, 0x60,
  0x61, 0x81, 0x83, 0x06, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x01, 0x8C, 0x06,
  0x20, 0x18, 0x00, 0xE0, 0x07, 0xFC, 0x1C, 0x30, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x20, 0x30, 0x7B, 0xE0, 0xFF,
  0x00, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C,
  0x00, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x02, 0x30, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x20, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x08, 0x40, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0,
  0x30, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0xE0, 0x73, 0xC0, 0x3F,
  0x80, 0xC0, 0x0F, 0x00, 0x6C, 0x01, 0xB0, 0x0C, 0xC0, 0x33, 0x00, 0xCC,
  0x06, 0x30, 0x18, 0xC0, 0xC3, 0x03, 0x0C, 0x18, 0x30, 0x60, 0x43, 0x01,
  0x0C, 0x04, 0x60, 0x11, 0x80, 0x46, 0x01, 0x30, 0x04, 0xC0, 0x16, 0x00,
  0x58, 0x01, 0x40, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x38, 0x07, 0x80, 0x70,
  0x1B, 0x00, 0xE0, 0x36, 0x03, 0xC0, 0x4C, 0x05, 0x81, 0x98, 0x1B, 0x03,
  0x30, 0x36, 0x0C, 0x60, 0x4C, 0x18, 0xC1, 0x98, 0x61, 0x82, 0x20, 0xC3,
  0x0C, 0x41, 0x86, 0x18, 0x86, 0x0C, 0x61, 0x0C, 0x18, 0xC2, 0x30, 0x31,
  0x04, 0x60, 0x66, 0x08, 0x80, 0xC8, 0x13, 0x01, 0xB0, 0x26, 0x03, 0x60,
  0x58, 0x06, 0x80, 0xB0, 0x0F, 0x01, 0x40, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0x70, 0x0C, 0x00, 0x03, 0x01, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x04,
  0x18, 0x01, 0x86, 0x00, 0x63, 0x00, 0x19, 0x80, 0x06, 0x60, 0x00, 0xB0,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x36, 0x00, 0x19, 0x80, 0x06, 0x20, 0x03, 0x0C, 0x00, 0xC3, 0x00, 0x60,
  0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x06, 0x01, 0x03, 0x00, 0x60, 0xC0, 0x3E,
  0x01, 0xB0, 0x18, 0x80, 0xC6, 0x0C, 0x30, 0xC1, 0x86, 0x0C, 0x60, 0x63,
  0x03, 0x30, 0x09, 0x80, 0x58, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18,
  0x00, 0x07, 0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0xFF,
  0xE0, 0x01, 0xF8, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00,
  0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0F, 0xE0,
  0x00, 0xC1, 0x06, 0x18, 0x61, 0x86, 0x08, 0x20, 0xC3, 0x0C, 0x30, 0xC1,
  0x04, 0x18, 0x61, 0x86, 0x18, 0x20, 0x83, 0x03, 0xF0, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x40, 0xFC, 0x00, 0x01, 0x80, 0x0E, 0x00, 0x2C, 0x01, 0xB0, 0x04, 0x40,
  0x31, 0x81, 0x86, 0x06, 0x0C, 0x30, 0x30, 0xC0, 0x46, 0x01, 0x90, 0x06,
  0xC0, 0x0C, 0xFF, 0xFF, 0xFC, 0xC4, 0x62, 0x30, 0x07, 0xCC, 0x39, 0xB1,
  0x82, 0x8E, 0x06, 0x30, 0x18, 0xC0, 0x66, 0x01, 0x18, 0x0C, 0x60, 0x33,
  0x00, 0xCC, 0x03, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x8C, 0x0E, 0x38, 0x58,
  0x73, 0x40, 0xF9, 0x00, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0xF8, 0x3C, 0x60, 0xA0, 0xC7,
  0x03, 0x1C, 0x0C, 0x60, 0x31, 0x80, 0xC4, 0x03, 0x30, 0x0C, 0xC0, 0x33,
  0x01, 0x8C, 0x06, 0x30, 0x19, 0xC0, 0xC7, 0x03, 0x1C, 0x18, 0x59, 0xC3,
  0x3E, 0x00, 0x07, 0xE1, 0xC4, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x71, 0x07, 0xE0, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x07, 0xCC, 0x0E, 0x6C, 0x18,
  0x28, 0x38, 0x18, 0x30, 0x18, 0x20, 0x18, 0x60, 0x18, 0x60, 0x30, 0x60,
  0x30, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x60, 0xC0, 0x60, 0xC0, 0xE0, 0xC0,
  0xE0, 0xC1, 0xE0, 0x63, 0x40, 0x3E, 0x40, 0x07, 0xE0, 0xE6, 0x18, 0x33,
  0x03, 0x30, 0x36, 0x06, 0x60, 0xE6, 0x1C, 0x7F, 0x0F, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x71, 0x83, 0xF8, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x40, 0x03, 0xF8, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00,
  0x18, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x03, 0xE6, 0x0E, 0x6C, 0x30, 0x50,
  0xE0, 0x61, 0x80, 0xC2, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x30, 0x18, 0xC0,
  0x31, 0x80, 0x63, 0x01, 0x86, 0x03, 0x0C, 0x0E, 0x18, 0x1C, 0x30, 0x78,
  0x39, 0xA0, 0x3E, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00,
  0x30, 0x40, 0xC0, 0xEF, 0x01, 0xFC, 0x00, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0D, 0xF8, 0x3C,
  0x60, 0xA0, 0xC7, 0x03, 0x1C, 0x0C, 0x60, 0x21, 0x81, 0x84, 0x06, 0x30,
  0x18, 0xC0, 0x63, 0x03, 0x0C, 0x0C, 0x20, 0x31, 0x80, 0xC6, 0x02, 0x18,
  0x18, 0x60, 0x63, 0x01, 0x80, 0x02, 0x0C, 0x18, 0x00, 0x00, 0x00, 0x06,
  0x0C, 0x10, 0x60, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x0C,
  0x18, 0x30, 0xC0, 0x00, 0x20, 0x07, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0x18, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x1C, 0x30, 0x60, 0x83,
  0x06, 0x18, 0x18, 0xC0, 0x66, 0x01, 0xB0, 0x05, 0xC0, 0x37, 0x00, 0xEC,
  0x03, 0x98, 0x0C, 0x60, 0x21, 0x81, 0x86, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC3, 0x03, 0x80, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20,
  0x60, 0x60, 0x60, 0x60, 0xC0, 0x0D, 0xF1, 0xF0, 0x59, 0xD9, 0xC3, 0x87,
  0x86, 0x38, 0x38, 0x31, 0x81, 0x81, 0x8C, 0x0C, 0x0C, 0x60, 0x60, 0x62,
  0x03, 0x03, 0x30, 0x30, 0x11, 0x81, 0x81, 0x8C, 0x0C, 0x0C, 0x60, 0x60,
  0x62, 0x02, 0x02, 0x30, 0x30, 0x31, 0x81, 0x81, 0x8C, 0x0C, 0x0C, 0x60,
  0x60, 0x66, 0x06, 0x02, 0x00, 0x0D, 0xF8, 0x2C, 0x60, 0xE0, 0xC7, 0x03,
  0x1C, 0x0C, 0x60, 0x61, 0x81, 0x84, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x03,
  0x0C, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x02, 0x18, 0x18, 0x60, 0x63, 0x01,
  0x80, 0x07, 0xE0, 0x73, 0x86, 0x0C, 0x60, 0x33, 0x01, 0xB0, 0x0D, 0x80,
  0x6C, 0x03, 0x40, 0x16, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x06, 0x60, 0x33,
  0x03, 0x0C, 0x18, 0x73, 0x81, 0xF8, 0x00, 0x06, 0x7C, 0x0B, 0x18, 0x14,
  0x18, 0x70, 0x30, 0xE0, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x18, 0x06,
  0x30, 0x0C, 0x60, 0x30, 0xC0, 0x61, 0x80, 0xC7, 0x03, 0x0E, 0x06, 0x1C,
  0x18, 0x2C, 0xE0, 0xCF, 0x81, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x07, 0xCC, 0x39, 0xB1,
  0x82, 0x8E, 0x06, 0x30, 0x18, 0xC0, 0x66, 0x01, 0x98, 0x0C, 0x60, 0x33,
  0x00, 0xCC, 0x03, 0x30, 0x18, 0xC0, 0x63, 0x03, 0x8C, 0x0E, 0x30, 0x78,
  0x63, 0x40, 0xFB, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0D, 0xE1, 0x74, 0x28, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x00, 0x0F, 0xE3, 0x8C, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0xC7, 0x1F, 0xC0, 0x0C, 0x08, 0x08, 0x18,
  0x7F, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x40,
  0xC0, 0xC0, 0xC0, 0xC0, 0xE8, 0x78, 0x18, 0x18, 0xC0, 0xC4, 0x06, 0x60,
  0x33, 0x01, 0x18, 0x18, 0xC0, 0xCC, 0x06, 0x60, 0x33, 0x01, 0x18, 0x18,
  0x80, 0xCC, 0x06, 0x60, 0x73, 0x03, 0x18, 0x28, 0xE6, 0xC3, 0xE6, 0x00,
  0xC0, 0x78, 0x0F, 0x03, 0x60, 0x6C, 0x19, 0x83, 0x30, 0xC6, 0x18, 0xC6,
  0x18, 0xC3, 0x10, 0x66, 0x0C, 0x80, 0xB0, 0x14, 0x03, 0x80, 0x70, 0x0C,
  0x00, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x1C, 0x1B, 0x05, 0x06, 0xC3, 0x41,
  0xB0, 0xD0, 0xCC, 0x64, 0x33, 0x19, 0x18, 0xC4, 0x46, 0x33, 0x11, 0x0C,
  0x84, 0xC3, 0x61, 0x30, 0xD8, 0x58, 0x3C, 0x16, 0x0F, 0x05, 0x03, 0x81,
  0xC0, 0xE0, 0x60, 0x30, 0x18, 0x00, 0x0C, 0x0C, 0x30, 0x60, 0xC1, 0x81,
  0x0C, 0x06, 0x60, 0x19, 0x00, 0x6C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x78, 0x03, 0x60, 0x19, 0x80, 0x62, 0x03, 0x0C, 0x18, 0x30, 0x60, 0xC3,
  0x01, 0x80, 0x03, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x03,
  0x03, 0x00, 0x41, 0x80, 0x10, 0x60, 0x04, 0x30, 0x01, 0x0C, 0x00, 0x46,
  0x00, 0x19, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x68, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x9C, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xF0, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06,
  0x00, 0xFF, 0x8F, 0xF8, 0x00, 0xF0, 0x1C, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x03,
  0x80, 0xE0, 0x07, 0x00, 0x10, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x1E, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x03, 0x80, 0xF0, 0x00, 0x38, 0x0F, 0xF0, 0xE1, 0xFD, 0x01, 0xC0,
};

const GFXglyph NotoSans_Condensed_LightItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 24, 8, 1, -24 },
  { 22, 9, 9, 11, 3, -24 },
  { 33, 16, 24, 16, 0, -24 },
  { 81, 14, 28, 14, 0, -26 },
  { 130, 18, 25, 21, 2, -25 },
  { 187, 15, 25, 16, 0, -25 },
  { 234, 4, 9, 6, 3, -24 },
  { 239, 10, 29, 9, 1, -24 },
  { 276, 9, 29, 9, -2, -24 },
  { 309, 11, 12, 14, 4, -26 },
  { 326, 13, 16, 16, 2, -20 },
  { 352, 5, 8, 7, -1, -4 },
  { 357, 7, 2, 9, 1, -10 },
  { 359, 2, 3, 7, 1, -3 },
  { 360, 15, 24, 11, -2, -24 },
  { 405, 13, 25, 14, 1, -25 },
  { 446, 8, 24, 14, 4, -24 },
  { 470, 15, 25, 14, -1, -25 },
  { 517, 14, 25, 14, 0, -25 },
  { 561, 14, 24, 14, 0, -24 },
  { 603, 14, 24, 14, 0, -24 },
  { 645, 14, 25, 14, 1, -25 },
  { 689, 13, 24, 14, 2, -24 },
  { 728, 14, 25, 14, 0, -25 },
  { 772, 14, 25, 14, 0, -25 },
  { 816, 6, 18, 7, 0, -18 },
  { 830, 8, 22, 7, -2, -18 },
  { 852, 13, 15, 16, 2, -20 },
  { 877, 13, 8, 16, 2, -16 },
  { 890, 13, 15, 16, 2, -20 },
  { 915, 11, 25, 11, 1, -25 },
  { 950, 20, 27, 22, 1, -24 },
  { 1018, 14, 24, 14, -2, -24 },
  { 1060, 15, 24, 16, 1, -24 },
  { 1105, 15, 25, 15, 2, -25 },
  { 1152, 16, 24, 17, 1, -24 },
  { 1200, 15, 24, 14, 0, -24 },
  { 1245, 15, 24, 13, 0, -24 },
  { 1290, 17, 25, 18, 2, -25 },
  { 1344, 18, 24, 18, 0, -24 },
  { 1398, 11, 24, 8, -1, -24 },
  { 1431, 13, 30, 7, -5, -24 },
  { 1480, 17, 24, 15, 0, -24 },
  { 1531, 10, 24, 13, 0, -24 },
  { 1561, 24, 24, 23, 0, -24 },
  { 1633, 19, 24, 19, 0, -24 },
  { 1690, 16, 25, 19, 2, -25 },
  { 1740, 14, 24, 15, 1, -24 },
  { 1782, 16, 31, 19, 2, -25 },
  { 1844, 14, 24, 15, 1, -24 },
  { 1886, 15, 25, 14, 0, -25 },
  { 1933, 12, 24, 13, 3, -24 },
  { 1969, 16, 24, 18, 2, -24 },
  { 2017, 14, 24, 14, 3, -24 },
  { 2059, 23, 24, 23, 3, -24 },
  { 2128, 18, 24, 13, -2, -24 },
  { 2182, 13, 24, 13, 3, -24 },
  { 2221, 16, 24, 13, -1, -24 },
  { 2269, 13, 29, 10, -1, -24 },
  { 2317, 6, 24, 11, 3, -24 },
  { 2335, 12, 29, 10, -2, -24 },
  { 2379, 14, 13, 15, 1, -24 },
  { 2402, 11, 2, 11, -3, 3 },
  { 2405, 4, 5, 8, 5, -26 },
  { 2408, 14, 18, 15, 1, -18 },
  { 2440, 14, 26, 15, 0, -26 },
  { 2486, 11, 18, 12, 1, -18 },
  { 2511, 16, 26, 15, 1, -26 },
  { 2563, 12, 18, 13, 1, -18 },
  { 2590, 16, 34, 8, -4, -26 },
  { 2658, 15, 26, 15, 0, -18 },
  { 2707, 14, 26, 15, 0, -26 },
  { 2753, 7, 25, 7, 0, -25 },
  { 2775, 12, 33, 7, -4, -25 },
  { 2825, 14, 26, 13, 0, -26 },
  { 2871, 8, 26, 6, 0, -26 },
  { 2897, 21, 18, 23, 0, -18 },
  { 2945, 14, 18, 15, 0, -18 },
  { 2977, 13, 18, 15, 1, -18 },
  { 3007, 15, 26, 15, -1, -18 },
  { 3056, 14, 26, 15, 1, -18 },
  { 3102, 11, 18, 10, 0, -18 },
  { 3127, 11, 18, 11, 0, -18 },
  { 3152, 8, 22, 8, 1, -22 },
  { 3174, 13, 18, 15, 1, -18 },
  { 3204, 11, 18, 12, 2, -18 },
  { 3229, 18, 18, 19, 2, -18 },
  { 3270, 14, 18, 12, -1, -18 },
  { 3302, 18, 26, 12, -4, -18 },
  { 3361, 12, 18, 11, -1, -18 },
  { 3388, 12, 29, 11, 1, -24 },
  { 3432, 2, 34, 14, 6, -26 },
  { 3441, 12, 29, 11, -2, -24 },
  { 3485, 13, 4, 16, 2, -14 },
};

const GFXfont NotoSans_Condensed_LightItalic34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC34PT7B_H_
