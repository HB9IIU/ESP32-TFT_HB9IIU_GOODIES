#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC69PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x1E, 0x07, 0x8F,
  0x07, 0x87, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x70, 0xE0, 0x78,
  0x70, 0x3C, 0x78, 0x1E, 0x3C, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x03,
  0xC3, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x18, 0x00,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x80, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x38, 0x07, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0x38, 0x07, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x70, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xC6, 0x0E, 0x01, 0xF0, 0x60, 0x20, 0x1E, 0x0E, 0x00, 0x03, 0xC0,
  0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x38, 0x0C, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0x80, 0x00, 0x3C,
  0x18, 0x00, 0x03, 0xC1, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xF3, 0x80,
  0x00, 0x0F, 0xB0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0E, 0xF8, 0x00, 0x00, 0xE7, 0xC0, 0x00, 0x0C, 0x3E, 0x00,
  0x00, 0xC1, 0xE0, 0x00, 0x0C, 0x1E, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C,
  0x0E, 0x00, 0x01, 0x80, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x01, 0x80, 0xE0,
  0x00, 0x38, 0x1E, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x30, 0x3C, 0x08, 0x03,
  0x07, 0x80, 0xE0, 0x70, 0xF8, 0x0F, 0xE7, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0xFF, 0xC0, 0x00, 0xE0, 0x0F, 0x8F,
  0x00, 0x0F, 0x00, 0x70, 0x38, 0x00, 0x70, 0x07, 0x81, 0xC0, 0x07, 0x00,
  0x38, 0x0E, 0x00, 0x78, 0x03, 0x80, 0x70, 0x03, 0x80, 0x1C, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x1E, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0xF0,
  0x01, 0xC0, 0x1E, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x07,
  0x03, 0x80, 0x07, 0x80, 0x38, 0x3C, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0x01,
  0xC0, 0x1C, 0x1C, 0x00, 0x0E, 0x00, 0xE1, 0xE0, 0xFC, 0x70, 0x07, 0x0E,
  0x1F, 0xF3, 0x80, 0x70, 0xF1, 0xFF, 0xDC, 0x03, 0x87, 0x0F, 0x1E, 0xE0,
  0x3C, 0x70, 0xE0, 0x77, 0x01, 0xC3, 0x8F, 0x03, 0xFC, 0x1E, 0x38, 0x70,
  0x1E, 0xF1, 0xE3, 0xC7, 0x80, 0xF7, 0xFE, 0x1C, 0x38, 0x07, 0x9F, 0xE1,
  0xE1, 0xC0, 0x3C, 0x7C, 0x0E, 0x1C, 0x01, 0xC0, 0x00, 0xE0, 0xE0, 0x0E,
  0x00, 0x0F, 0x07, 0x00, 0x70, 0x00, 0x70, 0x78, 0x03, 0x80, 0x07, 0x83,
  0x80, 0x1C, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0x03, 0xC0, 0xE0, 0x0F, 0x00,
  0x1C, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x1E, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x78,
  0x03, 0x80, 0x07, 0x03, 0x80, 0x3C, 0x00, 0x38, 0x3C, 0x01, 0xC0, 0x01,
  0xE3, 0xC0, 0x1E, 0x00, 0x07, 0xFC, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x78, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x1F, 0x1E, 0x00, 0x10, 0x7C, 0x3C, 0x01, 0xC1, 0xF0, 0x3C, 0x07,
  0x83, 0xC0, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0x1C, 0x3C, 0x00, 0xF0, 0x78,
  0x78, 0x01, 0xE0, 0xE0, 0xE0, 0x01, 0xE3, 0xC3, 0xC0, 0x03, 0xC7, 0x07,
  0x80, 0x03, 0xDE, 0x0E, 0x00, 0x07, 0xB8, 0x1C, 0x00, 0x0F, 0xF0, 0x78,
  0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x1F, 0x81, 0xE0, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x7C, 0x03, 0xC0, 0x01, 0xFC, 0x07, 0x80, 0x07, 0xF8, 0x0F, 0x80,
  0x3E, 0xF0, 0x0F, 0x80, 0xF8, 0xF0, 0x1F, 0xFF, 0xE1, 0xE0, 0x1F, 0xFF,
  0x81, 0xE0, 0x0F, 0xFC, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x3C,
  0x79, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xF1, 0xC3, 0x87, 0x0E, 0x18, 0x70,
  0xE1, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x01, 0x00, 0xE0, 0x0F, 0x03, 0x80, 0x3E, 0x0E, 0x00,
  0x7E, 0x30, 0x00, 0x7E, 0xC3, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x39, 0x80, 0x01, 0xC7, 0x00, 0x1E, 0x1C,
  0x00, 0xF8, 0x38, 0x07, 0xC0, 0xE0, 0x1E, 0x01, 0xC0, 0x30, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0,
  0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x39, 0xFF, 0xFF, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xEF,
  0xC0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x38,
  0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x3C, 0x78, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x78, 0xF0, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0x70,
  0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x83,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFE,
  0x01, 0xEE, 0x07, 0xDE, 0x0F, 0x9E, 0x1F, 0x1E, 0x7E, 0x1C, 0xF8, 0x3C,
  0x70, 0x3C, 0x20, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xBF, 0xC0, 0x03, 0xF0,
  0x0F, 0x80, 0x03, 0x80, 0x0F, 0x80, 0x02, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x38, 0x00, 0xF8, 0x01, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x40, 0x00, 0xFC, 0x03, 0x80, 0x0F, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x70,
  0x70, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x3C,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03,
  0x80, 0x1C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x07,
  0x80, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x03, 0x80, 0x01, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x20, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x08, 0x00, 0x1F, 0x80, 0x70, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F,
  0x8E, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x10, 0x00, 0x1E, 0x1F, 0xF0,
  0x01, 0xE7, 0xFF, 0x80, 0x1C, 0xFF, 0xFC, 0x03, 0xDE, 0x03, 0xE0, 0x3F,
  0x80, 0x1E, 0x03, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x07, 0xE0, 0x00,
  0xF0, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0x70, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x07, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x03,
  0xE0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x80, 0x70, 0x00, 0x3C, 0x03,
  0x80, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC1, 0xF0,
  0x00, 0x0F, 0x1F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x7E, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x38, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x83, 0x80, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07,
  0xC0, 0x01, 0xE0, 0x1F, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xCF, 0xC0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x00,
  0x70, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x01,
  0xC3, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x3C, 0x38, 0x00, 0x07, 0x87, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x3E,
  0x1C, 0x00, 0x07, 0xC3, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00,
  0x0F, 0xC1, 0xF0, 0x03, 0xF8, 0x1E, 0x00, 0xEF, 0x03, 0xF0, 0x7D, 0xC0,
  0x3F, 0xFF, 0x38, 0x03, 0xFF, 0x8F, 0x00, 0x3F, 0xC1, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x20, 0x0F, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1E, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x3E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xFF, 0x01, 0xFD, 0xFE, 0x07, 0x00, 0xF8, 0x10, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xE7, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x00, 0x38, 0x0E,
  0x00, 0x3F, 0xF8, 0x1E, 0x0E, 0x00, 0x3F, 0xFC, 0x0F, 0x07, 0x00, 0x7C,
  0x1C, 0x03, 0x87, 0x00, 0x78, 0x0E, 0x03, 0xC3, 0x80, 0x38, 0x07, 0x01,
  0xE3, 0xC0, 0x38, 0x07, 0x80, 0xF1, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0xE0,
  0x1C, 0x01, 0xC0, 0x38, 0xF0, 0x1E, 0x00, 0xE0, 0x1C, 0x70, 0x0E, 0x00,
  0xF0, 0x0E, 0x38, 0x0F, 0x00, 0x70, 0x07, 0x1C, 0x07, 0x00, 0x38, 0x07,
  0x9E, 0x03, 0x80, 0x3C, 0x03, 0x8E, 0x03, 0xC0, 0x1E, 0x01, 0xC7, 0x01,
  0xC0, 0x0E, 0x00, 0xE3, 0x80, 0xE0, 0x07, 0x00, 0xE1, 0xC0, 0x70, 0x07,
  0x80, 0x70, 0xE0, 0x38, 0x03, 0xC0, 0x38, 0xF0, 0x1C, 0x01, 0xC0, 0x38,
  0x78, 0x0E, 0x01, 0xE0, 0x1C, 0x3C, 0x07, 0x00, 0xF0, 0x1C, 0x1C, 0x03,
  0x80, 0xD8, 0x0E, 0x0E, 0x01, 0xC0, 0xEC, 0x0E, 0x07, 0x00, 0xF0, 0xE7,
  0x0E, 0x03, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xE0, 0x1F, 0xF0, 0xFF, 0x00,
  0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x20, 0x00, 0x00, 0xFC, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x3C, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x38, 0x3E,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x1F, 0xC0, 0x07, 0x80, 0x0F, 0xC0, 0x0F,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x70,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x01,
  0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x70, 0x00, 0x1F, 0x01, 0xE0, 0x00,
  0x7C, 0x03, 0xC0, 0x01, 0xF8, 0x07, 0x80, 0x07, 0xE0, 0x0F, 0x01, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0xFC, 0x00, 0xC0, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x06, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0xFF, 0x00,
  0x07, 0x80, 0x0F, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0xF0, 0x07, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x00, 0xF0, 0x1C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x80, 0x1C, 0x00, 0x0F, 0x80,
  0x1E, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x80, 0x07, 0x80, 0x3F, 0x80,
  0x03, 0x83, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x40, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x01, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xC1, 0xE0, 0x00, 0x7F, 0xF0,
  0x3C, 0x00, 0x1F, 0xFE, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0xE0, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0x00,
  0x00, 0xF0, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x03, 0x80, 0x03,
  0xF8, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x40, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x0F, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x0F, 0x80, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0x70, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0xF0, 0x1F, 0x00, 0x00, 0x38, 0x0F, 0x80, 0x00, 0x1E, 0x07, 0xC0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x70, 0x7C, 0x00,
  0x00, 0x3C, 0x3E, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x03, 0xCF, 0x80,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x39, 0xF8, 0x00, 0x00, 0x1E, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFD, 0xE0, 0x00, 0x00, 0x7E,
  0x3C, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1D, 0xC0,
  0x00, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x77, 0x00,
  0x00, 0x07, 0x78, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x03, 0xDE, 0x00,
  0x00, 0x39, 0xC0, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x0E, 0x78, 0x00,
  0x01, 0xCF, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x00,
  0x0E, 0x3C, 0x00, 0xF1, 0xC0, 0x00, 0x3C, 0x70, 0x01, 0xE3, 0x80, 0x00,
  0x71, 0xE0, 0x03, 0x87, 0x00, 0x01, 0xE3, 0xC0, 0x0F, 0x0E, 0x00, 0x03,
  0x87, 0x80, 0x1E, 0x1C, 0x00, 0x0F, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0x70, 0x00, 0x78, 0x78, 0x00, 0xE0, 0xF0, 0x00, 0xE0,
  0xF0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x03,
  0x80, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x38, 0x1E,
  0x00, 0x38, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x1C, 0x01, 0xC0, 0x78,
  0x01, 0xE0, 0x38, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0x1E, 0x01, 0xC0, 0x70, 0x0F, 0x00,
  0x3C, 0x03, 0x81, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x03, 0x80, 0x38, 0x00,
  0xF0, 0x0E, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x1E, 0x1C, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0xF3, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE7, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xDE, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xB8, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x1F, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x00, 0x78, 0x01, 0xFC,
  0x00, 0x01, 0xC0, 0x07, 0x70, 0x00, 0x07, 0x00, 0x1D, 0xE0, 0x00, 0x3C,
  0x00, 0x77, 0x80, 0x00, 0xF0, 0x03, 0xDE, 0x00, 0x03, 0xC0, 0x0F, 0x38,
  0x00, 0x0E, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0x00, 0xE3, 0xC0, 0x01, 0xE0,
  0x03, 0x8F, 0x00, 0x07, 0x80, 0x1E, 0x1C, 0x00, 0x1E, 0x00, 0x78, 0x78,
  0x00, 0x70, 0x01, 0xE1, 0xE0, 0x03, 0xC0, 0x07, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0xF0,
  0x03, 0x80, 0x0E, 0x03, 0xC0, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x78, 0x01,
  0xE0, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x07, 0x00, 0x1E, 0x01, 0xE0,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x0E, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x01, 0xC1,
  0xE0, 0x03, 0x80, 0x07, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x78,
  0x00, 0x78, 0x78, 0x01, 0xE0, 0x00, 0xE1, 0xC0, 0x07, 0x80, 0x03, 0x8F,
  0x00, 0x1C, 0x00, 0x0F, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0xF0, 0x03, 0xC0,
  0x00, 0x73, 0x80, 0x0F, 0x00, 0x01, 0xCE, 0x00, 0x38, 0x00, 0x07, 0xB8,
  0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x07, 0x80, 0x00, 0x7F, 0x80, 0x1E, 0x00,
  0x00, 0xFC, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x01, 0xC0, 0x00, 0x0F, 0xC0,
  0x0F, 0x00, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xF0, 0x07, 0xC0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x1C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87,
  0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xF0,
  0x07, 0x80, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0E, 0x03,
  0xFC, 0x00, 0x78, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x07,
  0x80, 0x1E, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xF0,
  0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03,
  0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x78, 0x07, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x7C,
  0x01, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x3F, 0x80, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x07,
  0x80, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0E, 0x03, 0xFC, 0x00, 0x78, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1E,
  0x00, 0x70, 0x00, 0x38, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0, 0x1E,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x01,
  0xE0, 0x0F, 0x00, 0x0F, 0x80, 0x38, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0xE0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0,
  0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x78, 0x03,
  0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x1E,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF0, 0x00, 0x20, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x03, 0x00,
  0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x38, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1C, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x38, 0x07,
  0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xF0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1E,
  0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x0E,
  0x00, 0x07, 0x80, 0x70, 0x00, 0x78, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x03,
  0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0xF0, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xE7,
  0x80, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xB8, 0x00, 0x07, 0xE0,
  0x00, 0x3C, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xF3, 0x80, 0x00, 0x7E, 0x00,
  0x07, 0x8E, 0x00, 0x03, 0xF8, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0xE0, 0x00,
  0x78, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xDC, 0x00, 0x0F,
  0x0E, 0x00, 0x0F, 0x70, 0x00, 0x78, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0xE7, 0x00, 0x07, 0x83, 0x80, 0x07, 0x9C, 0x00, 0x3C, 0x0E,
  0x00, 0x1C, 0x70, 0x00, 0xF0, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x80, 0xE0,
  0x03, 0x87, 0x00, 0x1E, 0x03, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0x0E, 0x00,
  0x78, 0x70, 0x03, 0xC0, 0x38, 0x01, 0xC1, 0xC0, 0x0F, 0x00, 0xE0, 0x0F,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xE0, 0x0E, 0x01, 0xE0,
  0x70, 0x07, 0x00, 0x38, 0x07, 0x01, 0xC0, 0x3C, 0x00, 0xE0, 0x1C, 0x07,
  0x00, 0xF0, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0x0E, 0x03, 0x80, 0x70,
  0x1E, 0x00, 0x38, 0x1E, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x70, 0x07, 0x03,
  0xC0, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x70, 0x78,
  0x00, 0x38, 0x38, 0x01, 0xC1, 0xE0, 0x00, 0xE1, 0xE0, 0x07, 0x0F, 0x00,
  0x03, 0x87, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x70, 0xE0, 0x00,
  0x38, 0xF0, 0x01, 0xC7, 0x80, 0x00, 0xE3, 0x80, 0x07, 0x1E, 0x00, 0x03,
  0x9E, 0x00, 0x1C, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x73, 0xC0, 0x00, 0x3B,
  0xC0, 0x01, 0xCE, 0x00, 0x00, 0xEE, 0x00, 0x07, 0x78, 0x00, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x77, 0x00, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x3C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x1E,
  0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF1,
  0xC0, 0x00, 0x3C, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x03, 0x80,
  0x0F, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x03, 0xC0,
  0x01, 0xC1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9E,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C,
  0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x38, 0x78,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xE0, 0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x0F, 0x00, 0x70, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x3C, 0x00,
  0x01, 0xC7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0F,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF8, 0x78,
  0x78, 0x3C, 0x3C, 0x1E, 0x0E, 0x0E, 0x07, 0x03, 0x00, 0x0F, 0xF0, 0x70,
  0x03, 0xFF, 0x87, 0x00, 0x7F, 0xFC, 0xF0, 0x0F, 0xC1, 0xCE, 0x01, 0xF0,
  0x0E, 0xE0, 0x3E, 0x00, 0x6E, 0x03, 0xC0, 0x07, 0xE0, 0x78, 0x00, 0x7E,
  0x0F, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0x78,
  0x00, 0x07, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x7C, 0x0F, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0xFC, 0x07, 0x80, 0x1F, 0x80,
  0x7C, 0x03, 0xB8, 0x03, 0xC0, 0x73, 0x80, 0x3F, 0xFE, 0x38, 0x01, 0xFF,
  0xC3, 0x80, 0x0F, 0xF8, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1E, 0x0F, 0xE0, 0x01, 0xE3, 0xFF, 0x80, 0x1E, 0x7F, 0xFC,
  0x01, 0xCF, 0x07, 0xC0, 0x1D, 0xE0, 0x3E, 0x03, 0xF8, 0x01, 0xE0, 0x3F,
  0x80, 0x1E, 0x03, 0xF0, 0x00, 0xE0, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0xF0, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1C, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78,
  0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x07, 0xE0,
  0x03, 0xE0, 0x76, 0x00, 0x7C, 0x07, 0x70, 0x07, 0x80, 0xF7, 0x81, 0xF0,
  0x0E, 0x3F, 0xFE, 0x00, 0xE3, 0xFF, 0xC0, 0x0E, 0x0F, 0xF8, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8,
  0x07, 0xE0, 0x60, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x03, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xF0, 0x70, 0x00, 0x3F, 0xF8,
  0xF0, 0x00, 0x7F, 0xFC, 0xF0, 0x00, 0xFC, 0x1E, 0xF0, 0x01, 0xF0, 0x0E,
  0xE0, 0x03, 0xE0, 0x06, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0x80, 0x03,
  0xE0, 0x07, 0x80, 0x03, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03,
  0x80, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x38, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x78, 0x01, 0xFC,
  0x00, 0x78, 0x03, 0xB8, 0x00, 0x3C, 0x0F, 0x38, 0x00, 0x3F, 0xFE, 0x38,
  0x00, 0x1F, 0xFC, 0x38, 0x00, 0x0F, 0xF8, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xF8,
  0x1E, 0x01, 0xF0, 0x0F, 0x03, 0xE0, 0x0F, 0x03, 0xC0, 0x0F, 0x07, 0x80,
  0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x1E, 0x00,
  0x1E, 0x1C, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x38, 0x03,
  0xF0, 0x78, 0x1F, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x20, 0x3E, 0x00, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x1C, 0x00, 0x3F, 0xF8,
  0x70, 0x01, 0xFF, 0xF1, 0xC0, 0x0F, 0xC1, 0xEF, 0x00, 0x7C, 0x03, 0xB8,
  0x03, 0xE0, 0x06, 0xE0, 0x0F, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0xF0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF8, 0x0F, 0x00,
  0x07, 0xE0, 0x3C, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xFC, 0x01, 0xE0, 0x07,
  0xF0, 0x07, 0x80, 0x1F, 0xC0, 0x1E, 0x00, 0xEE, 0x00, 0x3C, 0x0F, 0x38,
  0x00, 0xFF, 0xF9, 0xE0, 0x01, 0xFF, 0xC7, 0x80, 0x03, 0xFE, 0x1E, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x80, 0x03, 0xC0, 0x03, 0x80, 0x3F, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x07, 0xF0, 0x01, 0xE3,
  0xFF, 0x80, 0x3C, 0xFF, 0xF8, 0x07, 0x3C, 0x1F, 0x00, 0xEE, 0x01, 0xE0,
  0x3F, 0x80, 0x1E, 0x07, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x1F, 0x00,
  0x0F, 0x03, 0xC0, 0x01, 0xC0, 0xF8, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x03,
  0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x1C, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E,
  0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x07, 0x80,
  0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0,
  0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x3C,
  0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x81,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x70, 0xF0, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x7B, 0xF0,
  0x00, 0x0E, 0x7E, 0x00, 0x01, 0xDD, 0xE0, 0x00, 0x7F, 0x3C, 0x00, 0x0F,
  0xC7, 0x80, 0x01, 0xF8, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x80, 0x78, 0x00, 0xE0,
  0x0F, 0x00, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x00,
  0x1E, 0x03, 0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x01,
  0xE1, 0xFE, 0x01, 0xFE, 0x00, 0x70, 0xFF, 0xC0, 0xFF, 0xC0, 0x1C, 0xFF,
  0xF8, 0xFF, 0xF8, 0x07, 0x38, 0x3E, 0x78, 0x3F, 0x01, 0xDC, 0x07, 0x9C,
  0x03, 0xC0, 0xFE, 0x00, 0xFE, 0x00, 0xF0, 0x3F, 0x00, 0x3F, 0x00, 0x3C,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x00,
  0xE0, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x01, 0xE0, 0x00, 0xE0,
  0x70, 0x00, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0xFF, 0x00, 0x38, 0x7F, 0xF0, 0x07, 0x1F, 0xFF,
  0x00, 0xE7, 0x83, 0xE0, 0x1D, 0xC0, 0x3C, 0x07, 0xF0, 0x03, 0xC0, 0xFC,
  0x00, 0x78, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x38,
  0x1F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x0E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x0F,
  0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xE0, 0x70, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE0,
  0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x0E, 0x0F, 0x80, 0x03,
  0xC3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x38,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E,
  0x78, 0x00, 0x07, 0x9C, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x70, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0x81, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x0E, 0x0F, 0xE0, 0x00, 0x1C, 0x3F, 0xF8, 0x00, 0x1C, 0x7F, 0xFC, 0x00,
  0x1C, 0xF0, 0x7C, 0x00, 0x1D, 0xE0, 0x3E, 0x00, 0x3D, 0xC0, 0x1E, 0x00,
  0x3F, 0x80, 0x1E, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0x60, 0x0F, 0x80, 0x07,
  0x70, 0x1F, 0x00, 0x0F, 0x3F, 0xFE, 0x00, 0x0F, 0x1F, 0xFC, 0x00, 0x0F,
  0x0F, 0xF8, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x70, 0x03,
  0xFF, 0x87, 0x00, 0x7F, 0xFC, 0x70, 0x0F, 0x81, 0xEF, 0x01, 0xF0, 0x0E,
  0xE0, 0x3E, 0x00, 0x6E, 0x03, 0xC0, 0x07, 0xE0, 0x78, 0x00, 0x3E, 0x07,
  0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x78, 0x38, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x7C,
  0x0F, 0x00, 0x0F, 0xC0, 0x70, 0x00, 0xFC, 0x07, 0x80, 0x1F, 0xC0, 0x78,
  0x03, 0xB8, 0x03, 0xC0, 0x73, 0x80, 0x3F, 0xFE, 0x78, 0x01, 0xFF, 0xC7,
  0x80, 0x0F, 0xF8, 0x78, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC1, 0xFC, 0x07, 0x0F, 0xF0, 0x1C, 0x7F, 0x80, 0x73, 0xE2,
  0x01, 0xDE, 0x00, 0x0F, 0xE0, 0x00, 0x3B, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0x00, 0xE0, 0x7C, 0x00, 0x40, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x80, 0x07, 0x81, 0x80, 0x1F, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x07, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x0F, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x78, 0x1E,
  0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x07,
  0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xF0,
  0x38, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00,
  0x7E, 0x07, 0x80, 0x1F, 0xC0, 0x78, 0x07, 0x70, 0x0F, 0x81, 0xEE, 0x01,
  0xFF, 0xF9, 0xC0, 0x1F, 0xFC, 0x38, 0x01, 0xFF, 0x07, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80,
  0x01, 0xEF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0x78, 0x00,
  0x78, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x07, 0x80, 0x1E,
  0x0F, 0x00, 0x38, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0x38, 0x07, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x3C, 0x01, 0xC0, 0x78, 0x03, 0x81, 0xE0, 0x07,
  0x03, 0xC0, 0x0E, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x78, 0x00, 0x70,
  0xF0, 0x00, 0xE3, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0x8E, 0x00, 0x07, 0x3C,
  0x00, 0x0F, 0x70, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x03, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0x80, 0x0F,
  0x78, 0x00, 0xFC, 0x00, 0xF3, 0xC0, 0x0E, 0xE0, 0x07, 0x9E, 0x00, 0x77,
  0x00, 0x38, 0xF0, 0x07, 0xB8, 0x03, 0xC7, 0x80, 0x39, 0xC0, 0x1E, 0x3C,
  0x01, 0xCE, 0x01, 0xE1, 0xE0, 0x1C, 0x70, 0x0F, 0x0F, 0x00, 0xE3, 0x80,
  0x70, 0x78, 0x0F, 0x1C, 0x07, 0x83, 0xC0, 0x70, 0xE0, 0x38, 0x1E, 0x07,
  0x87, 0x03, 0xC0, 0xF0, 0x38, 0x38, 0x1E, 0x07, 0x81, 0xC1, 0xC0, 0xE0,
  0x3C, 0x1C, 0x0E, 0x0F, 0x01, 0xE0, 0xE0, 0x70, 0x70, 0x0F, 0x0F, 0x03,
  0x87, 0x80, 0x78, 0x70, 0x1C, 0x3C, 0x03, 0xC7, 0x80, 0xE1, 0xC0, 0x1E,
  0x38, 0x07, 0x1E, 0x00, 0xF3, 0xC0, 0x38, 0xE0, 0x07, 0x9C, 0x01, 0xCF,
  0x00, 0x3C, 0xE0, 0x0E, 0x70, 0x01, 0xEF, 0x00, 0x73, 0x80, 0x0F, 0x70,
  0x03, 0xBC, 0x00, 0x7F, 0x80, 0x1D, 0xC0, 0x03, 0xF8, 0x00, 0xEE, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x01, 0xE0,
  0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x78, 0xE0, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07,
  0x80, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x38, 0x78, 0x00, 0x00, 0x07, 0x0E,
  0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x27, 0xFF, 0x00, 0x05, 0xFF, 0xF8, 0x01, 0xFC, 0x3F,
  0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x20, 0x00, 0x3F, 0xC0,
};

const GFXglyph NotoSans_Condensed_LightItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 15, 49, 15, 1, -49 },
  { 93, 17, 18, 22, 7, -49 },
  { 132, 32, 49, 32, 1, -49 },
  { 328, 28, 56, 29, 1, -52 },
  { 524, 37, 51, 43, 4, -50 },
  { 760, 31, 51, 32, 0, -50 },
  { 958, 7, 18, 12, 7, -49 },
  { 974, 20, 60, 18, 2, -49 },
  { 1124, 20, 60, 18, -5, -49 },
  { 1274, 22, 23, 28, 8, -52 },
  { 1338, 27, 33, 32, 3, -41 },
  { 1450, 11, 16, 13, -3, -7 },
  { 1472, 15, 3, 19, 2, -20 },
  { 1478, 6, 6, 13, 1, -6 },
  { 1483, 30, 49, 22, -3, -49 },
  { 1667, 27, 51, 29, 2, -50 },
  { 1840, 16, 49, 29, 8, -49 },
  { 1938, 31, 50, 29, -2, -50 },
  { 2132, 29, 51, 29, 0, -50 },
  { 2317, 30, 50, 29, -1, -50 },
  { 2505, 29, 50, 29, 0, -49 },
  { 2687, 28, 51, 29, 2, -50 },
  { 2866, 27, 49, 29, 4, -49 },
  { 3032, 29, 51, 29, 0, -50 },
  { 3217, 27, 51, 29, 1, -50 },
  { 3390, 12, 37, 13, 1, -37 },
  { 3446, 16, 46, 14, -3, -37 },
  { 3538, 27, 31, 32, 3, -40 },
  { 3643, 27, 18, 32, 3, -33 },
  { 3704, 27, 31, 32, 3, -40 },
  { 3809, 22, 50, 21, 2, -50 },
  { 3947, 41, 55, 44, 2, -49 },
  { 4229, 29, 49, 29, -4, -49 },
  { 4407, 31, 49, 32, 1, -49 },
  { 4597, 31, 51, 30, 3, -50 },
  { 4795, 33, 49, 35, 1, -49 },
  { 4998, 30, 49, 28, 1, -49 },
  { 5182, 30, 49, 26, 1, -49 },
  { 5366, 35, 51, 37, 3, -50 },
  { 5590, 36, 49, 36, 1, -49 },
  { 5811, 24, 49, 16, -3, -49 },
  { 5958, 25, 62, 14, -10, -49 },
  { 6152, 34, 49, 30, 1, -49 },
  { 6361, 19, 49, 25, 1, -49 },
  { 6478, 47, 49, 47, 1, -49 },
  { 6766, 38, 49, 38, 1, -49 },
  { 6999, 33, 51, 38, 3, -50 },
  { 7210, 30, 49, 30, 1, -49 },
  { 7394, 33, 62, 38, 3, -50 },
  { 7650, 30, 49, 30, 1, -49 },
  { 7834, 30, 51, 28, -1, -50 },
  { 8026, 25, 49, 26, 6, -49 },
  { 8180, 34, 50, 36, 3, -49 },
  { 8393, 29, 49, 29, 6, -49 },
  { 8571, 46, 49, 48, 7, -49 },
  { 8853, 36, 49, 27, -4, -49 },
  { 9074, 26, 49, 26, 6, -49 },
  { 9234, 32, 49, 27, -2, -49 },
  { 9430, 25, 60, 20, -1, -49 },
  { 9618, 11, 49, 23, 7, -49 },
  { 9686, 26, 60, 20, -5, -49 },
  { 9881, 28, 26, 31, 2, -49 },
  { 9972, 22, 3, 22, -6, 6 },
  { 9981, 8, 11, 16, 10, -53 },
  { 9992, 28, 38, 31, 2, -37 },
  { 10125, 28, 53, 31, 1, -52 },
  { 10311, 23, 38, 24, 2, -37 },
  { 10421, 32, 53, 31, 2, -52 },
  { 10633, 24, 38, 27, 2, -37 },
  { 10747, 34, 70, 16, -9, -53 },
  { 11045, 30, 54, 31, 0, -37 },
  { 11248, 27, 52, 30, 1, -52 },
  { 11424, 14, 50, 13, 1, -50 },
  { 11512, 24, 67, 13, -9, -50 },
  { 11713, 27, 52, 26, 1, -52 },
  { 11889, 15, 52, 13, 1, -52 },
  { 11987, 42, 37, 46, 1, -37 },
  { 12182, 27, 37, 30, 1, -37 },
  { 12307, 26, 38, 30, 2, -37 },
  { 12431, 32, 53, 31, -3, -37 },
  { 12643, 28, 53, 31, 2, -37 },
  { 12829, 22, 37, 20, 1, -37 },
  { 12931, 23, 38, 23, 0, -37 },
  { 13041, 16, 46, 17, 2, -45 },
  { 13133, 27, 38, 30, 2, -37 },
  { 13262, 23, 37, 24, 4, -37 },
  { 13369, 37, 37, 38, 4, -37 },
  { 13541, 30, 37, 25, -3, -37 },
  { 13680, 35, 54, 24, -7, -37 },
  { 13917, 25, 37, 22, -2, -37 },
  { 14033, 25, 60, 22, 2, -49 },
  { 14221, 3, 70, 28, 13, -53 },
  { 14248, 25, 60, 22, -4, -49 },
  { 14436, 27, 7, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_LightItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC69PT7B_H_
