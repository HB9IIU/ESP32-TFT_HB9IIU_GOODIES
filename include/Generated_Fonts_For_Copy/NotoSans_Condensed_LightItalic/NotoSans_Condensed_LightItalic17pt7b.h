#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC17PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x22, 0x22, 0x44, 0x40, 0x4C, 0x9A, 0xAA, 0x09, 0x0A, 0x12,
  0x7F, 0x14, 0x24, 0x24, 0xFE, 0x48, 0x48, 0x48, 0x50, 0x04, 0x18, 0xE9,
  0x42, 0x85, 0x04, 0x0C, 0x14, 0x28, 0x57, 0xC2, 0x04, 0x00, 0x71, 0x28,
  0xA4, 0x92, 0x89, 0x54, 0xD7, 0xB2, 0x29, 0x14, 0x92, 0x51, 0x48, 0xE0,
  0x1C, 0x12, 0x24, 0x24, 0x18, 0x10, 0x31, 0x4A, 0x8A, 0x84, 0x8C, 0x72,
  0xEA, 0x08, 0x84, 0x44, 0x21, 0x08, 0x84, 0x21, 0x04, 0x21, 0x00, 0x10,
  0x82, 0x10, 0x84, 0x22, 0x10, 0x84, 0x44, 0x22, 0x00, 0x25, 0x1E, 0x4D,
  0x08, 0x10, 0x41, 0x04, 0xFC, 0x41, 0x04, 0x29, 0x40, 0xF0, 0x70, 0x03,
  0x02, 0x04, 0x04, 0x08, 0x08, 0x10, 0x10, 0x20, 0x20, 0x40, 0x80, 0x3D,
  0x14, 0x61, 0x86, 0x18, 0x62, 0x8A, 0x29, 0x38, 0x35, 0xA2, 0x22, 0x24,
  0x44, 0x4C, 0x3E, 0x04, 0x08, 0x10, 0x40, 0x82, 0x08, 0x20, 0x82, 0x07,
  0xC0, 0x3E, 0x04, 0x08, 0x10, 0x47, 0x02, 0x02, 0x04, 0x08, 0x27, 0x80,
  0x06, 0x0C, 0x28, 0xA1, 0x44, 0x91, 0x24, 0xFE, 0x10, 0x20, 0x40, 0x1E,
  0x40, 0x81, 0x04, 0x0F, 0x81, 0x02, 0x04, 0x08, 0x27, 0x80, 0x1C, 0x84,
  0x10, 0xB3, 0x28, 0xA2, 0x8A, 0x28, 0xBC, 0x7E, 0x08, 0x10, 0x40, 0x82,
  0x04, 0x10, 0x20, 0x81, 0x04, 0x00, 0x1E, 0x44, 0x89, 0x12, 0x43, 0x0A,
  0x22, 0x85, 0x0A, 0x13, 0xC0, 0x1C, 0x45, 0x0A, 0x14, 0x28, 0xCE, 0x82,
  0x04, 0x10, 0x27, 0x80, 0x24, 0x00, 0x04, 0xC0, 0x11, 0x00, 0x00, 0x02,
  0x44, 0x80, 0x04, 0x33, 0x30, 0xC0, 0xC0, 0xC1, 0xFC, 0x00, 0x3F, 0x81,
  0x03, 0x03, 0x0C, 0xCC, 0x20, 0x78, 0x42, 0x11, 0x11, 0x10, 0x80, 0x21,
  0x00, 0x1F, 0x08, 0x24, 0x09, 0x39, 0x92, 0x64, 0xAA, 0x4A, 0x92, 0xA4,
  0xAF, 0xC8, 0x02, 0x00, 0x44, 0x0E, 0x00, 0x06, 0x0C, 0x28, 0x51, 0x22,
  0x48, 0x9F, 0x22, 0x85, 0x0C, 0x10, 0x1E, 0x21, 0x21, 0x21, 0x22, 0x3C,
  0x46, 0x42, 0x42, 0x42, 0x44, 0xF8, 0x1E, 0x41, 0x02, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x02, 0x03, 0xC0, 0x1E, 0x21, 0x21, 0x21, 0x21, 0x21, 0x41,
  0x41, 0x42, 0x42, 0x44, 0xF8, 0x1F, 0x20, 0x20, 0x20, 0x20, 0x3C, 0x40,
  0x40, 0x40, 0x40, 0x40, 0xF8, 0x1F, 0x20, 0x20, 0x20, 0x20, 0x20, 0x7C,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x1F, 0x20, 0x40, 0x40, 0x80, 0x80, 0x8E,
  0x82, 0x82, 0x82, 0x84, 0x7C, 0x10, 0x90, 0x48, 0x24, 0x22, 0x11, 0xF9,
  0x04, 0x82, 0x42, 0x21, 0x10, 0x90, 0x40, 0x1C, 0x21, 0x04, 0x10, 0x41,
  0x08, 0x20, 0x82, 0x3C, 0x02, 0x08, 0x10, 0x20, 0x40, 0x82, 0x04, 0x08,
  0x10, 0x20, 0x81, 0x02, 0x38, 0x00, 0x11, 0x91, 0x09, 0x04, 0x82, 0x81,
  0x81, 0xA0, 0x90, 0x48, 0x24, 0x11, 0x10, 0x80, 0x11, 0x08, 0x42, 0x11,
  0x08, 0x42, 0x11, 0xF0, 0x10, 0x33, 0x06, 0x30, 0x63, 0x0A, 0x28, 0xA2,
  0x92, 0x49, 0x44, 0xA4, 0x4A, 0x44, 0xC4, 0x8C, 0x48, 0x88, 0x10, 0xCC,
  0x22, 0x88, 0xA2, 0x28, 0x8A, 0x44, 0x51, 0x14, 0x45, 0x11, 0x48, 0x22,
  0x08, 0x1E, 0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x84,
  0x78, 0x1E, 0x22, 0x21, 0x21, 0x22, 0x26, 0x7C, 0x40, 0x40, 0x40, 0x40,
  0x80, 0x1E, 0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x82, 0x82, 0x84, 0x84,
  0x78, 0x10, 0x08, 0x08, 0x1E, 0x22, 0x21, 0x22, 0x22, 0x26, 0x78, 0x48,
  0x48, 0x44, 0x44, 0x84, 0x1E, 0x41, 0x01, 0x02, 0x02, 0x02, 0x06, 0x04,
  0x08, 0x27, 0xC0, 0xFE, 0x20, 0x41, 0x02, 0x04, 0x08, 0x10, 0x40, 0x81,
  0x02, 0x00, 0x21, 0x41, 0x41, 0x42, 0x42, 0x82, 0x82, 0x84, 0x84, 0x84,
  0x88, 0x78, 0x87, 0x0A, 0x24, 0x49, 0x12, 0x24, 0x50, 0xA1, 0x83, 0x04,
  0x00, 0x84, 0x31, 0x8A, 0x31, 0x4A, 0x29, 0x49, 0x49, 0x29, 0x45, 0x28,
  0xC6, 0x18, 0xC2, 0x18, 0x42, 0x00, 0x11, 0x88, 0x84, 0x81, 0x40, 0xC0,
  0x40, 0x20, 0x28, 0x24, 0x12, 0x11, 0x10, 0x80, 0xC6, 0x89, 0x22, 0x45,
  0x0A, 0x18, 0x10, 0x40, 0x81, 0x02, 0x00, 0x1F, 0x01, 0x02, 0x04, 0x04,
  0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0xFC, 0x1C, 0x82, 0x08, 0x20, 0x84,
  0x10, 0x41, 0x04, 0x20, 0x82, 0x0E, 0x00, 0xAA, 0xA5, 0x55, 0x1C, 0x10,
  0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x20, 0x8E, 0x00, 0x08, 0x28,
  0x51, 0x24, 0x38, 0x40, 0xF8, 0xC8, 0x80, 0x3D, 0x18, 0x61, 0x8A, 0x28,
  0xA6, 0xE8, 0x10, 0x20, 0x81, 0x03, 0xE4, 0x48, 0xA1, 0x42, 0x85, 0x12,
  0x2B, 0x80, 0x3A, 0x21, 0x08, 0x42, 0x10, 0xF0, 0x02, 0x04, 0x08, 0x13,
  0xC8, 0xA1, 0x42, 0x85, 0x12, 0x24, 0xCE, 0x80, 0x3A, 0x63, 0x3E, 0x42,
  0x10, 0xF0, 0x07, 0x04, 0x04, 0x08, 0x1E, 0x08, 0x08, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0xC0, 0x1E, 0x45, 0x0A, 0x14, 0x28,
  0x91, 0x26, 0x74, 0x10, 0x20, 0x4F, 0x00, 0x10, 0x20, 0x81, 0x03, 0xE4,
  0x48, 0xA1, 0x44, 0x89, 0x14, 0x28, 0xC0, 0x30, 0x02, 0x22, 0x44, 0x44,
  0x88, 0x04, 0x00, 0x02, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x82,
  0x30, 0x10, 0x20, 0x81, 0x02, 0x64, 0x8A, 0x28, 0x70, 0xA1, 0x24, 0x48,
  0x80, 0x11, 0x22, 0x22, 0x24, 0x44, 0x48, 0x80, 0x3D, 0xC4, 0x44, 0x88,
  0xA2, 0x24, 0x44, 0x88, 0x91, 0x14, 0x42, 0x88, 0x80, 0x3E, 0x44, 0x8A,
  0x14, 0x48, 0x91, 0x42, 0x88, 0x39, 0x18, 0x61, 0x86, 0x28, 0xA2, 0xF0,
  0x1F, 0x11, 0x11, 0x21, 0x21, 0x21, 0x22, 0x22, 0x5C, 0x40, 0x40, 0x40,
  0x80, 0x3D, 0x18, 0x61, 0x86, 0x28, 0xA6, 0xE8, 0x41, 0x04, 0x10, 0x3C,
  0x82, 0x10, 0x41, 0x04, 0x20, 0x80, 0x3D, 0x04, 0x18, 0x30, 0x40, 0x84,
  0xF0, 0x44, 0xF4, 0x88, 0x88, 0x88, 0xC0, 0x45, 0x18, 0x62, 0x8A, 0x28,
  0xA6, 0xE8, 0x8E, 0x28, 0xA4, 0x92, 0x8A, 0x30, 0xC0, 0x88, 0xCC, 0x66,
  0x53, 0x2A, 0xA5, 0x53, 0x29, 0x98, 0x8C, 0x00, 0x23, 0x12, 0x14, 0x18,
  0x18, 0x18, 0x28, 0x48, 0xC4, 0x10, 0x88, 0x84, 0x42, 0x41, 0x20, 0xA0,
  0x50, 0x10, 0x08, 0x08, 0x04, 0x04, 0x0E, 0x00, 0x3E, 0x08, 0x20, 0x41,
  0x04, 0x08, 0x20, 0xF8, 0x0E, 0x10, 0x40, 0x81, 0x02, 0x08, 0x60, 0x20,
  0x40, 0x82, 0x04, 0x08, 0x0C, 0x00, 0xFF, 0xFF, 0x80, 0x18, 0x20, 0x82,
  0x08, 0x20, 0x83, 0x10, 0x41, 0x08, 0x20, 0x8C, 0x00, 0xE6, 0x70,
};

const GFXglyph NotoSans_Condensed_LightItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 12, 4, 0, -12 },
  { 7, 4, 4, 5, 2, -12 },
  { 9, 8, 12, 8, 0, -12 },
  { 21, 7, 14, 7, 0, -13 },
  { 34, 9, 12, 11, 1, -12 },
  { 48, 8, 12, 8, 0, -12 },
  { 60, 2, 4, 3, 2, -12 },
  { 61, 5, 15, 4, 0, -12 },
  { 71, 5, 15, 4, -1, -12 },
  { 81, 5, 6, 7, 2, -13 },
  { 85, 6, 8, 8, 1, -10 },
  { 91, 3, 4, 3, -1, -2 },
  { 93, 4, 1, 5, 0, -5 },
  { 94, 2, 2, 3, 0, -2 },
  { 95, 8, 12, 5, -1, -12 },
  { 107, 6, 12, 7, 1, -12 },
  { 116, 4, 12, 7, 2, -12 },
  { 122, 7, 12, 7, 0, -12 },
  { 133, 7, 12, 7, 0, -12 },
  { 144, 7, 12, 7, 0, -12 },
  { 155, 7, 12, 7, 0, -12 },
  { 166, 6, 12, 7, 1, -12 },
  { 175, 7, 12, 7, 1, -12 },
  { 186, 7, 12, 7, 0, -12 },
  { 197, 7, 12, 7, 0, -12 },
  { 208, 3, 9, 3, 0, -9 },
  { 212, 4, 11, 3, -1, -9 },
  { 218, 6, 8, 8, 1, -10 },
  { 224, 6, 4, 8, 1, -8 },
  { 227, 6, 8, 8, 1, -10 },
  { 233, 5, 12, 5, 1, -12 },
  { 241, 10, 14, 11, 1, -12 },
  { 259, 7, 12, 7, -1, -12 },
  { 270, 8, 12, 8, 0, -12 },
  { 282, 7, 12, 7, 1, -12 },
  { 293, 8, 12, 9, 0, -12 },
  { 305, 8, 12, 7, 0, -12 },
  { 317, 8, 12, 6, 0, -12 },
  { 329, 8, 12, 9, 1, -12 },
  { 341, 9, 12, 9, 0, -12 },
  { 355, 6, 12, 4, -1, -12 },
  { 364, 7, 15, 3, -3, -12 },
  { 378, 9, 12, 7, 0, -12 },
  { 392, 5, 12, 6, 0, -12 },
  { 400, 12, 12, 12, 0, -12 },
  { 418, 10, 12, 9, 0, -12 },
  { 433, 8, 12, 9, 1, -12 },
  { 445, 8, 12, 7, 0, -12 },
  { 457, 8, 15, 9, 1, -12 },
  { 472, 8, 12, 8, 0, -12 },
  { 484, 7, 12, 7, 0, -12 },
  { 495, 7, 12, 6, 1, -12 },
  { 506, 8, 12, 9, 1, -12 },
  { 518, 7, 12, 7, 2, -12 },
  { 529, 11, 12, 12, 2, -12 },
  { 546, 9, 12, 7, -1, -12 },
  { 560, 7, 12, 6, 1, -12 },
  { 571, 8, 12, 7, -1, -12 },
  { 583, 6, 15, 5, 0, -12 },
  { 595, 2, 12, 6, 2, -12 },
  { 598, 6, 15, 5, -1, -12 },
  { 610, 7, 6, 8, 0, -12 },
  { 616, 5, 1, 5, -1, 1 },
  { 617, 3, 3, 4, 2, -13 },
  { 619, 6, 9, 8, 1, -9 },
  { 626, 7, 13, 8, 0, -13 },
  { 638, 5, 9, 6, 1, -9 },
  { 644, 7, 13, 8, 1, -13 },
  { 656, 5, 9, 7, 1, -9 },
  { 662, 8, 17, 4, -2, -13 },
  { 679, 7, 13, 8, 0, -9 },
  { 691, 7, 13, 7, 0, -13 },
  { 703, 4, 12, 3, 0, -12 },
  { 709, 6, 16, 3, -2, -12 },
  { 721, 7, 13, 6, 0, -13 },
  { 733, 4, 13, 3, 0, -13 },
  { 740, 11, 9, 11, 0, -9 },
  { 753, 7, 9, 7, 0, -9 },
  { 761, 6, 9, 7, 1, -9 },
  { 768, 8, 13, 8, -1, -9 },
  { 781, 6, 13, 8, 1, -9 },
  { 791, 6, 9, 5, 0, -9 },
  { 798, 6, 9, 6, 0, -9 },
  { 805, 4, 11, 4, 1, -11 },
  { 811, 6, 9, 7, 1, -9 },
  { 818, 6, 9, 6, 1, -9 },
  { 825, 9, 9, 9, 1, -9 },
  { 836, 8, 9, 6, -1, -9 },
  { 845, 9, 13, 6, -2, -9 },
  { 860, 7, 9, 5, -1, -9 },
  { 868, 7, 15, 6, 0, -12 },
  { 882, 1, 17, 7, 3, -13 },
  { 885, 6, 15, 6, -1, -12 },
  { 897, 6, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_LightItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC17PT7B_H_
