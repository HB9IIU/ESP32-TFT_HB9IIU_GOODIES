#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC40PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x03, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C,
  0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x20, 0x00,
  0x00, 0x00, 0x40, 0xE0, 0xE0, 0xC0, 0x31, 0xCC, 0x77, 0x19, 0x86, 0x61,
  0x98, 0x66, 0x31, 0x0C, 0xC3, 0x30, 0x8C, 0x20, 0x00, 0x30, 0xC0, 0x04,
  0x18, 0x01, 0x83, 0x00, 0x30, 0x40, 0x06, 0x18, 0x01, 0x83, 0x00, 0x30,
  0x40, 0x06, 0x18, 0x00, 0x83, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x83,
  0x00, 0x30, 0x60, 0x06, 0x08, 0x00, 0x83, 0x00, 0x30, 0x60, 0x06, 0x08,
  0x00, 0xC3, 0x01, 0xFF, 0xFE, 0x7F, 0xFF, 0x80, 0xC3, 0x00, 0x10, 0x60,
  0x06, 0x0C, 0x00, 0xC3, 0x00, 0x10, 0x60, 0x06, 0x0C, 0x00, 0xC1, 0x00,
  0x18, 0x60, 0x06, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00,
  0x1F, 0xC0, 0x3F, 0xF8, 0x39, 0x88, 0x18, 0xC0, 0x18, 0x40, 0x0C, 0x20,
  0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x00, 0xE4, 0x00, 0x3A, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x5C, 0x00, 0x27, 0x00, 0x31, 0x80,
  0x18, 0xC0, 0x08, 0x60, 0x04, 0x30, 0x02, 0x18, 0x03, 0x18, 0x61, 0x9C,
  0x3F, 0xFC, 0x07, 0xF8, 0x00, 0x60, 0x00, 0x30, 0x00, 0x10, 0x00, 0x08,
  0x00, 0x07, 0x80, 0x30, 0x3F, 0x00, 0xC1, 0x8C, 0x06, 0x06, 0x30, 0x30,
  0x30, 0x40, 0xC0, 0xC3, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0xC0, 0x60,
  0xC3, 0x01, 0x03, 0x18, 0x0C, 0x0C, 0xC0, 0x30, 0x63, 0x00, 0xC1, 0x98,
  0xFB, 0x06, 0x66, 0x6C, 0x33, 0x30, 0x99, 0x99, 0x83, 0x7E, 0x66, 0x0C,
  0xE3, 0x18, 0x20, 0x0C, 0xC0, 0x80, 0x63, 0x06, 0x01, 0x8C, 0x18, 0x0C,
  0x30, 0x60, 0x60, 0x81, 0x81, 0x82, 0x0C, 0x0C, 0x08, 0x30, 0x30, 0x20,
  0xC1, 0x80, 0xC6, 0x06, 0x03, 0x30, 0x30, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x3F, 0x80, 0x18, 0x60, 0x0E, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x30,
  0x60, 0x0C, 0x18, 0x03, 0x0C, 0x00, 0xC7, 0x00, 0x31, 0x80, 0x0C, 0xC0,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3B, 0x00, 0x1C, 0xE1, 0xCE,
  0x18, 0x63, 0x06, 0x19, 0x81, 0xCC, 0x60, 0x33, 0x38, 0x0F, 0x8C, 0x01,
  0xE3, 0x00, 0x70, 0xC0, 0x1C, 0x38, 0x0F, 0x06, 0x06, 0xE1, 0xFF, 0x18,
  0x3F, 0x87, 0x00, 0x33, 0x36, 0x66, 0x64, 0xCC, 0xC0, 0x00, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00,
  0x30, 0x00, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0x80, 0x38, 0x03, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x40,
  0xC6, 0x0F, 0x30, 0x0F, 0xBC, 0x1F, 0xE0, 0xE0, 0x0D, 0x00, 0xCC, 0x1C,
  0x30, 0x41, 0x80, 0x0E, 0x00, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x31, 0x86, 0x38, 0xC3, 0x18, 0xC0, 0xFF, 0xFF,
  0xC0, 0x5F, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x01,
  0xFC, 0x03, 0x8E, 0x07, 0x06, 0x06, 0x06, 0x0C, 0x07, 0x0C, 0x07, 0x18,
  0x07, 0x18, 0x07, 0x38, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x06, 0x70,
  0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x0C, 0xE0,
  0x1C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x30, 0xE0, 0x70, 0x60,
  0x60, 0x60, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x01, 0x81, 0xC3, 0xE3, 0xE3,
  0xB7, 0x1B, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30,
  0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18,
  0x18, 0x0C, 0x06, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x38, 0x38, 0x08,
  0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xF0, 0xFF, 0xF8, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0x01, 0xC1, 0xC0, 0x80, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x20, 0x1C, 0x1F, 0xFC, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xB0, 0x01,
  0xB8, 0x00, 0xD8, 0x00, 0xCC, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x63, 0x00,
  0x61, 0x80, 0x30, 0xC0, 0x30, 0x60, 0x30, 0x70, 0x38, 0x30, 0x18, 0x18,
  0x18, 0x0C, 0x18, 0x06, 0x0C, 0x07, 0x0F, 0xFF, 0xF7, 0xFF, 0xF0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x20, 0x1C, 0x1F,
  0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x01, 0xE0, 0x03, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0xC0, 0x37, 0xF8, 0x3E, 0x38, 0x68, 0x1C, 0x70, 0x0C,
  0x70, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x0C, 0xE0, 0x0C, 0xE0, 0x1C,
  0xE0, 0x18, 0xE0, 0x18, 0x60, 0x38, 0x60, 0x30, 0x70, 0x60, 0x3F, 0xE0,
  0x1F, 0x80, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0xFF, 0x00, 0xE1, 0xC0, 0xE0, 0x70, 0x60, 0x18, 0x30,
  0x0C, 0x38, 0x06, 0x18, 0x03, 0x0E, 0x03, 0x83, 0x01, 0x81, 0x81, 0x80,
  0x61, 0x80, 0x3B, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0E, 0xE0, 0x1C, 0x38,
  0x1C, 0x0E, 0x1C, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC7, 0x00, 0x73, 0x00,
  0x31, 0x80, 0x18, 0xE0, 0x0C, 0x30, 0x0E, 0x1C, 0x0E, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x78, 0x01, 0xFE, 0x03, 0x86, 0x07, 0x07, 0x0E, 0x03,
  0x0C, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03,
  0x18, 0x03, 0x18, 0x07, 0x18, 0x07, 0x18, 0x0F, 0x1C, 0x1E, 0x0F, 0xF6,
  0x07, 0xC6, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0xFF, 0x80, 0xFF, 0x00,
  0x0E, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x41, 0xC7, 0x0E, 0x00, 0x01, 0x81, 0xC0, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x07, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60,
  0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x00, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x04, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x06, 0x00,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x00,
  0xC0, 0x01, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0x86, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x70,
  0x38, 0x00, 0xC0, 0x0C, 0x03, 0x80, 0x06, 0x03, 0x00, 0x06, 0x06, 0x00,
  0x06, 0x0C, 0x00, 0x03, 0x0C, 0x07, 0x03, 0x18, 0x1F, 0xC3, 0x18, 0x30,
  0xC3, 0x30, 0x61, 0x83, 0x30, 0xC1, 0x83, 0x20, 0xC1, 0x82, 0x61, 0x81,
  0x86, 0x61, 0x83, 0x06, 0x61, 0x83, 0x06, 0x61, 0x03, 0x06, 0x43, 0x03,
  0x0C, 0xC3, 0x06, 0x0C, 0xC3, 0x06, 0x18, 0xC3, 0x0A, 0x18, 0xC1, 0x9B,
  0x30, 0xC1, 0xF3, 0xE0, 0xC0, 0x40, 0x80, 0x60, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x0E,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xD8, 0x00, 0x64, 0x00, 0x63,
  0x00, 0x31, 0x80, 0x38, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x0C, 0x18, 0x06,
  0x0C, 0x06, 0x06, 0x03, 0x03, 0x03, 0x01, 0x81, 0xFF, 0xC1, 0xFF, 0xE0,
  0xC0, 0x30, 0xE0, 0x18, 0x60, 0x0C, 0x70, 0x06, 0x30, 0x03, 0x18, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0x6E, 0x00, 0x3E, 0x00, 0x18, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0x87, 0xC0, 0xC0, 0x70, 0x60, 0x18, 0x30, 0x0C, 0x38, 0x06,
  0x18, 0x03, 0x0C, 0x01, 0x86, 0x01, 0xC7, 0x00, 0xC3, 0x80, 0xE1, 0x80,
  0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0x70, 0x38, 0x30, 0x0E, 0x18, 0x03, 0x0C,
  0x01, 0x86, 0x00, 0xC7, 0x00, 0x63, 0x00, 0x31, 0x80, 0x38, 0xC0, 0x1C,
  0x60, 0x1C, 0x70, 0x0C, 0x30, 0x1E, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0xF0, 0x1C, 0x08, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01,
  0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0x80, 0x63, 0xF0,
  0x18, 0x0E, 0x06, 0x01, 0x81, 0x80, 0x70, 0xE0, 0x0C, 0x30, 0x03, 0x0C,
  0x00, 0xC3, 0x00, 0x31, 0xC0, 0x0C, 0x60, 0x03, 0x18, 0x00, 0xC6, 0x00,
  0x31, 0x80, 0x0C, 0xE0, 0x07, 0x30, 0x01, 0xCC, 0x00, 0x63, 0x00, 0x18,
  0xC0, 0x0E, 0x70, 0x03, 0x18, 0x01, 0xC6, 0x00, 0x61, 0x80, 0x30, 0x60,
  0x1C, 0x30, 0x0E, 0x0C, 0x0F, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x83, 0xFF, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xF0, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x01, 0xE0, 0xE0, 0x38,
  0x02, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x1F, 0xCE, 0x01, 0xF8, 0xC0, 0x21, 0x8C, 0x00, 0x18,
  0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x0E, 0x00, 0x70, 0x60, 0x06, 0x07, 0x00, 0x60, 0x38, 0x06, 0x01, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x38, 0x38, 0x01, 0x81, 0x80, 0x0C,
  0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x38, 0x38, 0x01, 0x81, 0x80,
  0x0C, 0x0C, 0x00, 0x60, 0x60, 0x07, 0x07, 0x00, 0x30, 0x30, 0x01, 0x81,
  0x80, 0x0C, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0x00, 0x30, 0x30, 0x01,
  0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x07, 0x07, 0x00, 0x30, 0x30,
  0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x06, 0x07, 0x00, 0x30,
  0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0F, 0x80, 0xFF, 0x00,
  0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0x00, 0x60, 0xE0,
  0x18, 0x18, 0x07, 0x03, 0x01, 0xC0, 0x60, 0x70, 0x0C, 0x0C, 0x03, 0x83,
  0x00, 0x60, 0xE0, 0x0C, 0x38, 0x01, 0x8E, 0x00, 0x73, 0x80, 0x0C, 0x60,
  0x01, 0x98, 0x00, 0x37, 0x00, 0x07, 0xE0, 0x01, 0xEE, 0x00, 0x38, 0xC0,
  0x06, 0x18, 0x00, 0xC3, 0x80, 0x18, 0x30, 0x07, 0x06, 0x00, 0xC0, 0xC0,
  0x18, 0x1C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x1C, 0x07, 0x03, 0x00, 0x60,
  0x60, 0x0C, 0x0C, 0x01, 0xC0, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x6C, 0x0F, 0x00, 0x0F, 0x83, 0x60, 0x03, 0x60, 0x6C, 0x00, 0x6C,
  0x0D, 0x80, 0x19, 0x81, 0xB0, 0x03, 0x30, 0x76, 0x00, 0xCE, 0x0C, 0x60,
  0x19, 0x81, 0x8C, 0x06, 0x30, 0x31, 0x80, 0xC6, 0x06, 0x30, 0x31, 0xC1,
  0xC6, 0x06, 0x30, 0x30, 0xC1, 0x86, 0x06, 0x18, 0x30, 0xC0, 0xC3, 0x0C,
  0x18, 0x18, 0x61, 0x87, 0x06, 0x0C, 0x60, 0xC0, 0xC1, 0x8C, 0x18, 0x18,
  0x33, 0x03, 0x03, 0x02, 0x60, 0x60, 0x60, 0x78, 0x1C, 0x18, 0x0F, 0x03,
  0x03, 0x01, 0xC0, 0x60, 0x60, 0x38, 0x0C, 0x0C, 0x06, 0x03, 0x80, 0x03,
  0x00, 0x18, 0x38, 0x00, 0xC1, 0xE0, 0x06, 0x0F, 0x00, 0x30, 0x78, 0x03,
  0x83, 0xC0, 0x18, 0x37, 0x00, 0xC1, 0x98, 0x06, 0x0C, 0xC0, 0x30, 0x66,
  0x03, 0x87, 0x38, 0x18, 0x30, 0xC0, 0xC1, 0x86, 0x06, 0x0C, 0x30, 0x30,
  0x61, 0xC3, 0x07, 0x06, 0x18, 0x30, 0x30, 0xC1, 0x81, 0x86, 0x0C, 0x0E,
  0x70, 0x60, 0x33, 0x07, 0x01, 0x98, 0x30, 0x0C, 0xC1, 0x80, 0x66, 0x0C,
  0x01, 0xF0, 0x60, 0x0F, 0x06, 0x00, 0x78, 0x30, 0x03, 0xC1, 0x80, 0x0E,
  0x0C, 0x00, 0x60, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0E, 0x0E, 0x03,
  0x80, 0xE0, 0xE0, 0x0C, 0x18, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x03, 0x38,
  0x00, 0x66, 0x00, 0x0D, 0xC0, 0x01, 0xB8, 0x00, 0x76, 0x00, 0x0E, 0xC0,
  0x01, 0xB8, 0x00, 0x37, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x00,
  0x06, 0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x30, 0x01, 0xC6, 0x00,
  0x30, 0xE0, 0x0E, 0x0C, 0x03, 0x81, 0xC0, 0xE0, 0x1F, 0xF8, 0x01, 0xFE,
  0x00, 0x03, 0xE0, 0x03, 0xFE, 0x01, 0x8F, 0x80, 0xC0, 0xE0, 0x60, 0x30,
  0x30, 0x1C, 0x38, 0x0E, 0x18, 0x07, 0x0C, 0x03, 0x86, 0x01, 0xC7, 0x00,
  0xC3, 0x00, 0x61, 0x80, 0x70, 0xC0, 0x70, 0x60, 0x70, 0x7F, 0xF0, 0x3F,
  0xE0, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0E, 0x0E, 0x03, 0x80,
  0xE0, 0xE0, 0x0C, 0x18, 0x01, 0xC7, 0x00, 0x38, 0xC0, 0x03, 0x38, 0x00,
  0x66, 0x00, 0x0D, 0xC0, 0x01, 0xB8, 0x00, 0x76, 0x00, 0x0E, 0xC0, 0x01,
  0xB8, 0x00, 0x37, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00, 0x3B, 0x00, 0x06,
  0x60, 0x00, 0xCC, 0x00, 0x39, 0x80, 0x06, 0x30, 0x01, 0xC6, 0x00, 0x30,
  0xE0, 0x0E, 0x0C, 0x03, 0x81, 0xC0, 0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x03, 0xFE, 0x01, 0x8F, 0x80,
  0xC0, 0xE0, 0x60, 0x30, 0x30, 0x1C, 0x38, 0x0E, 0x18, 0x07, 0x0C, 0x03,
  0x86, 0x01, 0x87, 0x00, 0xC3, 0x00, 0xE1, 0x80, 0x60, 0xC0, 0x70, 0x60,
  0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0x18, 0x70, 0x0C, 0x18, 0x06, 0x0C, 0x07,
  0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x70, 0x1C,
  0x30, 0x0E, 0x18, 0x03, 0x0C, 0x01, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0xF0,
  0x3C, 0x1C, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x07, 0x04, 0x03, 0x81, 0xFF, 0xC0, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0xFF, 0xFE, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x00, 0x0E, 0x00, 0x61, 0x80,
  0x0C, 0x30, 0x01, 0x86, 0x00, 0x30, 0xC0, 0x0E, 0x38, 0x01, 0x86, 0x00,
  0x30, 0xC0, 0x06, 0x18, 0x00, 0xC7, 0x00, 0x38, 0xC0, 0x06, 0x18, 0x00,
  0xC3, 0x00, 0x18, 0x60, 0x07, 0x1C, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x03,
  0x0C, 0x00, 0x61, 0x80, 0x1C, 0x70, 0x03, 0x0C, 0x00, 0x61, 0x80, 0x0C,
  0x30, 0x03, 0x86, 0x00, 0x60, 0xC0, 0x1C, 0x1C, 0x03, 0x01, 0xC0, 0xE0,
  0x3F, 0xF8, 0x01, 0xFC, 0x00, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0,
  0x0E, 0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xC0,
  0x30, 0xC0, 0x70, 0xC0, 0x60, 0xC0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC1,
  0x80, 0xC1, 0x80, 0xC3, 0x00, 0xC3, 0x00, 0xC6, 0x00, 0xC6, 0x00, 0xCE,
  0x00, 0xCC, 0x00, 0xDC, 0x00, 0xD8, 0x00, 0x58, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0xC0, 0x0C, 0x00, 0xF8, 0x01, 0x80, 0x1B, 0x00, 0x70,
  0x07, 0x60, 0x0E, 0x00, 0xCC, 0x03, 0xC0, 0x19, 0x80, 0x78, 0x07, 0x30,
  0x0F, 0x00, 0xC6, 0x03, 0x60, 0x38, 0xC0, 0x6C, 0x06, 0x18, 0x19, 0x80,
  0xC3, 0x03, 0x30, 0x30, 0x60, 0x66, 0x06, 0x0C, 0x18, 0xC1, 0xC1, 0x83,
  0x18, 0x30, 0x30, 0xC3, 0x06, 0x06, 0x18, 0x61, 0x80, 0xC7, 0x0C, 0x30,
  0x18, 0xC1, 0x8E, 0x03, 0x18, 0x31, 0x80, 0x66, 0x06, 0x70, 0x0C, 0xC0,
  0xCC, 0x01, 0xB0, 0x19, 0x80, 0x36, 0x03, 0x60, 0x06, 0xC0, 0x6C, 0x00,
  0xF0, 0x0D, 0x80, 0x1E, 0x01, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x70, 0x07,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x30, 0x18, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x01, 0xC0, 0xC0, 0x0C, 0x18, 0x00, 0xC3, 0x80, 0x0C,
  0x30, 0x00, 0xC6, 0x00, 0x0C, 0x60, 0x00, 0x6C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1B, 0x00, 0x03, 0x98, 0x00, 0x31, 0x80, 0x06, 0x18, 0x00, 0xE1, 0x80,
  0x0C, 0x18, 0x01, 0xC1, 0xC0, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x70, 0x0C,
  0x06, 0x00, 0xC0, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0xC0, 0x1D, 0x80, 0x33,
  0x00, 0xE6, 0x01, 0x8C, 0x07, 0x1C, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x61,
  0x80, 0xC7, 0x01, 0x8C, 0x03, 0x38, 0x07, 0x60, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0xFE,
  0x01, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0xFC, 0x00, 0xC3, 0x0C, 0x10, 0x61, 0x86, 0x18, 0x61, 0x83,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x61, 0x86, 0x18, 0x61, 0x86, 0x0C, 0x30,
  0xC3, 0x0C, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x06, 0x03, 0xFC, 0x00, 0x00, 0x40, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xF0, 0x01, 0xB0, 0x03, 0x30, 0x06, 0x18, 0x06, 0x18,
  0x0C, 0x18, 0x0C, 0x0C, 0x18, 0x0C, 0x18, 0x0E, 0x30, 0x06, 0x70, 0x06,
  0x60, 0x03, 0xC0, 0x03, 0xFF, 0xF0, 0xC7, 0x18, 0xC3, 0x08, 0x60, 0x00,
  0x40, 0x03, 0xF3, 0x07, 0x1B, 0x0E, 0x0B, 0x1C, 0x07, 0x18, 0x06, 0x38,
  0x06, 0x30, 0x06, 0x30, 0x06, 0x70, 0x0E, 0x60, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0x60,
  0x78, 0x60, 0xD0, 0x7F, 0xB0, 0x3F, 0x30, 0x01, 0x80, 0x01, 0xC0, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x06, 0x18, 0x03, 0x3F, 0x01, 0xB1, 0xC1, 0xB0, 0x60, 0xF0, 0x30, 0x70,
  0x1C, 0x38, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8C, 0x01, 0x86, 0x00, 0xC3,
  0x00, 0x63, 0x80, 0x31, 0x80, 0x38, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x0E,
  0x38, 0x06, 0x1C, 0x06, 0x0F, 0x07, 0x06, 0xFF, 0x06, 0x3F, 0x00, 0x00,
  0x70, 0x0F, 0xF0, 0x70, 0x83, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0xC3, 0x80, 0xFC,
  0xC0, 0x71, 0xB0, 0x38, 0x3C, 0x1C, 0x07, 0x06, 0x01, 0xC3, 0x80, 0x60,
  0xC0, 0x18, 0x30, 0x06, 0x1C, 0x03, 0x86, 0x00, 0xC1, 0x80, 0x30, 0x60,
  0x0C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x60, 0xE0, 0x38, 0x38, 0x0E,
  0x06, 0x07, 0x81, 0x83, 0x60, 0x7F, 0xB0, 0x0F, 0xCC, 0x00, 0x00, 0xE0,
  0x0F, 0xE0, 0x71, 0xC3, 0x83, 0x1C, 0x0C, 0x60, 0x33, 0x00, 0xCC, 0x06,
  0x70, 0x39, 0x81, 0xC7, 0xFE, 0x1F, 0xC0, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x08, 0x3D, 0xE0, 0x7F,
  0x00, 0x00, 0x00, 0x80, 0x00, 0xFC, 0x00, 0x3C, 0x80, 0x06, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x06,
  0x00, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x27, 0x00, 0x07, 0xC0, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x20, 0x40, 0x7F, 0x20, 0x38, 0xD8, 0x1C, 0x1E,
  0x0E, 0x03, 0x83, 0x00, 0xE1, 0xC0, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x0E,
  0x01, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x1C, 0x03, 0x87, 0x00,
  0xE1, 0xC0, 0x30, 0x70, 0x1C, 0x1C, 0x07, 0x03, 0x03, 0xC0, 0xC1, 0xF0,
  0x3F, 0xD8, 0x07, 0xE6, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x80, 0x80, 0xE0, 0x38, 0xF0, 0x0F, 0xF8,
  0x00, 0x20, 0x00, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x18, 0x06, 0x7E, 0x07,
  0xCF, 0x0D, 0x03, 0x0E, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x1C, 0x03, 0x1C,
  0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x38, 0x0E, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0x1C, 0x60, 0x18, 0x60, 0x18, 0x60,
  0x18, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x00,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0xB8, 0x03, 0xE0, 0x04, 0x00, 0x00, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x07, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x18, 0x0C,
  0x30, 0x0C, 0x70, 0x1C, 0xE0, 0x19, 0xC0, 0x19, 0x80, 0x1B, 0x80, 0x1F,
  0xC0, 0x3C, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x30, 0xE0, 0x30, 0x60, 0x70,
  0x60, 0x60, 0x60, 0x60, 0x70, 0x60, 0x30, 0xE0, 0x30, 0x01, 0x81, 0xC0,
  0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x00, 0x00, 0x38, 0x0C, 0x03, 0x7F,
  0x1F, 0x81, 0x73, 0x99, 0xE1, 0xA0, 0xD8, 0x30, 0xE0, 0x78, 0x18, 0x70,
  0x38, 0x0C, 0x30, 0x1C, 0x06, 0x38, 0x0C, 0x03, 0x1C, 0x06, 0x03, 0x0C,
  0x03, 0x01, 0x86, 0x03, 0x80, 0xC3, 0x01, 0x80, 0x63, 0x80, 0xC0, 0x71,
  0x80, 0x60, 0x30, 0xC0, 0x30, 0x18, 0x60, 0x30, 0x0C, 0x30, 0x18, 0x06,
  0x38, 0x0C, 0x07, 0x18, 0x06, 0x03, 0x0C, 0x07, 0x01, 0x86, 0x03, 0x00,
  0xC7, 0x01, 0x80, 0xE0, 0x00, 0x18, 0x06, 0x7E, 0x05, 0xCF, 0x0D, 0x03,
  0x0E, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x1C, 0x07, 0x1C, 0x07, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x06, 0x38, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C,
  0x30, 0x0C, 0x70, 0x1C, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0xE0, 0x38,
  0x00, 0x60, 0x07, 0xF0, 0x1C, 0x70, 0x70, 0x71, 0xC0, 0x63, 0x00, 0xCE,
  0x01, 0x98, 0x03, 0x70, 0x06, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x76, 0x00,
  0xFC, 0x01, 0xB8, 0x03, 0x70, 0x0E, 0xE0, 0x19, 0xC0, 0x71, 0x80, 0xC3,
  0x83, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0xCF, 0xC0, 0x26,
  0x38, 0x1B, 0x06, 0x07, 0x81, 0x81, 0xC0, 0x70, 0x70, 0x1C, 0x18, 0x07,
  0x0E, 0x01, 0xC3, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x1C, 0x01, 0x86,
  0x00, 0xE1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x07, 0x0E, 0x01, 0x83, 0x80,
  0xE0, 0xF0, 0x70, 0x37, 0xF8, 0x0C, 0xFC, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x60, 0x81, 0xF8, 0x81, 0xC6, 0xC1, 0xC1,
  0xE1, 0xC0, 0x70, 0xC0, 0x38, 0xE0, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x38,
  0x03, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC7, 0x00, 0xE3, 0x80, 0x71,
  0xC0, 0x30, 0xE0, 0x38, 0x70, 0x1C, 0x18, 0x1E, 0x0C, 0x1F, 0x07, 0xFB,
  0x01, 0xF9, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x03, 0x00, 0x00, 0x38,
  0x37, 0xC1, 0x7E, 0x1B, 0x00, 0xF0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x3F, 0xC3, 0x8E, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x60, 0x07, 0x00, 0x31, 0x03, 0x8F, 0xF8, 0x7F, 0x80, 0x06, 0x01,
  0x80, 0x40, 0x30, 0x0C, 0x1F, 0xF7, 0xF8, 0x60, 0x18, 0x06, 0x01, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x00, 0xFC, 0x1F, 0x00, 0x0C, 0x03, 0x1C, 0x07, 0x18,
  0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x38, 0x0E, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60,
  0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xF0, 0x7F, 0xB0, 0x3F,
  0x30, 0xC0, 0x1F, 0x00, 0x6C, 0x03, 0x30, 0x0C, 0xE0, 0x73, 0x81, 0x86,
  0x0E, 0x18, 0x30, 0x61, 0xC1, 0x86, 0x06, 0x38, 0x18, 0xC0, 0x63, 0x01,
  0x98, 0x06, 0x60, 0x1B, 0x00, 0x6C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x00, 0xC0, 0x30, 0x1F, 0x01, 0xC0, 0x6C, 0x07, 0x01, 0xB0, 0x34,
  0x0C, 0xC0, 0xD0, 0x33, 0x03, 0x41, 0xCC, 0x19, 0x06, 0x30, 0x64, 0x18,
  0xC3, 0x10, 0xC3, 0x0C, 0x43, 0x04, 0x61, 0x1C, 0x11, 0x84, 0x60, 0x46,
  0x19, 0x81, 0x30, 0x6C, 0x04, 0xC1, 0xB0, 0x16, 0x07, 0x80, 0x58, 0x16,
  0x01, 0x40, 0x58, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x60, 0x18, 0x00,
  0x07, 0x01, 0xC0, 0xC0, 0xC0, 0x30, 0x70, 0x0C, 0x18, 0x03, 0x8C, 0x00,
  0x67, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x80, 0x03, 0x60, 0x01, 0xD8, 0x00, 0x63, 0x00, 0x30, 0xC0,
  0x1C, 0x30, 0x06, 0x0C, 0x03, 0x01, 0x81, 0xC0, 0x60, 0xE0, 0x18, 0x00,
  0x01, 0x80, 0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x01, 0x80,
  0xC0, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x38, 0x01, 0x83, 0x00, 0x18,
  0x70, 0x01, 0x86, 0x00, 0x18, 0xE0, 0x01, 0x8C, 0x00, 0x19, 0xC0, 0x01,
  0x98, 0x00, 0x09, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x9C, 0x00,
  0x0F, 0x80, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xC0, 0x06, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x00, 0x04, 0x01, 0xF0, 0x0F,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x1C,
  0x03, 0xC0, 0x0F, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x00, 0xF0, 0x07, 0xC0, 0x38, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0x1C, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x7E, 0x03, 0xFF,
  0x0E, 0x07, 0xFC, 0x03, 0xC0,
};

const GFXglyph NotoSans_Condensed_LightItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 8, 29, 9, 1, -29 },
  { 30, 10, 11, 13, 4, -29 },
  { 44, 19, 29, 19, 0, -29 },
  { 113, 17, 32, 17, 0, -30 },
  { 181, 22, 29, 25, 2, -29 },
  { 261, 18, 29, 19, 0, -29 },
  { 327, 4, 11, 7, 4, -29 },
  { 333, 12, 35, 10, 1, -29 },
  { 386, 12, 35, 10, -3, -29 },
  { 439, 13, 13, 16, 4, -30 },
  { 461, 15, 18, 18, 2, -23 },
  { 495, 6, 9, 8, -2, -4 },
  { 502, 9, 2, 11, 1, -12 },
  { 505, 3, 4, 8, 1, -4 },
  { 507, 18, 29, 13, -2, -29 },
  { 573, 16, 29, 17, 1, -29 },
  { 631, 9, 29, 17, 5, -29 },
  { 664, 18, 29, 17, -1, -29 },
  { 730, 17, 29, 17, 0, -29 },
  { 792, 17, 29, 17, 0, -29 },
  { 854, 17, 29, 17, 0, -29 },
  { 916, 16, 29, 17, 1, -29 },
  { 974, 16, 29, 17, 2, -29 },
  { 1032, 17, 29, 17, 0, -29 },
  { 1094, 16, 29, 17, 0, -29 },
  { 1152, 7, 21, 8, 0, -21 },
  { 1171, 9, 26, 8, -2, -21 },
  { 1201, 15, 18, 18, 2, -23 },
  { 1235, 15, 10, 18, 2, -19 },
  { 1254, 15, 18, 18, 2, -23 },
  { 1288, 13, 29, 12, 1, -29 },
  { 1336, 24, 33, 25, 1, -29 },
  { 1435, 17, 29, 17, -3, -29 },
  { 1497, 17, 29, 18, 1, -29 },
  { 1559, 18, 29, 17, 2, -29 },
  { 1625, 18, 29, 20, 1, -29 },
  { 1691, 17, 29, 16, 1, -29 },
  { 1753, 17, 29, 15, 1, -29 },
  { 1815, 20, 29, 21, 2, -29 },
  { 1888, 21, 29, 21, 1, -29 },
  { 1965, 14, 29, 10, -2, -29 },
  { 2016, 15, 36, 8, -6, -29 },
  { 2084, 19, 29, 17, 1, -29 },
  { 2153, 11, 29, 15, 1, -29 },
  { 2193, 27, 29, 27, 1, -29 },
  { 2291, 21, 29, 22, 1, -29 },
  { 2368, 19, 29, 22, 2, -29 },
  { 2437, 17, 29, 17, 1, -29 },
  { 2499, 19, 36, 22, 2, -29 },
  { 2585, 17, 29, 18, 1, -29 },
  { 2647, 18, 29, 16, -1, -29 },
  { 2713, 15, 29, 15, 3, -29 },
  { 2768, 19, 29, 21, 2, -29 },
  { 2837, 16, 29, 17, 4, -29 },
  { 2895, 27, 29, 28, 4, -29 },
  { 2993, 20, 29, 16, -2, -29 },
  { 3066, 15, 29, 15, 3, -29 },
  { 3121, 19, 29, 15, -1, -29 },
  { 3190, 15, 35, 11, -1, -29 },
  { 3256, 6, 29, 13, 4, -29 },
  { 3278, 15, 35, 11, -3, -29 },
  { 3344, 16, 16, 18, 1, -29 },
  { 3376, 12, 1, 12, -3, 4 },
  { 3378, 5, 7, 9, 6, -31 },
  { 3383, 16, 22, 18, 1, -22 },
  { 3427, 17, 30, 18, 0, -30 },
  { 3491, 14, 22, 14, 1, -22 },
  { 3530, 18, 30, 18, 1, -30 },
  { 3598, 14, 22, 16, 1, -22 },
  { 3637, 19, 41, 9, -5, -31 },
  { 3735, 18, 32, 18, 0, -22 },
  { 3807, 16, 30, 18, 0, -30 },
  { 3867, 9, 29, 8, 0, -29 },
  { 3900, 14, 39, 8, -5, -29 },
  { 3969, 16, 30, 15, 0, -30 },
  { 4029, 9, 30, 8, 0, -30 },
  { 4063, 25, 22, 27, 0, -22 },
  { 4132, 16, 22, 18, 0, -22 },
  { 4176, 15, 22, 17, 1, -22 },
  { 4218, 18, 31, 18, -1, -22 },
  { 4288, 17, 31, 18, 1, -22 },
  { 4354, 13, 22, 12, 0, -22 },
  { 4390, 13, 22, 13, 0, -22 },
  { 4426, 10, 26, 10, 1, -26 },
  { 4459, 16, 21, 18, 1, -21 },
  { 4501, 14, 21, 14, 2, -21 },
  { 4538, 22, 21, 22, 2, -21 },
  { 4596, 18, 21, 14, -2, -21 },
  { 4644, 20, 31, 14, -4, -21 },
  { 4722, 14, 21, 12, -1, -21 },
  { 4759, 14, 35, 13, 1, -29 },
  { 4821, 2, 40, 16, 7, -30 },
  { 4831, 14, 35, 13, -2, -29 },
  { 4893, 15, 4, 18, 2, -16 },
};

const GFXfont NotoSans_Condensed_LightItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC40PT7B_H_
