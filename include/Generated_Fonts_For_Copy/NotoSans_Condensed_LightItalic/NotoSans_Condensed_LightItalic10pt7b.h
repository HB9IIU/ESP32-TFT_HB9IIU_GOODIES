#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC10PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x48, 0xF0, 0x29, 0x96, 0xAF, 0x52, 0x80, 0x13, 0x66, 0x25,
  0x5E, 0x40, 0xDE, 0xB9, 0x76, 0xB6, 0xC0, 0x75, 0x64, 0xB9, 0xF0, 0xC0,
  0x29, 0x49, 0x24, 0x40, 0x24, 0x92, 0x52, 0x80, 0x59, 0xD0, 0x22, 0xF2,
  0x20, 0xC0, 0xC0, 0x80, 0x12, 0x24, 0x48, 0x80, 0x75, 0x59, 0x99, 0xE0,
  0x79, 0x24, 0xA0, 0x71, 0x12, 0x24, 0xE0, 0x71, 0x16, 0x11, 0xE0, 0x13,
  0x55, 0xA7, 0x20, 0x74, 0x43, 0x11, 0xE0, 0x34, 0x69, 0x99, 0xE0, 0xF2,
  0x24, 0x48, 0x80, 0x75, 0x56, 0x99, 0xE0, 0x75, 0x97, 0x12, 0xE0, 0x40,
  0x80, 0x40, 0xA0, 0x12, 0xC2, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80, 0x64,
  0xA4, 0x20, 0x3D, 0x17, 0xEB, 0xB6, 0xA8, 0x1C, 0x10, 0x8A, 0x55, 0xA6,
  0x20, 0x7A, 0x54, 0xE9, 0x4B, 0x80, 0x3A, 0x11, 0x08, 0x41, 0xC0, 0x72,
  0x52, 0x98, 0xCB, 0x80, 0x74, 0x47, 0x88, 0xE0, 0x74, 0x47, 0x88, 0x80,
  0x3A, 0x11, 0x38, 0xC5, 0xC0, 0x4A, 0x52, 0xF8, 0xCA, 0x40, 0x69, 0x25,
  0x30, 0x11, 0x11, 0x22, 0x22, 0xC0, 0x4A, 0x98, 0xCA, 0x52, 0x40, 0x49,
  0x29, 0x38, 0x42, 0xCD, 0x93, 0x6A, 0xD6, 0xA9, 0x00, 0x45, 0xA6, 0x9A,
  0x9A, 0x49, 0x00, 0x3A, 0x53, 0x18, 0xC5, 0xC0, 0x75, 0x57, 0x88, 0x80,
  0x3A, 0x53, 0x18, 0xC5, 0x44, 0x10, 0x75, 0x57, 0xAA, 0x90, 0x74, 0x42,
  0x11, 0xE0, 0xF4, 0x48, 0x88, 0x80, 0x4A, 0x52, 0x98, 0xC9, 0xC0, 0x99,
  0xAA, 0xC8, 0x80, 0x93, 0x6A, 0xD6, 0xCD, 0x92, 0x24, 0x00, 0x2C, 0xA1,
  0x04, 0x31, 0x4D, 0x00, 0xBA, 0xCC, 0x88, 0x80, 0x71, 0x24, 0x48, 0xE0,
  0x74, 0x44, 0x88, 0x88, 0xC0, 0xAA, 0x94, 0x31, 0x12, 0x22, 0x22, 0xC0,
  0x25, 0x59, 0xE0, 0x90, 0x79, 0x99, 0xE0, 0x44, 0x65, 0x59, 0x9E, 0x78,
  0x88, 0xE0, 0x08, 0x4A, 0xA9, 0x4A, 0x5C, 0x79, 0xE8, 0xE0, 0x19, 0x0C,
  0x42, 0x21, 0x08, 0x46, 0x00, 0x79, 0x99, 0xE2, 0xE0, 0x44, 0x65, 0x59,
  0x9A, 0x45, 0xA8, 0x20, 0x94, 0x92, 0xC0, 0x44, 0x45, 0x64, 0xAA, 0x55,
  0x6A, 0x7D, 0x59, 0x65, 0xA4, 0x75, 0x99, 0xA0, 0x79, 0x99, 0xE0, 0x75,
  0x99, 0xE8, 0x80, 0x79, 0x99, 0xE2, 0x20, 0x6A, 0x48, 0xF1, 0x1E, 0x4D,
  0x29, 0x30, 0x55, 0x99, 0xE0, 0xBB, 0x48, 0xAF, 0xAD, 0x4A, 0x00, 0x56,
  0x4A, 0xA0, 0x49, 0x8C, 0x42, 0x23, 0x00, 0x65, 0x4C, 0x32, 0x44, 0xC4,
  0x48, 0x40, 0xFF, 0xC0, 0x31, 0x22, 0x12, 0x24, 0x80, 0xF0,
};

const GFXglyph NotoSans_Condensed_LightItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 2, 7, 2, 0, -7 },
  { 3, 2, 2, 3, 1, -7 },
  { 4, 5, 7, 5, 0, -7 },
  { 9, 4, 9, 4, 0, -8 },
  { 14, 5, 7, 6, 1, -7 },
  { 19, 4, 7, 5, 0, -7 },
  { 23, 1, 2, 2, 1, -7 },
  { 24, 3, 9, 3, 0, -7 },
  { 28, 3, 9, 3, -1, -7 },
  { 32, 3, 4, 4, 1, -8 },
  { 34, 4, 5, 5, 0, -6 },
  { 37, 1, 2, 2, 0, -1 },
  { 38, 2, 1, 3, 0, -3 },
  { 39, 1, 1, 2, 0, -1 },
  { 40, 4, 7, 3, 0, -7 },
  { 44, 4, 7, 4, 0, -7 },
  { 48, 3, 7, 4, 1, -7 },
  { 51, 4, 7, 4, 0, -7 },
  { 55, 4, 7, 4, 0, -7 },
  { 59, 4, 7, 4, 0, -7 },
  { 63, 4, 7, 4, 0, -7 },
  { 67, 4, 7, 4, 0, -7 },
  { 71, 4, 7, 4, 1, -7 },
  { 75, 4, 7, 4, 0, -7 },
  { 79, 4, 7, 4, 0, -7 },
  { 83, 2, 5, 2, 0, -5 },
  { 85, 2, 6, 2, 0, -5 },
  { 87, 4, 5, 5, 0, -6 },
  { 90, 4, 3, 5, 0, -5 },
  { 92, 4, 5, 5, 0, -6 },
  { 95, 3, 7, 3, 0, -7 },
  { 98, 6, 8, 6, 0, -7 },
  { 104, 5, 7, 4, -1, -7 },
  { 109, 5, 7, 5, 0, -7 },
  { 114, 5, 7, 4, 0, -7 },
  { 119, 5, 7, 5, 0, -7 },
  { 124, 4, 7, 4, 0, -7 },
  { 128, 4, 7, 4, 0, -7 },
  { 132, 5, 7, 5, 0, -7 },
  { 137, 5, 7, 5, 0, -7 },
  { 142, 3, 7, 2, 0, -7 },
  { 145, 4, 9, 2, -2, -7 },
  { 150, 5, 7, 4, 0, -7 },
  { 155, 3, 7, 4, 0, -7 },
  { 158, 7, 7, 7, 0, -7 },
  { 165, 6, 7, 5, 0, -7 },
  { 171, 5, 7, 5, 0, -7 },
  { 176, 4, 7, 4, 0, -7 },
  { 180, 5, 9, 5, 0, -7 },
  { 186, 4, 7, 4, 0, -7 },
  { 190, 4, 7, 4, 0, -7 },
  { 194, 4, 7, 4, 1, -7 },
  { 198, 5, 7, 5, 0, -7 },
  { 203, 4, 7, 4, 1, -7 },
  { 207, 7, 7, 7, 1, -7 },
  { 214, 6, 7, 4, -1, -7 },
  { 220, 4, 7, 4, 1, -7 },
  { 224, 4, 7, 4, 0, -7 },
  { 228, 4, 9, 3, 0, -7 },
  { 233, 2, 7, 3, 1, -7 },
  { 235, 4, 9, 3, -1, -7 },
  { 240, 4, 4, 4, 0, -7 },
  { 242, 3, 1, 3, -1, 1 },
  { 243, 2, 2, 2, 1, -8 },
  { 244, 4, 5, 4, 0, -5 },
  { 247, 4, 8, 4, 0, -8 },
  { 251, 4, 5, 3, 0, -5 },
  { 254, 5, 8, 5, 0, -8 },
  { 259, 4, 5, 4, 0, -5 },
  { 262, 5, 10, 2, -1, -8 },
  { 269, 4, 7, 5, 0, -5 },
  { 273, 4, 8, 4, 0, -8 },
  { 277, 2, 7, 2, 0, -7 },
  { 279, 3, 9, 2, -1, -7 },
  { 283, 4, 8, 4, 0, -8 },
  { 287, 2, 8, 2, 0, -8 },
  { 289, 6, 5, 7, 0, -5 },
  { 293, 4, 5, 4, 0, -5 },
  { 296, 4, 5, 4, 0, -5 },
  { 299, 4, 7, 4, 0, -5 },
  { 303, 4, 7, 5, 0, -5 },
  { 307, 3, 5, 3, 0, -5 },
  { 309, 3, 5, 3, 0, -5 },
  { 311, 3, 7, 2, 0, -7 },
  { 314, 4, 5, 4, 0, -5 },
  { 317, 3, 5, 3, 1, -5 },
  { 319, 5, 5, 6, 1, -5 },
  { 323, 4, 5, 4, 0, -5 },
  { 326, 5, 7, 4, -1, -5 },
  { 331, 3, 5, 3, 0, -5 },
  { 333, 4, 9, 3, 0, -7 },
  { 338, 1, 10, 4, 2, -8 },
  { 340, 4, 9, 3, -1, -7 },
  { 345, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_LightItalic10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC10PT7B_H_
