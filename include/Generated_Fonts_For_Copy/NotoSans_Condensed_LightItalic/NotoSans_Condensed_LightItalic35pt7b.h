#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC35PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x0C, 0x18, 0x30, 0x60, 0x83,
  0x06, 0x0C, 0x18, 0x20, 0xC1, 0x80, 0x00, 0x00, 0x30, 0x60, 0xC0, 0x63,
  0x63, 0x62, 0xC6, 0xC6, 0xC6, 0xC4, 0x84, 0x8C, 0x00, 0x43, 0x00, 0x61,
  0x80, 0x30, 0x80, 0x10, 0xC0, 0x18, 0x60, 0x0C, 0x20, 0x04, 0x30, 0x3F,
  0xFF, 0x1F, 0xFF, 0x81, 0x04, 0x00, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x00,
  0x21, 0x80, 0x30, 0xC0, 0x18, 0x44, 0xFF, 0xFC, 0x0C, 0x30, 0x06, 0x10,
  0x02, 0x18, 0x03, 0x0C, 0x01, 0x84, 0x00, 0x82, 0x00, 0x43, 0x00, 0x61,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x40, 0x00, 0x80, 0x07, 0x80, 0x3F, 0xE0,
  0xC8, 0x83, 0x10, 0x04, 0x20, 0x18, 0xC0, 0x31, 0x00, 0x62, 0x00, 0x64,
  0x00, 0xE8, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xF0, 0x01, 0x70, 0x06, 0x60,
  0x0C, 0xC0, 0x10, 0x80, 0x23, 0x00, 0x46, 0x01, 0x9C, 0x72, 0x70, 0x7F,
  0x80, 0x08, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x00, 0x0F, 0x01, 0x83,
  0x20, 0x30, 0xC6, 0x0C, 0x10, 0xC1, 0x06, 0x18, 0x60, 0xC3, 0x18, 0x10,
  0x63, 0x06, 0x08, 0xC0, 0xC3, 0x10, 0x18, 0x66, 0x03, 0x0C, 0x9F, 0x61,
  0x33, 0x6C, 0x6C, 0xC7, 0x99, 0xB0, 0xDE, 0x66, 0x18, 0x08, 0x82, 0x03,
  0x30, 0x40, 0x46, 0x08, 0x18, 0xC3, 0x06, 0x18, 0x60, 0xC2, 0x08, 0x30,
  0x43, 0x04, 0x0C, 0x61, 0x81, 0x98, 0x60, 0x1E, 0x00, 0x01, 0xF0, 0x03,
  0x98, 0x03, 0x18, 0x06, 0x08, 0x06, 0x08, 0x06, 0x18, 0x06, 0x18, 0x06,
  0x30, 0x06, 0x30, 0x06, 0x60, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x1D,
  0x81, 0x39, 0x86, 0x30, 0xC6, 0x60, 0xC4, 0x60, 0x6C, 0xC0, 0x68, 0xC0,
  0x78, 0xC0, 0x30, 0xC0, 0x70, 0xE0, 0xD8, 0x73, 0x98, 0x3F, 0x0C, 0x6D,
  0xAD, 0xB4, 0x80, 0x00, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x04,
  0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0x03, 0x00, 0x40, 0x18, 0x06, 0x01,
  0x80, 0x20, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x00, 0x04, 0x00, 0xC0,
  0x18, 0x43, 0x0E, 0x40, 0x79, 0xC3, 0xF8, 0xF0, 0x32, 0x0C, 0x63, 0x0C,
  0x00, 0xC0, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0xFF, 0xF8, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x0C, 0x71, 0x86, 0x30, 0xC6, 0x18,
  0xC0, 0xFF, 0xFC, 0x00, 0x03, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x02, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x00, 0x01, 0xF0, 0x1C, 0xE0, 0x61, 0x83, 0x06,
  0x18, 0x08, 0x60, 0x33, 0x00, 0xCC, 0x02, 0x30, 0x19, 0x80, 0x66, 0x01,
  0x98, 0x06, 0x60, 0x19, 0x80, 0x6C, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00,
  0xCC, 0x06, 0x30, 0x18, 0xC0, 0xC3, 0x03, 0x06, 0x18, 0x1D, 0xC0, 0x3E,
  0x00, 0x03, 0x07, 0x1F, 0x3B, 0xE6, 0x46, 0x06, 0x06, 0x04, 0x0C, 0x0C,
  0x0C, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x60, 0x60, 0x01, 0xF8, 0x0F, 0x3C, 0x08, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x7F, 0xF8, 0xFF,
  0xF0, 0x03, 0xF8, 0x1E, 0x78, 0x30, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x3F, 0x00,
  0x7C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x20, 0x38, 0x71, 0xE0, 0xFF, 0x00,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0x60, 0x06, 0xC0, 0x19, 0x00,
  0x26, 0x00, 0xCC, 0x03, 0x18, 0x04, 0x30, 0x18, 0xC0, 0x61, 0x81, 0x83,
  0x03, 0x06, 0x0C, 0x08, 0x30, 0x30, 0x60, 0x61, 0xFF, 0xFB, 0xFF, 0xF0,
  0x02, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0xFE, 0x0F, 0xF8, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x20, 0x38, 0x71, 0xE0, 0xFF, 0x00, 0x00, 0xFC,
  0x07, 0x10, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00,
  0x30, 0x00, 0xC4, 0x06, 0x7E, 0x1B, 0x1C, 0x70, 0x31, 0x80, 0xC6, 0x03,
  0x38, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x61, 0x01,
  0x86, 0x0C, 0x1C, 0xE0, 0x3F, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0xC0, 0x00, 0x01, 0xF8, 0x0F, 0x38, 0x18, 0x38, 0x60, 0x30, 0xC0, 0x61,
  0x80, 0xC3, 0x01, 0x86, 0x06, 0x0C, 0x0C, 0x0C, 0x30, 0x1D, 0xC0, 0x1E,
  0x00, 0x7C, 0x03, 0x9C, 0x0E, 0x1C, 0x38, 0x18, 0x60, 0x30, 0x80, 0x33,
  0x00, 0x66, 0x00, 0xCC, 0x03, 0x1C, 0x06, 0x18, 0x1C, 0x3C, 0x70, 0x1F,
  0x80, 0x01, 0xF0, 0x1E, 0xE0, 0x60, 0xC3, 0x03, 0x18, 0x0C, 0x60, 0x31,
  0x80, 0xC4, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x07, 0x18, 0x3C,
  0x71, 0xA0, 0xFD, 0x80, 0x86, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x31, 0xC0, 0xFE, 0x00, 0x04, 0x30, 0xC2,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0x8E, 0x00,
  0x01, 0x01, 0xC0, 0xC0, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x18, 0x0C, 0x06, 0x06, 0x03, 0x03,
  0x01, 0x01, 0x80, 0x00, 0x08, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x18, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x00, 0x70, 0x0E, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0x70, 0x02, 0x00, 0x00, 0x1F, 0xC7, 0xB8, 0x81,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x07, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0x9E,
  0x00, 0x60, 0x18, 0x06, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x08, 0x60,
  0x00, 0x43, 0x07, 0xE3, 0x30, 0x62, 0x19, 0x86, 0x30, 0xC8, 0x61, 0x86,
  0xC2, 0x0C, 0x26, 0x30, 0x41, 0x21, 0x86, 0x19, 0x08, 0x30, 0xD8, 0x41,
  0x84, 0xC6, 0x18, 0x66, 0x30, 0xC3, 0x31, 0x8E, 0x31, 0x86, 0xDB, 0x0C,
  0x3C, 0x70, 0x60, 0x00, 0x01, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0x66,
  0x01, 0x8C, 0x03, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x20, 0xC0, 0xC1, 0x81,
  0xFF, 0x07, 0xFE, 0x0C, 0x0C, 0x30, 0x18, 0x60, 0x31, 0x80, 0x63, 0x00,
  0x4C, 0x00, 0x98, 0x01, 0x70, 0x03, 0xC0, 0x06, 0x07, 0xF0, 0x1F, 0xF8,
  0x30, 0x38, 0x60, 0x30, 0xC0, 0x61, 0x80, 0xC6, 0x01, 0x8C, 0x03, 0x18,
  0x0C, 0x30, 0x38, 0x60, 0xE1, 0xFF, 0x03, 0xFE, 0x06, 0x06, 0x0C, 0x06,
  0x10, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x00, 0xCC, 0x03, 0x18,
  0x06, 0x30, 0x38, 0x7F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x07, 0x9C, 0x1C,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x1E, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xFC, 0x0C, 0x0E,
  0x0C, 0x06, 0x0C, 0x07, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x03, 0x18, 0x03,
  0x18, 0x03, 0x10, 0x03, 0x30, 0x03, 0x30, 0x03, 0x30, 0x06, 0x30, 0x06,
  0x20, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0xC0, 0x30,
  0xC0, 0x70, 0xC1, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x03, 0xFF, 0x07, 0xFE,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x18, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x03, 0xFF,
  0x07, 0xFE, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x1F, 0xF8,
  0x1F, 0xF0, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0x00, 0xFF, 0x01, 0xF7, 0xC1, 0xC0, 0x21, 0x80, 0x01, 0xC0, 0x01, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x0C, 0x07, 0xE6, 0x03, 0xF3, 0x00, 0x19, 0x80, 0x08, 0xC0, 0x0C,
  0x60, 0x06, 0x30, 0x03, 0x18, 0x01, 0x8C, 0x01, 0x87, 0x00, 0xC1, 0xC0,
  0x60, 0x79, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x60, 0xC0, 0x0C, 0x18,
  0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x83, 0x00, 0x30, 0x60,
  0x0C, 0x0C, 0x01, 0x81, 0x80, 0x30, 0x30, 0x06, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x30, 0x06, 0x06, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x06, 0x06, 0x00,
  0xC0, 0xC0, 0x18, 0x18, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x18, 0x18, 0x03,
  0x03, 0x00, 0x60, 0xE0, 0x0C, 0x00, 0x07, 0xF0, 0x18, 0x01, 0x80, 0x10,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x10, 0x03, 0x20, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x5E, 0x03, 0xE0, 0x00, 0x03,
  0x01, 0xC1, 0x80, 0xE0, 0x60, 0x70, 0x18, 0x18, 0x06, 0x0C, 0x01, 0x86,
  0x00, 0xC3, 0x80, 0x31, 0xC0, 0x0C, 0xE0, 0x03, 0x30, 0x00, 0x98, 0x00,
  0x6E, 0x00, 0x1F, 0x80, 0x07, 0x60, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x30,
  0xC0, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1, 0x80, 0x60, 0x70, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x18, 0x00, 0x03, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x07, 0x07, 0x80, 0x07, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x0A, 0x07, 0x80, 0x1E, 0x05, 0x80, 0x16, 0x0D, 0x80,
  0x36, 0x0D, 0x80, 0x26, 0x0D, 0x80, 0x6C, 0x0D, 0x80, 0x4C, 0x08, 0x80,
  0xCC, 0x18, 0x80, 0x8C, 0x18, 0x81, 0x8C, 0x18, 0xC1, 0x18, 0x18, 0xC3,
  0x18, 0x30, 0xC2, 0x18, 0x30, 0xC6, 0x18, 0x30, 0xC4, 0x18, 0x30, 0xCC,
  0x30, 0x30, 0xC8, 0x30, 0x60, 0xD8, 0x30, 0x60, 0xD0, 0x30, 0x60, 0x70,
  0x20, 0x60, 0x60, 0x60, 0xC0, 0x60, 0x60, 0x03, 0x00, 0x30, 0x70, 0x06,
  0x07, 0x80, 0x60, 0x78, 0x06, 0x07, 0x80, 0x60, 0x58, 0x04, 0x0C, 0xC0,
  0xC0, 0xCC, 0x0C, 0x0C, 0xC0, 0xC0, 0xCC, 0x0C, 0x08, 0x60, 0x81, 0x86,
  0x18, 0x18, 0x61, 0x81, 0x86, 0x18, 0x18, 0x31, 0x83, 0x03, 0x30, 0x30,
  0x33, 0x03, 0x03, 0x30, 0x30, 0x13, 0x03, 0x01, 0xA0, 0x60, 0x1E, 0x06,
  0x01, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0xE0, 0xC0, 0x0C, 0x00, 0x01, 0xFC,
  0x07, 0x9E, 0x0E, 0x06, 0x0C, 0x03, 0x18, 0x03, 0x38, 0x03, 0x30, 0x03,
  0x70, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0, 0x0C,
  0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x30, 0x60, 0x70, 0x79, 0xE0, 0x3F, 0x80,
  0x07, 0xE0, 0x1F, 0xF0, 0x30, 0x70, 0x60, 0x60, 0xC0, 0xC1, 0x80, 0xC6,
  0x01, 0x8C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x40, 0x61, 0x81, 0xC3, 0x07,
  0x07, 0xFC, 0x0F, 0xC0, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x01,
  0xFC, 0x07, 0x9E, 0x0E, 0x06, 0x0C, 0x03, 0x18, 0x03, 0x38, 0x03, 0x30,
  0x03, 0x70, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0C, 0xC0,
  0x0C, 0xC0, 0x1C, 0xC0, 0x18, 0xC0, 0x30, 0x60, 0x70, 0x79, 0xE0, 0x3F,
  0x80, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00,
  0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0x30, 0x70, 0x60, 0x60, 0xC0, 0xC1, 0x80,
  0xC6, 0x01, 0x8C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x61, 0x81, 0xC3,
  0xFF, 0x07, 0xF8, 0x0C, 0x60, 0x10, 0xC0, 0x60, 0xC0, 0xC1, 0x81, 0x83,
  0x03, 0x06, 0x0C, 0x0C, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x70,
  0x03, 0xFC, 0x0F, 0xFC, 0x38, 0x10, 0x60, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x20, 0x38, 0x7B, 0xE0, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xC1, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x00, 0x1C, 0x01, 0x8C, 0x00, 0x86, 0x00, 0xC3, 0x00,
  0x61, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18,
  0x03, 0x18, 0x01, 0x8C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0x61, 0x00, 0x31,
  0x80, 0x10, 0xC0, 0x18, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x06, 0x0C, 0x03,
  0x06, 0x03, 0x83, 0x81, 0x80, 0xF7, 0x80, 0x3F, 0x80, 0x00, 0xC0, 0x0F,
  0x80, 0x1B, 0x00, 0x36, 0x00, 0xCC, 0x01, 0x98, 0x06, 0x30, 0x0C, 0x60,
  0x30, 0xC0, 0x61, 0x81, 0x81, 0x03, 0x02, 0x0C, 0x04, 0x18, 0x08, 0x30,
  0x10, 0xC0, 0x21, 0x80, 0x66, 0x00, 0xCC, 0x01, 0xB0, 0x03, 0x60, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x18, 0x03,
  0xC0, 0x18, 0x06, 0xC0, 0x38, 0x06, 0xC0, 0x38, 0x0C, 0xC0, 0x78, 0x0C,
  0xC0, 0x78, 0x0C, 0xC0, 0xD8, 0x18, 0xC0, 0xD8, 0x18, 0xC0, 0x98, 0x30,
  0xC1, 0x98, 0x30, 0xC1, 0x98, 0x60, 0xC3, 0x18, 0x60, 0xC3, 0x18, 0x60,
  0xC2, 0x18, 0xC0, 0xC6, 0x18, 0xC0, 0xC4, 0x19, 0x80, 0xCC, 0x19, 0x80,
  0xCC, 0x19, 0x80, 0xD8, 0x1B, 0x00, 0xD8, 0x1B, 0x00, 0xD0, 0x1E, 0x00,
  0xF0, 0x1E, 0x00, 0xF0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x00,
  0x03, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x0C, 0x01, 0x86, 0x00,
  0x61, 0x80, 0x18, 0xC0, 0x02, 0x60, 0x00, 0xD8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0D, 0x80,
  0x06, 0x20, 0x01, 0x8C, 0x00, 0xC3, 0x00, 0x70, 0xC0, 0x18, 0x30, 0x0C,
  0x0C, 0x03, 0x01, 0x81, 0x80, 0x60, 0xC0, 0x18, 0x00, 0xC0, 0x1E, 0x01,
  0xB0, 0x0C, 0x80, 0xC6, 0x06, 0x30, 0x61, 0x86, 0x0C, 0x30, 0x63, 0x03,
  0x18, 0x09, 0x80, 0x6C, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0xC0, 0x00, 0x07, 0xFF, 0x07, 0xFF, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xFF, 0xF0, 0xFF, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x86, 0x31, 0x8C, 0x61, 0x08,
  0x63, 0x18, 0xC6, 0x10, 0x86, 0x31, 0x8C, 0x61, 0x08, 0x63, 0x18, 0x03,
  0xF8, 0x1F, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x7E, 0x03,
  0xF0, 0x00, 0x01, 0x80, 0x07, 0x00, 0x3C, 0x00, 0xB0, 0x06, 0x60, 0x31,
  0x80, 0xC2, 0x06, 0x0C, 0x18, 0x30, 0xC0, 0x62, 0x01, 0x98, 0x06, 0xC0,
  0x0F, 0x00, 0x30, 0xFF, 0xFF, 0xFC, 0xC6, 0x62, 0x31, 0x03, 0xC4, 0x1F,
  0xB0, 0xC3, 0xC6, 0x07, 0x30, 0x18, 0xC0, 0x66, 0x01, 0x98, 0x06, 0x60,
  0x19, 0x80, 0xCC, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x01, 0x8C, 0x06, 0x30,
  0x38, 0x61, 0xE1, 0xCD, 0x83, 0xE4, 0x00, 0x03, 0x00, 0x06, 0x00, 0x08,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x70,
  0x1B, 0xF0, 0x3C, 0x30, 0x50, 0x61, 0xC0, 0x63, 0x80, 0xC6, 0x01, 0x8C,
  0x02, 0x18, 0x0C, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x63, 0x01, 0x86, 0x03,
  0x1C, 0x06, 0x38, 0x18, 0x70, 0x60, 0xB1, 0xC3, 0x3E, 0x00, 0x03, 0xF0,
  0x7E, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x07,
  0x18, 0x3F, 0x80, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x03, 0xCC, 0x07, 0xEC, 0x0C,
  0x3C, 0x18, 0x1C, 0x30, 0x18, 0x30, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60,
  0x18, 0x60, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x70, 0xC0,
  0x60, 0xC0, 0xE0, 0xE1, 0xE0, 0x73, 0x60, 0x3E, 0x60, 0x03, 0xC0, 0x7F,
  0x0C, 0x31, 0x83, 0x30, 0x33, 0x03, 0x60, 0x66, 0x0E, 0x63, 0xC7, 0xF0,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x18,
  0x3F, 0x80, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x30, 0x00, 0x30, 0x00, 0x20,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xF8, 0x03, 0xF8, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xB8, 0x00, 0xF0, 0x00,
  0x01, 0xE2, 0x07, 0xE4, 0x18, 0x78, 0x60, 0x71, 0x80, 0xC3, 0x01, 0x8C,
  0x03, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x31, 0x80, 0x63, 0x00, 0xC6, 0x01,
  0x8C, 0x07, 0x18, 0x0C, 0x30, 0x38, 0x70, 0xF0, 0x73, 0x60, 0x7C, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC1, 0x8F,
  0x03, 0xFC, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x00, 0x0C, 0xF0, 0x37, 0xE0, 0xF0, 0xC3, 0x83,
  0x1C, 0x0C, 0x70, 0x31, 0x80, 0xC6, 0x02, 0x18, 0x18, 0xC0, 0x63, 0x01,
  0x8C, 0x06, 0x30, 0x10, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x81,
  0x8C, 0x06, 0x00, 0x07, 0x07, 0x02, 0x00, 0x00, 0x00, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60,
  0x60, 0x60, 0x60, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x04, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x13, 0x00, 0xF8, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x20, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00,
  0x0C, 0x0C, 0x30, 0x60, 0xC3, 0x83, 0x0C, 0x18, 0x60, 0x63, 0x01, 0x98,
  0x06, 0xC0, 0x17, 0x00, 0xDC, 0x03, 0x98, 0x0E, 0x60, 0x31, 0x80, 0x86,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0C, 0x06, 0x00, 0x03, 0x03,
  0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18,
  0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60,
  0xC0, 0x0C, 0xF0, 0xF0, 0x37, 0xE7, 0xE0, 0xF1, 0xB1, 0xC3, 0x83, 0x83,
  0x1C, 0x0C, 0x0C, 0x60, 0x30, 0x31, 0x81, 0x80, 0xC6, 0x06, 0x06, 0x10,
  0x18, 0x18, 0xC0, 0x60, 0x63, 0x01, 0x01, 0x8C, 0x0C, 0x04, 0x30, 0x30,
  0x30, 0x80, 0xC0, 0xC6, 0x03, 0x03, 0x18, 0x18, 0x0C, 0x60, 0x60, 0x21,
  0x81, 0x81, 0x8C, 0x06, 0x06, 0x00, 0x0C, 0xF0, 0x37, 0xF0, 0xF0, 0xC3,
  0x83, 0x1C, 0x0C, 0x70, 0x31, 0x80, 0xC6, 0x02, 0x10, 0x18, 0xC0, 0x63,
  0x01, 0x8C, 0x06, 0x30, 0x30, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31,
  0x81, 0x8C, 0x06, 0x00, 0x03, 0xC0, 0x3F, 0x83, 0x0C, 0x30, 0x33, 0x01,
  0x98, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xF0, 0x07, 0x80, 0x6C,
  0x03, 0x60, 0x1B, 0x01, 0x98, 0x0C, 0x60, 0xC3, 0x9C, 0x0F, 0xC0, 0x06,
  0x38, 0x06, 0xFE, 0x07, 0x86, 0x05, 0x06, 0x0E, 0x03, 0x0E, 0x03, 0x0C,
  0x03, 0x0C, 0x02, 0x0C, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18,
  0x0C, 0x18, 0x0C, 0x38, 0x0C, 0x38, 0x18, 0x38, 0x30, 0x3C, 0x70, 0x27,
  0xC0, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0x03, 0xC4, 0x1F, 0x90, 0xC3, 0xC6, 0x07,
  0x30, 0x18, 0xC0, 0x66, 0x01, 0x98, 0x06, 0x60, 0x19, 0x80, 0x4C, 0x03,
  0x30, 0x0C, 0xC0, 0x33, 0x01, 0xCC, 0x06, 0x30, 0x38, 0xE1, 0xE1, 0xCD,
  0x83, 0xE6, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x0C, 0xF0, 0xDE, 0x0B, 0x00, 0xA0, 0x1C,
  0x01, 0xC0, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x00, 0x07, 0xC0,
  0xFF, 0x18, 0x23, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x81, 0x8E,
  0x70, 0xFE, 0x00, 0x04, 0x0C, 0x0C, 0x08, 0x1F, 0x7F, 0x18, 0x10, 0x30,
  0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0, 0xC0,
  0xE8, 0x78, 0x18, 0x0C, 0x60, 0x31, 0x80, 0x84, 0x06, 0x30, 0x18, 0xC0,
  0x63, 0x01, 0x8C, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x60,
  0x63, 0x01, 0x8C, 0x0E, 0x30, 0x38, 0xC1, 0x41, 0x9D, 0x07, 0xEC, 0x00,
  0xC0, 0x3C, 0x06, 0xC0, 0x6C, 0x0C, 0xC0, 0xCC, 0x18, 0xC1, 0x8C, 0x30,
  0xC3, 0x0C, 0x20, 0xC6, 0x0C, 0x60, 0x4C, 0x04, 0xC0, 0x58, 0x05, 0x80,
  0x70, 0x07, 0x00, 0x60, 0x00, 0xC0, 0x60, 0x78, 0x1C, 0x0F, 0x03, 0x83,
  0x60, 0xF0, 0x6C, 0x16, 0x19, 0x86, 0xC3, 0x30, 0xD8, 0x46, 0x13, 0x18,
  0xC6, 0x63, 0x18, 0x8C, 0xC3, 0x31, 0x98, 0x66, 0x32, 0x0D, 0x86, 0xC1,
  0xB0, 0xD8, 0x34, 0x1E, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x03,
  0x81, 0x80, 0x00, 0x0C, 0x06, 0x18, 0x18, 0x30, 0x60, 0x20, 0xC0, 0x63,
  0x00, 0xCC, 0x01, 0x90, 0x01, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xD8, 0x03, 0x10, 0x06, 0x30, 0x18, 0x60, 0x60, 0xC0, 0xC0,
  0xC3, 0x01, 0x80, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x30, 0x18, 0x0C, 0x06,
  0x01, 0x03, 0x00, 0x40, 0xC0, 0x10, 0x60, 0x04, 0x18, 0x01, 0x8C, 0x00,
  0x63, 0x00, 0x19, 0x80, 0x06, 0x60, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1A,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x27,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x07, 0xFC, 0x3F, 0xE0, 0x00,
  0x70, 0x1F, 0x01, 0x80, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0xF8, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0xC0, 0x04, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x0C,
  0x00, 0xF0, 0x07, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x18, 0x0F, 0x00,
  0x80, 0x00, 0x7C, 0x0F, 0xF8, 0xE0, 0xFE,
};

const GFXglyph NotoSans_Condensed_LightItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 25, 8, 1, -25 },
  { 23, 8, 9, 11, 4, -25 },
  { 32, 17, 25, 16, 0, -25 },
  { 86, 15, 29, 15, 0, -27 },
  { 141, 19, 25, 22, 2, -25 },
  { 201, 16, 25, 16, 0, -25 },
  { 251, 3, 9, 6, 4, -25 },
  { 255, 10, 31, 9, 1, -25 },
  { 294, 10, 31, 9, -2, -25 },
  { 333, 11, 12, 14, 4, -27 },
  { 350, 13, 17, 16, 2, -21 },
  { 378, 6, 9, 7, -2, -4 },
  { 385, 8, 1, 10, 1, -10 },
  { 386, 2, 3, 7, 1, -3 },
  { 387, 16, 25, 11, -2, -25 },
  { 437, 14, 25, 15, 1, -25 },
  { 481, 8, 25, 15, 4, -25 },
  { 506, 15, 25, 15, -1, -25 },
  { 553, 15, 25, 15, 0, -25 },
  { 600, 15, 25, 15, 0, -25 },
  { 647, 15, 25, 15, 0, -25 },
  { 694, 14, 25, 15, 1, -25 },
  { 738, 14, 25, 15, 2, -25 },
  { 782, 15, 25, 15, 0, -25 },
  { 829, 14, 25, 15, 0, -25 },
  { 873, 6, 19, 7, 0, -19 },
  { 888, 9, 24, 7, -2, -19 },
  { 915, 13, 15, 16, 2, -20 },
  { 940, 13, 9, 16, 2, -17 },
  { 955, 13, 15, 16, 2, -20 },
  { 980, 11, 25, 11, 1, -25 },
  { 1015, 21, 28, 22, 1, -25 },
  { 1089, 15, 25, 15, -2, -25 },
  { 1136, 15, 25, 16, 1, -25 },
  { 1183, 15, 25, 15, 2, -25 },
  { 1230, 16, 25, 18, 1, -25 },
  { 1280, 16, 25, 14, 0, -25 },
  { 1330, 16, 25, 13, 0, -25 },
  { 1380, 17, 25, 19, 2, -25 },
  { 1434, 19, 25, 18, 0, -25 },
  { 1494, 12, 25, 8, -1, -25 },
  { 1532, 13, 31, 7, -5, -25 },
  { 1583, 18, 25, 15, 0, -25 },
  { 1640, 10, 25, 13, 0, -25 },
  { 1672, 24, 25, 24, 0, -25 },
  { 1747, 20, 25, 19, 0, -25 },
  { 1810, 16, 25, 19, 2, -25 },
  { 1860, 15, 25, 15, 1, -25 },
  { 1907, 16, 31, 19, 2, -25 },
  { 1969, 15, 25, 15, 1, -25 },
  { 2016, 15, 25, 14, 0, -25 },
  { 2063, 13, 25, 13, 3, -25 },
  { 2104, 17, 25, 18, 2, -25 },
  { 2158, 15, 25, 15, 3, -25 },
  { 2205, 24, 25, 24, 3, -25 },
  { 2280, 18, 25, 14, -2, -25 },
  { 2337, 13, 25, 13, 3, -25 },
  { 2378, 16, 25, 13, -1, -25 },
  { 2428, 13, 31, 10, -1, -25 },
  { 2479, 5, 25, 12, 4, -25 },
  { 2495, 13, 31, 10, -2, -25 },
  { 2546, 14, 14, 16, 1, -25 },
  { 2571, 11, 2, 11, -3, 3 },
  { 2574, 4, 6, 8, 5, -27 },
  { 2577, 14, 19, 16, 1, -19 },
  { 2611, 15, 27, 16, 0, -27 },
  { 2662, 12, 19, 12, 1, -19 },
  { 2691, 16, 27, 16, 1, -27 },
  { 2745, 12, 19, 14, 1, -19 },
  { 2774, 16, 35, 8, -4, -27 },
  { 2844, 15, 27, 16, 0, -19 },
  { 2895, 14, 27, 15, 0, -27 },
  { 2943, 8, 25, 7, 0, -25 },
  { 2968, 13, 33, 7, -5, -25 },
  { 3022, 14, 27, 13, 0, -27 },
  { 3070, 8, 27, 7, 0, -27 },
  { 3097, 22, 19, 23, 0, -19 },
  { 3150, 14, 19, 15, 0, -19 },
  { 3184, 13, 19, 15, 1, -19 },
  { 3215, 16, 27, 16, -1, -19 },
  { 3269, 14, 27, 16, 1, -19 },
  { 3317, 12, 19, 10, 0, -19 },
  { 3346, 12, 19, 12, 0, -19 },
  { 3375, 8, 23, 9, 1, -23 },
  { 3398, 14, 19, 15, 1, -19 },
  { 3432, 12, 19, 12, 2, -19 },
  { 3461, 19, 19, 20, 2, -19 },
  { 3507, 15, 19, 13, -1, -19 },
  { 3543, 18, 27, 12, -4, -19 },
  { 3604, 13, 19, 11, -1, -19 },
  { 3635, 12, 31, 11, 1, -25 },
  { 3682, 1, 35, 14, 7, -27 },
  { 3687, 12, 31, 11, -2, -25 },
  { 3734, 13, 3, 16, 2, -14 },
};

const GFXfont NotoSans_Condensed_LightItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC35PT7B_H_
