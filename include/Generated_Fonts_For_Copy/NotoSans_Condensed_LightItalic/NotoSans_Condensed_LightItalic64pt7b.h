#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC64PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0E, 0x1C, 0x0E, 0x1C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C,
  0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x70, 0x38, 0x70, 0x38,
  0x70, 0x38, 0x60, 0x30, 0x60, 0x30, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x06, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x1C,
  0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0xE0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x01, 0x80, 0x70, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x38,
  0x0E, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x03, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0xC0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x60, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0xE0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x30, 0x0E, 0x00, 0x01, 0xC0, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3E, 0x30, 0xE0, 0x1E, 0x1C,
  0x08, 0x0F, 0x06, 0x00, 0x03, 0x81, 0x80, 0x00, 0xE0, 0x60, 0x00, 0x78,
  0x18, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00,
  0x78, 0x30, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF9, 0x80,
  0x00, 0x1F, 0x60, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0x7C, 0x00, 0x01, 0x8F, 0x80, 0x00, 0x61, 0xE0, 0x00, 0x18, 0x38,
  0x00, 0x0E, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xC0, 0xF0, 0x00, 0x30,
  0x3C, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC1, 0xE0, 0x00,
  0x60, 0xF0, 0x20, 0x18, 0x7C, 0x0F, 0x06, 0x7E, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0xFF,
  0x00, 0x03, 0x80, 0x7F, 0xE0, 0x01, 0xC0, 0x3C, 0x38, 0x00, 0xF0, 0x0E,
  0x07, 0x00, 0x38, 0x07, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x70,
  0x07, 0x00, 0x60, 0x3C, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x70, 0x0E, 0x07,
  0x00, 0x38, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0x38,
  0x38, 0x00, 0xE0, 0x1C, 0x1C, 0x00, 0x38, 0x07, 0x0F, 0x00, 0x0E, 0x01,
  0xC3, 0x83, 0xE3, 0x80, 0xF1, 0xC3, 0xFC, 0xE0, 0x38, 0x71, 0xFF, 0xB8,
  0x0E, 0x38, 0xF0, 0xEE, 0x07, 0x1E, 0x38, 0x3B, 0x81, 0xC7, 0x1C, 0x07,
  0xE0, 0xE3, 0x87, 0x01, 0xDE, 0xF0, 0xE3, 0x80, 0x77, 0xF8, 0x70, 0xE0,
  0x1C, 0xFC, 0x1C, 0x38, 0x07, 0x00, 0x0E, 0x1C, 0x03, 0x80, 0x07, 0x87,
  0x00, 0xE0, 0x01, 0xC1, 0xC0, 0x38, 0x00, 0xE0, 0xE0, 0x0E, 0x00, 0x38,
  0x38, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x70, 0x03,
  0x80, 0xE0, 0x1C, 0x01, 0xE0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x03, 0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x38, 0x1C,
  0x01, 0xC0, 0x0E, 0x07, 0x00, 0xE0, 0x03, 0x83, 0x80, 0x78, 0x00, 0xF1,
  0xE0, 0x1C, 0x00, 0x1F, 0xF0, 0x0E, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x38, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0x78, 0x07, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x70, 0x0E, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38,
  0x78, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3C, 0x78, 0x07, 0x07, 0x87, 0x80,
  0x70, 0xF0, 0x3C, 0x0F, 0x1E, 0x03, 0xC0, 0xE3, 0xC0, 0x1C, 0x0E, 0x3C,
  0x01, 0xE1, 0xC7, 0x80, 0x1E, 0x1C, 0x78, 0x00, 0xF3, 0x87, 0x00, 0x0F,
  0x38, 0x70, 0x00, 0x77, 0x0F, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x3E, 0x0F,
  0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xE0, 0x70, 0x00,
  0xFE, 0x07, 0x80, 0x1E, 0xE0, 0x7C, 0x07, 0xCF, 0x03, 0xFB, 0xF8, 0x70,
  0x1F, 0xFE, 0x07, 0x80, 0xFF, 0xC0, 0x78, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0xF3, 0xCE, 0x39, 0xE7, 0x9C, 0x71, 0xC7, 0x38, 0xE3, 0x8E, 0x30, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x20, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x20, 0x1C, 0x01, 0x80,
  0xC0, 0x1F, 0x06, 0x00, 0x7E, 0x70, 0x00, 0xFF, 0x87, 0xC1, 0xFF, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1E, 0xE0, 0x01, 0xE3,
  0x00, 0x1E, 0x1C, 0x01, 0xE0, 0x70, 0x1E, 0x03, 0x80, 0x60, 0x1E, 0x01,
  0x00, 0x70, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x00, 0x7F, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF8, 0x33, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0x83, 0xC0, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x1C, 0x07,
  0x80, 0x0E, 0x03, 0xC0, 0x07, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0,
  0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x38, 0x38, 0x00, 0x1C,
  0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8F, 0x00, 0x03,
  0xC7, 0x80, 0x01, 0xE3, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x79, 0xE0, 0x00,
  0x38, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x1C, 0x00,
  0x07, 0x8E, 0x00, 0x03, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0,
  0x00, 0xF1, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C,
  0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x07, 0x80, 0x0F, 0x03,
  0xC0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0x70, 0x07, 0x80, 0x3C, 0x07, 0x80,
  0x1F, 0x07, 0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x0F, 0xC0, 0x7F, 0x03,
  0xFC, 0x3E, 0xE1, 0xF3, 0x8F, 0x9E, 0x78, 0x7B, 0xC1, 0xC6, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x3E, 0x03, 0xE0, 0x07, 0x00, 0x3E, 0x00, 0x40, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFC, 0x07, 0xC0, 0x0E, 0x00, 0x3C, 0x01, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x10, 0x00, 0x3C, 0x03, 0x00,
  0x1F, 0x80, 0x7F, 0x3F, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x38, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0x70,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x1E,
  0x00, 0x1C, 0x01, 0xE0, 0x03, 0xC0, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x03,
  0x80, 0x3C, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x30,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xCF, 0xF0, 0x00,
  0x80, 0x3F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x10, 0x00, 0x3C, 0x03, 0x00, 0x1F, 0x80, 0x7F, 0x3F,
  0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7E,
  0x01, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC3,
  0xFC, 0x00, 0x73, 0xFF, 0xC0, 0x3D, 0xFF, 0xF0, 0x0E, 0xF0, 0x3E, 0x03,
  0xB0, 0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x07,
  0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x1C, 0x00,
  0x07, 0x0F, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x78, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0x7E, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x03, 0xC0,
  0x38, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x00, 0xE0, 0x38, 0x00,
  0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x03,
  0xC0, 0x03, 0x80, 0x78, 0x00, 0xF0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x0E, 0x01, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x3C, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xF0, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x38, 0x78, 0x00, 0x07, 0x0F, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x3C, 0x1C,
  0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x0F,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0xE7, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x38, 0x0F, 0x00, 0x1E, 0x07, 0x00, 0x0F, 0x07, 0x80, 0x03, 0x83, 0x80,
  0x01, 0xC1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70,
  0x00, 0x1C, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0xF8, 0x38, 0x00, 0xFC, 0x1E, 0x00, 0x6E, 0x0F, 0x80, 0xFF,
  0x03, 0xFB, 0xF7, 0x00, 0xFF, 0xF3, 0x80, 0x3F, 0xE3, 0xC0, 0x03, 0x81,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x1F, 0x7F, 0x80, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF,
  0xE0, 0xF0, 0x3E, 0x04, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x00, 0x0E, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x1C, 0x00, 0x7F, 0x80, 0x60, 0x70, 0x03, 0xFF, 0x01, 0xC3,
  0x80, 0x3F, 0xFC, 0x07, 0x0E, 0x01, 0xE0, 0x70, 0x1C, 0x70, 0x07, 0x01,
  0xC0, 0x61, 0xC0, 0x38, 0x0E, 0x01, 0x87, 0x01, 0xC0, 0x38, 0x0E, 0x38,
  0x07, 0x00, 0xE0, 0x38, 0xE0, 0x38, 0x07, 0x80, 0xE3, 0x80, 0xE0, 0x1C,
  0x03, 0x8C, 0x07, 0x00, 0x70, 0x0E, 0x70, 0x1C, 0x01, 0xC0, 0x31, 0xC0,
  0x70, 0x0F, 0x01, 0xC7, 0x03, 0x80, 0x38, 0x07, 0x1C, 0x0E, 0x00, 0xE0,
  0x1C, 0x60, 0x38, 0x03, 0x80, 0xE3, 0x80, 0xE0, 0x1E, 0x03, 0x8E, 0x03,
  0x80, 0x70, 0x0E, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0xE0, 0x38, 0x0F, 0x01,
  0xC3, 0x80, 0xE0, 0x6C, 0x0E, 0x0E, 0x03, 0x81, 0xB0, 0x70, 0x38, 0x0F,
  0x0C, 0xE3, 0xC0, 0xE0, 0x1F, 0xF3, 0xFE, 0x03, 0x80, 0x7F, 0x87, 0xF0,
  0x0E, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x80, 0x00,
  0x07, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x0E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x1E, 0x3C, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x70, 0x00, 0x1C,
  0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x00,
  0x70, 0x01, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x78, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x70,
  0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xE0, 0x7F, 0xC0, 0x07, 0x00,
  0x3E, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1E,
  0x00, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x3E, 0x00, 0x78, 0x1F, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x3C, 0x0F, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x7C, 0x03,
  0x80, 0x07, 0xC0, 0x1C, 0x01, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0xE0, 0x03, 0xE0, 0x02,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x08, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x70, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x03, 0x80, 0x00, 0xE0, 0x1E,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x00,
  0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x01,
  0xC0, 0x70, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xE0,
  0x38, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x7C, 0x03, 0x80, 0x03, 0xE0, 0x1E,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x07, 0x03,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0x06, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x7F, 0xF0, 0x70, 0x00, 0x7F, 0xF0, 0xF0, 0x00, 0x7F, 0xF0, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x00, 0xE0, 0xF0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x01, 0xC0, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x03, 0x80, 0x78, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x07, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x01, 0xC0,
  0x0F, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x07, 0x80, 0x1C, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00,
  0xF0, 0x07, 0x80, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0xE0, 0x07, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x01, 0xC0, 0xF8, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x03, 0x8F, 0x80, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x07, 0x7F, 0x00, 0x00, 0x07,
  0x7F, 0x00, 0x00, 0x0F, 0xE7, 0x00, 0x00, 0x0F, 0xC7, 0x00, 0x00, 0x0F,
  0x87, 0x80, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x3B, 0x80, 0x00, 0x07, 0x70, 0x07, 0x70, 0x00, 0x01, 0xFE, 0x00, 0xEE,
  0x00, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x00, 0x0F, 0x70, 0x07, 0xB8, 0x00,
  0x01, 0xCE, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0xC0, 0x1C, 0xE0, 0x00, 0x0E,
  0x78, 0x03, 0x9E, 0x00, 0x03, 0xCE, 0x00, 0x73, 0xC0, 0x00, 0x71, 0xC0,
  0x1E, 0x38, 0x00, 0x1E, 0x38, 0x03, 0xC7, 0x00, 0x03, 0x8F, 0x00, 0x70,
  0xE0, 0x00, 0xF1, 0xE0, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x07, 0x87, 0x00, 0x78, 0x70, 0x00, 0xE1, 0xE0, 0x0E, 0x0E, 0x00, 0x3C,
  0x3C, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x80, 0x38, 0x38, 0x01, 0xE0, 0xE0,
  0x0F, 0x07, 0x00, 0x38, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x80, 0x38,
  0x1E, 0x01, 0xC0, 0xF0, 0x07, 0x03, 0xC0, 0x78, 0x1C, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x3C, 0x07, 0x03, 0xC0, 0x70, 0x07, 0x80, 0xE0, 0x70,
  0x1E, 0x00, 0xE0, 0x1C, 0x1E, 0x03, 0xC0, 0x1C, 0x03, 0x83, 0x80, 0x70,
  0x03, 0x80, 0x70, 0xF0, 0x0E, 0x00, 0xF0, 0x0E, 0x1C, 0x01, 0xC0, 0x1E,
  0x01, 0xC7, 0x80, 0x78, 0x03, 0x80, 0x38, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE7, 0x00, 0x38, 0x03, 0xC0, 0x1F, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0xF8, 0x01, 0xE0, 0x0E, 0x00, 0x3F, 0x00, 0x3C,
  0x01, 0xC0, 0x07, 0xC0, 0x07, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xE0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x07,
  0x00, 0x3E, 0x00, 0x00, 0xE0, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0xFC, 0x00,
  0x07, 0x80, 0x3B, 0x80, 0x00, 0xF0, 0x07, 0x70, 0x00, 0x1C, 0x00, 0xEF,
  0x00, 0x03, 0x80, 0x1D, 0xE0, 0x00, 0x70, 0x07, 0x9C, 0x00, 0x1E, 0x00,
  0xF3, 0x80, 0x03, 0xC0, 0x1C, 0x78, 0x00, 0x70, 0x03, 0x8F, 0x00, 0x0E,
  0x00, 0x70, 0xE0, 0x03, 0xC0, 0x1E, 0x1C, 0x00, 0x78, 0x03, 0xC3, 0xC0,
  0x0E, 0x00, 0x70, 0x78, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0xE0, 0x0F, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x0E, 0x03, 0xC0, 0x38, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xE0, 0x3C,
  0x01, 0xE0, 0x1E, 0x07, 0x80, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x38,
  0x1C, 0x00, 0xE0, 0x07, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0x80,
  0x0E, 0x1C, 0x00, 0xE0, 0x01, 0xC3, 0x80, 0x1C, 0x00, 0x38, 0x70, 0x03,
  0x80, 0x07, 0x9E, 0x00, 0xF0, 0x00, 0x73, 0xC0, 0x1E, 0x00, 0x0E, 0x70,
  0x03, 0x80, 0x01, 0xCE, 0x00, 0x70, 0x00, 0x3D, 0xC0, 0x1E, 0x00, 0x03,
  0xB8, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x0E, 0x00,
  0x01, 0xF8, 0x01, 0xC0, 0x00, 0x3F, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x0F,
  0x00, 0x00, 0x7C, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x07, 0x80,
  0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78,
  0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x71, 0xE0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00,
  0x1C, 0xF0, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x1E,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x1F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x38, 0x7F, 0xC0, 0x07, 0x00, 0x7C, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x1E,
  0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x1E, 0x00, 0x0F,
  0x03, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0x01, 0xC0,
  0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x0F, 0x80,
  0x38, 0x07, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x71, 0xE0,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x00, 0x73, 0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xFC, 0x00, 0x38, 0x3F, 0xC0, 0x07, 0x00, 0x7C, 0x00, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x1C,
  0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0,
  0x78, 0x00, 0xF8, 0x0F, 0x00, 0x3E, 0x01, 0xC0, 0x1F, 0x80, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0x70,
  0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x01, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x01, 0xE0,
  0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x78, 0x0E, 0x00,
  0x0F, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x78, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x03, 0xF0, 0x1F, 0x00, 0x7C, 0x00, 0x20, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x08, 0x00, 0x0F, 0x80, 0xF0, 0x03, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0x01, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x70, 0x1E, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x38, 0x0F,
  0x00, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1A, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1E, 0xE0,
  0x00, 0x07, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x78,
  0xE0, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x03,
  0xC0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x01, 0xE0, 0x07, 0x00, 0x70,
  0x01, 0xC0, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x01,
  0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x07,
  0x07, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x38, 0x00,
  0x07, 0x1E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0x78, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x00,
  0x01, 0xEE, 0x00, 0x03, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x38, 0x00, 0x1F, 0x80, 0x01, 0xC7, 0x00, 0x03, 0xF0, 0x00, 0x78, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0x1C, 0x00, 0x1D, 0xC0, 0x01, 0xC3, 0x80, 0x03,
  0xB8, 0x00, 0x78, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0xE0,
  0x03, 0xC1, 0xC0, 0x07, 0x9C, 0x00, 0x78, 0x38, 0x00, 0xE3, 0x80, 0x1E,
  0x07, 0x00, 0x1C, 0x70, 0x03, 0xC0, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x1C,
  0x00, 0xE1, 0xC0, 0x1E, 0x03, 0x80, 0x3C, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x1C,
  0x03, 0x80, 0x38, 0x07, 0x03, 0x80, 0xF0, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x00, 0xE0, 0x38, 0x0E, 0x07, 0x80, 0x1C, 0x0F, 0x01, 0xC0, 0xF0, 0x03,
  0x81, 0xC0, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x07, 0x07, 0x80, 0x0E, 0x0E,
  0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x1C, 0x3C, 0x00, 0x38, 0x78, 0x03,
  0x87, 0x00, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x00, 0xE3, 0xC0, 0x0E, 0x3C,
  0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x39, 0xE0, 0x00,
  0x73, 0x80, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x01, 0xDE,
  0x00, 0x1D, 0xE0, 0x00, 0x3B, 0x80, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x07, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00,
  0x1E, 0x38, 0x00, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x00, 0xE0, 0xE0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x70, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0xE0, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x70, 0x00,
  0xF0, 0x70, 0x00, 0xE0, 0x70, 0x01, 0xE0, 0x70, 0x01, 0xC0, 0x78, 0x03,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x0F, 0x00, 0x38, 0x0E,
  0x00, 0x38, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x1D, 0xE0,
  0x00, 0x1D, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x40, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x38, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x1E, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x1C, 0x07, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0x83, 0x80, 0x01, 0xC3, 0xC0, 0x00, 0xF1, 0xC0,
  0x00, 0x39, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x78, 0x78, 0x38,
  0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0x03, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xF8,
  0x70, 0x07, 0xFF, 0x1C, 0x03, 0xF3, 0xCE, 0x01, 0xF0, 0x3B, 0x80, 0xF0,
  0x06, 0xE0, 0x78, 0x01, 0xF8, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x03,
  0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x0E,
  0x0F, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x1E, 0x00, 0x07, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x07,
  0xC0, 0xF0, 0x01, 0xF0, 0x1C, 0x00, 0xDC, 0x07, 0x80, 0x77, 0x01, 0xF0,
  0x3B, 0x80, 0x3F, 0x7C, 0xE0, 0x0F, 0xFE, 0x38, 0x00, 0xFF, 0x0E, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x06, 0x00, 0x07, 0x0F, 0xF0, 0x01, 0xC7, 0xFE, 0x00, 0xF7,
  0xEF, 0xC0, 0x39, 0xC0, 0xF8, 0x0E, 0xE0, 0x1E, 0x03, 0xF0, 0x07, 0x81,
  0xF8, 0x00, 0xE0, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x0F, 0x00,
  0x03, 0x83, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x1E,
  0x00, 0x07, 0x87, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0x81, 0xF0,
  0x03, 0xE0, 0x7E, 0x00, 0xF0, 0x39, 0xC0, 0xF8, 0x0E, 0x7C, 0xFC, 0x03,
  0x8F, 0xFE, 0x00, 0xE1, 0xFF, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xFD, 0xF0, 0x1F, 0x00, 0x81,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x20, 0x3F, 0x9F,
  0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x07, 0x00, 0x07, 0xFC, 0x38, 0x00, 0x7F, 0xF3, 0xC0, 0x07,
  0xE7, 0xDE, 0x00, 0x7C, 0x0E, 0xE0, 0x07, 0x80, 0x37, 0x00, 0x78, 0x00,
  0xF8, 0x03, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x01, 0xE0,
  0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x78, 0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0,
  0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0xF8, 0x07, 0x80, 0x0F, 0x80, 0x3C, 0x00, 0x7C, 0x01, 0xE0, 0x06, 0xE0,
  0x07, 0x80, 0x77, 0x00, 0x3C, 0x07, 0x38, 0x00, 0xFD, 0xF3, 0x80, 0x07,
  0xFF, 0x1C, 0x00, 0x0F, 0xF0, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0x3E, 0x01, 0xE0,
  0x3C, 0x0F, 0x00, 0xF0, 0x78, 0x01, 0xC1, 0xC0, 0x07, 0x0F, 0x00, 0x1C,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xE0,
  0x03, 0xC3, 0x80, 0x3E, 0x1E, 0x03, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8,
  0x07, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x60, 0x3F, 0x0F, 0x80, 0x7F, 0xFE, 0x00, 0x7F, 0xF0, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x78, 0x20, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0xFF, 0x87, 0x00, 0x1F, 0xFC, 0x70, 0x03, 0xF3, 0xE7,
  0x00, 0x7C, 0x0E, 0xE0, 0x0F, 0x00, 0x6E, 0x01, 0xE0, 0x03, 0xE0, 0x1E,
  0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x3C, 0x07, 0x80, 0x03,
  0xC0, 0x70, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x38, 0x0E,
  0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x78, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00,
  0x1E, 0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0xC0,
  0x3C, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0xC0, 0x1E, 0x01, 0xDC, 0x01, 0xE0,
  0x3B, 0xC0, 0x0F, 0xDF, 0x38, 0x00, 0xFF, 0xE3, 0x80, 0x03, 0xFC, 0x38,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x08,
  0x00, 0x78, 0x00, 0xE0, 0x1F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x01, 0xC0, 0x03, 0x87, 0xF8, 0x01, 0xCF, 0xFE, 0x01, 0xEF,
  0xFF, 0x80, 0xEF, 0x03, 0xC0, 0x76, 0x00, 0xF0, 0x3E, 0x00, 0x78, 0x1F,
  0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x03,
  0xC0, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0,
  0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x78, 0x00,
  0x38, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x0F, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x38, 0x07, 0x80,
  0x1C, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0E, 0x07, 0x80, 0x07, 0x07, 0x80,
  0x03, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xE3, 0xC0,
  0x00, 0x73, 0xE0, 0x00, 0x3B, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1D, 0xDC,
  0x00, 0x0F, 0xCF, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xC1, 0xC0, 0x03, 0xC0,
  0xF0, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0x70, 0x0E, 0x00, 0x78,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x03, 0x80,
  0xE0, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x8F, 0xF8, 0x1F, 0xF0, 0x06, 0x3F,
  0xF8, 0x7F, 0xF0, 0x1C, 0xFB, 0xF1, 0xF7, 0xE0, 0x3B, 0x81, 0xE7, 0x03,
  0xE0, 0x76, 0x01, 0xFC, 0x03, 0xC0, 0xF8, 0x03, 0xF0, 0x07, 0x83, 0xE0,
  0x07, 0xC0, 0x07, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x38, 0x00, 0x78, 0x00, 0xE0, 0xF0,
  0x00, 0xE0, 0x01, 0xC1, 0xE0, 0x01, 0xC0, 0x03, 0x83, 0xC0, 0x07, 0x80,
  0x0F, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x3C,
  0x00, 0x38, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0xE0, 0x01, 0xE0,
  0x03, 0xC1, 0xC0, 0x03, 0x80, 0x07, 0x83, 0x80, 0x07, 0x00, 0x0E, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x70, 0x00, 0xE0, 0x01, 0xE1, 0xE0, 0x01, 0xC0, 0x03, 0x83,
  0xC0, 0x03, 0x80, 0x07, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E,
  0x00, 0x3C, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x78, 0x00, 0x70, 0x00, 0xE0,
  0xF0, 0x01, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0xC0, 0x07, 0x83, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xE1, 0xFE, 0x00, 0x63, 0xFF,
  0x80, 0x73, 0xFF, 0xE0, 0x3B, 0xC0, 0xF0, 0x1D, 0x80, 0x3C, 0x0F, 0x80,
  0x1E, 0x0F, 0xC0, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0x81, 0xE0,
  0x01, 0xC0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xE0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0x80, 0x03,
  0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x70, 0x00,
  0x70, 0x38, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0xFC, 0xFC, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x1E, 0x07,
  0x80, 0x0E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x38,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF0,
  0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0x78,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x3F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xC3, 0xFC,
  0x00, 0x0E, 0x3F, 0xF0, 0x00, 0xE3, 0xCF, 0xC0, 0x07, 0x38, 0x1F, 0x00,
  0x3B, 0x80, 0x78, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0xF8,
  0x00, 0x78, 0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0xF0, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xC0,
  0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x38, 0x07, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x78, 0x03, 0xDC, 0x0F,
  0x80, 0x1E, 0xF9, 0xF8, 0x00, 0xE3, 0xFF, 0x80, 0x07, 0x0F, 0xF8, 0x00,
  0x38, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F,
  0xF8, 0x70, 0x07, 0xFF, 0x1C, 0x03, 0xF7, 0xE7, 0x01, 0xE0, 0x3B, 0x80,
  0xF0, 0x06, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x0F,
  0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0x83, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x78,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x83, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x83, 0xC0,
  0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xFC, 0x07, 0x80, 0x77, 0x01,
  0xE0, 0x3B, 0xC0, 0x3F, 0x7C, 0xE0, 0x0F, 0xFE, 0x38, 0x01, 0xFF, 0x0E,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x60, 0x1C, 0x3F, 0x01, 0x8F, 0xF0, 0x39, 0xFF,
  0x03, 0xBC, 0x00, 0x3B, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0xFC, 0x3E, 0x07, 0xC0, 0x10, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x08, 0x00, 0xF0, 0x30, 0x07, 0xC0, 0xF8, 0xFE,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x1F, 0xFE, 0x7F, 0xFD, 0xFF, 0xF8, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x7C, 0xC0,
  0x7F, 0x80, 0x7F, 0x00, 0x38, 0x00, 0x03, 0x80, 0x03, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x38, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x07, 0x00,
  0x07, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0xE0,
  0x00, 0xE0, 0x70, 0x00, 0x70, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1C,
  0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xF0,
  0x78, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x3E,
  0x07, 0x80, 0x37, 0x03, 0xE0, 0x73, 0x80, 0xFD, 0xF9, 0xC0, 0x3F, 0xF9,
  0xC0, 0x0F, 0xF0, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x3D, 0xC0, 0x01, 0xEE, 0x00, 0x0E, 0x70, 0x00, 0xF3,
  0x80, 0x07, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x01,
  0xC1, 0xC0, 0x1E, 0x0E, 0x00, 0xE0, 0x70, 0x0F, 0x03, 0x80, 0x70, 0x1E,
  0x07, 0x80, 0xF0, 0x38, 0x07, 0x83, 0xC0, 0x3C, 0x1C, 0x01, 0xE1, 0xE0,
  0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x80, 0x0E, 0x38, 0x00, 0x73,
  0xC0, 0x03, 0x9C, 0x00, 0x1D, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0xFE, 0x00,
  0x3E, 0x00, 0x3B, 0x80, 0x0F, 0x80, 0x1E, 0xE0, 0x07, 0xE0, 0x07, 0xB8,
  0x01, 0xF8, 0x01, 0xCE, 0x00, 0x7E, 0x00, 0xF3, 0x80, 0x3B, 0x80, 0x38,
  0xE0, 0x0E, 0xE0, 0x1E, 0x38, 0x07, 0x38, 0x07, 0x0E, 0x01, 0xCE, 0x01,
  0xC3, 0x80, 0xE3, 0x80, 0xF0, 0xE0, 0x38, 0xE0, 0x38, 0x38, 0x0E, 0x38,
  0x1E, 0x0E, 0x07, 0x0E, 0x07, 0x03, 0x81, 0xC3, 0x81, 0xC0, 0xE0, 0xE0,
  0xE0, 0xE0, 0x38, 0x38, 0x38, 0x38, 0x0E, 0x1E, 0x0E, 0x1E, 0x03, 0x87,
  0x03, 0x87, 0x00, 0xE1, 0xC0, 0xE3, 0xC0, 0x38, 0xE0, 0x38, 0xE0, 0x0E,
  0x38, 0x0E, 0x38, 0x03, 0x9C, 0x03, 0x9E, 0x00, 0xE7, 0x00, 0xE7, 0x00,
  0x3B, 0xC0, 0x39, 0xC0, 0x0E, 0xE0, 0x0E, 0xE0, 0x03, 0xB8, 0x03, 0xB8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x03, 0x80, 0x70,
  0x00, 0x38, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x01,
  0xC3, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x1E, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x0E, 0x1C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x00,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0x78, 0x0F, 0x80,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x3C, 0x00,
  0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x38, 0x0F, 0x00, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x07, 0x03, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1C, 0x70,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x03, 0xBC,
  0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x9F, 0xF8, 0x00, 0x5F, 0xFF, 0x00, 0xFE, 0x0F,
  0xF1, 0xFC, 0x01, 0xFF, 0xF4, 0x00, 0x3F, 0xF2, 0x00, 0x03, 0xC0,
};

const GFXglyph NotoSans_Condensed_LightItalic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 46, 14, 1, -46 },
  { 82, 16, 17, 20, 6, -46 },
  { 116, 30, 46, 30, 1, -46 },
  { 289, 26, 53, 27, 1, -49 },
  { 462, 34, 47, 40, 4, -46 },
  { 662, 28, 47, 30, 0, -46 },
  { 827, 6, 17, 11, 7, -46 },
  { 840, 18, 56, 16, 2, -46 },
  { 966, 19, 56, 16, -5, -46 },
  { 1099, 21, 22, 26, 7, -49 },
  { 1157, 25, 30, 30, 3, -38 },
  { 1251, 10, 15, 12, -3, -7 },
  { 1270, 15, 3, 18, 1, -19 },
  { 1276, 5, 6, 12, 1, -6 },
  { 1280, 28, 46, 20, -3, -46 },
  { 1441, 25, 47, 27, 2, -46 },
  { 1588, 14, 46, 27, 8, -46 },
  { 1669, 27, 46, 27, -1, -46 },
  { 1825, 27, 47, 27, 0, -46 },
  { 1984, 28, 46, 27, -1, -46 },
  { 2145, 27, 47, 27, 0, -46 },
  { 2304, 26, 47, 27, 2, -46 },
  { 2457, 26, 46, 27, 3, -46 },
  { 2607, 27, 47, 27, 0, -46 },
  { 2766, 25, 47, 27, 1, -46 },
  { 2913, 11, 34, 12, 1, -34 },
  { 2960, 15, 42, 13, -3, -34 },
  { 3039, 25, 28, 30, 3, -37 },
  { 3127, 25, 17, 30, 3, -31 },
  { 3181, 25, 28, 30, 3, -37 },
  { 3269, 20, 46, 20, 2, -46 },
  { 3384, 38, 52, 41, 2, -46 },
  { 3631, 27, 46, 27, -4, -46 },
  { 3787, 29, 46, 30, 1, -46 },
  { 3954, 29, 47, 28, 3, -46 },
  { 4125, 30, 46, 33, 1, -46 },
  { 4298, 27, 46, 26, 1, -46 },
  { 4454, 27, 46, 24, 1, -46 },
  { 4610, 32, 47, 34, 3, -46 },
  { 4798, 34, 46, 34, 1, -46 },
  { 4994, 22, 46, 15, -3, -46 },
  { 5121, 24, 58, 13, -10, -46 },
  { 5295, 32, 46, 27, 1, -46 },
  { 5479, 18, 46, 24, 1, -46 },
  { 5583, 43, 46, 43, 1, -46 },
  { 5831, 35, 46, 35, 1, -46 },
  { 6033, 30, 47, 35, 3, -46 },
  { 6210, 27, 46, 28, 1, -46 },
  { 6366, 30, 57, 35, 3, -46 },
  { 6580, 27, 46, 28, 1, -46 },
  { 6736, 28, 47, 26, -1, -46 },
  { 6901, 24, 46, 24, 5, -46 },
  { 7039, 31, 47, 33, 3, -46 },
  { 7222, 26, 46, 27, 6, -46 },
  { 7372, 43, 46, 44, 6, -46 },
  { 7620, 34, 46, 25, -4, -46 },
  { 7816, 24, 46, 24, 6, -46 },
  { 7954, 30, 46, 25, -2, -46 },
  { 8127, 23, 56, 18, -1, -46 },
  { 8288, 9, 46, 21, 7, -46 },
  { 8340, 23, 56, 18, -4, -46 },
  { 8501, 25, 25, 28, 2, -46 },
  { 8580, 20, 3, 20, -5, 6 },
  { 8588, 8, 10, 15, 9, -49 },
  { 8598, 26, 36, 29, 2, -35 },
  { 8715, 26, 50, 29, 1, -49 },
  { 8878, 21, 36, 22, 2, -35 },
  { 8973, 29, 50, 29, 2, -49 },
  { 9155, 22, 36, 25, 2, -35 },
  { 9254, 31, 64, 15, -8, -49 },
  { 9502, 28, 50, 29, 0, -35 },
  { 9677, 25, 49, 28, 1, -49 },
  { 9831, 13, 46, 12, 1, -46 },
  { 9906, 22, 61, 12, -8, -46 },
  { 10074, 25, 49, 24, 1, -49 },
  { 10228, 13, 49, 12, 1, -49 },
  { 10308, 39, 35, 42, 1, -35 },
  { 10479, 25, 35, 28, 1, -35 },
  { 10589, 24, 36, 28, 2, -35 },
  { 10697, 29, 50, 29, -2, -35 },
  { 10879, 26, 50, 29, 2, -35 },
  { 11042, 20, 35, 19, 1, -35 },
  { 11130, 22, 36, 21, 0, -35 },
  { 11229, 15, 43, 16, 2, -42 },
  { 11310, 25, 35, 28, 2, -34 },
  { 11420, 21, 34, 22, 4, -34 },
  { 11510, 34, 34, 36, 4, -34 },
  { 11655, 28, 34, 23, -3, -34 },
  { 11774, 33, 49, 23, -7, -34 },
  { 11977, 23, 34, 20, -2, -34 },
  { 12075, 23, 56, 21, 2, -46 },
  { 12236, 3, 64, 26, 12, -49 },
  { 12260, 23, 56, 21, -4, -46 },
  { 12421, 25, 7, 30, 3, -26 },
};

const GFXfont NotoSans_Condensed_LightItalic64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic64pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC64PT7B_H_
