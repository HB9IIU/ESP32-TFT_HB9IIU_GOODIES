#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC14PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0x94, 0x90, 0x10, 0x55, 0xAA, 0x14, 0x28, 0x53, 0xF2, 0x85,
  0x3F, 0x28, 0x51, 0x20, 0x08, 0x23, 0x54, 0x50, 0x81, 0x0A, 0x2A, 0xC6,
  0x10, 0x63, 0x4A, 0xA5, 0x4B, 0x7B, 0x4A, 0x95, 0x4B, 0x18, 0x18, 0xA2,
  0x8A, 0x31, 0x59, 0x62, 0x8B, 0xF0, 0x5A, 0x12, 0x24, 0x44, 0x88, 0x88,
  0x84, 0x11, 0x11, 0x11, 0x11, 0x22, 0x48, 0x2C, 0x74, 0xA0, 0x21, 0x09,
  0xF2, 0x10, 0x6A, 0x00, 0xE0, 0x80, 0x06, 0x08, 0x20, 0x41, 0x02, 0x08,
  0x10, 0x41, 0x00, 0x18, 0x94, 0x51, 0x45, 0x18, 0xA2, 0x91, 0xC0, 0x75,
  0x24, 0x94, 0x90, 0x38, 0x10, 0x41, 0x08, 0x42, 0x10, 0x43, 0xC0, 0x38,
  0x10, 0x42, 0x30, 0x20, 0x82, 0x0B, 0xC0, 0x04, 0x21, 0x8A, 0x29, 0x28,
  0xBE, 0x10, 0x40, 0x3C, 0x84, 0x10, 0x70, 0x20, 0x82, 0x0B, 0xC0, 0x1C,
  0x82, 0x10, 0x79, 0x28, 0xA2, 0x89, 0xC0, 0xF8, 0x44, 0x22, 0x11, 0x08,
  0x84, 0x00, 0x3C, 0x94, 0x4A, 0x31, 0x48, 0xA2, 0x89, 0xC0, 0x39, 0x14,
  0x51, 0x45, 0xE0, 0x82, 0x13, 0x80, 0x28, 0x00, 0x04, 0x12, 0x00, 0x00,
  0x04, 0x48, 0x09, 0xB1, 0x83, 0x04, 0xF8, 0x01, 0xF0, 0x83, 0x06, 0x36,
  0x40, 0x78, 0x42, 0x22, 0x11, 0x00, 0x06, 0x00, 0x0F, 0x18, 0x88, 0x29,
  0xD5, 0x4C, 0xA6, 0x95, 0x5A, 0x92, 0x20, 0x0F, 0x00, 0x0C, 0x31, 0x45,
  0x14, 0x93, 0xD1, 0x46, 0x10, 0x3C, 0x92, 0x51, 0x79, 0x24, 0x51, 0x8B,
  0xC0, 0x3D, 0x04, 0x20, 0x82, 0x08, 0x20, 0x81, 0xC0, 0x3C, 0x44, 0x8A,
  0x14, 0x28, 0x51, 0x22, 0x89, 0xE0, 0x3C, 0x82, 0x10, 0x79, 0x04, 0x10,
  0x83, 0xC0, 0x3C, 0x82, 0x10, 0x41, 0xE4, 0x10, 0x82, 0x00, 0x3E, 0x81,
  0x04, 0x08, 0x13, 0xA1, 0x44, 0x88, 0xF0, 0x21, 0x22, 0x22, 0x42, 0x7E,
  0x44, 0x44, 0x44, 0x84, 0x84, 0x38, 0x84, 0x22, 0x10, 0x84, 0x27, 0x00,
  0x08, 0x42, 0x21, 0x08, 0x42, 0x21, 0x08, 0x4C, 0x00, 0x22, 0x48, 0xA2,
  0x87, 0x0A, 0x14, 0x28, 0x89, 0x10, 0x22, 0x24, 0x44, 0x44, 0x8F, 0x20,
  0xCC, 0x23, 0x19, 0x46, 0x52, 0x94, 0xA5, 0x51, 0x54, 0x99, 0x26, 0x40,
  0x21, 0x31, 0x32, 0x52, 0x52, 0x4A, 0x4A, 0x4C, 0x84, 0x84, 0x3D, 0x14,
  0x61, 0x86, 0x18, 0x62, 0x8B, 0xC0, 0x3C, 0x92, 0x51, 0x45, 0xE4, 0x10,
  0x82, 0x00, 0x3D, 0x14, 0x61, 0x86, 0x18, 0x62, 0x8B, 0xC2, 0x04, 0x3C,
  0x92, 0x51, 0x4D, 0xC5, 0x12, 0x8A, 0x20, 0x3D, 0x04, 0x10, 0x20, 0x40,
  0x82, 0x0B, 0xC0, 0xF9, 0x08, 0x44, 0x21, 0x08, 0x44, 0x00, 0x42, 0x89,
  0x14, 0x28, 0x51, 0x22, 0x44, 0x89, 0xE0, 0x86, 0x28, 0xA2, 0x92, 0x4A,
  0x28, 0x41, 0x00, 0x88, 0x62, 0x29, 0x4A, 0x54, 0x95, 0x29, 0x4A, 0x63,
  0x18, 0xC4, 0x21, 0x00, 0x12, 0x24, 0x50, 0xC0, 0x83, 0x0A, 0x14, 0x49,
  0x10, 0x8C, 0x64, 0xA6, 0x21, 0x08, 0x44, 0x00, 0x3C, 0x10, 0x84, 0x10,
  0x84, 0x10, 0x83, 0xC0, 0x39, 0x08, 0x84, 0x21, 0x08, 0x84, 0x21, 0x80,
  0x91, 0x24, 0x92, 0x44, 0x18, 0x42, 0x11, 0x08, 0x42, 0x11, 0x09, 0xC0,
  0x10, 0xA2, 0x92, 0xC4, 0xF0, 0xA4, 0x10, 0xB4, 0x51, 0x8A, 0x28, 0x9E,
  0x20, 0x82, 0x0E, 0x25, 0x14, 0x51, 0x4A, 0x2F, 0x00, 0x19, 0x10, 0x88,
  0x42, 0x0E, 0x02, 0x04, 0x10, 0xA2, 0xC8, 0x91, 0x44, 0x89, 0x11, 0xE0,
  0x11, 0x52, 0xB6, 0x42, 0x0E, 0x06, 0x10, 0x20, 0xE0, 0x82, 0x04, 0x08,
  0x10, 0x40, 0x81, 0x02, 0x18, 0x00, 0x10, 0xB4, 0x51, 0x8A, 0x28, 0x9E,
  0x08, 0x4F, 0x00, 0x20, 0x82, 0x0E, 0x25, 0x14, 0x92, 0x4A, 0x28, 0x80,
  0x20, 0x24, 0x92, 0x90, 0x08, 0x02, 0x21, 0x08, 0x42, 0x21, 0x08, 0x4C,
  0x00, 0x20, 0x82, 0x09, 0x49, 0x46, 0x14, 0x52, 0x49, 0x00, 0x24, 0x94,
  0x92, 0x52, 0x00, 0x1B, 0x16, 0x51, 0x29, 0x14, 0x92, 0x4A, 0x25, 0x22,
  0x18, 0x94, 0x52, 0x49, 0x28, 0xA2, 0x10, 0xA4, 0x51, 0x86, 0x28, 0x9C,
  0x0C, 0x24, 0x89, 0x12, 0x24, 0x91, 0x3C, 0x40, 0x83, 0x00, 0x10, 0xB4,
  0x51, 0x8A, 0x28, 0x9E, 0x08, 0x41, 0x00, 0x19, 0x10, 0x84, 0x22, 0x10,
  0x32, 0x50, 0x82, 0x08, 0x5C, 0x23, 0x44, 0x44, 0x48, 0x40, 0x45, 0x14,
  0x92, 0x8A, 0x27, 0x80, 0x9C, 0xA9, 0x4C, 0x62, 0x00, 0x93, 0x66, 0xD6,
  0xAD, 0x93, 0x24, 0x00, 0x24, 0xA1, 0x04, 0x31, 0x2C, 0x80, 0x26, 0x48,
  0xA1, 0x43, 0x06, 0x08, 0x10, 0x21, 0x80, 0x78, 0x88, 0x84, 0x43, 0x80,
  0x08, 0x88, 0x42, 0x13, 0x08, 0x42, 0x10, 0xC0, 0xFF, 0xFC, 0x10, 0x42,
  0x21, 0x08, 0x62, 0x21, 0x09, 0x80, 0xCD, 0xC0,
};

const GFXglyph NotoSans_Condensed_LightItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 10, 3, 0, -10 },
  { 5, 4, 4, 4, 1, -10 },
  { 7, 7, 10, 7, 0, -10 },
  { 16, 6, 12, 6, 0, -11 },
  { 25, 7, 10, 9, 1, -10 },
  { 34, 6, 10, 7, 0, -10 },
  { 42, 2, 4, 2, 1, -10 },
  { 43, 4, 12, 4, 0, -10 },
  { 49, 4, 12, 4, -1, -10 },
  { 55, 4, 5, 6, 2, -11 },
  { 58, 5, 6, 6, 1, -8 },
  { 62, 3, 3, 3, -1, -1 },
  { 64, 3, 1, 4, 0, -4 },
  { 65, 1, 1, 3, 0, -1 },
  { 66, 7, 10, 4, -1, -10 },
  { 75, 6, 10, 6, 0, -10 },
  { 83, 3, 10, 6, 2, -10 },
  { 87, 6, 10, 6, 0, -10 },
  { 95, 6, 10, 6, 0, -10 },
  { 103, 6, 10, 6, 0, -10 },
  { 111, 6, 10, 6, 0, -10 },
  { 119, 6, 10, 6, 0, -10 },
  { 127, 5, 10, 6, 1, -10 },
  { 134, 6, 10, 6, 0, -10 },
  { 142, 6, 10, 6, 0, -10 },
  { 150, 3, 8, 3, 0, -8 },
  { 153, 4, 10, 3, -1, -8 },
  { 158, 5, 6, 6, 1, -8 },
  { 162, 5, 4, 6, 1, -7 },
  { 165, 5, 6, 6, 1, -8 },
  { 169, 5, 10, 4, 0, -10 },
  { 176, 9, 11, 9, 0, -10 },
  { 189, 6, 10, 6, -1, -10 },
  { 197, 6, 10, 6, 0, -10 },
  { 205, 6, 10, 6, 1, -10 },
  { 213, 7, 10, 7, 0, -10 },
  { 222, 6, 10, 6, 0, -10 },
  { 230, 6, 10, 5, 0, -10 },
  { 238, 7, 10, 8, 1, -10 },
  { 247, 8, 10, 7, 0, -10 },
  { 257, 5, 10, 3, -1, -10 },
  { 264, 5, 13, 3, -2, -10 },
  { 273, 7, 10, 6, 0, -10 },
  { 282, 4, 10, 5, 0, -10 },
  { 287, 10, 10, 10, 0, -10 },
  { 300, 8, 10, 8, 0, -10 },
  { 310, 6, 10, 8, 1, -10 },
  { 318, 6, 10, 6, 0, -10 },
  { 326, 6, 12, 8, 1, -10 },
  { 335, 6, 10, 6, 0, -10 },
  { 343, 6, 10, 6, 0, -10 },
  { 351, 5, 10, 5, 1, -10 },
  { 358, 7, 10, 7, 1, -10 },
  { 367, 6, 10, 6, 1, -10 },
  { 375, 10, 10, 10, 1, -10 },
  { 388, 7, 10, 5, -1, -10 },
  { 397, 5, 10, 5, 1, -10 },
  { 404, 6, 10, 5, 0, -10 },
  { 412, 5, 12, 4, 0, -10 },
  { 420, 3, 10, 5, 1, -10 },
  { 424, 5, 12, 4, -1, -10 },
  { 432, 6, 5, 6, 0, -10 },
  { 436, 4, 1, 4, -1, 1 },
  { 437, 2, 3, 3, 2, -11 },
  { 438, 6, 8, 6, 0, -8 },
  { 444, 6, 11, 6, 0, -11 },
  { 453, 5, 8, 5, 0, -8 },
  { 458, 7, 11, 6, 0, -11 },
  { 468, 5, 8, 6, 0, -8 },
  { 473, 7, 14, 3, -2, -11 },
  { 486, 6, 11, 6, 0, -8 },
  { 495, 6, 11, 6, 0, -11 },
  { 504, 3, 10, 3, 0, -10 },
  { 508, 5, 13, 3, -2, -10 },
  { 517, 6, 11, 5, 0, -11 },
  { 526, 3, 11, 3, 0, -11 },
  { 531, 9, 8, 9, 0, -8 },
  { 540, 6, 8, 6, 0, -8 },
  { 546, 6, 8, 6, 0, -8 },
  { 552, 7, 11, 6, -1, -8 },
  { 562, 6, 11, 6, 0, -8 },
  { 571, 5, 8, 4, 0, -8 },
  { 576, 5, 8, 5, 0, -8 },
  { 581, 4, 9, 3, 0, -9 },
  { 586, 6, 7, 6, 0, -7 },
  { 592, 5, 7, 5, 1, -7 },
  { 597, 7, 7, 8, 1, -7 },
  { 604, 6, 7, 5, -1, -7 },
  { 610, 7, 10, 5, -1, -7 },
  { 619, 5, 7, 4, 0, -7 },
  { 624, 5, 12, 5, 0, -10 },
  { 632, 1, 14, 6, 2, -11 },
  { 634, 5, 12, 5, -1, -10 },
  { 642, 5, 2, 6, 1, -6 },
};

const GFXfont NotoSans_Condensed_LightItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC14PT7B_H_
