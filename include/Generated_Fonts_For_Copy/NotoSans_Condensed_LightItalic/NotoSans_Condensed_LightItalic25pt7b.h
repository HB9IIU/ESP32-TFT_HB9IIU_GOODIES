#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC25PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x04, 0x10, 0xC2, 0x08, 0x20, 0x00,
  0x00, 0x43, 0x00, 0x4F, 0x2C, 0xA2, 0x9A, 0x49, 0x00, 0x02, 0x20, 0x22,
  0x02, 0x20, 0x44, 0x04, 0x43, 0xFF, 0x08, 0x80, 0x88, 0x08, 0x81, 0x98,
  0x11, 0x0F, 0xFC, 0x31, 0x02, 0x20, 0x22, 0x02, 0x20, 0x44, 0x04, 0x40,
  0x01, 0x00, 0x20, 0x1F, 0x0F, 0x31, 0x20, 0x64, 0x0C, 0x80, 0x90, 0x1C,
  0x01, 0x80, 0x18, 0x02, 0x80, 0x58, 0x11, 0x02, 0x60, 0x48, 0xCF, 0x0F,
  0x80, 0x40, 0x08, 0x00, 0x1C, 0x18, 0x98, 0x42, 0x22, 0x10, 0x88, 0x46,
  0x41, 0x11, 0x04, 0x48, 0x31, 0x6E, 0xCD, 0x6D, 0x29, 0x17, 0x28, 0x41,
  0x23, 0x0C, 0x88, 0x22, 0x21, 0x98, 0x84, 0x66, 0x20, 0x91, 0x83, 0x80,
  0x07, 0x81, 0x90, 0x23, 0x04, 0x61, 0x88, 0x13, 0x02, 0x40, 0x70, 0x0C,
  0x02, 0x80, 0x98, 0xA1, 0x34, 0x35, 0x83, 0xB0, 0x66, 0x0C, 0xC6, 0x8F,
  0x98, 0x7E, 0xA8, 0x06, 0x08, 0x20, 0x83, 0x04, 0x18, 0x20, 0x41, 0x82,
  0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x04, 0x08, 0x00, 0x04,
  0x06, 0x02, 0x02, 0x02, 0x02, 0x02, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06,
  0x06, 0x04, 0x0C, 0x08, 0x18, 0x10, 0x20, 0x60, 0xC0, 0x08, 0x08, 0x88,
  0x73, 0x1E, 0x28, 0x48, 0xC4, 0x04, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x0F, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x32, 0x26, 0x48,
  0xF8, 0x70, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x10, 0x02, 0x00, 0x80,
  0x10, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0x60, 0x08, 0x03, 0x00,
  0x40, 0x10, 0x00, 0x0F, 0x0C, 0xC4, 0x24, 0x12, 0x0B, 0x05, 0x02, 0x81,
  0xC0, 0xE0, 0xE0, 0x70, 0x28, 0x14, 0x1A, 0x09, 0x0C, 0xCC, 0x3C, 0x00,
  0x0C, 0x66, 0xB2, 0x98, 0x61, 0x04, 0x10, 0xC3, 0x08, 0x20, 0x86, 0x18,
  0x41, 0x00, 0x07, 0xC1, 0x8C, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18,
  0x02, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x60, 0x1F, 0xF0, 0x0F, 0x86, 0x30, 0x04, 0x01, 0x00, 0x40, 0x10, 0x0C,
  0x06, 0x1E, 0x01, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x86,
  0x3F, 0x00, 0x00, 0xC0, 0x30, 0x14, 0x0F, 0x02, 0x81, 0x20, 0xC8, 0x26,
  0x11, 0x88, 0x46, 0x11, 0x04, 0x83, 0x3F, 0xF0, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x0F, 0xE1, 0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x01, 0xF0,
  0x37, 0x00, 0x30, 0x02, 0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x86,
  0x1F, 0x80, 0x03, 0xC3, 0x01, 0x80, 0x40, 0x20, 0x08, 0x04, 0x01, 0x78,
  0x73, 0x30, 0x4C, 0x1A, 0x06, 0x81, 0x20, 0x48, 0x32, 0x08, 0xC6, 0x1F,
  0x00, 0x3F, 0xC0, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x06,
  0x01, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x30, 0x00,
  0x07, 0x81, 0x18, 0x41, 0x88, 0x31, 0x06, 0x20, 0x86, 0x30, 0x4C, 0x06,
  0x03, 0x60, 0x84, 0x20, 0xCC, 0x09, 0x81, 0x30, 0x26, 0x0C, 0x63, 0x07,
  0xC0, 0x07, 0x82, 0x31, 0x04, 0xC1, 0x20, 0x48, 0x12, 0x04, 0x83, 0x20,
  0xCC, 0x71, 0xE8, 0x02, 0x01, 0x80, 0x40, 0x30, 0x08, 0x0C, 0x3E, 0x00,
  0x18, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0x8C, 0x00, 0x0C, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x08, 0x61, 0x04, 0x20, 0x00, 0xC0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x04, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x70, 0x70, 0x30, 0x30, 0x30, 0x08, 0x00, 0x3E, 0x66, 0x03,
  0x03, 0x02, 0x02, 0x04, 0x0C, 0x18, 0x30, 0x20, 0x40, 0x40, 0x00, 0x00,
  0x00, 0xC0, 0xC0, 0x01, 0xF0, 0x18, 0x60, 0x80, 0xC4, 0x01, 0x30, 0x04,
  0x87, 0x94, 0x26, 0x51, 0x11, 0x4C, 0x46, 0x21, 0x18, 0x8C, 0x62, 0x22,
  0x88, 0x8A, 0x26, 0x48, 0xE7, 0x20, 0x00, 0x80, 0x01, 0x00, 0x06, 0x08,
  0x0F, 0xE0, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xA0, 0x14, 0x04, 0x80, 0x98,
  0x33, 0x04, 0x61, 0x8C, 0x3F, 0x8F, 0xF1, 0x06, 0x60, 0xCC, 0x09, 0x01,
  0x60, 0x38, 0x04, 0x0F, 0xC0, 0x8E, 0x08, 0x21, 0x83, 0x18, 0x21, 0x02,
  0x10, 0x61, 0x0C, 0x3F, 0x03, 0x18, 0x20, 0xC2, 0x04, 0x20, 0x46, 0x04,
  0x40, 0xC4, 0x08, 0x43, 0x0F, 0xE0, 0x03, 0xE1, 0xC4, 0x60, 0x08, 0x03,
  0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x02, 0x00, 0x61, 0x07, 0xE0, 0x0F, 0x80, 0x9E, 0x08, 0x21,
  0x83, 0x18, 0x11, 0x01, 0x10, 0x11, 0x01, 0x30, 0x33, 0x03, 0x20, 0x32,
  0x02, 0x20, 0x66, 0x04, 0x40, 0xC4, 0x18, 0x47, 0x0F, 0xC0, 0x0F, 0xE1,
  0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x3F, 0x86, 0x00,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x41, 0x1F, 0xC0, 0x0F,
  0xE1, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x00, 0x80, 0x30, 0x07,
  0xF0, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x10, 0x02, 0x00, 0x40, 0x18, 0x00,
  0x03, 0xF0, 0x70, 0xC6, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01, 0x80, 0x08,
  0x00, 0x40, 0x06, 0x0F, 0x30, 0x09, 0x80, 0xCC, 0x04, 0x60, 0x23, 0x01,
  0x08, 0x18, 0x60, 0xC1, 0xFC, 0x00, 0x0C, 0x0C, 0x20, 0x20, 0x80, 0x86,
  0x06, 0x18, 0x18, 0x40, 0x41, 0x01, 0x04, 0x04, 0x3F, 0xF0, 0xC0, 0xC2,
  0x02, 0x08, 0x08, 0x20, 0x61, 0x81, 0x84, 0x04, 0x10, 0x10, 0x40, 0x43,
  0x03, 0x00, 0x0F, 0x83, 0x01, 0x00, 0x80, 0x40, 0x60, 0x30, 0x10, 0x08,
  0x04, 0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x7C, 0x00, 0x00,
  0xC0, 0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0,
  0x20, 0x08, 0x02, 0x01, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x3C, 0x06, 0x00, 0x0C, 0x18, 0x41, 0x82, 0x18, 0x31, 0x81, 0x98,
  0x08, 0x80, 0x4C, 0x02, 0xC0, 0x3C, 0x01, 0xF0, 0x0C, 0x80, 0x44, 0x02,
  0x30, 0x31, 0x81, 0x04, 0x08, 0x20, 0x41, 0x86, 0x04, 0x00, 0x0C, 0x10,
  0x20, 0xC1, 0x82, 0x04, 0x08, 0x30, 0x60, 0x81, 0x02, 0x0C, 0x10, 0x20,
  0x41, 0xFC, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xE3, 0x80, 0x71, 0xC0,
  0x50, 0xA0, 0x28, 0x58, 0x24, 0x2C, 0x16, 0x36, 0x13, 0x11, 0x09, 0x08,
  0x88, 0x84, 0x44, 0x42, 0x24, 0x63, 0x12, 0x21, 0x0A, 0x10, 0x85, 0x08,
  0x43, 0x0C, 0x61, 0x86, 0x00, 0x0C, 0x04, 0x30, 0x30, 0xC0, 0xC7, 0x02,
  0x1E, 0x08, 0x48, 0x21, 0x21, 0x84, 0x84, 0x33, 0x10, 0x84, 0x42, 0x13,
  0x08, 0x4C, 0x21, 0xA1, 0x82, 0x84, 0x0A, 0x10, 0x38, 0x40, 0xE3, 0x01,
  0x00, 0x07, 0xC0, 0xC6, 0x18, 0x33, 0x03, 0x20, 0x16, 0x01, 0x60, 0x14,
  0x03, 0x40, 0x3C, 0x03, 0xC0, 0x2C, 0x02, 0xC0, 0x6C, 0x04, 0xC0, 0xC4,
  0x08, 0x63, 0x03, 0xE0, 0x0F, 0x81, 0x18, 0x21, 0x8C, 0x11, 0x82, 0x20,
  0x44, 0x18, 0x82, 0x30, 0xC7, 0xF0, 0xF0, 0x10, 0x02, 0x00, 0xC0, 0x10,
  0x02, 0x00, 0x40, 0x18, 0x00, 0x07, 0xC0, 0xC6, 0x18, 0x33, 0x03, 0x20,
  0x16, 0x01, 0x60, 0x14, 0x03, 0x40, 0x3C, 0x03, 0xC0, 0x2C, 0x02, 0xC0,
  0x6C, 0x04, 0xC0, 0xC4, 0x08, 0x63, 0x03, 0xE0, 0x04, 0x00, 0x60, 0x02,
  0x00, 0x30, 0x0F, 0x81, 0x18, 0x21, 0x8C, 0x11, 0x82, 0x20, 0x44, 0x18,
  0x82, 0x30, 0xC7, 0xE0, 0x88, 0x11, 0x02, 0x30, 0xC6, 0x10, 0x42, 0x08,
  0x41, 0x98, 0x30, 0x07, 0xE3, 0x88, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x10, 0x03, 0x00, 0x40,
  0x18, 0x86, 0x1F, 0x80, 0xFF, 0x84, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60,
  0x00, 0x10, 0x11, 0x01, 0x30, 0x13, 0x03, 0x20, 0x22, 0x02, 0x20, 0x26,
  0x06, 0x60, 0x64, 0x04, 0x40, 0x44, 0x04, 0xC0, 0xCC, 0x08, 0xC0, 0x8C,
  0x18, 0x63, 0x03, 0xE0, 0xC0, 0x78, 0x0B, 0x03, 0x60, 0x4C, 0x19, 0x82,
  0x30, 0xC2, 0x10, 0x46, 0x08, 0x81, 0x30, 0x24, 0x04, 0x80, 0xB0, 0x14,
  0x03, 0x80, 0x60, 0x0C, 0x00, 0xC0, 0x80, 0xE0, 0x40, 0xF0, 0x60, 0x58,
  0x30, 0x6C, 0x38, 0x26, 0x14, 0x33, 0x1A, 0x19, 0x89, 0x08, 0xC4, 0x8C,
  0x64, 0x44, 0x32, 0x26, 0x1B, 0x12, 0x0D, 0x09, 0x06, 0x85, 0x83, 0x82,
  0x81, 0xC1, 0xC0, 0xE0, 0xC0, 0x60, 0x60, 0x00, 0x08, 0x18, 0x41, 0x83,
  0x08, 0x08, 0x80, 0x4C, 0x02, 0x40, 0x16, 0x00, 0xE0, 0x02, 0x00, 0x30,
  0x03, 0x80, 0x16, 0x01, 0x90, 0x18, 0x80, 0x84, 0x0C, 0x20, 0xC1, 0x84,
  0x0C, 0x00, 0xC0, 0xF0, 0x64, 0x11, 0x0C, 0x42, 0x11, 0x04, 0xC1, 0xA0,
  0x78, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01, 0x00, 0x40, 0x30,
  0x00, 0x0F, 0xF0, 0x03, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x20, 0x06,
  0x00, 0x40, 0x0F, 0xF8, 0x0F, 0x84, 0x02, 0x03, 0x01, 0x80, 0x80, 0x40,
  0x20, 0x30, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x60,
  0x30, 0x10, 0x08, 0x07, 0x80, 0x92, 0x49, 0xB2, 0x49, 0x26, 0xC9, 0x24,
  0x07, 0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00,
  0xC0, 0x20, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC0,
  0x20, 0x08, 0x3E, 0x00, 0x04, 0x03, 0x80, 0xA0, 0x68, 0x13, 0x08, 0x42,
  0x11, 0x02, 0xC0, 0xA0, 0x30, 0xFF, 0x99, 0x10, 0x04, 0x07, 0xD3, 0x1D,
  0x82, 0x40, 0x90, 0x6C, 0x1B, 0x04, 0x81, 0x20, 0x48, 0x32, 0x1C, 0xC6,
  0x1E, 0x80, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x41, 0x7C, 0x61,
  0x38, 0x4C, 0x13, 0x04, 0x81, 0x20, 0x58, 0x36, 0x0D, 0x82, 0x61, 0x98,
  0xC9, 0xE0, 0x06, 0x1F, 0x30, 0x60, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80,
  0x80, 0x80, 0xC4, 0x7C, 0x00, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x04, 0x08,
  0x87, 0xF1, 0x8E, 0x60, 0x88, 0x11, 0x02, 0x60, 0xCC, 0x19, 0x02, 0x20,
  0xC4, 0x18, 0x87, 0x18, 0xC1, 0xE8, 0x00, 0x04, 0x1F, 0x31, 0x61, 0x41,
  0x43, 0xDE, 0xF8, 0x80, 0x80, 0x80, 0x80, 0xC2, 0x7C, 0x00, 0xF0, 0x18,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x30, 0x0F, 0xC0, 0x20, 0x02, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80,
  0x08, 0x01, 0x80, 0x10, 0x01, 0x00, 0x10, 0x03, 0x00, 0xE0, 0x00, 0x02,
  0x01, 0xF4, 0x63, 0x98, 0x22, 0x04, 0x40, 0x98, 0x33, 0x06, 0x40, 0x88,
  0x31, 0x06, 0x21, 0xC6, 0x30, 0x7A, 0x00, 0x40, 0x18, 0x03, 0x00, 0x42,
  0x30, 0x7C, 0x00, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04, 0x41, 0x7C,
  0x61, 0x30, 0x4C, 0x12, 0x0C, 0x82, 0x20, 0x98, 0x26, 0x19, 0x06, 0x41,
  0x10, 0x4C, 0x10, 0x08, 0x40, 0x00, 0x08, 0x46, 0x31, 0x08, 0x46, 0x31,
  0x08, 0x46, 0x00, 0x01, 0x80, 0x80, 0x00, 0x00, 0x00, 0x10, 0x08, 0x04,
  0x06, 0x02, 0x01, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x06,
  0x02, 0x01, 0x01, 0x80, 0x81, 0xC0, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18,
  0x04, 0x01, 0x0C, 0x46, 0x33, 0x0C, 0x82, 0x40, 0xB0, 0x34, 0x19, 0x06,
  0x61, 0x18, 0x42, 0x10, 0x8C, 0x30, 0x0C, 0x20, 0x82, 0x18, 0x41, 0x04,
  0x30, 0xC2, 0x08, 0x21, 0x86, 0x10, 0x41, 0x0C, 0x00, 0x01, 0x04, 0x17,
  0x9E, 0x18, 0xE3, 0x30, 0xC3, 0x30, 0xC2, 0x20, 0x82, 0x20, 0x82, 0x20,
  0x82, 0x61, 0x86, 0x61, 0x84, 0x41, 0x04, 0x41, 0x04, 0x41, 0x0C, 0xC3,
  0x0C, 0x01, 0x05, 0xF1, 0x8C, 0xC1, 0x30, 0x48, 0x32, 0x08, 0x82, 0x60,
  0x98, 0x64, 0x19, 0x04, 0x41, 0x30, 0x40, 0x04, 0x0F, 0x8C, 0x6C, 0x14,
  0x0A, 0x07, 0x03, 0x03, 0x81, 0xC0, 0xA0, 0xD0, 0x4C, 0x63, 0xE0, 0x00,
  0x81, 0x7C, 0x30, 0x8E, 0x11, 0x82, 0x30, 0x44, 0x08, 0x81, 0x30, 0x66,
  0x0C, 0xC1, 0x18, 0x63, 0x18, 0xDE, 0x18, 0x02, 0x00, 0x40, 0x08, 0x03,
  0x00, 0x40, 0x00, 0x04, 0x07, 0xD3, 0x1D, 0x82, 0x40, 0x90, 0x2C, 0x1A,
  0x06, 0x81, 0x20, 0x48, 0x32, 0x1C, 0xC6, 0x1E, 0x80, 0x20, 0x08, 0x06,
  0x01, 0x00, 0x40, 0x10, 0x01, 0x17, 0x18, 0x30, 0x30, 0x30, 0x20, 0x20,
  0x60, 0x60, 0x40, 0x40, 0x40, 0xC0, 0x04, 0x1F, 0x20, 0x20, 0x20, 0x20,
  0x30, 0x18, 0x0C, 0x06, 0x06, 0x06, 0x84, 0xF8, 0x10, 0xC2, 0x3F, 0x21,
  0x86, 0x10, 0x41, 0x0C, 0x30, 0x82, 0x08, 0x38, 0x20, 0xC8, 0x26, 0x09,
  0x86, 0x41, 0x90, 0x44, 0x13, 0x04, 0x83, 0x20, 0xC8, 0x63, 0x38, 0xFA,
  0x00, 0xC1, 0xE0, 0x90, 0xC8, 0x44, 0x62, 0x21, 0x30, 0x90, 0x58, 0x28,
  0x1C, 0x0C, 0x06, 0x00, 0x86, 0x1C, 0x30, 0xA3, 0x8D, 0x14, 0x49, 0xA2,
  0x49, 0x32, 0x49, 0x14, 0x58, 0xA2, 0x87, 0x14, 0x30, 0xC1, 0x86, 0x08,
  0x30, 0x00, 0x18, 0x63, 0x18, 0x26, 0x04, 0x80, 0xE0, 0x0C, 0x03, 0x00,
  0x70, 0x1A, 0x06, 0x40, 0x88, 0x21, 0x8C, 0x10, 0x04, 0x18, 0x20, 0x81,
  0x0C, 0x08, 0x40, 0x46, 0x02, 0x20, 0x11, 0x00, 0x90, 0x04, 0x80, 0x28,
  0x01, 0x40, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00,
  0x80, 0x38, 0x00, 0x1F, 0x80, 0xC0, 0x40, 0x40, 0x60, 0x20, 0x20, 0x30,
  0x10, 0x18, 0x18, 0x08, 0x0F, 0xE0, 0x03, 0x83, 0x03, 0x01, 0x00, 0x80,
  0x40, 0x60, 0x20, 0x10, 0x18, 0x38, 0x18, 0x02, 0x01, 0x00, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x08, 0x06, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x0C,
  0x06, 0x02, 0x02, 0x02, 0x02, 0x06, 0x06, 0x04, 0x04, 0x03, 0x07, 0x0C,
  0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x30, 0x60, 0xC0, 0x78, 0x63, 0xF0,
};

const GFXglyph NotoSans_Condensed_LightItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 18, 6, 0, -18 },
  { 15, 6, 7, 8, 3, -18 },
  { 21, 12, 18, 12, 0, -18 },
  { 48, 11, 20, 11, 0, -19 },
  { 76, 14, 18, 16, 1, -18 },
  { 108, 11, 18, 12, 0, -18 },
  { 133, 2, 7, 4, 3, -18 },
  { 135, 7, 22, 6, 1, -18 },
  { 155, 8, 22, 6, -2, -18 },
  { 177, 8, 9, 10, 3, -19 },
  { 186, 10, 12, 12, 1, -15 },
  { 201, 4, 6, 5, -1, -3 },
  { 204, 5, 1, 7, 1, -7 },
  { 205, 2, 2, 5, 0, -2 },
  { 206, 11, 18, 8, -1, -18 },
  { 231, 9, 18, 11, 1, -18 },
  { 252, 6, 18, 11, 3, -18 },
  { 266, 11, 18, 11, -1, -18 },
  { 291, 10, 18, 11, 0, -18 },
  { 314, 10, 18, 11, 0, -18 },
  { 337, 11, 18, 11, 0, -18 },
  { 362, 10, 18, 11, 1, -18 },
  { 385, 10, 18, 11, 1, -18 },
  { 408, 11, 18, 11, 0, -18 },
  { 433, 10, 18, 11, 0, -18 },
  { 456, 5, 13, 5, 0, -13 },
  { 465, 6, 16, 5, -1, -13 },
  { 477, 10, 11, 12, 1, -14 },
  { 491, 10, 6, 12, 1, -12 },
  { 499, 10, 11, 12, 1, -14 },
  { 513, 8, 18, 8, 1, -18 },
  { 531, 14, 20, 16, 1, -18 },
  { 566, 11, 18, 11, -2, -18 },
  { 591, 12, 18, 12, 0, -18 },
  { 618, 11, 18, 11, 1, -18 },
  { 643, 12, 18, 13, 0, -18 },
  { 670, 11, 18, 10, 0, -18 },
  { 695, 11, 18, 9, 0, -18 },
  { 720, 13, 18, 13, 1, -18 },
  { 750, 14, 18, 13, 0, -18 },
  { 782, 9, 18, 6, -1, -18 },
  { 803, 10, 23, 5, -4, -18 },
  { 832, 13, 18, 11, 0, -18 },
  { 862, 7, 18, 9, 0, -18 },
  { 878, 17, 18, 17, 0, -18 },
  { 917, 14, 18, 14, 0, -18 },
  { 949, 12, 18, 14, 1, -18 },
  { 976, 11, 18, 11, 0, -18 },
  { 1001, 12, 22, 14, 1, -18 },
  { 1034, 11, 18, 11, 0, -18 },
  { 1059, 11, 18, 10, 0, -18 },
  { 1084, 9, 18, 9, 2, -18 },
  { 1105, 12, 18, 13, 1, -18 },
  { 1132, 11, 18, 11, 2, -18 },
  { 1157, 17, 18, 17, 2, -18 },
  { 1196, 13, 18, 10, -1, -18 },
  { 1226, 10, 18, 9, 2, -18 },
  { 1249, 12, 18, 10, -1, -18 },
  { 1276, 9, 22, 7, 0, -18 },
  { 1301, 3, 18, 8, 3, -18 },
  { 1308, 10, 22, 7, -2, -18 },
  { 1336, 10, 10, 11, 1, -18 },
  { 1349, 8, 1, 8, -2, 2 },
  { 1350, 3, 4, 6, 4, -19 },
  { 1352, 10, 14, 11, 1, -14 },
  { 1370, 10, 19, 11, 0, -19 },
  { 1394, 8, 14, 9, 1, -14 },
  { 1408, 11, 19, 11, 1, -19 },
  { 1435, 8, 14, 10, 1, -14 },
  { 1449, 12, 25, 6, -3, -19 },
  { 1487, 11, 20, 11, 0, -14 },
  { 1515, 10, 19, 11, 0, -19 },
  { 1539, 5, 18, 5, 0, -18 },
  { 1551, 9, 24, 5, -3, -18 },
  { 1578, 10, 19, 9, 0, -19 },
  { 1602, 6, 19, 5, 0, -19 },
  { 1617, 16, 14, 17, 0, -14 },
  { 1645, 10, 14, 11, 0, -14 },
  { 1663, 9, 14, 11, 1, -14 },
  { 1679, 11, 20, 11, -1, -14 },
  { 1707, 10, 20, 11, 1, -14 },
  { 1732, 8, 14, 7, 0, -14 },
  { 1746, 8, 14, 8, 0, -14 },
  { 1760, 6, 16, 6, 1, -16 },
  { 1772, 10, 13, 11, 1, -13 },
  { 1789, 9, 13, 9, 1, -13 },
  { 1804, 13, 13, 14, 2, -13 },
  { 1826, 11, 13, 9, -1, -13 },
  { 1844, 13, 19, 9, -3, -13 },
  { 1875, 9, 13, 8, -1, -13 },
  { 1890, 9, 22, 8, 1, -18 },
  { 1915, 1, 25, 10, 5, -19 },
  { 1919, 8, 22, 8, -1, -18 },
  { 1941, 10, 2, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_LightItalic25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC25PT7B_H_
