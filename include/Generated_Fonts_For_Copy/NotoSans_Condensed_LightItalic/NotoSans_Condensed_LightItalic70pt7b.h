#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC70PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x1E,
  0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC3, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0x78,
  0xF0, 0x38, 0x70, 0x1C, 0x38, 0x1E, 0x1C, 0x0F, 0x1E, 0x07, 0x0E, 0x03,
  0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00,
  0x00, 0x38, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xE0,
  0x1E, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x38,
  0x07, 0x80, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x03, 0xF3, 0x8F, 0x80, 0x3E, 0x1C, 0x0C, 0x03, 0xC0, 0xC0,
  0x00, 0x1E, 0x06, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x70, 0x18, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x18, 0x00, 0x01, 0xF0, 0xC0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0x3E, 0x70, 0x00, 0x00, 0xFB, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1B, 0xE0, 0x00, 0x00, 0xCF,
  0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x07, 0x80,
  0x00, 0x18, 0x1E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00,
  0x70, 0x3C, 0x00, 0x03, 0x01, 0xE0, 0x00, 0x18, 0x0E, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x70, 0x78, 0x08, 0x03, 0x07, 0xC0,
  0x70, 0x18, 0x7C, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x7F, 0xC0, 0x00, 0xF0, 0x07, 0xDF,
  0x00, 0x07, 0x00, 0x78, 0x38, 0x00, 0x78, 0x07, 0x81, 0xC0, 0x03, 0x80,
  0x38, 0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x03, 0x80, 0x38, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x78,
  0x01, 0xC0, 0x0E, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x38, 0x00, 0x70, 0x07,
  0x83, 0xC0, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x3C, 0x01, 0xC1, 0xE0, 0x01,
  0xC0, 0x0E, 0x0E, 0x00, 0x0E, 0x00, 0xF0, 0xF0, 0x10, 0x70, 0x07, 0x07,
  0x07, 0xF3, 0x80, 0x38, 0x70, 0xFF, 0xDC, 0x03, 0xC7, 0x87, 0xFE, 0xE0,
  0x1C, 0x38, 0x78, 0x7F, 0x01, 0xE3, 0xC7, 0x81, 0xFC, 0x0E, 0x1C, 0x38,
  0x0E, 0xE0, 0xE1, 0xC3, 0x80, 0x77, 0xDF, 0x1E, 0x1C, 0x03, 0xBF, 0xF0,
  0xE1, 0xE0, 0x1C, 0xFF, 0x0F, 0x0E, 0x00, 0xE1, 0xC0, 0x70, 0x70, 0x07,
  0x00, 0x07, 0x87, 0x80, 0x38, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x03, 0x81,
  0xC0, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0xE0, 0x01, 0xC0, 0xF0, 0x07, 0x00,
  0x1E, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x0F, 0x01, 0xC0,
  0x1E, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x3C,
  0x01, 0xC0, 0x07, 0x01, 0xC0, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0xE0, 0x01,
  0xE1, 0xE0, 0x0E, 0x00, 0x0F, 0x9E, 0x00, 0xF0, 0x00, 0x3F, 0xF0, 0x07,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x3C, 0x00,
  0x07, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0xE1, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x3E, 0x3C,
  0x01, 0xE0, 0xF8, 0x3C, 0x03, 0xC3, 0xE0, 0x78, 0x07, 0x07, 0x80, 0xF0,
  0x1E, 0x1E, 0x00, 0xF0, 0x3C, 0x78, 0x01, 0xE0, 0xF0, 0xF0, 0x01, 0xE1,
  0xE3, 0xC0, 0x03, 0xC3, 0x87, 0x80, 0x07, 0xCF, 0x0F, 0x00, 0x07, 0xBC,
  0x1C, 0x00, 0x0F, 0x78, 0x38, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x1F, 0x81,
  0xE0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xFC, 0x07,
  0x80, 0x03, 0xF8, 0x0F, 0x00, 0x0F, 0xF0, 0x1F, 0x00, 0x3C, 0xF0, 0x1F,
  0x01, 0xF1, 0xE0, 0x3F, 0xFF, 0xC1, 0xE0, 0x3F, 0xFF, 0x03, 0xC0, 0x1F,
  0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xC7,
  0x8F, 0x1E, 0x38, 0x71, 0xE3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x01, 0x00, 0xE0, 0x06, 0x03, 0x80,
  0x3E, 0x0E, 0x00, 0xFE, 0x38, 0x00, 0xFE, 0xC0, 0x70, 0x7F, 0x7F, 0xC0,
  0x7F, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xE0, 0x00, 0x3D, 0x80, 0x01, 0xE7,
  0x00, 0x0F, 0x1C, 0x00, 0x78, 0x38, 0x03, 0xC0, 0xF0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0x40, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x39, 0xFF, 0xFF,
  0xF9, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x3C,
  0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x3C, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3C, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x1E, 0x00,
  0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x01, 0xFE, 0x03, 0xFE, 0x07, 0xDC,
  0x0F, 0xBC, 0x3F, 0x3C, 0x7C, 0x3C, 0xF8, 0x3C, 0xF0, 0x78, 0x40, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xF8, 0x0F, 0x80,
  0x03, 0xC0, 0x0F, 0x80, 0x02, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x38, 0x00, 0x78, 0x01, 0x80, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x02, 0x00, 0x03, 0xE0,
  0x1C, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x03,
  0x9C, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x02, 0x00, 0x07, 0xE0, 0x0E, 0x00, 0x7F, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x20, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x3C, 0x0F, 0xC0, 0x03, 0xC7, 0xFF, 0x00, 0x3C, 0xFF, 0xF8, 0x03,
  0x9F, 0x1F, 0xC0, 0x7B, 0x80, 0x7C, 0x07, 0xF0, 0x03, 0xE0, 0x7E, 0x00,
  0x1E, 0x07, 0xC0, 0x01, 0xE0, 0xFC, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0,
  0xF8, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E,
  0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x07,
  0xC0, 0x7C, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x38, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x1E, 0x07, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x3F, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0E, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3C,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0xF0, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0, 0xE0, 0x00,
  0x1E, 0x0E, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3E, 0x0E, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0xFC, 0x0F, 0x80,
  0x1D, 0xC0, 0x7C, 0x03, 0xBC, 0x07, 0xF1, 0xFB, 0xC0, 0x3F, 0xFE, 0x38,
  0x01, 0xFF, 0xC7, 0x80, 0x07, 0xF0, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x08,
  0x03, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x1E, 0x01, 0xF0, 0x3F, 0x03,
  0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x00, 0x00, 0x04, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0x80, 0xF8, 0x18, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x1E, 0x00, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x0E, 0x00,
  0x1F, 0xF0, 0x0E, 0x0F, 0x00, 0x1F, 0xFC, 0x07, 0x07, 0x00, 0x3F, 0xFE,
  0x03, 0x83, 0x80, 0x3C, 0x0F, 0x01, 0xC3, 0x80, 0x3C, 0x07, 0x00, 0xE1,
  0xC0, 0x1C, 0x03, 0x80, 0x71, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x78, 0x0F, 0x00, 0x70,
  0x07, 0x38, 0x07, 0x00, 0x38, 0x07, 0x1C, 0x07, 0x80, 0x3C, 0x03, 0x8E,
  0x03, 0x80, 0x1C, 0x01, 0xCF, 0x01, 0xC0, 0x0E, 0x00, 0xE7, 0x00, 0xE0,
  0x0F, 0x00, 0xF3, 0x80, 0xF0, 0x07, 0x80, 0x71, 0xC0, 0x70, 0x03, 0x80,
  0x38, 0xE0, 0x38, 0x01, 0xC0, 0x3C, 0x70, 0x1C, 0x01, 0xE0, 0x1C, 0x78,
  0x0E, 0x00, 0xF0, 0x0E, 0x3C, 0x07, 0x00, 0xF8, 0x0E, 0x1E, 0x03, 0x80,
  0x7C, 0x07, 0x0F, 0x01, 0xC0, 0x7E, 0x07, 0x07, 0x80, 0xF0, 0x77, 0x07,
  0x83, 0xC0, 0x78, 0x73, 0x87, 0x81, 0xE0, 0x1F, 0xF9, 0xFF, 0x80, 0xF0,
  0x0F, 0xF8, 0x7F, 0x80, 0x78, 0x01, 0xF0, 0x1F, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0x7E, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E,
  0x3C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x0E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x1E,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x78, 0xF8, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xE0, 0x7F, 0xC0, 0x03, 0x80, 0x0F, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x03,
  0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x70, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07,
  0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x0F, 0x80, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x7C, 0x07, 0x80, 0x03, 0xF0, 0x0F, 0x00, 0x0F, 0xC0, 0x1E, 0x03, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x0E, 0x00, 0x1F, 0x80,
  0x04, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x18,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xC0,
  0x1F, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x38, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x3E, 0x07, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x07, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x07, 0xC0, 0x0E, 0x00,
  0x07, 0xE0, 0x0F, 0x00, 0x07, 0xE0, 0x07, 0x80, 0x07, 0xE0, 0x03, 0xC0,
  0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x03, 0x80, 0x0F, 0xC0, 0x00, 0x10, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xF8, 0x3C, 0x00,
  0x0F, 0xFF, 0x07, 0x80, 0x01, 0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x70,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x07, 0xE0, 0x00,
  0x78, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x04, 0x0F, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x03, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x78,
  0x01, 0xF0, 0x00, 0x0E, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00,
  0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x00, 0x38, 0x0F, 0x80, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0xF8,
  0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00,
  0xF3, 0xE0, 0x00, 0x00, 0x1C, 0xFC, 0x00, 0x00, 0x07, 0xBF, 0x80, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xCF, 0x00, 0x00, 0x03, 0xF1, 0xE0,
  0x00, 0x00, 0x7C, 0x3C, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x03, 0x80, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x77, 0x80, 0x00, 0x07, 0xBC,
  0x00, 0xEF, 0x00, 0x00, 0x0F, 0x70, 0x03, 0xDE, 0x00, 0x00, 0x3D, 0xE0,
  0x07, 0xBC, 0x00, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x00, 0x01, 0xE7, 0x80,
  0x1C, 0x70, 0x00, 0x03, 0xCF, 0x00, 0x38, 0xE0, 0x00, 0x0F, 0x1C, 0x00,
  0xF1, 0xC0, 0x00, 0x1E, 0x78, 0x01, 0xE3, 0x80, 0x00, 0x78, 0xF0, 0x03,
  0xC7, 0x00, 0x00, 0xF1, 0xE0, 0x07, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x1E,
  0x1C, 0x00, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x01, 0xC1,
  0xE0, 0x01, 0xE0, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x83, 0xC0, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x3C, 0x0F, 0x00, 0x38, 0x0E,
  0x00, 0x78, 0x1E, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0x38, 0x01, 0xE0, 0x38,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x70, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xE0,
  0x1E, 0x03, 0xC0, 0x0E, 0x01, 0xC0, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0xF0, 0x0E, 0x00, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x07,
  0x80, 0x78, 0x01, 0xE0, 0x1E, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x3C, 0x3C,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x71, 0xE0,
  0x0F, 0x00, 0x3C, 0x00, 0xE7, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xCF, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0xBC, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1F, 0xC0, 0x07,
  0x80, 0x1C, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x03,
  0xF0, 0x00, 0x03, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x00,
  0x38, 0x01, 0xFC, 0x00, 0x01, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0x80, 0x1D,
  0xE0, 0x00, 0x1E, 0x00, 0x77, 0x80, 0x00, 0x70, 0x01, 0xCE, 0x00, 0x01,
  0xC0, 0x0F, 0x38, 0x00, 0x0F, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0x00, 0xF3,
  0xC0, 0x00, 0xF0, 0x03, 0x87, 0x00, 0x03, 0x80, 0x0E, 0x1C, 0x00, 0x1E,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0x07, 0x83,
  0x80, 0x07, 0x80, 0x1C, 0x0E, 0x00, 0x1C, 0x00, 0xF0, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x0F, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x1E, 0x00, 0xE0, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x0F,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0xF0, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x0E, 0x00, 0x1E,
  0x0E, 0x00, 0x78, 0x00, 0x78, 0x78, 0x01, 0xE0, 0x00, 0xE1, 0xE0, 0x07,
  0x80, 0x03, 0xC7, 0x80, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x70, 0x00, 0x3C,
  0x70, 0x03, 0xC0, 0x00, 0x73, 0xC0, 0x0F, 0x00, 0x01, 0xEF, 0x00, 0x3C,
  0x00, 0x07, 0xBC, 0x00, 0xF0, 0x00, 0x1E, 0xE0, 0x03, 0x80, 0x00, 0x3B,
  0x80, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x01, 0xE0,
  0x00, 0x0F, 0xE0, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x1C, 0x00, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x7C,
  0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0x0F, 0xFC, 0x00, 0x38, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0,
  0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0xF0, 0x0F,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x00, 0xE0, 0x01, 0xF0, 0x07, 0x80,
  0x0F, 0xC0, 0x1E, 0x01, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xE8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x1E, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00,
  0x7C, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0x0F, 0xFC, 0x00, 0x38, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0,
  0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xF0, 0x0F,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x3E, 0x00, 0xE0, 0x03, 0xF0, 0x07, 0x80,
  0x3F, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0, 0x0E, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x38, 0x03, 0xC0, 0x01,
  0xE0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0,
  0x1C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x01, 0x80,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x30, 0x00,
  0x3F, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1C, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x78, 0x70, 0x00, 0x07, 0xC3, 0x80, 0x00,
  0x3C, 0x1C, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0,
  0x38, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07,
  0x80, 0x01, 0xE0, 0x38, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xCE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xF0,
  0x00, 0x1E, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x1D, 0xC0,
  0x00, 0xF8, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0xF7, 0x00,
  0x03, 0xC3, 0x80, 0x01, 0xCE, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x9C, 0x00,
  0x1E, 0x0E, 0x00, 0x0F, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x1C, 0x70, 0x00,
  0xF0, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xE0, 0x70, 0x00, 0xE1, 0xC0, 0x07,
  0x80, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x87, 0x00, 0x3C,
  0x03, 0x80, 0x0E, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0,
  0x0E, 0x00, 0x70, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x70, 0x07, 0x80,
  0x38, 0x03, 0x80, 0xE0, 0x1E, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x3C, 0x00,
  0xE0, 0x1E, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x03,
  0x80, 0xF0, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xC0, 0x1C, 0x0F, 0x00, 0x0E,
  0x07, 0x80, 0x78, 0x1E, 0x00, 0x1C, 0x0F, 0x00, 0xF0, 0x78, 0x00, 0x38,
  0x1C, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x78, 0x03, 0xC1, 0xE0, 0x00, 0xE0,
  0xE0, 0x07, 0x87, 0x80, 0x01, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x03, 0x87,
  0x00, 0x1E, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0x3C,
  0x00, 0x78, 0xE0, 0x00, 0x1C, 0x70, 0x00, 0xF3, 0xC0, 0x00, 0x39, 0xE0,
  0x01, 0xE7, 0x80, 0x00, 0x73, 0x80, 0x03, 0xDE, 0x00, 0x00, 0xE7, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xDE, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xB8, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x79, 0xC0, 0x00,
  0x00, 0x0F, 0x1C, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x1E, 0x1E,
  0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E, 0x00,
  0x07, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x0E,
  0x00, 0x1E, 0x03, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x1C, 0x07,
  0x80, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x1E,
  0x1E, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x39, 0xE0, 0x00,
  0x0E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0,
  0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03,
  0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03,
  0x83, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x1E,
  0x00, 0x0E, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x80, 0x0F, 0x00, 0x78, 0x00, 0x70, 0x07, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x38, 0x0E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x7C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1C, 0x0F, 0x03, 0x80, 0xE0,
  0x70, 0x00, 0x03, 0xE0, 0x08, 0x00, 0xFF, 0xC3, 0x80, 0x0F, 0xFF, 0x1C,
  0x00, 0xFE, 0xF8, 0xE0, 0x0F, 0x80, 0xEF, 0x00, 0xF8, 0x03, 0x78, 0x0F,
  0x80, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x7C, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C,
  0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x3C,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C,
  0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x3E, 0x01, 0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x1B, 0x80, 0x78, 0x01, 0xFC,
  0x03, 0xE0, 0x1D, 0xE0, 0x0F, 0x81, 0xCE, 0x00, 0x7F, 0xFC, 0x70, 0x01,
  0xFF, 0xC3, 0x80, 0x07, 0xFC, 0x1C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0E, 0x07, 0xE0, 0x01, 0xE1, 0xFF, 0x80, 0x1E,
  0x3F, 0xFC, 0x01, 0xE7, 0xDF, 0xC0, 0x1C, 0xF0, 0x3E, 0x01, 0xDC, 0x01,
  0xE0, 0x3F, 0x80, 0x1F, 0x03, 0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x07, 0xC0, 0x01, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0x60, 0x03, 0xC0, 0x77,
  0x00, 0x7C, 0x0F, 0x78, 0x1F, 0x80, 0xE3, 0xFF, 0xF0, 0x0E, 0x1F, 0xFE,
  0x00, 0xE0, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xF9, 0xF0, 0x0F, 0x80, 0x20, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x06,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0xF8, 0x78, 0x00, 0x3F, 0xFC,
  0x70, 0x00, 0x7F, 0x7E, 0xF0, 0x00, 0xF8, 0x0E, 0xF0, 0x01, 0xF0, 0x07,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x03,
  0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x7E,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x78, 0x01, 0xDC,
  0x00, 0x7C, 0x03, 0xBC, 0x00, 0x3E, 0x07, 0x3C, 0x00, 0x3F, 0xFE, 0x38,
  0x00, 0x1F, 0xFC, 0x38, 0x00, 0x0F, 0xF8, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0x7E, 0x00, 0xF8, 0x0F, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x0F, 0x07, 0xC0,
  0x07, 0x07, 0x80, 0x07, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x3C, 0x00,
  0xF8, 0x3C, 0x03, 0xF0, 0x78, 0x7F, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x20, 0x3E, 0x00, 0xE0, 0x1F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x3C, 0x00, 0x3F, 0xFC, 0x70,
  0x00, 0xFE, 0xFC, 0xE0, 0x03, 0xE0, 0x39, 0xC0, 0x0F, 0x80, 0x3F, 0x80,
  0x3E, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0xF8, 0x07,
  0xC0, 0x01, 0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x78, 0x07, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07,
  0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x7C,
  0x03, 0xC0, 0x01, 0xF8, 0x07, 0x80, 0x03, 0xF0, 0x0F, 0x00, 0x0F, 0xC0,
  0x0F, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x7F, 0x00, 0x3E, 0x01, 0xDE, 0x00,
  0x3C, 0x07, 0x3C, 0x00, 0x7F, 0xFC, 0x70, 0x00, 0x7F, 0xF1, 0xE0, 0x00,
  0x7F, 0xC3, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x01, 0x00, 0x07,
  0xC0, 0x03, 0x80, 0x1F, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x03, 0xF0, 0x01, 0xE1, 0xFF, 0x80, 0x3C, 0xFF, 0xF8, 0x07,
  0xBF, 0xFF, 0x00, 0xE7, 0x01, 0xF0, 0x1D, 0xC0, 0x1E, 0x07, 0xF0, 0x03,
  0xC0, 0xFC, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x1F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x07, 0x80, 0x03, 0xC0, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x1E,
  0x00, 0x0F, 0x03, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x18, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x01, 0x01,
  0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x01, 0xC0, 0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0x70, 0xF0, 0x00,
  0x07, 0x1E, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x0F, 0x7E, 0x00, 0x00, 0xE7,
  0xF0, 0x00, 0x0E, 0xEF, 0x00, 0x01, 0xFC, 0xF0, 0x00, 0x1F, 0x8F, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3C,
  0x03, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0x80, 0x3C,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x00, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x3F, 0xE0, 0x3F, 0xE0,
  0x07, 0x1F, 0xFE, 0x1F, 0xFE, 0x00, 0xE7, 0xFF, 0xC7, 0xEF, 0xE0, 0x1D,
  0xE0, 0x7D, 0xE0, 0x3C, 0x03, 0xB0, 0x07, 0xB8, 0x07, 0xC0, 0xFE, 0x00,
  0xFE, 0x00, 0x78, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3C, 0x3F, 0xF0, 0x07, 0x1F, 0xFF,
  0x00, 0xE7, 0xFF, 0xE0, 0x1D, 0xE0, 0x3E, 0x03, 0xB8, 0x03, 0xC0, 0xFE,
  0x00, 0x78, 0x1F, 0x80, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3C,
  0x0F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1C, 0x0F, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x78, 0x1C,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F,
  0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFD, 0xFC,
  0x00, 0xF8, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x1F, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x3C,
  0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF8, 0x0F, 0x00,
  0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0E,
  0x1F, 0xF8, 0x00, 0x1E, 0x3F, 0xFC, 0x00, 0x1C, 0x7C, 0xFC, 0x00, 0x1C,
  0xE0, 0x3E, 0x00, 0x1D, 0xC0, 0x1E, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x3F,
  0x80, 0x0F, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0xE0,
  0x01, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0x70, 0x07, 0xC0, 0x07, 0x78,
  0x1F, 0x80, 0x0F, 0x3F, 0xFF, 0x00, 0x0F, 0x1F, 0xFE, 0x00, 0x0F, 0x0F,
  0xF8, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0xC3, 0xC0, 0x0F, 0xFF, 0x1C, 0x00, 0xFE, 0xFC, 0xE0, 0x0F, 0x80, 0xE7,
  0x00, 0xF8, 0x03, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x78, 0x00, 0x7C, 0x07,
  0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x3C, 0x1E,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x0F,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x3F, 0x03, 0xC0, 0x03, 0xF0, 0x0F, 0x00,
  0x1F, 0x80, 0x78, 0x01, 0xFC, 0x03, 0xE0, 0x1D, 0xE0, 0x0F, 0x81, 0xCF,
  0x00, 0x7F, 0xFC, 0x70, 0x01, 0xFF, 0xC7, 0x80, 0x07, 0xFC, 0x3C, 0x00,
  0x07, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0x87, 0xF0, 0x1C, 0x7F, 0xC0, 0x73,
  0xFF, 0x01, 0xCF, 0x00, 0x07, 0x70, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFC, 0x7E, 0x03,
  0xE0, 0x0C, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x80, 0x07, 0xC0, 0xE0, 0x0F, 0x80, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x0F, 0xFF, 0xCF, 0xFF, 0xC7, 0xFF, 0xE0, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x38,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xC0, 0x78, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x01,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x01, 0xF8,
  0x0F, 0x00, 0x1B, 0x80, 0x78, 0x07, 0xF8, 0x07, 0xC0, 0xF7, 0x80, 0x7F,
  0xFE, 0x70, 0x03, 0xFF, 0xC7, 0x00, 0x1F, 0xF0, 0x70, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x70, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0x70, 0x07, 0x80, 0x70, 0x07, 0x80, 0x70, 0x0F,
  0x00, 0x70, 0x0F, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x3C,
  0x00, 0x70, 0x3C, 0x00, 0x70, 0x78, 0x00, 0x70, 0x78, 0x00, 0x70, 0x70,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x79, 0xC0,
  0x00, 0x7B, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x03, 0xE0,
  0x01, 0xEF, 0x00, 0x0F, 0x80, 0x07, 0xBC, 0x00, 0x3E, 0x00, 0x1C, 0xF0,
  0x01, 0xF8, 0x00, 0xF3, 0xC0, 0x07, 0xE0, 0x03, 0xCF, 0x00, 0x3F, 0x80,
  0x1E, 0x3C, 0x00, 0xEE, 0x00, 0x78, 0xF0, 0x07, 0xB8, 0x01, 0xC3, 0xC0,
  0x1C, 0xE0, 0x0F, 0x0F, 0x00, 0x73, 0x80, 0x3C, 0x3C, 0x03, 0xCE, 0x01,
  0xE0, 0xF0, 0x0E, 0x38, 0x07, 0x83, 0xC0, 0x78, 0xE0, 0x1C, 0x0F, 0x01,
  0xC3, 0x80, 0xF0, 0x3C, 0x0F, 0x0E, 0x03, 0x80, 0xF0, 0x38, 0x38, 0x1E,
  0x03, 0xC0, 0xE0, 0xE0, 0x78, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0x3C, 0x1C,
  0x0E, 0x0F, 0x00, 0xF0, 0xF0, 0x38, 0x38, 0x03, 0xC3, 0x80, 0xE1, 0xE0,
  0x0F, 0x1E, 0x03, 0x87, 0x00, 0x3C, 0x70, 0x0E, 0x3C, 0x00, 0xF1, 0xC0,
  0x38, 0xF0, 0x03, 0xCF, 0x00, 0xE3, 0x80, 0x0F, 0x38, 0x03, 0x9E, 0x00,
  0x3D, 0xE0, 0x0E, 0x70, 0x00, 0xF7, 0x00, 0x39, 0xC0, 0x03, 0xDC, 0x00,
  0xEF, 0x00, 0x0F, 0xE0, 0x03, 0xB8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xC3,
  0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x0E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x1E,
  0x00, 0x07, 0x80, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x3C, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x00,
  0x70, 0x38, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x00, 0x38, 0x78, 0x00, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x10, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x27, 0xFF, 0x80, 0x05, 0xFF, 0xFC, 0x03, 0xF8,
  0x1F, 0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0x20, 0x00, 0x1F,
  0x80,
};

const GFXglyph NotoSans_Condensed_LightItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 15, 50, 16, 1, -50 },
  { 95, 17, 18, 22, 7, -50 },
  { 134, 33, 50, 33, 1, -50 },
  { 341, 29, 57, 29, 1, -53 },
  { 548, 37, 52, 44, 4, -51 },
  { 789, 31, 52, 33, 0, -51 },
  { 991, 7, 18, 12, 7, -50 },
  { 1007, 20, 61, 18, 2, -50 },
  { 1160, 20, 61, 18, -5, -50 },
  { 1313, 22, 24, 28, 8, -53 },
  { 1379, 27, 33, 32, 3, -41 },
  { 1491, 11, 16, 13, -3, -7 },
  { 1513, 15, 4, 19, 2, -21 },
  { 1521, 6, 6, 14, 1, -6 },
  { 1526, 31, 50, 22, -3, -50 },
  { 1720, 27, 52, 30, 2, -51 },
  { 1896, 16, 50, 30, 9, -50 },
  { 1996, 31, 51, 30, -2, -51 },
  { 2194, 29, 52, 30, 0, -51 },
  { 2383, 30, 50, 30, -1, -50 },
  { 2571, 30, 51, 30, 0, -50 },
  { 2763, 28, 52, 30, 3, -51 },
  { 2945, 28, 50, 30, 4, -50 },
  { 3120, 30, 52, 30, 0, -51 },
  { 3315, 28, 52, 30, 1, -51 },
  { 3497, 12, 38, 14, 1, -38 },
  { 3554, 16, 47, 14, -3, -38 },
  { 3648, 27, 30, 32, 3, -40 },
  { 3750, 27, 18, 32, 3, -34 },
  { 3811, 27, 30, 32, 3, -40 },
  { 3913, 22, 51, 22, 2, -51 },
  { 4054, 41, 56, 45, 2, -50 },
  { 4341, 29, 50, 30, -4, -50 },
  { 4523, 31, 50, 32, 1, -50 },
  { 4717, 32, 52, 30, 3, -51 },
  { 4925, 33, 50, 36, 1, -50 },
  { 5132, 30, 50, 28, 1, -50 },
  { 5320, 30, 50, 26, 1, -50 },
  { 5508, 35, 52, 38, 3, -51 },
  { 5736, 37, 50, 37, 1, -50 },
  { 5968, 24, 50, 17, -3, -50 },
  { 6118, 26, 63, 14, -11, -50 },
  { 6323, 35, 50, 30, 1, -50 },
  { 6542, 20, 50, 26, 1, -50 },
  { 6667, 47, 50, 48, 1, -50 },
  { 6961, 38, 50, 38, 1, -50 },
  { 7199, 34, 52, 38, 3, -51 },
  { 7420, 30, 50, 30, 1, -50 },
  { 7608, 34, 63, 38, 3, -51 },
  { 7876, 30, 50, 31, 1, -50 },
  { 8064, 31, 52, 28, -1, -51 },
  { 8266, 26, 50, 26, 6, -50 },
  { 8429, 35, 51, 36, 3, -50 },
  { 8653, 29, 50, 30, 6, -50 },
  { 8835, 47, 50, 48, 7, -50 },
  { 9129, 36, 50, 27, -4, -50 },
  { 9354, 26, 50, 26, 6, -50 },
  { 9517, 33, 50, 27, -2, -50 },
  { 9724, 26, 61, 20, -1, -50 },
  { 9923, 11, 50, 23, 7, -50 },
  { 9992, 26, 61, 20, -5, -50 },
  { 10191, 28, 27, 31, 2, -50 },
  { 10286, 22, 3, 22, -6, 6 },
  { 10295, 9, 12, 16, 10, -54 },
  { 10309, 29, 39, 31, 2, -38 },
  { 10451, 28, 54, 31, 1, -53 },
  { 10640, 23, 39, 24, 2, -38 },
  { 10753, 32, 54, 32, 2, -53 },
  { 10969, 24, 39, 28, 2, -38 },
  { 11086, 34, 71, 16, -9, -54 },
  { 11388, 31, 55, 32, 0, -38 },
  { 11602, 27, 53, 31, 1, -53 },
  { 11781, 14, 51, 13, 1, -51 },
  { 11871, 24, 68, 14, -9, -51 },
  { 12075, 28, 53, 26, 1, -53 },
  { 12261, 15, 53, 13, 1, -53 },
  { 12361, 43, 38, 46, 1, -38 },
  { 12566, 27, 38, 31, 1, -38 },
  { 12695, 26, 39, 31, 2, -38 },
  { 12822, 32, 54, 31, -3, -38 },
  { 13038, 29, 55, 32, 2, -38 },
  { 13238, 22, 38, 21, 1, -38 },
  { 13343, 24, 39, 23, 0, -38 },
  { 13460, 17, 47, 17, 2, -46 },
  { 13560, 28, 38, 31, 2, -37 },
  { 13693, 24, 37, 24, 4, -37 },
  { 13804, 38, 37, 39, 4, -37 },
  { 13980, 30, 37, 25, -3, -37 },
  { 14119, 35, 54, 25, -7, -37 },
  { 14356, 25, 37, 22, -2, -37 },
  { 14472, 25, 61, 23, 2, -50 },
  { 14663, 3, 70, 29, 13, -53 },
  { 14690, 25, 61, 23, -4, -50 },
  { 14881, 27, 7, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_LightItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC70PT7B_H_
