#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC32PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x30, 0xC3, 0x08, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0x82,
  0x18, 0x60, 0x00, 0x00, 0xC3, 0x0C, 0x00, 0x33, 0x63, 0x62, 0x62, 0x46,
  0x46, 0x44, 0xC4, 0x00, 0x86, 0x01, 0x08, 0x06, 0x30, 0x08, 0x60, 0x10,
  0x80, 0x61, 0x00, 0xC6, 0x0F, 0xFF, 0x26, 0x10, 0x0C, 0x60, 0x10, 0x80,
  0x61, 0x00, 0xC6, 0x01, 0x0C, 0x3F, 0xFE, 0x7F, 0xFC, 0x10, 0xC0, 0x21,
  0x00, 0xC2, 0x01, 0x8C, 0x02, 0x10, 0x04, 0x20, 0x18, 0xC0, 0x00, 0x00,
  0x40, 0x01, 0x00, 0x0E, 0x01, 0xFF, 0x0C, 0x88, 0x22, 0x01, 0x88, 0x06,
  0x20, 0x19, 0x80, 0x64, 0x00, 0xD0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00,
  0x2E, 0x00, 0x98, 0x02, 0x20, 0x18, 0x80, 0x46, 0x01, 0x18, 0xC4, 0xC3,
  0xFE, 0x00, 0xC0, 0x02, 0x00, 0x08, 0x00, 0x20, 0x00, 0x1E, 0x03, 0x19,
  0x83, 0x08, 0xC1, 0x0C, 0x61, 0x84, 0x30, 0x82, 0x18, 0xC3, 0x0C, 0xC1,
  0x84, 0x40, 0x82, 0x60, 0x43, 0x27, 0xA1, 0x37, 0xD1, 0x92, 0x3C, 0x9B,
  0x1B, 0x99, 0x0C, 0x08, 0x86, 0x0C, 0xC3, 0x04, 0x61, 0x06, 0x20, 0x82,
  0x10, 0xC3, 0x08, 0x63, 0x04, 0x61, 0x03, 0x21, 0x80, 0xF0, 0x01, 0xE0,
  0x0C, 0xC0, 0x63, 0x01, 0x04, 0x04, 0x30, 0x30, 0xC0, 0x43, 0x01, 0x18,
  0x06, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1B, 0x00, 0xC6, 0x36, 0x18,
  0xD8, 0x26, 0xC0, 0xDB, 0x03, 0xCC, 0x06, 0x30, 0x18, 0xC0, 0xF1, 0xCE,
  0xC3, 0xE1, 0x80, 0x36, 0x66, 0x44, 0x4C, 0x01, 0x81, 0x80, 0x80, 0xC0,
  0xC0, 0x40, 0x60, 0x60, 0x30, 0x10, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x20,
  0x18, 0x0C, 0x00, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80,
  0x80, 0xC0, 0x60, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x18, 0x00, 0x04,
  0x03, 0x08, 0xC3, 0x20, 0x3B, 0xC3, 0xC3, 0x41, 0x90, 0xC6, 0x10, 0xC0,
  0x20, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00, 0x08,
  0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x39, 0x88, 0xC4, 0x62, 0x00, 0xFE, 0xFC, 0x00, 0x0C, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x20, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01,
  0x80, 0x06, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x10, 0x00, 0xC0, 0x02,
  0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x08,
  0x00, 0x00, 0x03, 0xE0, 0x76, 0x0C, 0x31, 0x83, 0x18, 0x13, 0x01, 0x30,
  0x32, 0x03, 0x60, 0x36, 0x03, 0x60, 0x34, 0x03, 0xC0, 0x2C, 0x06, 0xC0,
  0x6C, 0x06, 0xC0, 0x4C, 0x0C, 0xC0, 0xCC, 0x18, 0xC3, 0x06, 0x70, 0x3E,
  0x00, 0x06, 0x1C, 0x7B, 0xBC, 0x51, 0x83, 0x06, 0x08, 0x30, 0x60, 0xC1,
  0x82, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x10, 0x00, 0x01, 0xF0,
  0x1E, 0xE0, 0x40, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xFF,
  0x8F, 0xFE, 0x00, 0x03, 0xE0, 0x7B, 0x82, 0x06, 0x00, 0x30, 0x00, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x03, 0xF0, 0x1F, 0x00, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0,
  0x0C, 0x61, 0xC3, 0xFC, 0x00, 0x00, 0x18, 0x01, 0xC0, 0x1E, 0x00, 0xB0,
  0x0D, 0x00, 0xD8, 0x04, 0xC0, 0x66, 0x06, 0x30, 0x21, 0x03, 0x18, 0x30,
  0xC1, 0x06, 0x18, 0x21, 0x81, 0x18, 0x18, 0xFF, 0xFF, 0xFF, 0x80, 0x20,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x40,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x5E,
  0x03, 0xFC, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC3, 0x0E, 0x0F, 0xF0, 0x00,
  0x00, 0xF8, 0x1E, 0x41, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06,
  0x00, 0x20, 0x03, 0x3C, 0x1F, 0x30, 0xE0, 0xC6, 0x06, 0x70, 0x33, 0x01,
  0x98, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x31, 0x81, 0x84, 0x18, 0x31, 0xC0,
  0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20,
  0x03, 0x00, 0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x1C, 0xE0, 0xC1, 0x83, 0x03, 0x08,
  0x0C, 0x60, 0x30, 0x81, 0x82, 0x06, 0x0C, 0x30, 0x19, 0x80, 0x3C, 0x01,
  0xE0, 0x1C, 0xC0, 0xC1, 0x86, 0x06, 0x18, 0x08, 0xC0, 0x33, 0x00, 0xCC,
  0x02, 0x30, 0x18, 0x60, 0x61, 0xC7, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x3B,
  0x83, 0x06, 0x30, 0x31, 0x81, 0x88, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19,
  0x80, 0xCC, 0x0E, 0x60, 0x61, 0x8D, 0x07, 0xD8, 0x00, 0xC0, 0x04, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x00, 0x18, 0x43, 0x83, 0xF0, 0x00, 0x0C,
  0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x38, 0xC0,
  0x03, 0x07, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x18, 0x30, 0x30, 0x20, 0x60, 0xC0, 0x00, 0x18, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x04, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x1F, 0x0E, 0xE0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x03, 0x00, 0x80, 0x60, 0x30, 0x18,
  0x0C, 0x03, 0x00, 0x80, 0x60, 0x00, 0x00, 0x00, 0x00, 0x40, 0x38, 0x0C,
  0x00, 0x00, 0x7E, 0x00, 0x3C, 0xE0, 0x0C, 0x06, 0x03, 0x00, 0x60, 0xC0,
  0x04, 0x30, 0x00, 0xC4, 0x04, 0x19, 0x87, 0xE3, 0x21, 0x8C, 0x6C, 0x21,
  0x8D, 0x8C, 0x21, 0xA1, 0x04, 0x24, 0x61, 0x85, 0x8C, 0x31, 0xB1, 0x04,
  0x36, 0x21, 0x84, 0xC4, 0x31, 0x98, 0xCA, 0x63, 0x1F, 0x78, 0x60, 0x00,
  0x0C, 0x00, 0x00, 0x80, 0x00, 0x18, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0xF8, 0x00, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xD8,
  0x03, 0x60, 0x09, 0x80, 0x66, 0x01, 0x18, 0x0C, 0x60, 0x21, 0x81, 0x86,
  0x06, 0x18, 0x3F, 0xE0, 0xFF, 0x86, 0x06, 0x18, 0x08, 0x40, 0x23, 0x00,
  0x88, 0x02, 0x60, 0x09, 0x80, 0x2C, 0x00, 0xC0, 0x07, 0xF0, 0x0F, 0xF8,
  0x18, 0x30, 0x20, 0x30, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x06, 0x08,
  0x0C, 0x30, 0x30, 0x7F, 0xC0, 0xFF, 0x01, 0x03, 0x06, 0x03, 0x0C, 0x06,
  0x18, 0x0C, 0x30, 0x18, 0x40, 0x31, 0x80, 0x63, 0x01, 0x86, 0x06, 0x0F,
  0xF8, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x1E, 0x70, 0xE0, 0x07, 0x00, 0x18,
  0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0x60, 0x01, 0xE2, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x07,
  0xF8, 0x06, 0x0C, 0x04, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x02, 0x0C,
  0x03, 0x08, 0x03, 0x18, 0x02, 0x18, 0x06, 0x18, 0x06, 0x10, 0x06, 0x30,
  0x06, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x20, 0x18, 0x60, 0x38, 0x60,
  0x70, 0x60, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x60,
  0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x08, 0x00, 0x60,
  0x01, 0xFF, 0x07, 0xF8, 0x10, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xFF, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x1F, 0xF0, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x01, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xBC, 0x38, 0x08, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x07, 0xEC, 0x0F, 0x90, 0x03, 0x20, 0x06, 0x40, 0x0C, 0x80,
  0x19, 0x80, 0x23, 0x00, 0xC6, 0x01, 0x86, 0x03, 0x0F, 0x1E, 0x07, 0xF8,
  0x00, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x60, 0x80, 0x30, 0xC0, 0x10,
  0x60, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x08, 0x03, 0x0C, 0x01, 0x07, 0xFF,
  0x83, 0xFF, 0xC1, 0x00, 0x61, 0x80, 0x20, 0xC0, 0x30, 0x60, 0x18, 0x30,
  0x0C, 0x10, 0x06, 0x18, 0x02, 0x0C, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC3,
  0x00, 0x60, 0x0F, 0xE0, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40,
  0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x3F, 0x00, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x0F, 0x80, 0xF0, 0x00, 0x06, 0x03, 0x06, 0x06, 0x06, 0x0C,
  0x04, 0x1C, 0x0C, 0x18, 0x0C, 0x30, 0x0C, 0x60, 0x0C, 0xC0, 0x09, 0x80,
  0x1B, 0x80, 0x1B, 0x00, 0x1F, 0x00, 0x1D, 0x80, 0x39, 0x80, 0x31, 0x80,
  0x30, 0xC0, 0x30, 0xC0, 0x20, 0xC0, 0x60, 0x40, 0x60, 0x60, 0x60, 0x60,
  0x60, 0x60, 0xC0, 0x30, 0x06, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x10,
  0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFE, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70,
  0x70, 0x03, 0xC1, 0xC0, 0x0E, 0x0D, 0x00, 0x78, 0x34, 0x01, 0xE0, 0xD0,
  0x0D, 0x82, 0x40, 0x36, 0x09, 0x01, 0x90, 0x64, 0x06, 0xC1, 0x98, 0x33,
  0x06, 0x60, 0xCC, 0x11, 0x86, 0x30, 0xC6, 0x18, 0x83, 0x18, 0xC6, 0x0C,
  0x63, 0x18, 0x31, 0x98, 0x60, 0x82, 0x61, 0x06, 0x0B, 0x0C, 0x18, 0x2C,
  0x30, 0x60, 0xE0, 0xC1, 0x03, 0x83, 0x0C, 0x0C, 0x08, 0x00, 0x06, 0x00,
  0xC1, 0xC0, 0x30, 0x70, 0x08, 0x1C, 0x02, 0x0D, 0x01, 0x83, 0x60, 0x60,
  0xD8, 0x18, 0x26, 0x04, 0x08, 0x83, 0x06, 0x30, 0xC1, 0x8C, 0x30, 0x63,
  0x0C, 0x10, 0x42, 0x0C, 0x19, 0x83, 0x06, 0x60, 0xC1, 0x98, 0x30, 0x24,
  0x08, 0x0D, 0x06, 0x03, 0xC1, 0x80, 0xF0, 0x60, 0x1C, 0x10, 0x06, 0x0C,
  0x01, 0x80, 0x03, 0xF0, 0x0E, 0xF0, 0x30, 0x30, 0xC0, 0x63, 0x00, 0x66,
  0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x07, 0x80, 0x0F, 0x00, 0x16, 0x00,
  0x6C, 0x00, 0xD8, 0x01, 0xA0, 0x03, 0x40, 0x0C, 0x80, 0x19, 0x00, 0x63,
  0x00, 0xC6, 0x03, 0x0C, 0x0E, 0x0E, 0x38, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x1F, 0xE0, 0x61, 0xC1, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x03,
  0x08, 0x0C, 0x60, 0x61, 0x81, 0x86, 0x1C, 0x1F, 0xE0, 0xFC, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x00, 0x03, 0xF0, 0x0E, 0xF0, 0x30, 0x30, 0xC0, 0x63, 0x00,
  0x66, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x07, 0x80, 0x0F, 0x00, 0x16,
  0x00, 0x6C, 0x00, 0xD8, 0x01, 0xA0, 0x03, 0x40, 0x0C, 0x80, 0x19, 0x00,
  0x63, 0x00, 0xC6, 0x03, 0x0C, 0x0E, 0x0E, 0x38, 0x0F, 0xC0, 0x01, 0x00,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x1F, 0xE0,
  0x61, 0xC1, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x08, 0x0C,
  0x60, 0x61, 0x83, 0x86, 0x3C, 0x1F, 0xC0, 0xC6, 0x03, 0x08, 0x0C, 0x30,
  0x30, 0xC0, 0x83, 0x06, 0x04, 0x18, 0x18, 0x60, 0x61, 0x81, 0x8C, 0x06,
  0x00, 0x03, 0xF8, 0x1F, 0xF0, 0xC0, 0x86, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x30,
  0x80, 0xC3, 0x9E, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x30, 0x00, 0x0C, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x02, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x06, 0x10, 0x06, 0x30, 0x04, 0x30, 0x0C, 0x30, 0x0C,
  0x20, 0x0C, 0x60, 0x0C, 0x60, 0x08, 0x60, 0x18, 0x60, 0x18, 0x40, 0x18,
  0x40, 0x10, 0xC0, 0x30, 0x40, 0x30, 0x60, 0x60, 0x71, 0xC0, 0x3F, 0x80,
  0xC0, 0x1E, 0x00, 0xF0, 0x0D, 0x80, 0x6C, 0x06, 0x60, 0x33, 0x03, 0x18,
  0x18, 0xC0, 0x86, 0x0C, 0x30, 0x41, 0x86, 0x0C, 0x30, 0x63, 0x03, 0x18,
  0x19, 0x80, 0xCC, 0x02, 0xC0, 0x16, 0x00, 0xA0, 0x07, 0x00, 0x30, 0x01,
  0x80, 0x00, 0xC0, 0x30, 0x1F, 0x01, 0xC0, 0x6C, 0x07, 0x01, 0xB0, 0x1C,
  0x0C, 0xC0, 0xF0, 0x33, 0x02, 0xC1, 0x8C, 0x1B, 0x06, 0x30, 0x4C, 0x10,
  0xC3, 0x30, 0xC3, 0x0C, 0xC3, 0x0C, 0x23, 0x18, 0x31, 0x8C, 0x60, 0xC4,
  0x31, 0x03, 0x30, 0xCC, 0x0C, 0xC3, 0x30, 0x32, 0x0D, 0x80, 0xD8, 0x36,
  0x03, 0x40, 0xD0, 0x0F, 0x02, 0xC0, 0x3C, 0x0A, 0x00, 0xE0, 0x38, 0x03,
  0x80, 0xE0, 0x0C, 0x03, 0x00, 0x00, 0x02, 0x01, 0x81, 0x81, 0x80, 0xC1,
  0x80, 0x60, 0xC0, 0x10, 0xC0, 0x08, 0x40, 0x06, 0x60, 0x03, 0x60, 0x01,
  0xB0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1A, 0x00,
  0x09, 0x00, 0x0C, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x06, 0x08, 0x06, 0x04,
  0x03, 0x03, 0x03, 0x01, 0x83, 0x00, 0xC0, 0xC0, 0x3C, 0x06, 0xC0, 0x4C,
  0x0C, 0xC1, 0x84, 0x18, 0x43, 0x06, 0x30, 0x66, 0x06, 0x40, 0x6C, 0x03,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x30,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01,
  0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x1F, 0xFC, 0x3F,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x42, 0x0F, 0xC0, 0xC6, 0x10, 0x84, 0x31,
  0x8C, 0x61, 0x08, 0x43, 0x18, 0xC6, 0x10, 0x86, 0x31, 0x8C, 0x60, 0x03,
  0xF0, 0x3E, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0x40, 0x0C, 0x0F, 0xC0, 0x01, 0x00, 0x1C, 0x00, 0xE0, 0x0D, 0x00,
  0xCC, 0x04, 0x60, 0x61, 0x02, 0x0C, 0x30, 0x21, 0x01, 0x98, 0x0D, 0x80,
  0x2C, 0x01, 0x80, 0xFF, 0xE0, 0xCC, 0x62, 0x30, 0x07, 0xD8, 0x62, 0xC6,
  0x0C, 0x60, 0x63, 0x03, 0x30, 0x19, 0x80, 0xC8, 0x04, 0xC0, 0x66, 0x03,
  0x30, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0x63, 0x07, 0x0C, 0x58, 0x7C, 0x80,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0xBE, 0x0B, 0x38, 0xF0, 0xC7, 0x06, 0x30, 0x11, 0x80, 0x88, 0x0C, 0xC0,
  0x66, 0x03, 0x30, 0x19, 0x00, 0x88, 0x0C, 0xC0, 0x66, 0x06, 0x28, 0x31,
  0x67, 0x19, 0xF0, 0x07, 0xE1, 0x88, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03,
  0x88, 0x3F, 0x00, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x00, 0x06, 0x03, 0xEC, 0x0C, 0x58, 0x30, 0x60, 0xC0, 0xC1,
  0x81, 0x86, 0x03, 0x0C, 0x06, 0x10, 0x08, 0x60, 0x30, 0xC0, 0x61, 0x80,
  0xC3, 0x03, 0x86, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x19, 0xB0, 0x3E, 0x60,
  0x07, 0xC1, 0x8C, 0x61, 0x98, 0x32, 0x06, 0xC0, 0x98, 0x32, 0x3C, 0xFE,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x8C, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x30, 0x01, 0xFC, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x02, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x03, 0xEC, 0x18, 0xB0, 0xC1, 0x86, 0x06, 0x18, 0x18, 0xC0, 0x63, 0x01,
  0x88, 0x04, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x1C, 0x60, 0x61, 0x83,
  0x86, 0x0E, 0x0C, 0xD8, 0x3E, 0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x06, 0x08, 0x30, 0x3F, 0x80, 0x38, 0x00, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x08, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xBE, 0x0B, 0x38, 0xE0,
  0xC7, 0x06, 0x30, 0x31, 0x81, 0x88, 0x08, 0xC0, 0xC6, 0x06, 0x30, 0x31,
  0x01, 0x08, 0x08, 0xC0, 0xC6, 0x06, 0x30, 0x31, 0x01, 0x18, 0x18, 0x06,
  0x0C, 0x10, 0x00, 0x00, 0x03, 0x04, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C,
  0x18, 0x20, 0x41, 0x83, 0x06, 0x08, 0x30, 0x00, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x81,
  0xE0, 0x38, 0x00, 0x06, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x83, 0x08, 0x30, 0xC3, 0x06, 0x30, 0x33, 0x01, 0x10,
  0x09, 0x80, 0xD8, 0x07, 0xE0, 0x3B, 0x01, 0x98, 0x08, 0x40, 0xC3, 0x06,
  0x18, 0x30, 0xC1, 0x03, 0x18, 0x18, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x83,
  0x06, 0x08, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06,
  0x0C, 0x10, 0x60, 0x09, 0xF3, 0xE0, 0xB3, 0x67, 0x1C, 0x1C, 0x31, 0xC1,
  0x83, 0x18, 0x18, 0x31, 0x83, 0x03, 0x10, 0x30, 0x23, 0x03, 0x02, 0x30,
  0x20, 0x63, 0x02, 0x06, 0x20, 0x60, 0x62, 0x06, 0x04, 0x60, 0x60, 0xC6,
  0x04, 0x0C, 0x60, 0xC0, 0xC4, 0x0C, 0x0C, 0xC0, 0xC0, 0x80, 0x09, 0xF0,
  0x59, 0xC7, 0x06, 0x38, 0x31, 0x81, 0x8C, 0x0C, 0x40, 0x46, 0x06, 0x30,
  0x31, 0x81, 0x88, 0x08, 0xC0, 0x46, 0x06, 0x30, 0x31, 0x81, 0x88, 0x08,
  0xC0, 0xC0, 0x07, 0xC0, 0xCE, 0x18, 0x23, 0x03, 0x20, 0x36, 0x03, 0x60,
  0x34, 0x03, 0xC0, 0x3C, 0x02, 0xC0, 0x6C, 0x06, 0xC0, 0x4C, 0x0C, 0xC1,
  0x86, 0x30, 0x3E, 0x00, 0x04, 0xF8, 0x16, 0x70, 0xF0, 0xC3, 0x83, 0x0C,
  0x04, 0x30, 0x10, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x31, 0x80, 0x84,
  0x06, 0x30, 0x18, 0xC0, 0xC3, 0x87, 0x0B, 0x38, 0x67, 0xC1, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x07, 0xD8,
  0x62, 0xC6, 0x0C, 0x60, 0x63, 0x03, 0x30, 0x19, 0x80, 0xC8, 0x04, 0xC0,
  0x66, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0xE3, 0x07, 0x0C, 0xD8,
  0x7C, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00,
  0x60, 0x03, 0x00, 0x09, 0xE1, 0x64, 0x78, 0x0E, 0x01, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x00, 0x0F, 0xE3, 0x08, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC6,
  0x38, 0xFE, 0x00, 0x08, 0x08, 0x18, 0x18, 0x7F, 0x10, 0x30, 0x30, 0x30,
  0x20, 0x60, 0x60, 0x60, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC8, 0x78,
  0x18, 0x18, 0x80, 0x8C, 0x0C, 0x60, 0x63, 0x03, 0x10, 0x11, 0x81, 0x8C,
  0x0C, 0x60, 0x63, 0x03, 0x10, 0x11, 0x81, 0x8C, 0x0C, 0x60, 0xE3, 0x07,
  0x1C, 0xD0, 0x7C, 0x80, 0x80, 0x78, 0x1B, 0x02, 0x60, 0xCC, 0x11, 0x86,
  0x30, 0xC6, 0x30, 0xC6, 0x19, 0x83, 0x30, 0x6C, 0x0D, 0x81, 0xA0, 0x3C,
  0x03, 0x00, 0x60, 0x00, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0xD8, 0x78,
  0x6C, 0x2C, 0x26, 0x36, 0x33, 0x13, 0x11, 0x99, 0x98, 0xCC, 0xCC, 0x64,
  0x64, 0x36, 0x36, 0x1A, 0x1A, 0x0F, 0x0F, 0x07, 0x07, 0x83, 0x83, 0x81,
  0xC1, 0xC0, 0xC0, 0xC0, 0x00, 0x08, 0x1C, 0x30, 0x40, 0xC3, 0x03, 0x18,
  0x04, 0x40, 0x1B, 0x00, 0x78, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0xD0,
  0x06, 0x60, 0x19, 0x80, 0xC6, 0x06, 0x08, 0x18, 0x30, 0xC0, 0xC0, 0x06,
  0x03, 0x06, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x08, 0x06,
  0x18, 0x02, 0x10, 0x02, 0x30, 0x02, 0x20, 0x02, 0x60, 0x02, 0x40, 0x02,
  0xC0, 0x02, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x18, 0x00, 0xF0, 0x00, 0xC0,
  0x00, 0x0F, 0xF0, 0x06, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x20, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x30, 0x03, 0x00, 0x60, 0x0C,
  0x08, 0xFF, 0x00, 0x00, 0x60, 0x3C, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x01, 0x81, 0xE0, 0x38, 0x01,
  0x80, 0x10, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0x00, 0x3C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0F, 0x00,
  0xE0, 0x18, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x78, 0x0E, 0x00, 0x3C, 0x0B, 0xF8, 0xE0,
  0x7C,
};

const GFXglyph NotoSans_Condensed_LightItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 23, 7, 1, -23 },
  { 19, 8, 8, 10, 3, -23 },
  { 27, 15, 23, 15, 0, -23 },
  { 71, 14, 26, 13, 0, -24 },
  { 117, 17, 23, 20, 2, -23 },
  { 166, 14, 23, 15, 0, -23 },
  { 207, 4, 8, 6, 3, -23 },
  { 211, 9, 28, 8, 1, -23 },
  { 243, 9, 28, 8, -2, -23 },
  { 275, 10, 11, 13, 4, -24 },
  { 289, 13, 15, 15, 1, -19 },
  { 314, 5, 7, 6, -1, -3 },
  { 319, 7, 1, 9, 1, -9 },
  { 320, 2, 3, 6, 1, -3 },
  { 321, 14, 23, 10, -1, -23 },
  { 362, 12, 23, 14, 1, -23 },
  { 397, 7, 23, 14, 4, -23 },
  { 418, 14, 23, 14, -1, -23 },
  { 459, 13, 23, 14, 0, -23 },
  { 497, 13, 23, 14, 0, -23 },
  { 535, 14, 23, 14, 0, -23 },
  { 576, 13, 23, 14, 1, -23 },
  { 614, 13, 23, 14, 2, -23 },
  { 652, 14, 23, 14, 0, -23 },
  { 693, 13, 23, 14, 0, -23 },
  { 731, 6, 17, 6, 0, -17 },
  { 744, 8, 21, 6, -2, -17 },
  { 765, 13, 14, 15, 1, -18 },
  { 788, 13, 8, 15, 1, -15 },
  { 801, 13, 14, 15, 1, -18 },
  { 824, 10, 23, 10, 1, -23 },
  { 853, 19, 26, 20, 1, -23 },
  { 915, 14, 23, 14, -2, -23 },
  { 956, 15, 23, 15, 0, -23 },
  { 1000, 14, 23, 14, 2, -23 },
  { 1041, 16, 23, 16, 0, -23 },
  { 1087, 14, 23, 13, 0, -23 },
  { 1128, 14, 23, 12, 0, -23 },
  { 1169, 15, 23, 17, 2, -23 },
  { 1213, 17, 23, 17, 0, -23 },
  { 1262, 11, 23, 8, -1, -23 },
  { 1294, 12, 29, 6, -5, -23 },
  { 1338, 16, 23, 14, 0, -23 },
  { 1384, 9, 23, 12, 0, -23 },
  { 1410, 22, 23, 22, 0, -23 },
  { 1474, 18, 23, 18, 0, -23 },
  { 1526, 15, 23, 17, 2, -23 },
  { 1570, 14, 23, 14, 0, -23 },
  { 1611, 15, 28, 17, 2, -23 },
  { 1664, 14, 23, 14, 0, -23 },
  { 1705, 14, 23, 13, 0, -23 },
  { 1746, 11, 23, 12, 3, -23 },
  { 1778, 16, 23, 17, 1, -23 },
  { 1824, 13, 23, 14, 3, -23 },
  { 1862, 22, 23, 22, 3, -23 },
  { 1926, 17, 23, 12, -2, -23 },
  { 1975, 12, 23, 12, 3, -23 },
  { 2010, 15, 23, 12, -1, -23 },
  { 2054, 12, 28, 9, -1, -23 },
  { 2096, 5, 23, 11, 3, -23 },
  { 2111, 12, 28, 9, -2, -23 },
  { 2153, 13, 13, 14, 1, -23 },
  { 2175, 11, 1, 10, -3, 3 },
  { 2177, 4, 5, 7, 5, -24 },
  { 2180, 13, 17, 14, 1, -17 },
  { 2208, 13, 24, 14, 0, -24 },
  { 2247, 11, 17, 11, 1, -17 },
  { 2271, 15, 24, 14, 1, -24 },
  { 2316, 11, 17, 13, 1, -17 },
  { 2340, 15, 32, 7, -4, -24 },
  { 2400, 14, 25, 14, 0, -17 },
  { 2444, 13, 24, 14, 0, -24 },
  { 2483, 7, 23, 6, 0, -23 },
  { 2504, 11, 31, 6, -4, -23 },
  { 2547, 13, 24, 12, 0, -24 },
  { 2586, 7, 24, 6, 0, -24 },
  { 2607, 20, 17, 21, 0, -17 },
  { 2650, 13, 17, 14, 0, -17 },
  { 2678, 12, 17, 14, 1, -17 },
  { 2704, 14, 24, 14, -1, -17 },
  { 2746, 13, 25, 15, 1, -17 },
  { 2787, 11, 17, 9, 0, -17 },
  { 2811, 11, 17, 11, 0, -17 },
  { 2835, 8, 21, 8, 1, -21 },
  { 2856, 13, 17, 14, 1, -17 },
  { 2884, 11, 17, 11, 2, -17 },
  { 2908, 17, 17, 18, 2, -17 },
  { 2945, 14, 17, 12, -1, -17 },
  { 2975, 16, 25, 11, -3, -17 },
  { 3025, 12, 17, 10, -1, -17 },
  { 3051, 11, 28, 10, 1, -23 },
  { 3090, 2, 32, 13, 6, -24 },
  { 3098, 12, 28, 10, -2, -23 },
  { 3140, 13, 3, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_LightItalic32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC32PT7B_H_
