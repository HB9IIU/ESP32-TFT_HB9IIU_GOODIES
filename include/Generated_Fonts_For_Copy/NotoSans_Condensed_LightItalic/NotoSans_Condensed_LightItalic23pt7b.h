#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC23PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x08, 0x46, 0x21, 0x08, 0x46, 0x21, 0x08, 0xC0, 0x01, 0x18, 0x6D,
  0x24, 0x92, 0x8A, 0x40, 0x06, 0x40, 0x88, 0x11, 0x02, 0x43, 0xFE, 0x11,
  0x02, 0x40, 0x88, 0x11, 0x02, 0x43, 0xFF, 0x11, 0x02, 0x20, 0x48, 0x11,
  0x02, 0x60, 0x03, 0x00, 0xC1, 0xFC, 0x48, 0x22, 0x09, 0x03, 0x40, 0x70,
  0x0C, 0x01, 0x80, 0xB0, 0x24, 0x09, 0x02, 0x49, 0x21, 0xF0, 0x10, 0x04,
  0x00, 0x18, 0x11, 0xA1, 0x09, 0x08, 0x88, 0x84, 0x48, 0x22, 0x42, 0x14,
  0x11, 0x2E, 0x8A, 0x92, 0xB4, 0xD9, 0x44, 0x12, 0x20, 0x91, 0x08, 0x88,
  0x44, 0xC4, 0x24, 0x61, 0xC0, 0x02, 0x03, 0x60, 0x88, 0x62, 0x11, 0x84,
  0x41, 0xA0, 0x30, 0x1C, 0x0D, 0x06, 0x45, 0x1A, 0xC2, 0xA0, 0xC8, 0x33,
  0x1C, 0x7C, 0x80, 0x69, 0x29, 0x00, 0x0C, 0x21, 0x08, 0x21, 0x04, 0x30,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x04, 0x10, 0x04, 0x08, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x18, 0x20, 0x41, 0x82, 0x0C, 0x10,
  0x41, 0x86, 0x00, 0x11, 0x23, 0x41, 0xF3, 0x19, 0x22, 0x00, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x32,
  0x44, 0x80, 0xF8, 0x70, 0x00, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x00, 0x80,
  0x40, 0x10, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x10, 0x04, 0x02, 0x00,
  0x06, 0x0D, 0x8C, 0x44, 0x36, 0x1A, 0x0D, 0x05, 0x82, 0xC1, 0x40, 0xA0,
  0xD0, 0x48, 0x24, 0x32, 0x11, 0x98, 0x78, 0x00, 0x1B, 0xF5, 0x21, 0x08,
  0xC4, 0x21, 0x18, 0xC4, 0x21, 0x18, 0x03, 0x01, 0xF8, 0x21, 0x00, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x04, 0x01, 0x80, 0x60, 0x08, 0x02, 0x00, 0x80,
  0x20, 0x08, 0x03, 0x00, 0xFF, 0x00, 0x06, 0x07, 0x61, 0x08, 0x03, 0x00,
  0xC0, 0x20, 0x18, 0x0C, 0x1C, 0x00, 0x80, 0x10, 0x04, 0x01, 0x00, 0x40,
  0x32, 0x18, 0xFC, 0x00, 0x00, 0xC0, 0x60, 0x18, 0x0A, 0x04, 0x81, 0x40,
  0x90, 0x44, 0x31, 0x08, 0xC4, 0x23, 0x08, 0xFF, 0x80, 0x80, 0x60, 0x10,
  0x04, 0x00, 0x0F, 0xC6, 0x01, 0x00, 0x40, 0x30, 0x08, 0x03, 0xE0, 0x8C,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0xC8, 0x63, 0xF0, 0x03, 0x87,
  0x46, 0x06, 0x02, 0x03, 0x01, 0x00, 0xBC, 0xE2, 0x61, 0xA0, 0xD0, 0x68,
  0x34, 0x12, 0x19, 0x88, 0x78, 0x00, 0x7F, 0x80, 0x40, 0x40, 0x20, 0x20,
  0x10, 0x10, 0x08, 0x08, 0x04, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80,
  0x07, 0x03, 0x61, 0x0C, 0x41, 0x30, 0xC4, 0x21, 0x18, 0x2C, 0x0C, 0x0C,
  0x86, 0x31, 0x04, 0xC1, 0x20, 0x4C, 0x11, 0x08, 0x7C, 0x00, 0x06, 0x06,
  0xC4, 0x26, 0x12, 0x09, 0x04, 0x82, 0x41, 0x21, 0x99, 0x47, 0x60, 0x20,
  0x10, 0x10, 0x18, 0x18, 0xF8, 0x00, 0x33, 0x00, 0x00, 0x00, 0x00, 0xCC,
  0x08, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x08, 0xC4, 0x22, 0x00, 0x01, 0x81,
  0x83, 0x06, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x40, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x18,
  0x30, 0x70, 0xE0, 0x40, 0x00, 0x18, 0xDC, 0x08, 0x10, 0x20, 0x83, 0x04,
  0x10, 0x41, 0x02, 0x04, 0x00, 0x00, 0x60, 0x80, 0x07, 0xE0, 0x40, 0x84,
  0x02, 0x40, 0x12, 0x3C, 0xA2, 0x25, 0x32, 0x31, 0x11, 0x88, 0x8C, 0x84,
  0xA4, 0x45, 0x22, 0x28, 0xEE, 0x40, 0x02, 0x00, 0x18, 0x00, 0x61, 0x01,
  0xF8, 0x00, 0x01, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x64, 0x22, 0x31, 0x10,
  0x8F, 0xC8, 0x24, 0x16, 0x0A, 0x07, 0x03, 0x01, 0x0F, 0xC3, 0x08, 0x41,
  0x88, 0x31, 0x04, 0x21, 0x8C, 0x61, 0xF0, 0x21, 0x84, 0x10, 0x82, 0x30,
  0x44, 0x08, 0x83, 0x10, 0xC7, 0xE0, 0x03, 0x83, 0xB1, 0x80, 0xC0, 0x20,
  0x18, 0x04, 0x01, 0x00, 0xC0, 0x30, 0x08, 0x02, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x3E, 0x00, 0x0F, 0xC3, 0x08, 0x41, 0x88, 0x11, 0x02, 0x20,
  0x4C, 0x09, 0x01, 0x20, 0x64, 0x08, 0x81, 0x30, 0x64, 0x08, 0x82, 0x11,
  0x87, 0xE0, 0x0F, 0xC6, 0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0xFC,
  0x20, 0x08, 0x06, 0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0xF8, 0x0F, 0xC6,
  0x01, 0x00, 0x40, 0x10, 0x04, 0x03, 0x00, 0x80, 0x3F, 0x08, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0x03, 0xC0, 0xEF, 0x18, 0x03, 0x00,
  0x20, 0x06, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x3C, 0x80, 0x48, 0x0C,
  0x80, 0x8C, 0x08, 0x40, 0x86, 0x08, 0x3F, 0x80, 0x08, 0x11, 0x81, 0x10,
  0x11, 0x03, 0x10, 0x21, 0x02, 0x30, 0x23, 0xFE, 0x20, 0x62, 0x04, 0x60,
  0x46, 0x04, 0x40, 0xC4, 0x08, 0x40, 0x8C, 0x08, 0x1F, 0x04, 0x04, 0x0C,
  0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0xF8,
  0x01, 0x03, 0x02, 0x02, 0x02, 0x02, 0x06, 0x04, 0x04, 0x04, 0x04, 0x0C,
  0x08, 0x08, 0x08, 0x18, 0x18, 0x10, 0x30, 0xE0, 0x08, 0x71, 0x84, 0x10,
  0x81, 0x10, 0x13, 0x01, 0x60, 0x3C, 0x02, 0xC0, 0x34, 0x02, 0x60, 0x66,
  0x06, 0x20, 0x42, 0x04, 0x30, 0x41, 0x0C, 0x10, 0x08, 0x30, 0x40, 0x81,
  0x02, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x04, 0x08, 0x10, 0x7F, 0x0C, 0x03,
  0x1C, 0x06, 0x14, 0x06, 0x14, 0x0A, 0x14, 0x0A, 0x14, 0x16, 0x34, 0x14,
  0x24, 0x24, 0x24, 0x24, 0x24, 0x44, 0x64, 0x4C, 0x64, 0x88, 0x46, 0x88,
  0x43, 0x08, 0x43, 0x18, 0xC2, 0x18, 0x08, 0x18, 0xE0, 0x85, 0x04, 0x28,
  0x21, 0x41, 0x0B, 0x18, 0xC8, 0x84, 0x44, 0x22, 0x21, 0x19, 0x18, 0x58,
  0x82, 0x84, 0x14, 0x20, 0xE1, 0x03, 0x18, 0x18, 0x03, 0x01, 0xB8, 0x61,
  0x98, 0x32, 0x02, 0xC0, 0x50, 0x0A, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0x40,
  0x28, 0x0D, 0x81, 0x30, 0x63, 0x18, 0x3E, 0x00, 0x0F, 0x86, 0x31, 0x04,
  0x41, 0x10, 0x44, 0x13, 0x08, 0x86, 0x3F, 0x08, 0x02, 0x01, 0x80, 0x40,
  0x10, 0x04, 0x03, 0x00, 0x03, 0x01, 0xB8, 0x61, 0x98, 0x32, 0x02, 0xC0,
  0x50, 0x0A, 0x01, 0xC0, 0x78, 0x0E, 0x01, 0x40, 0x28, 0x0D, 0x81, 0x30,
  0x63, 0x18, 0x3E, 0x00, 0x80, 0x10, 0x03, 0x00, 0x20, 0x0F, 0x86, 0x31,
  0x04, 0x41, 0x10, 0x44, 0x33, 0x08, 0x86, 0x3E, 0x09, 0x82, 0x21, 0x88,
  0x42, 0x10, 0xC4, 0x13, 0x04, 0x07, 0x07, 0xF1, 0x00, 0x80, 0x20, 0x08,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x00, 0xC0, 0x22,
  0x18, 0xFC, 0x00, 0xFF, 0x18, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20,
  0x20, 0x60, 0x40, 0x40, 0x40, 0xC0, 0xC0, 0x30, 0x26, 0x04, 0x81, 0x90,
  0x22, 0x04, 0xC0, 0x90, 0x12, 0x06, 0x40, 0x88, 0x13, 0x02, 0x40, 0xC8,
  0x11, 0x02, 0x30, 0x83, 0xE0, 0x80, 0xE0, 0x68, 0x12, 0x04, 0x82, 0x20,
  0x8C, 0x43, 0x10, 0xCC, 0x32, 0x0D, 0x81, 0x40, 0x70, 0x18, 0x06, 0x01,
  0x00, 0x81, 0x83, 0x81, 0x86, 0x83, 0x04, 0x83, 0x04, 0x85, 0x0C, 0x85,
  0x08, 0x8D, 0x18, 0x89, 0x10, 0x89, 0x10, 0x91, 0x20, 0x91, 0x20, 0xB1,
  0x60, 0xA1, 0x40, 0xA1, 0x40, 0xC1, 0x80, 0xC1, 0x80, 0x08, 0x30, 0x84,
  0x08, 0xC0, 0xC8, 0x05, 0x80, 0x50, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xA0,
  0x12, 0x01, 0x20, 0x23, 0x06, 0x10, 0x41, 0x08, 0x10, 0x81, 0xE1, 0xB0,
  0x88, 0x84, 0xC2, 0x41, 0x60, 0xA0, 0x60, 0x10, 0x18, 0x08, 0x04, 0x02,
  0x01, 0x01, 0x80, 0x0F, 0xE0, 0x08, 0x03, 0x00, 0x40, 0x10, 0x06, 0x00,
  0x80, 0x30, 0x04, 0x01, 0x00, 0x60, 0x08, 0x02, 0x00, 0xC0, 0x10, 0x07,
  0xF8, 0x0F, 0x18, 0x10, 0x10, 0x10, 0x10, 0x30, 0x20, 0x20, 0x20, 0x20,
  0x40, 0x40, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0xF0, 0xC4, 0x44, 0x44,
  0x46, 0x22, 0x22, 0x22, 0x31, 0x07, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x08,
  0x08, 0x04, 0x02, 0x01, 0x01, 0x80, 0x80, 0x40, 0x20, 0x10, 0x18, 0x08,
  0x04, 0x02, 0x1F, 0x00, 0x0C, 0x06, 0x05, 0x86, 0x42, 0x22, 0x09, 0x05,
  0x03, 0xFE, 0xC9, 0x90, 0x1E, 0x91, 0x58, 0x48, 0x2C, 0x14, 0x0A, 0x0D,
  0x04, 0x82, 0x43, 0x22, 0x8E, 0xC0, 0x08, 0x02, 0x01, 0x80, 0x40, 0x10,
  0x05, 0xE3, 0x88, 0xC3, 0x30, 0xC8, 0x22, 0x09, 0x82, 0x40, 0x90, 0x64,
  0x11, 0x88, 0x9C, 0x00, 0x1E, 0x41, 0x82, 0x0C, 0x10, 0x20, 0x40, 0x81,
  0x03, 0x03, 0xC0, 0x00, 0x40, 0x10, 0x0C, 0x02, 0x00, 0x87, 0xA2, 0x19,
  0x84, 0x41, 0x30, 0x48, 0x12, 0x0C, 0x82, 0x20, 0x88, 0x62, 0x28, 0x76,
  0x00, 0x1E, 0x23, 0x43, 0x42, 0xC6, 0xF8, 0x80, 0x80, 0x80, 0x80, 0xC4,
  0x7C, 0x00, 0x40, 0x34, 0x04, 0x00, 0x80, 0x30, 0x04, 0x03, 0xE0, 0x10,
  0x06, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x18, 0x02, 0x00, 0x40, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x01, 0x00, 0x20, 0x38, 0x02, 0x00, 0x0F, 0x44,
  0x33, 0x0C, 0x82, 0x60, 0x90, 0x24, 0x19, 0x04, 0x41, 0x10, 0xC4, 0x50,
  0xEC, 0x02, 0x00, 0x80, 0x20, 0x10, 0xFC, 0x08, 0x00, 0x08, 0x04, 0x06,
  0x02, 0x01, 0x00, 0xBC, 0xE2, 0x61, 0x20, 0x90, 0x48, 0x6C, 0x24, 0x12,
  0x09, 0x04, 0x86, 0xC2, 0x00, 0x08, 0xC0, 0x00, 0x08, 0xC4, 0x21, 0x08,
  0xC4, 0x21, 0x08, 0xC0, 0x01, 0x03, 0x00, 0x00, 0x00, 0x02, 0x02, 0x06,
  0x04, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10,
  0x30, 0xE0, 0x40, 0x08, 0x04, 0x06, 0x02, 0x01, 0x00, 0x8C, 0xC4, 0x44,
  0x24, 0x14, 0x0E, 0x0D, 0x86, 0x42, 0x21, 0x10, 0x8C, 0xC2, 0x00, 0x08,
  0x46, 0x21, 0x08, 0xC4, 0x21, 0x08, 0xC4, 0x21, 0x08, 0xC0, 0x1F, 0xBC,
  0xE3, 0x13, 0x08, 0x48, 0x21, 0x21, 0x84, 0x84, 0x16, 0x10, 0xD0, 0x42,
  0x43, 0x09, 0x08, 0x24, 0x21, 0xB0, 0x84, 0x17, 0x9C, 0x4C, 0x24, 0x12,
  0x09, 0x0D, 0x84, 0x82, 0x41, 0x20, 0x90, 0xD8, 0x40, 0x1E, 0x21, 0x61,
  0x41, 0xC1, 0x81, 0x81, 0x83, 0x82, 0x86, 0xC4, 0x78, 0x0B, 0xC3, 0x88,
  0x61, 0x8C, 0x31, 0x06, 0x20, 0x8C, 0x11, 0x02, 0x20, 0xC4, 0x10, 0xC4,
  0x37, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0xC0, 0x00, 0x1E, 0x90, 0xD8,
  0x68, 0x2C, 0x14, 0x0A, 0x0D, 0x04, 0x82, 0x43, 0x22, 0x8E, 0xC0, 0x40,
  0x20, 0x10, 0x08, 0x0C, 0x00, 0x17, 0x38, 0x30, 0x30, 0x20, 0x20, 0x60,
  0x40, 0x40, 0x40, 0x40, 0xC0, 0x3F, 0x20, 0x60, 0x60, 0x20, 0x10, 0x08,
  0x04, 0x04, 0x04, 0x8C, 0xF8, 0x11, 0x09, 0xF6, 0x21, 0x08, 0x46, 0x21,
  0x08, 0x43, 0x80, 0x21, 0xB0, 0x90, 0x48, 0x24, 0x12, 0x1B, 0x09, 0x04,
  0x86, 0x43, 0x23, 0x1E, 0x80, 0xC3, 0xC2, 0xC2, 0xC4, 0xC4, 0x48, 0x48,
  0x50, 0x50, 0x60, 0x60, 0x40, 0xC2, 0x1E, 0x30, 0xB1, 0x8D, 0x94, 0x4C,
  0xA2, 0x65, 0x23, 0x49, 0x1A, 0x58, 0xE2, 0x87, 0x14, 0x30, 0xC1, 0x86,
  0x00, 0x10, 0xC6, 0x60, 0x90, 0x28, 0x0E, 0x03, 0x00, 0xC0, 0x50, 0x36,
  0x08, 0x84, 0x23, 0x0C, 0x18, 0x21, 0x08, 0x21, 0x04, 0x60, 0x88, 0x13,
  0x02, 0x40, 0x58, 0x0A, 0x01, 0x40, 0x30, 0x06, 0x00, 0x80, 0x30, 0x04,
  0x01, 0x80, 0xE0, 0x10, 0x00, 0x1F, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x40,
  0x60, 0x20, 0x30, 0x10, 0x10, 0x1F, 0x80, 0x07, 0x08, 0x08, 0x18, 0x10,
  0x10, 0x10, 0x30, 0x20, 0xC0, 0x60, 0x20, 0x60, 0x40, 0x40, 0x40, 0x40,
  0x40, 0x60, 0x30, 0xFF, 0xFF, 0xFF, 0x0C, 0x02, 0x02, 0x06, 0x04, 0x04,
  0x04, 0x04, 0x04, 0x03, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x10, 0x10, 0x30,
  0x60, 0x80, 0xF8, 0xC3, 0x80,
};

const GFXglyph NotoSans_Condensed_LightItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 5, 16, 5, 0, -16 },
  { 11, 6, 6, 7, 2, -16 },
  { 16, 11, 16, 11, 0, -16 },
  { 38, 10, 18, 10, 0, -17 },
  { 61, 13, 17, 14, 1, -17 },
  { 89, 10, 17, 11, 0, -17 },
  { 111, 3, 6, 4, 2, -16 },
  { 114, 6, 20, 6, 1, -16 },
  { 129, 7, 20, 6, -2, -16 },
  { 147, 7, 7, 9, 3, -17 },
  { 154, 9, 11, 11, 1, -14 },
  { 167, 4, 5, 4, -1, -2 },
  { 170, 5, 1, 6, 1, -7 },
  { 171, 2, 2, 4, 0, -2 },
  { 172, 10, 16, 7, -1, -16 },
  { 192, 9, 17, 10, 1, -17 },
  { 212, 5, 16, 10, 3, -16 },
  { 222, 11, 17, 10, -1, -17 },
  { 246, 10, 17, 10, 0, -17 },
  { 268, 10, 17, 10, 0, -17 },
  { 290, 10, 16, 10, 0, -16 },
  { 310, 9, 17, 10, 1, -17 },
  { 330, 9, 16, 10, 1, -16 },
  { 348, 10, 17, 10, 0, -17 },
  { 370, 9, 17, 10, 0, -17 },
  { 390, 4, 12, 4, 0, -12 },
  { 396, 5, 15, 5, -1, -12 },
  { 406, 9, 10, 11, 1, -13 },
  { 418, 9, 6, 11, 1, -11 },
  { 425, 9, 10, 11, 1, -13 },
  { 437, 7, 17, 7, 1, -17 },
  { 452, 13, 18, 15, 1, -16 },
  { 482, 9, 16, 10, -1, -16 },
  { 500, 11, 16, 11, 0, -16 },
  { 522, 10, 17, 10, 1, -17 },
  { 544, 11, 16, 12, 0, -16 },
  { 566, 10, 16, 9, 0, -16 },
  { 586, 10, 16, 9, 0, -16 },
  { 606, 12, 17, 12, 1, -17 },
  { 632, 12, 16, 12, 0, -16 },
  { 656, 8, 16, 6, -1, -16 },
  { 672, 8, 20, 5, -3, -16 },
  { 692, 12, 16, 10, 0, -16 },
  { 716, 7, 16, 8, 0, -16 },
  { 730, 16, 16, 16, 0, -16 },
  { 762, 13, 16, 13, 0, -16 },
  { 788, 11, 17, 13, 1, -17 },
  { 812, 10, 16, 10, 0, -16 },
  { 832, 11, 21, 13, 1, -17 },
  { 861, 10, 16, 10, 0, -16 },
  { 881, 10, 17, 9, 0, -17 },
  { 903, 8, 16, 9, 2, -16 },
  { 919, 11, 16, 12, 1, -16 },
  { 941, 10, 16, 10, 2, -16 },
  { 961, 16, 16, 16, 2, -16 },
  { 993, 12, 16, 9, -1, -16 },
  { 1017, 9, 16, 9, 2, -16 },
  { 1035, 11, 16, 9, -1, -16 },
  { 1057, 8, 20, 7, 0, -16 },
  { 1077, 4, 16, 8, 2, -16 },
  { 1085, 9, 20, 7, -2, -16 },
  { 1108, 9, 8, 10, 1, -16 },
  { 1117, 7, 1, 7, -2, 2 },
  { 1118, 3, 4, 5, 3, -18 },
  { 1120, 9, 12, 10, 1, -12 },
  { 1134, 10, 17, 10, 0, -17 },
  { 1156, 7, 12, 8, 1, -12 },
  { 1167, 10, 17, 10, 1, -17 },
  { 1189, 8, 12, 9, 1, -12 },
  { 1201, 11, 24, 5, -3, -18 },
  { 1234, 10, 18, 10, 0, -12 },
  { 1257, 9, 17, 10, 0, -17 },
  { 1277, 5, 17, 4, 0, -17 },
  { 1288, 8, 23, 4, -3, -17 },
  { 1311, 9, 17, 9, 0, -17 },
  { 1331, 5, 17, 4, 0, -17 },
  { 1342, 14, 12, 15, 0, -12 },
  { 1363, 9, 12, 10, 0, -12 },
  { 1377, 8, 12, 10, 1, -12 },
  { 1389, 11, 17, 10, -1, -12 },
  { 1413, 9, 17, 10, 1, -12 },
  { 1433, 8, 12, 7, 0, -12 },
  { 1445, 8, 12, 8, 0, -12 },
  { 1457, 5, 15, 6, 1, -15 },
  { 1467, 9, 12, 10, 1, -12 },
  { 1481, 8, 12, 8, 1, -12 },
  { 1493, 13, 12, 13, 1, -12 },
  { 1513, 10, 12, 8, -1, -12 },
  { 1528, 11, 18, 8, -2, -12 },
  { 1553, 9, 12, 7, -1, -12 },
  { 1567, 8, 20, 7, 1, -16 },
  { 1587, 1, 24, 9, 4, -18 },
  { 1590, 8, 20, 7, -1, -16 },
  { 1610, 9, 2, 11, 1, -9 },
};

const GFXfont NotoSans_Condensed_LightItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC23PT7B_H_
