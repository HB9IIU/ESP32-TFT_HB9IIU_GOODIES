#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC41PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06,
  0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x38, 0x1C, 0x0C, 0x00, 0x30, 0xCC,
  0x77, 0x19, 0x86, 0x61, 0x98, 0x66, 0x31, 0x0C, 0xC3, 0x30, 0xC0, 0x00,
  0x30, 0x60, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x61, 0x80,
  0x0C, 0x18, 0x00, 0xC1, 0x80, 0x0C, 0x10, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x01, 0x82, 0x00, 0x10, 0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0C,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x60, 0x80, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF8, 0x0C, 0x10, 0x00, 0x83, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x18,
  0x60, 0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x04, 0x00, 0x06, 0x00, 0x07, 0x80, 0x1F, 0xF8, 0x1C,
  0x9C, 0x18, 0xC2, 0x1C, 0x60, 0x0C, 0x30, 0x06, 0x10, 0x03, 0x08, 0x01,
  0x8C, 0x00, 0xE6, 0x00, 0x3A, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x7C, 0x00, 0x26, 0x00, 0x13, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x06,
  0x30, 0x02, 0x18, 0x01, 0x0C, 0x01, 0x8E, 0x30, 0xCE, 0x1F, 0xFE, 0x03,
  0xFC, 0x00, 0x10, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x03,
  0x00, 0x08, 0x3F, 0x00, 0xC1, 0xCC, 0x03, 0x06, 0x18, 0x18, 0x30, 0x60,
  0xE0, 0xC1, 0x83, 0x02, 0x06, 0x18, 0x18, 0x10, 0x60, 0x60, 0xC3, 0x01,
  0x83, 0x0C, 0x06, 0x0C, 0x60, 0x10, 0x33, 0x00, 0xC1, 0x8C, 0x73, 0x06,
  0x63, 0xEC, 0x19, 0x98, 0xF0, 0xCC, 0xC3, 0x66, 0x33, 0x0D, 0xF9, 0x98,
  0x31, 0x8C, 0x60, 0xC0, 0x31, 0x83, 0x01, 0x8C, 0x0C, 0x06, 0x30, 0x30,
  0x30, 0xC1, 0x80, 0xC3, 0x06, 0x06, 0x0C, 0x18, 0x30, 0x30, 0xC0, 0xC0,
  0xC3, 0x06, 0x03, 0x18, 0x18, 0x0E, 0xE0, 0xC0, 0x1F, 0x00, 0x00, 0x38,
  0x00, 0x3F, 0x80, 0x1C, 0x60, 0x06, 0x1C, 0x03, 0x03, 0x00, 0xC0, 0xC0,
  0x30, 0x70, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x00, 0x31, 0xC0, 0x0C,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0E, 0xE0,
  0x07, 0x18, 0x33, 0x86, 0x1C, 0xC1, 0xC6, 0x60, 0x31, 0x98, 0x0E, 0xCE,
  0x01, 0xF3, 0x00, 0x78, 0xC0, 0x1E, 0x38, 0x07, 0x0E, 0x03, 0xE1, 0xC1,
  0xD8, 0x7F, 0xE7, 0x0F, 0xE0, 0xC0, 0x33, 0x36, 0x66, 0x64, 0xCC, 0x00,
  0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00,
  0xE0, 0x0C, 0x01, 0x80, 0x38, 0x03, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x18,
  0x00, 0xC1, 0x04, 0x0E, 0x20, 0x3F, 0x0C, 0x7F, 0xE1, 0xC0, 0x1B, 0x01,
  0xD8, 0x1C, 0x61, 0xC3, 0x04, 0x0C, 0x00, 0x40, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0E, 0x18,
  0x70, 0xC3, 0x86, 0x0C, 0x30, 0xC0, 0xFF, 0xFF, 0xC0, 0x5F, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x30, 0x00, 0xFC, 0x03, 0xCE, 0x03,
  0x06, 0x06, 0x07, 0x0E, 0x03, 0x0C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x18,
  0x03, 0x38, 0x03, 0x30, 0x03, 0x30, 0x07, 0x70, 0x07, 0x70, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x0E, 0x60, 0x0E, 0x60, 0x0C, 0xE0, 0x0C, 0xE0,
  0x1C, 0xE0, 0x18, 0xE0, 0x18, 0xE0, 0x30, 0x60, 0x70, 0x60, 0x60, 0x70,
  0xE0, 0x3F, 0xC0, 0x1F, 0x00, 0x03, 0x83, 0xC3, 0xE7, 0xF7, 0x37, 0x19,
  0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0C,
  0x06, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x3E, 0x78, 0x0C, 0x06, 0x00,
  0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x00, 0x78,
  0x01, 0xFF, 0x01, 0xE3, 0xC0, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xE0, 0x01, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x10, 0x0E, 0x0F, 0xFE, 0x07,
  0xFE, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xD8, 0x00, 0xCC, 0x00, 0x6E, 0x00, 0x66, 0x00, 0x63, 0x00,
  0x71, 0x80, 0x30, 0xC0, 0x30, 0xE0, 0x30, 0x60, 0x18, 0x30, 0x18, 0x18,
  0x18, 0x1C, 0x0C, 0x0C, 0x0C, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x87, 0xFF,
  0xFB, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xB8, 0x01, 0xFF, 0x00, 0x63, 0xE0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x1C, 0x20, 0x1C, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x3F,
  0xC0, 0x3C, 0x40, 0x38, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x1F, 0x01,
  0xBF, 0xC0, 0xF0, 0x70, 0xF0, 0x18, 0x70, 0x0C, 0x38, 0x07, 0x18, 0x03,
  0x8C, 0x01, 0xC6, 0x00, 0xC7, 0x00, 0x63, 0x80, 0x31, 0xC0, 0x38, 0x60,
  0x18, 0x30, 0x0C, 0x18, 0x0C, 0x0E, 0x0E, 0x03, 0xFE, 0x00, 0xFC, 0x00,
  0x3F, 0xFF, 0x9F, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x30, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x00, 0xF1, 0xC0, 0x60, 0x70, 0x60,
  0x18, 0x30, 0x0C, 0x18, 0x06, 0x1C, 0x03, 0x0E, 0x01, 0x83, 0x01, 0xC1,
  0x80, 0xC0, 0xE0, 0xC0, 0x31, 0xC0, 0x0D, 0xC0, 0x03, 0x80, 0x07, 0xE0,
  0x0F, 0x38, 0x0E, 0x0C, 0x0E, 0x03, 0x0E, 0x01, 0x86, 0x00, 0xE3, 0x00,
  0x33, 0x80, 0x19, 0xC0, 0x0C, 0xE0, 0x0E, 0x70, 0x06, 0x18, 0x07, 0x0E,
  0x07, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x38, 0x00, 0xFF, 0x00, 0xF3,
  0xC0, 0xE0, 0x60, 0x60, 0x30, 0x70, 0x1C, 0x30, 0x06, 0x38, 0x03, 0x18,
  0x01, 0x8C, 0x01, 0xC6, 0x00, 0xE3, 0x00, 0x71, 0x80, 0x30, 0xC0, 0x38,
  0x60, 0x1C, 0x38, 0x1E, 0x0E, 0x3B, 0x07, 0xFB, 0x00, 0xF1, 0x80, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x06, 0x1C,
  0x38, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x83, 0x8F, 0x1C, 0x00, 0x01, 0x80, 0xF0, 0x38, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x60, 0x18, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0x01, 0x80, 0xFF, 0x87, 0x9C, 0x20, 0x70, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x06, 0x03, 0x00, 0x06, 0x07, 0x00, 0x03, 0x06, 0x00, 0x03,
  0x0C, 0x00, 0x03, 0x18, 0x0F, 0xC3, 0x18, 0x1D, 0xC3, 0x18, 0x30, 0xC3,
  0x30, 0x60, 0xC3, 0x30, 0xC0, 0x83, 0x20, 0xC1, 0x83, 0x60, 0x81, 0x83,
  0x61, 0x81, 0x83, 0x61, 0x83, 0x06, 0x61, 0x83, 0x06, 0x41, 0x03, 0x06,
  0xC3, 0x07, 0x0C, 0xC3, 0x07, 0x0C, 0xC1, 0x8F, 0x18, 0xC1, 0x9B, 0x30,
  0xC0, 0xF1, 0xE0, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x06, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x36, 0x00, 0x0D, 0x80, 0x06, 0x60, 0x01, 0x98, 0x00, 0xC6,
  0x00, 0x31, 0x80, 0x1C, 0x60, 0x06, 0x18, 0x03, 0x86, 0x00, 0xC1, 0x80,
  0x30, 0x60, 0x18, 0x18, 0x06, 0x06, 0x03, 0x81, 0x80, 0xFF, 0xE0, 0x7F,
  0xF8, 0x18, 0x06, 0x0E, 0x01, 0x83, 0x00, 0x61, 0xC0, 0x18, 0x60, 0x07,
  0x38, 0x01, 0xCC, 0x00, 0x73, 0x00, 0x1D, 0xC0, 0x07, 0xE0, 0x01, 0xC0,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x60, 0x38, 0x18, 0x07, 0x06, 0x01, 0xC1,
  0x80, 0x70, 0xE0, 0x1C, 0x30, 0x07, 0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0,
  0x38, 0x70, 0x1C, 0x18, 0x3E, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0xE0, 0x38,
  0x38, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x70, 0xC0, 0x1C, 0x70, 0x07, 0x18,
  0x01, 0x86, 0x00, 0x61, 0x80, 0x38, 0x60, 0x0C, 0x38, 0x07, 0x0C, 0x07,
  0x83, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x1F, 0xF0, 0x1F,
  0x1C, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x20, 0x3F, 0xF0, 0x03,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x18, 0x1E, 0x03, 0x00, 0xE0,
  0x60, 0x0C, 0x0C, 0x01, 0x83, 0x80, 0x38, 0x60, 0x07, 0x0C, 0x00, 0x61,
  0x80, 0x0C, 0x30, 0x03, 0x8E, 0x00, 0x71, 0x80, 0x0E, 0x30, 0x01, 0xC6,
  0x00, 0x31, 0xC0, 0x06, 0x30, 0x00, 0xC6, 0x00, 0x38, 0xC0, 0x06, 0x18,
  0x01, 0xC7, 0x00, 0x38, 0xC0, 0x0E, 0x18, 0x01, 0x83, 0x00, 0x70, 0x60,
  0x1C, 0x1C, 0x07, 0x03, 0x03, 0xC0, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0x03,
  0xFF, 0x83, 0xFF, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x1F, 0xFC, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x83, 0xFF, 0xC1, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xFE, 0x01, 0xF9, 0xF0, 0x3C,
  0x03, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x01, 0xFC, 0xE0, 0x1F, 0xCC, 0x00, 0x1C,
  0xC0, 0x01, 0x8C, 0x00, 0x18, 0xC0, 0x01, 0x8C, 0x00, 0x38, 0xC0, 0x03,
  0x8E, 0x00, 0x30, 0xE0, 0x03, 0x06, 0x00, 0x30, 0x70, 0x07, 0x03, 0x80,
  0x60, 0x1F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0x00, 0x18, 0x38, 0x01, 0xC1,
  0x80, 0x0E, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x38, 0x01,
  0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x38,
  0x01, 0xC1, 0x80, 0x0C, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0x00, 0x18,
  0x30, 0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x07, 0x00,
  0x38, 0x30, 0x01, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x07,
  0x00, 0x38, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0x00, 0x03,
  0xFC, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0F, 0xC0,
  0xFF, 0x00, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0x00,
  0x70, 0x70, 0x0C, 0x06, 0x01, 0xC0, 0x60, 0x38, 0x06, 0x07, 0x00, 0x60,
  0xE0, 0x0E, 0x0C, 0x00, 0xC1, 0x80, 0x0C, 0x38, 0x00, 0xC7, 0x00, 0x0C,
  0xE0, 0x01, 0xDC, 0x00, 0x19, 0x80, 0x01, 0xB8, 0x00, 0x1F, 0xC0, 0x03,
  0xCC, 0x00, 0x38, 0xC0, 0x03, 0x0E, 0x00, 0x30, 0x60, 0x03, 0x06, 0x00,
  0x70, 0x70, 0x06, 0x07, 0x00, 0x60, 0x30, 0x06, 0x03, 0x00, 0x60, 0x38,
  0x0E, 0x01, 0x80, 0xC0, 0x18, 0x0C, 0x01, 0xC0, 0xC0, 0x1C, 0x00, 0x03,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0x7F, 0xFF, 0xFE, 0x03, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0D, 0x83,
  0x60, 0x01, 0xB0, 0x66, 0x00, 0x6E, 0x0C, 0xC0, 0x0D, 0x81, 0x98, 0x03,
  0x30, 0x33, 0x00, 0x66, 0x0C, 0x60, 0x18, 0xC1, 0x8C, 0x03, 0x38, 0x31,
  0x80, 0xC6, 0x06, 0x30, 0x18, 0xC1, 0xC6, 0x06, 0x18, 0x30, 0xC0, 0xC3,
  0x06, 0x18, 0x30, 0xE0, 0xC3, 0x06, 0x18, 0x18, 0x61, 0x83, 0x07, 0x06,
  0x30, 0x60, 0xC0, 0xCC, 0x0C, 0x18, 0x19, 0x83, 0x83, 0x03, 0x60, 0x60,
  0x60, 0x6C, 0x0C, 0x18, 0x0F, 0x01, 0x83, 0x01, 0xE0, 0x70, 0x60, 0x38,
  0x0C, 0x0C, 0x07, 0x01, 0x80, 0x03, 0x80, 0x0C, 0x1E, 0x00, 0x70, 0x78,
  0x01, 0x81, 0xE0, 0x06, 0x07, 0x80, 0x18, 0x1B, 0x00, 0x60, 0xCC, 0x03,
  0x83, 0x30, 0x0C, 0x0C, 0xC0, 0x30, 0x31, 0x80, 0xC0, 0xC6, 0x03, 0x06,
  0x18, 0x1C, 0x18, 0x60, 0x60, 0x60, 0xC1, 0x81, 0x83, 0x06, 0x0E, 0x0C,
  0x38, 0x30, 0x30, 0xC0, 0xC0, 0x63, 0x03, 0x01, 0x8C, 0x0C, 0x06, 0x30,
  0x70, 0x19, 0xC1, 0x80, 0x76, 0x06, 0x00, 0xD8, 0x18, 0x03, 0x60, 0x60,
  0x0D, 0x83, 0x80, 0x3E, 0x0C, 0x00, 0x70, 0x30, 0x01, 0xC0, 0xC0, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x07, 0x9F, 0x01, 0xC0, 0xE0, 0x70,
  0x0E, 0x1C, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x67, 0x00,
  0x0C, 0xC0, 0x01, 0xB8, 0x00, 0x37, 0x00, 0x06, 0xC0, 0x00, 0xD8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1B, 0x00, 0x03, 0x60, 0x00,
  0xEC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x18, 0xE0, 0x07,
  0x0C, 0x01, 0xC1, 0xC0, 0x70, 0x38, 0x1C, 0x03, 0xFF, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x03, 0xFF, 0x81, 0x81, 0xC0, 0xC0, 0x70, 0x60, 0x18,
  0x30, 0x0C, 0x38, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x00, 0xC3, 0x00,
  0xE3, 0x80, 0x61, 0x80, 0x70, 0xC0, 0x70, 0x60, 0xF0, 0x7F, 0xF0, 0x3F,
  0xE0, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x07, 0x9F, 0x01, 0xC0,
  0xE0, 0x70, 0x0E, 0x1C, 0x00, 0xC3, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00,
  0x67, 0x00, 0x0C, 0xC0, 0x01, 0xB8, 0x00, 0x37, 0x00, 0x06, 0xC0, 0x00,
  0xD8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1B, 0x00, 0x03,
  0x60, 0x00, 0xEC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x18,
  0xE0, 0x07, 0x1C, 0x01, 0xC1, 0xC0, 0x70, 0x38, 0x1E, 0x03, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00,
  0x01, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0x81,
  0x81, 0xC0, 0xC0, 0x70, 0x60, 0x18, 0x30, 0x0C, 0x38, 0x06, 0x18, 0x03,
  0x0C, 0x01, 0x86, 0x01, 0xC3, 0x00, 0xC3, 0x80, 0xE1, 0x80, 0x60, 0xC0,
  0xF0, 0x7F, 0xF0, 0x7F, 0xE0, 0x38, 0xE0, 0x18, 0x30, 0x0C, 0x18, 0x06,
  0x0C, 0x07, 0x07, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x38,
  0x70, 0x1C, 0x30, 0x06, 0x18, 0x03, 0x0C, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x1F, 0xFC, 0x07, 0xDF, 0x01, 0xC0, 0x20, 0x70, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x20, 0x1C, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18,
  0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x30, 0xC0, 0x07,
  0x0C, 0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0x61, 0xC0, 0x0E, 0x18, 0x00,
  0xE1, 0x80, 0x0C, 0x18, 0x00, 0xC3, 0x80, 0x0C, 0x38, 0x01, 0xC3, 0x00,
  0x18, 0x30, 0x01, 0x83, 0x00, 0x18, 0x70, 0x01, 0x86, 0x00, 0x38, 0x60,
  0x03, 0x06, 0x00, 0x30, 0x60, 0x03, 0x0E, 0x00, 0x70, 0xC0, 0x06, 0x0C,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x00, 0xE0, 0xC0, 0x0C, 0x0E, 0x01, 0xC0,
  0x70, 0x38, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xC0, 0x03, 0xE0, 0x01,
  0xB0, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0x63, 0x00, 0x71, 0x80,
  0x30, 0xC0, 0x38, 0x60, 0x18, 0x30, 0x1C, 0x18, 0x0C, 0x0C, 0x06, 0x06,
  0x06, 0x03, 0x03, 0x01, 0x83, 0x80, 0xC1, 0x80, 0x61, 0xC0, 0x30, 0xC0,
  0x18, 0xE0, 0x0C, 0x60, 0x07, 0x70, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0x60, 0x0F, 0x00, 0xEC,
  0x01, 0xE0, 0x19, 0x80, 0x6C, 0x03, 0x30, 0x0D, 0x80, 0xE6, 0x03, 0x30,
  0x18, 0xC0, 0x66, 0x07, 0x18, 0x0C, 0xC0, 0xC3, 0x03, 0x18, 0x18, 0x60,
  0x63, 0x07, 0x0C, 0x18, 0x60, 0xC1, 0x83, 0x0C, 0x38, 0x30, 0xC1, 0x86,
  0x06, 0x18, 0x30, 0xC0, 0xC3, 0x06, 0x30, 0x18, 0xC0, 0xC6, 0x03, 0x18,
  0x19, 0xC0, 0x66, 0x03, 0x30, 0x0C, 0xC0, 0x66, 0x01, 0x98, 0x0D, 0x80,
  0x36, 0x01, 0xB0, 0x06, 0xC0, 0x3C, 0x00, 0xF0, 0x05, 0x80, 0x1E, 0x00,
  0xB0, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x60, 0x00,
  0x01, 0x80, 0x38, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x03, 0x81, 0xC0, 0x0C,
  0x0C, 0x00, 0x60, 0xC0, 0x03, 0x0E, 0x00, 0x18, 0x60, 0x00, 0xE6, 0x00,
  0x03, 0x70, 0x00, 0x1B, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x0C, 0xC0, 0x00,
  0xE6, 0x00, 0x06, 0x30, 0x00, 0x61, 0x80, 0x07, 0x0E, 0x00, 0x30, 0x70,
  0x03, 0x81, 0x80, 0x38, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x80, 0xC0,
  0x1C, 0x0C, 0x00, 0x60, 0x00, 0xC0, 0x0F, 0x80, 0x3B, 0x00, 0x66, 0x01,
  0xCC, 0x03, 0x1C, 0x0E, 0x18, 0x18, 0x30, 0x60, 0x60, 0xC0, 0xC3, 0x01,
  0x8E, 0x03, 0x18, 0x03, 0x70, 0x06, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x10, 0x7F, 0xFC, 0x0F, 0xFF, 0x80, 0x00, 0xFE, 0x01,
  0xFC, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0,
  0x03, 0xFC, 0x07, 0xF8, 0x00, 0xC3, 0x06, 0x18, 0x61, 0x86, 0x18, 0x60,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x18, 0x61, 0x86, 0x18, 0x61, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x36, 0x00, 0x33, 0x00, 0x18, 0xC0,
  0x18, 0x60, 0x0C, 0x38, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x01, 0x87, 0x00,
  0xC3, 0x00, 0x63, 0x00, 0x19, 0x80, 0x0D, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xE3, 0x18, 0x63, 0x0C, 0x01, 0xF1, 0x81, 0xFC, 0xC1, 0xC3, 0xC1,
  0x80, 0xE1, 0xC0, 0x70, 0xC0, 0x38, 0xE0, 0x1C, 0x60, 0x0C, 0x70, 0x06,
  0x38, 0x03, 0x18, 0x03, 0x8C, 0x01, 0x86, 0x00, 0xC7, 0x00, 0x63, 0x80,
  0x71, 0xC0, 0x38, 0xE0, 0x38, 0x70, 0x1C, 0x18, 0x1E, 0x0E, 0x1B, 0x07,
  0xF9, 0x81, 0xF9, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03,
  0x1F, 0x01, 0xBF, 0xC0, 0xF0, 0x60, 0xD0, 0x38, 0x78, 0x0C, 0x38, 0x06,
  0x1C, 0x03, 0x1C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0x63, 0x00, 0x71, 0x80,
  0x31, 0xC0, 0x18, 0xC0, 0x0C, 0x60, 0x0E, 0x30, 0x06, 0x18, 0x07, 0x1C,
  0x03, 0x0F, 0x03, 0x86, 0x83, 0x83, 0x7F, 0x83, 0x1F, 0x80, 0x01, 0xFC,
  0x0F, 0xF0, 0x70, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x08, 0x3F, 0xC0, 0x7F,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x3E,
  0x30, 0x0F, 0xE6, 0x03, 0x87, 0x80, 0xC0, 0x70, 0x38, 0x0E, 0x06, 0x01,
  0xC1, 0xC0, 0x38, 0x30, 0x06, 0x0E, 0x00, 0xC1, 0xC0, 0x18, 0x30, 0x03,
  0x06, 0x00, 0xE0, 0xC0, 0x18, 0x38, 0x03, 0x07, 0x00, 0xE0, 0xE0, 0x1C,
  0x1C, 0x07, 0x83, 0x80, 0xE0, 0x30, 0x3C, 0x07, 0x0D, 0x80, 0xFF, 0x30,
  0x0F, 0xC4, 0x00, 0x01, 0xF8, 0x0F, 0xF0, 0x60, 0xC3, 0x03, 0x1C, 0x0C,
  0x60, 0x33, 0x00, 0xCC, 0x07, 0x70, 0x39, 0x83, 0xC7, 0xFC, 0x1F, 0x80,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x06, 0x00,
  0x1C, 0x08, 0x3F, 0xE0, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00,
  0x01, 0x80, 0x00, 0x18, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x18, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x03, 0x00, 0x00,
  0x30, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0xC0, 0x7F, 0x30, 0x38, 0x68, 0x18, 0x0E, 0x0E, 0x03,
  0x83, 0x00, 0xE1, 0xC0, 0x38, 0x60, 0x0C, 0x38, 0x03, 0x0E, 0x00, 0xC3,
  0x00, 0x30, 0xC0, 0x1C, 0x30, 0x06, 0x1C, 0x01, 0x87, 0x00, 0xE1, 0xC0,
  0x38, 0x70, 0x1E, 0x1C, 0x07, 0x03, 0x03, 0xC0, 0xE1, 0xB0, 0x3F, 0xCC,
  0x07, 0xE6, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x80, 0x60, 0x30, 0x70, 0x0F, 0xF8, 0x00, 0xF8,
  0x00, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x3E, 0x06, 0xFF, 0x07,
  0x83, 0x0D, 0x03, 0x0E, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x1C,
  0x03, 0x18, 0x07, 0x18, 0x06, 0x18, 0x06, 0x38, 0x06, 0x30, 0x06, 0x30,
  0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x70, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60,
  0x18, 0xE0, 0x18, 0x01, 0x81, 0xC0, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06,
  0x03, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x07,
  0x00, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x0F, 0x80, 0x38, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x01, 0xC1, 0x81, 0xC0, 0xC1,
  0xC0, 0xE0, 0xC0, 0x60, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0xE0, 0x0C,
  0xE0, 0x06, 0xE0, 0x03, 0x78, 0x01, 0xEC, 0x01, 0xE6, 0x00, 0xE3, 0x00,
  0x61, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x1C, 0x1C, 0x0C, 0x0E, 0x06, 0x03,
  0x03, 0x01, 0x83, 0x80, 0xE0, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18,
  0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C,
  0x0E, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C,
  0x06, 0x03, 0x03, 0x80, 0x06, 0x7C, 0x1F, 0x01, 0xBF, 0x9F, 0xE0, 0x58,
  0x76, 0x18, 0x34, 0x0F, 0x07, 0x0E, 0x03, 0x81, 0xC3, 0x80, 0xC0, 0x70,
  0xC0, 0x30, 0x18, 0x30, 0x1C, 0x06, 0x1C, 0x06, 0x01, 0x86, 0x01, 0x80,
  0x61, 0x80, 0x60, 0x38, 0x60, 0x38, 0x0C, 0x38, 0x0C, 0x03, 0x0C, 0x03,
  0x00, 0xC3, 0x00, 0xC0, 0x70, 0xC0, 0x30, 0x18, 0x30, 0x1C, 0x06, 0x1C,
  0x06, 0x01, 0x86, 0x01, 0x80, 0x61, 0x80, 0x60, 0x38, 0x60, 0x18, 0x0C,
  0x38, 0x0C, 0x03, 0x00, 0x06, 0x3E, 0x06, 0xFF, 0x05, 0x83, 0x0D, 0x03,
  0x0E, 0x03, 0x0E, 0x03, 0x0C, 0x03, 0x1C, 0x03, 0x1C, 0x03, 0x18, 0x07,
  0x18, 0x06, 0x18, 0x06, 0x38, 0x06, 0x30, 0x0E, 0x30, 0x0E, 0x30, 0x0C,
  0x30, 0x0C, 0x70, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x18, 0xE0, 0x18,
  0x01, 0xF8, 0x03, 0xFC, 0x06, 0x0E, 0x0C, 0x06, 0x1C, 0x06, 0x18, 0x06,
  0x38, 0x07, 0x30, 0x07, 0x70, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x60, 0x06, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0, 0x18, 0x60, 0x18,
  0x60, 0x30, 0x70, 0x70, 0x3F, 0xE0, 0x1F, 0x80, 0x01, 0x8F, 0x80, 0x37,
  0xF8, 0x07, 0xC3, 0x01, 0xA0, 0x70, 0x3C, 0x06, 0x07, 0x00, 0xC0, 0xE0,
  0x18, 0x18, 0x03, 0x07, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x03, 0x83, 0x00,
  0x70, 0xE0, 0x0C, 0x1C, 0x01, 0x83, 0x00, 0x70, 0x60, 0x0C, 0x0C, 0x03,
  0x83, 0x80, 0x60, 0x78, 0x1C, 0x0D, 0x07, 0x01, 0xBF, 0xC0, 0x33, 0xF0,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xF1, 0x81, 0xFC, 0xC1, 0xC3, 0x41, 0x80, 0xE1, 0xC0, 0x70, 0xC0,
  0x38, 0xE0, 0x1C, 0x60, 0x0C, 0x70, 0x06, 0x38, 0x03, 0x18, 0x01, 0x8C,
  0x01, 0xC6, 0x00, 0xC7, 0x00, 0x63, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x3C,
  0x70, 0x1C, 0x18, 0x1E, 0x0E, 0x1B, 0x07, 0xFB, 0x81, 0xF9, 0x80, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80, 0x06, 0x7C, 0x1B, 0xE0,
  0x5C, 0x03, 0x40, 0x0F, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x00, 0x03,
  0xF0, 0x3F, 0xF1, 0xC0, 0x86, 0x00, 0x18, 0x00, 0xE0, 0x01, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x20, 0x30, 0xFF, 0xC3,
  0xFC, 0x00, 0x02, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x07, 0xF7, 0xFC, 0x70,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xE0, 0x3F, 0x07, 0xC0,
  0x0C, 0x03, 0x0C, 0x03, 0x1C, 0x03, 0x18, 0x03, 0x18, 0x06, 0x18, 0x06,
  0x18, 0x06, 0x38, 0x06, 0x30, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C,
  0x70, 0x0C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x18, 0x60, 0x38, 0xE0, 0x38,
  0xE0, 0x58, 0x60, 0xF0, 0x7F, 0xB0, 0x3F, 0x30, 0xC0, 0x0F, 0x00, 0x7E,
  0x01, 0xB8, 0x0E, 0xE0, 0x31, 0x81, 0xC6, 0x06, 0x18, 0x38, 0x60, 0xC1,
  0x87, 0x06, 0x18, 0x18, 0x60, 0x63, 0x01, 0x8C, 0x06, 0x60, 0x19, 0x80,
  0x6C, 0x01, 0xB0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x00, 0xE0,
  0x38, 0x0E, 0xC0, 0x70, 0x19, 0x81, 0xE0, 0x73, 0x03, 0xC0, 0xC6, 0x05,
  0x81, 0x8C, 0x1B, 0x06, 0x18, 0x36, 0x0C, 0x30, 0xCC, 0x38, 0x61, 0x98,
  0x60, 0xC6, 0x30, 0xC1, 0x8C, 0x63, 0x03, 0x18, 0xC6, 0x06, 0x61, 0x98,
  0x0C, 0xC3, 0x30, 0x1B, 0x06, 0x60, 0x36, 0x0D, 0x80, 0x78, 0x1B, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0x80, 0xF0, 0x07, 0x01, 0xC0, 0x0C,
  0x03, 0x80, 0x00, 0x07, 0x01, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x0C, 0x1C,
  0x03, 0x86, 0x00, 0x63, 0x00, 0x19, 0xC0, 0x06, 0x60, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xD8, 0x00, 0x77,
  0x00, 0x18, 0xC0, 0x0C, 0x30, 0x07, 0x0C, 0x01, 0x81, 0x80, 0xC0, 0x60,
  0x70, 0x18, 0x38, 0x07, 0x00, 0x01, 0x80, 0x38, 0x0C, 0x01, 0x80, 0x60,
  0x1C, 0x03, 0x00, 0xC0, 0x18, 0x0E, 0x00, 0xC0, 0x60, 0x06, 0x07, 0x00,
  0x30, 0x30, 0x01, 0x83, 0x80, 0x0C, 0x18, 0x00, 0x61, 0xC0, 0x03, 0x0C,
  0x00, 0x18, 0x60, 0x00, 0xC6, 0x00, 0x03, 0x30, 0x00, 0x1B, 0x00, 0x00,
  0xD8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x70, 0x00,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00,
  0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0xC0, 0x01, 0x80, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0xC0,
  0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x7E, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0x70,
  0x07, 0xC0, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80,
  0x0C, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x18, 0x00, 0x7F, 0x01, 0xE7, 0xC7,
  0x80, 0xFE, 0x80, 0x18,
};

const GFXglyph NotoSans_Condensed_LightItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 9, 29, 9, 1, -29 },
  { 34, 10, 10, 13, 4, -29 },
  { 47, 20, 29, 19, 0, -29 },
  { 120, 17, 33, 17, 0, -31 },
  { 191, 22, 30, 26, 2, -30 },
  { 274, 18, 30, 19, 0, -30 },
  { 342, 4, 10, 7, 4, -29 },
  { 347, 12, 35, 10, 1, -29 },
  { 400, 12, 35, 10, -3, -29 },
  { 453, 13, 14, 16, 5, -31 },
  { 476, 16, 19, 19, 2, -24 },
  { 514, 7, 9, 8, -2, -4 },
  { 522, 9, 2, 11, 1, -12 },
  { 525, 3, 4, 8, 1, -4 },
  { 527, 18, 29, 13, -2, -29 },
  { 593, 16, 30, 17, 1, -30 },
  { 653, 9, 29, 17, 5, -29 },
  { 686, 18, 30, 17, -1, -30 },
  { 754, 17, 30, 17, 0, -30 },
  { 818, 17, 30, 17, 0, -30 },
  { 882, 17, 29, 17, 0, -29 },
  { 944, 17, 30, 17, 1, -30 },
  { 1008, 17, 29, 17, 2, -29 },
  { 1070, 17, 30, 17, 0, -30 },
  { 1134, 17, 30, 17, 0, -30 },
  { 1198, 7, 22, 8, 0, -22 },
  { 1218, 10, 27, 8, -2, -22 },
  { 1252, 16, 18, 19, 2, -24 },
  { 1288, 16, 11, 19, 2, -20 },
  { 1310, 16, 18, 19, 2, -24 },
  { 1346, 13, 30, 13, 1, -30 },
  { 1395, 24, 33, 26, 1, -29 },
  { 1494, 18, 29, 17, -3, -29 },
  { 1560, 18, 29, 19, 1, -29 },
  { 1626, 18, 30, 18, 2, -30 },
  { 1694, 19, 29, 21, 1, -29 },
  { 1763, 17, 29, 17, 1, -29 },
  { 1825, 17, 29, 15, 1, -29 },
  { 1887, 20, 30, 22, 2, -30 },
  { 1962, 21, 29, 22, 1, -29 },
  { 2039, 14, 29, 10, -2, -29 },
  { 2090, 15, 36, 8, -6, -29 },
  { 2158, 20, 29, 18, 1, -29 },
  { 2231, 11, 29, 15, 1, -29 },
  { 2271, 27, 29, 28, 1, -29 },
  { 2369, 22, 29, 22, 1, -29 },
  { 2449, 19, 30, 22, 2, -30 },
  { 2521, 17, 29, 18, 1, -29 },
  { 2583, 19, 37, 22, 2, -30 },
  { 2671, 17, 29, 18, 1, -29 },
  { 2733, 19, 30, 16, -1, -30 },
  { 2805, 16, 29, 15, 3, -29 },
  { 2863, 20, 29, 21, 2, -29 },
  { 2936, 17, 29, 17, 4, -29 },
  { 2998, 27, 29, 28, 4, -29 },
  { 3096, 21, 29, 16, -2, -29 },
  { 3173, 15, 29, 15, 4, -29 },
  { 3228, 19, 29, 16, -1, -29 },
  { 3297, 15, 36, 12, -1, -29 },
  { 3365, 6, 29, 14, 4, -29 },
  { 3387, 15, 36, 12, -3, -29 },
  { 3455, 17, 16, 18, 1, -29 },
  { 3489, 13, 2, 13, -3, 4 },
  { 3493, 5, 6, 10, 6, -31 },
  { 3497, 17, 22, 18, 1, -22 },
  { 3544, 17, 31, 18, 0, -31 },
  { 3610, 14, 22, 14, 1, -22 },
  { 3649, 19, 31, 19, 1, -31 },
  { 3723, 14, 22, 16, 1, -22 },
  { 3762, 20, 41, 10, -5, -31 },
  { 3865, 18, 32, 19, 0, -22 },
  { 3937, 16, 31, 18, 0, -31 },
  { 3999, 9, 30, 8, 0, -30 },
  { 4033, 14, 40, 8, -5, -30 },
  { 4103, 17, 31, 15, 0, -31 },
  { 4169, 9, 31, 8, 0, -31 },
  { 4204, 26, 22, 27, 0, -22 },
  { 4276, 16, 22, 18, 0, -22 },
  { 4320, 16, 22, 18, 1, -22 },
  { 4364, 19, 32, 18, -2, -22 },
  { 4440, 17, 32, 19, 1, -22 },
  { 4508, 14, 22, 12, 0, -22 },
  { 4547, 14, 22, 14, 0, -22 },
  { 4586, 10, 27, 10, 1, -27 },
  { 4620, 16, 22, 18, 1, -22 },
  { 4664, 14, 22, 14, 2, -22 },
  { 4703, 23, 22, 23, 2, -22 },
  { 4767, 18, 22, 15, -2, -22 },
  { 4817, 21, 32, 14, -4, -22 },
  { 4901, 15, 22, 13, -1, -22 },
  { 4943, 15, 35, 13, 1, -29 },
  { 5009, 2, 41, 17, 8, -31 },
  { 5020, 14, 35, 13, -2, -29 },
  { 5082, 16, 5, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_LightItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC41PT7B_H_
