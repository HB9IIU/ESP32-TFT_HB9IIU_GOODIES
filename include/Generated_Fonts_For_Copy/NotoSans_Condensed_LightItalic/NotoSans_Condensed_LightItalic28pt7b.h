#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC28PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x83,
  0x04, 0x08, 0x00, 0x00, 0x81, 0x86, 0x00, 0x66, 0x89, 0x16, 0x6C, 0xD1,
  0x22, 0x00, 0x01, 0x18, 0x04, 0x40, 0x31, 0x00, 0x8C, 0x02, 0x20, 0x18,
  0x93, 0xFF, 0x81, 0x18, 0x0C, 0x40, 0x21, 0x00, 0x8C, 0x06, 0x20, 0xFF,
  0xF3, 0xFF, 0xC1, 0x10, 0x0C, 0x40, 0x23, 0x00, 0x88, 0x06, 0x20, 0x11,
  0x80, 0x00, 0x80, 0x08, 0x03, 0xE0, 0xF7, 0x19, 0x01, 0x10, 0x11, 0x01,
  0x20, 0x1A, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x05, 0x80, 0x4C, 0x04, 0xC0,
  0x4C, 0x04, 0xC8, 0x98, 0xFF, 0x03, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x00,
  0x3C, 0x08, 0x90, 0x64, 0x61, 0x11, 0x88, 0xC6, 0x22, 0x11, 0x08, 0x4C,
  0x21, 0x20, 0x8D, 0xBE, 0x25, 0x99, 0xA4, 0x7D, 0xB1, 0x04, 0x84, 0x32,
  0x10, 0x88, 0x46, 0x23, 0x11, 0x88, 0x86, 0x26, 0x09, 0x90, 0x3C, 0x03,
  0xC0, 0x66, 0x0C, 0x60, 0xC6, 0x08, 0x60, 0x84, 0x0C, 0xC0, 0xD8, 0x07,
  0x00, 0xE0, 0x1E, 0x03, 0x21, 0x63, 0x34, 0x12, 0xC1, 0xEC, 0x0C, 0xC0,
  0xCC, 0x1C, 0x63, 0x47, 0xE6, 0x69, 0x6D, 0x20, 0x02, 0x06, 0x0C, 0x08,
  0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x06, 0x02, 0x02, 0x03,
  0x03, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x03, 0x03, 0x02, 0x02, 0x06,
  0x06, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x20, 0xC0, 0x04, 0x06, 0x32, 0x0D,
  0x11, 0xF8, 0xC0, 0x90, 0x8C, 0x42, 0x00, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x41, 0xFF, 0xFF, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x33, 0x26, 0x4C, 0x80, 0xFC, 0x4F, 0x00, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x08, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00, 0x40,
  0x08, 0x00, 0x07, 0x81, 0x98, 0x61, 0x08, 0x33, 0x06, 0x40, 0xD8, 0x1B,
  0x02, 0x40, 0x48, 0x0B, 0x03, 0x60, 0x6C, 0x0D, 0x01, 0x20, 0x64, 0x08,
  0x83, 0x18, 0x41, 0x18, 0x3E, 0x00, 0x06, 0x38, 0xD7, 0x24, 0xC1, 0x82,
  0x04, 0x18, 0x30, 0x60, 0x81, 0x06, 0x0C, 0x18, 0x20, 0x41, 0x83, 0x00,
  0x03, 0xE0, 0x71, 0x80, 0x04, 0x00, 0x30, 0x01, 0x80, 0x08, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x02, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x01, 0x00, 0x10, 0x01, 0x00, 0x18, 0x01, 0xFF, 0x80, 0x0F, 0xC1, 0xC6,
  0x10, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x04, 0x01, 0x80, 0xF0,
  0x03, 0x80, 0x08, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x83, 0x0F, 0xE0, 0x00, 0x70, 0x06, 0x00, 0xA0, 0x1E, 0x01, 0x60, 0x24,
  0x06, 0x40, 0x44, 0x08, 0xC1, 0x8C, 0x30, 0x82, 0x08, 0x61, 0x8C, 0x18,
  0xFF, 0xE0, 0x10, 0x01, 0x00, 0x30, 0x03, 0x00, 0x20, 0x07, 0xF0, 0xC0,
  0x08, 0x00, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x3F, 0x01, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0x80, 0x18,
  0x83, 0x0F, 0xE0, 0x03, 0xE0, 0xC0, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x5F, 0x0E, 0x33, 0x83, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x26,
  0x0C, 0xC1, 0x98, 0x61, 0x9C, 0x1E, 0x00, 0x3F, 0xF0, 0x02, 0x00, 0x60,
  0x04, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x10, 0x03, 0x00, 0x20, 0x06, 0x00,
  0x40, 0x0C, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30, 0x02, 0x00, 0x60, 0x0C,
  0x00, 0x07, 0xE0, 0xC6, 0x18, 0x31, 0x83, 0x18, 0x31, 0x83, 0x18, 0x20,
  0x84, 0x0D, 0x80, 0x70, 0x1F, 0x03, 0x18, 0x60, 0xC4, 0x0C, 0xC0, 0x4C,
  0x04, 0xC0, 0xCC, 0x0C, 0x61, 0x83, 0xF0, 0x07, 0xC1, 0x8C, 0x60, 0x88,
  0x13, 0x02, 0x60, 0x48, 0x09, 0x01, 0x20, 0x66, 0x0C, 0xC3, 0x8F, 0xB0,
  0x04, 0x01, 0x80, 0x20, 0x04, 0x01, 0x00, 0x62, 0x18, 0x7E, 0x00, 0x18,
  0xC4, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x63, 0x00, 0x0C, 0x30, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x86, 0x18, 0x42, 0x08, 0x00,
  0x00, 0x20, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x10, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0x60, 0x00, 0x3F, 0x11, 0x80, 0x60,
  0x30, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x04, 0x04, 0x06, 0x02, 0x03, 0x01,
  0x00, 0x00, 0x00, 0x20, 0x30, 0x18, 0x00, 0x00, 0xF8, 0x03, 0x0E, 0x04,
  0x02, 0x08, 0x03, 0x10, 0x01, 0x30, 0x01, 0x21, 0xF1, 0x63, 0x11, 0x42,
  0x31, 0x44, 0x21, 0xC4, 0x21, 0xCC, 0x23, 0x8C, 0x62, 0x88, 0x42, 0x88,
  0xC4, 0x8D, 0xAC, 0x87, 0x38, 0x80, 0x00, 0xC0, 0x00, 0x40, 0x00, 0x20,
  0x40, 0x1F, 0xC0, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0A, 0x01, 0xA0, 0x12,
  0x03, 0x30, 0x23, 0x02, 0x30, 0x63, 0x04, 0x30, 0xC3, 0x0F, 0xF1, 0x83,
  0x10, 0x33, 0x03, 0x30, 0x36, 0x03, 0x60, 0x3C, 0x01, 0x07, 0xE0, 0x63,
  0x83, 0x06, 0x10, 0x30, 0x81, 0x8C, 0x0C, 0x60, 0x43, 0x06, 0x10, 0x60,
  0xFC, 0x0C, 0x30, 0x60, 0xC3, 0x02, 0x10, 0x10, 0x80, 0x8C, 0x0C, 0x60,
  0x62, 0x06, 0x10, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x38, 0x83, 0x00, 0x30,
  0x01, 0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0x02, 0x00, 0x10, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x08, 0x00, 0x40, 0x03, 0x00, 0x0C,
  0x20, 0x3F, 0x00, 0x07, 0xC0, 0x33, 0xC0, 0xC1, 0x82, 0x06, 0x08, 0x08,
  0x60, 0x31, 0x80, 0xC6, 0x03, 0x10, 0x0C, 0x40, 0x23, 0x00, 0x8C, 0x06,
  0x30, 0x18, 0x80, 0x42, 0x03, 0x18, 0x18, 0x60, 0x61, 0x07, 0x04, 0x78,
  0x3F, 0x80, 0x07, 0xF0, 0xC0, 0x0C, 0x00, 0x80, 0x08, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x10, 0x01, 0xFC, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0F, 0xF0, 0x07, 0xF0, 0xC0, 0x0C,
  0x00, 0x80, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x01, 0x00, 0x3F,
  0xC3, 0x00, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x01, 0xFC, 0x1C, 0x30, 0xC0, 0x06, 0x00, 0x10, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x0F, 0xB0, 0x04, 0xC0,
  0x13, 0x00, 0xCC, 0x03, 0x10, 0x08, 0x40, 0x21, 0x80, 0x83, 0x06, 0x07,
  0xF0, 0x04, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x40, 0x20, 0x80, 0x43, 0x01,
  0x86, 0x03, 0x0C, 0x06, 0x10, 0x08, 0x3F, 0xF0, 0xC0, 0x61, 0x80, 0xC3,
  0x01, 0x04, 0x02, 0x08, 0x0C, 0x30, 0x18, 0x60, 0x30, 0x80, 0x41, 0x00,
  0x86, 0x03, 0x00, 0x0F, 0x81, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x18,
  0x0C, 0x06, 0x02, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10, 0x18, 0x0C,
  0x1F, 0x00, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x10, 0x0C, 0x03, 0x00, 0x82, 0xE0, 0xF0, 0x00, 0x04, 0x0C,
  0x30, 0x60, 0xC3, 0x02, 0x08, 0x08, 0x60, 0x63, 0x01, 0x98, 0x06, 0xC0,
  0x16, 0x00, 0x58, 0x03, 0xA0, 0x0C, 0xC0, 0x33, 0x00, 0x84, 0x02, 0x18,
  0x18, 0x60, 0x60, 0x81, 0x03, 0x04, 0x0C, 0x30, 0x30, 0x04, 0x0C, 0x0C,
  0x08, 0x08, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0x30, 0x30, 0x20, 0x20,
  0x60, 0x60, 0x40, 0x40, 0xFF, 0x06, 0x00, 0x61, 0xC0, 0x1C, 0x38, 0x03,
  0x85, 0x00, 0xF0, 0xA0, 0x14, 0x34, 0x06, 0x86, 0x80, 0xB0, 0xD0, 0x36,
  0x12, 0x04, 0xC2, 0x61, 0x90, 0xCC, 0x22, 0x19, 0x8C, 0xC2, 0x31, 0x18,
  0x46, 0x63, 0x08, 0x48, 0x43, 0x0B, 0x08, 0x61, 0x43, 0x08, 0x38, 0x61,
  0x06, 0x08, 0x60, 0xC1, 0x00, 0x04, 0x03, 0x0E, 0x02, 0x0E, 0x02, 0x0A,
  0x06, 0x0A, 0x06, 0x1B, 0x06, 0x1B, 0x04, 0x19, 0x04, 0x11, 0x0C, 0x11,
  0x8C, 0x31, 0x88, 0x30, 0x88, 0x20, 0x88, 0x20, 0xD8, 0x20, 0xD8, 0x60,
  0x50, 0x60, 0x50, 0x40, 0x70, 0x40, 0x70, 0xC0, 0x30, 0x03, 0xF0, 0x18,
  0xE0, 0xC1, 0x86, 0x02, 0x30, 0x0C, 0xC0, 0x32, 0x00, 0xD8, 0x03, 0x60,
  0x09, 0x00, 0x24, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0x4C, 0x03, 0x30,
  0x08, 0x40, 0x61, 0x83, 0x07, 0x18, 0x0F, 0xC0, 0x07, 0xC0, 0xCF, 0x0C,
  0x30, 0x81, 0x08, 0x11, 0x81, 0x18, 0x11, 0x83, 0x10, 0x31, 0x06, 0x3F,
  0xC3, 0xF0, 0x30, 0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0x03, 0xF0, 0x18, 0xE0, 0xC1, 0x86, 0x02, 0x30, 0x0C, 0xC0,
  0x32, 0x00, 0xD8, 0x03, 0x60, 0x09, 0x00, 0x24, 0x01, 0xB0, 0x06, 0xC0,
  0x1B, 0x00, 0x4C, 0x03, 0x30, 0x08, 0x40, 0x61, 0x83, 0x07, 0x18, 0x0F,
  0xC0, 0x02, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x07, 0xC0,
  0xCF, 0x0C, 0x30, 0x81, 0x08, 0x11, 0x81, 0x18, 0x11, 0x83, 0x10, 0x21,
  0x0E, 0x3F, 0x83, 0x30, 0x31, 0x02, 0x10, 0x21, 0x86, 0x18, 0x60, 0x84,
  0x08, 0x40, 0xCC, 0x0C, 0x07, 0xF0, 0xC3, 0x18, 0x01, 0x00, 0x30, 0x03,
  0x00, 0x10, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x08, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x18, 0x83, 0x0F, 0xE0, 0x7F, 0xF0,
  0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0x40, 0x18, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x20, 0x00, 0x18, 0x0C, 0x60, 0x31, 0x00, 0x84, 0x02, 0x10, 0x08, 0xC0,
  0x63, 0x01, 0x88, 0x04, 0x20, 0x11, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x40,
  0x21, 0x00, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x43, 0x03, 0x06, 0x18, 0x0F,
  0xC0, 0xC0, 0x34, 0x03, 0x40, 0x64, 0x06, 0x40, 0xC4, 0x0C, 0x40, 0x84,
  0x18, 0x41, 0x04, 0x30, 0x42, 0x04, 0x60, 0x44, 0x04, 0xC0, 0x4C, 0x04,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x06, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x38,
  0x1C, 0x0A, 0x07, 0x06, 0x83, 0xC1, 0xA0, 0xB0, 0x48, 0x2C, 0x32, 0x1B,
  0x08, 0x84, 0xC6, 0x23, 0x31, 0x88, 0x8C, 0x42, 0x23, 0x30, 0x98, 0xC8,
  0x24, 0x36, 0x0B, 0x0D, 0x02, 0x83, 0xC0, 0xE0, 0xF0, 0x30, 0x38, 0x0C,
  0x0E, 0x03, 0x03, 0x00, 0x06, 0x06, 0x0C, 0x18, 0x08, 0x20, 0x10, 0xC0,
  0x33, 0x00, 0x64, 0x00, 0x58, 0x00, 0xA0, 0x01, 0xC0, 0x03, 0x00, 0x0E,
  0x00, 0x14, 0x00, 0x68, 0x00, 0x98, 0x03, 0x30, 0x0C, 0x60, 0x10, 0x40,
  0x60, 0x81, 0x81, 0x86, 0x03, 0x00, 0xC0, 0x68, 0x19, 0x03, 0x20, 0xC6,
  0x10, 0xC6, 0x18, 0x81, 0x30, 0x2C, 0x05, 0x00, 0xE0, 0x18, 0x03, 0x00,
  0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x00, 0x07, 0xF8,
  0x40, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x06, 0x00,
  0x20, 0x03, 0x00, 0x10, 0x11, 0xFF, 0x00, 0x03, 0xE0, 0xC0, 0x18, 0x02,
  0x00, 0x40, 0x08, 0x03, 0x00, 0x60, 0x08, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x00, 0x20, 0x04, 0x01, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x06, 0x00,
  0xC0, 0x10, 0x07, 0xE0, 0x88, 0xCC, 0x44, 0x44, 0x46, 0x62, 0x22, 0x22,
  0x33, 0x11, 0x07, 0xC0, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06,
  0x01, 0x80, 0x40, 0x10, 0x04, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x02, 0x01,
  0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0xC3, 0xE0, 0x02, 0x00, 0xE0, 0x3C,
  0x04, 0x81, 0x98, 0x21, 0x0C, 0x21, 0x06, 0x60, 0x58, 0x0E, 0x01, 0x80,
  0xFF, 0x80, 0xC8, 0x90, 0x0F, 0x23, 0x14, 0xC3, 0x90, 0x36, 0x04, 0x81,
  0xB0, 0x36, 0x06, 0xC0, 0x98, 0x12, 0x06, 0x60, 0xCC, 0x39, 0x8A, 0x1E,
  0x40, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x1B, 0xC1,
  0xE6, 0x1C, 0x21, 0x83, 0x10, 0x33, 0x03, 0x30, 0x22, 0x02, 0x20, 0x26,
  0x06, 0x60, 0x46, 0x0C, 0x60, 0x87, 0x18, 0xDF, 0x00, 0x0F, 0x8C, 0x4C,
  0x04, 0x06, 0x02, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x20, 0x18, 0x0C, 0x03,
  0x11, 0xF8, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10,
  0x3C, 0x83, 0x14, 0x30, 0xE1, 0x03, 0x18, 0x10, 0x80, 0x8C, 0x0C, 0x60,
  0x63, 0x03, 0x18, 0x10, 0x81, 0x84, 0x0C, 0x30, 0xE1, 0x8A, 0x07, 0x90,
  0x00, 0x0F, 0x86, 0x63, 0x0C, 0x82, 0x60, 0x90, 0x6C, 0x73, 0xF0, 0xC0,
  0x20, 0x08, 0x03, 0x00, 0xC0, 0x18, 0x87, 0xE0, 0x00, 0x3C, 0x01, 0x80,
  0x04, 0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x3F, 0x00, 0x60, 0x01, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x40, 0x03, 0x00, 0x0C, 0x00, 0x20, 0x00, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x00, 0x04, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x08, 0x00, 0x60, 0x0F, 0x00, 0x38, 0x00, 0x07, 0x90, 0xC5,
  0x18, 0x71, 0x03, 0x30, 0x22, 0x02, 0x20, 0x66, 0x06, 0x60, 0x66, 0x04,
  0x40, 0xC6, 0x0C, 0x61, 0xC6, 0x28, 0x3C, 0x80, 0x08, 0x01, 0x80, 0x18,
  0x03, 0x08, 0x30, 0xFE, 0x07, 0x80, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x80, 0x10, 0x06, 0xF0, 0xF3, 0x18, 0x23, 0x04, 0x40, 0x98, 0x33, 0x06,
  0x40, 0x88, 0x13, 0x06, 0x60, 0xCC, 0x19, 0x02, 0x20, 0x4C, 0x18, 0x0C,
  0x30, 0x00, 0x00, 0x61, 0x84, 0x10, 0x43, 0x0C, 0x20, 0x86, 0x18, 0x61,
  0x04, 0x30, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x60, 0x18, 0x06,
  0x01, 0x00, 0x40, 0x30, 0x0C, 0x02, 0x00, 0x80, 0x20, 0x18, 0x06, 0x01,
  0x00, 0x40, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x18, 0x3C, 0x0E, 0x00,
  0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x18, 0xC2, 0x10,
  0x82, 0x30, 0x4C, 0x1B, 0x03, 0xC0, 0x5C, 0x0D, 0x83, 0x10, 0x62, 0x0C,
  0x61, 0x0C, 0x20, 0x8C, 0x18, 0x04, 0x30, 0xC3, 0x08, 0x21, 0x86, 0x10,
  0x41, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x84, 0x10, 0xC0, 0x1B, 0xC7, 0x85,
  0xBE, 0x61, 0x87, 0x0C, 0x61, 0x82, 0x10, 0x60, 0x8C, 0x18, 0x23, 0x04,
  0x18, 0x81, 0x06, 0x20, 0xC1, 0x18, 0x30, 0x46, 0x08, 0x11, 0x82, 0x0C,
  0x41, 0x83, 0x10, 0x60, 0x8C, 0x18, 0x20, 0x1B, 0xC2, 0xCC, 0x60, 0x8C,
  0x13, 0x02, 0x60, 0xCC, 0x19, 0x02, 0x20, 0x4C, 0x19, 0x83, 0x30, 0x64,
  0x08, 0x81, 0x30, 0x60, 0x0F, 0x86, 0x73, 0x0C, 0x81, 0x60, 0x50, 0x1C,
  0x07, 0x03, 0xC0, 0xF0, 0x38, 0x0B, 0x06, 0xC3, 0x19, 0x87, 0xC0, 0x0D,
  0xE0, 0x59, 0x82, 0x84, 0x18, 0x30, 0x81, 0x8C, 0x0C, 0x60, 0x62, 0x02,
  0x10, 0x11, 0x81, 0x8C, 0x08, 0x60, 0xC3, 0x04, 0x14, 0x61, 0xBE, 0x0C,
  0x00, 0x60, 0x02, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x00, 0x0F,
  0x23, 0x14, 0xC3, 0x90, 0x36, 0x04, 0x80, 0xB0, 0x36, 0x06, 0xC0, 0xD8,
  0x12, 0x06, 0x40, 0xCC, 0x39, 0x8A, 0x1E, 0x40, 0x08, 0x03, 0x00, 0x60,
  0x08, 0x01, 0x00, 0x60, 0x0C, 0x00, 0x1B, 0x8B, 0x47, 0x03, 0x01, 0x01,
  0x80, 0xC0, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x00, 0x1F,
  0x98, 0x48, 0x04, 0x02, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x00, 0xC0,
  0x60, 0x24, 0x33, 0xF0, 0x18, 0x20, 0x43, 0xF3, 0x04, 0x08, 0x30, 0x60,
  0xC1, 0x02, 0x0C, 0x18, 0x20, 0x40, 0xC1, 0xE0, 0x30, 0x66, 0x0C, 0x81,
  0x10, 0x26, 0x0C, 0xC1, 0x98, 0x32, 0x04, 0x40, 0x98, 0x33, 0x06, 0x60,
  0x88, 0x31, 0x8A, 0x1E, 0x40, 0x81, 0xC0, 0xA0, 0xD0, 0x48, 0x64, 0x22,
  0x31, 0x18, 0x88, 0x4C, 0x24, 0x16, 0x0A, 0x07, 0x03, 0x00, 0x83, 0x07,
  0x06, 0x0A, 0x1C, 0x34, 0x28, 0x48, 0x51, 0x91, 0xA3, 0x22, 0x44, 0x4C,
  0x98, 0x91, 0x21, 0x62, 0xC2, 0x85, 0x05, 0x0A, 0x0E, 0x1C, 0x18, 0x30,
  0x30, 0x60, 0x00, 0x18, 0x30, 0x86, 0x08, 0x40, 0xCC, 0x0D, 0x80, 0x50,
  0x07, 0x00, 0x60, 0x0E, 0x00, 0xA0, 0x1B, 0x03, 0x10, 0x21, 0x06, 0x18,
  0xC1, 0x80, 0x04, 0x04, 0x10, 0x30, 0x40, 0x81, 0x06, 0x06, 0x10, 0x18,
  0xC0, 0x62, 0x01, 0x98, 0x06, 0x40, 0x1B, 0x00, 0x68, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x00, 0xF0, 0x03, 0x80, 0x00, 0x0F, 0xC4, 0x30, 0x08, 0x06, 0x03, 0x00,
  0x80, 0x60, 0x30, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x0F, 0xF0,
  0x01, 0xC1, 0xC0, 0x60, 0x10, 0x0C, 0x03, 0x00, 0x80, 0x20, 0x08, 0x06,
  0x01, 0x03, 0xC0, 0xE0, 0x08, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01,
  0x80, 0x40, 0x10, 0x06, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x00, 0xE0, 0x08, 0x02, 0x01, 0x80, 0x60, 0x18, 0x04, 0x01,
  0x00, 0xC0, 0x30, 0x07, 0x01, 0xC0, 0xC0, 0x60, 0x18, 0x04, 0x01, 0x00,
  0x40, 0x30, 0x0C, 0x02, 0x01, 0x83, 0xC0, 0x7C, 0x30, 0xFE, 0x02, 0x00,
};

const GFXglyph NotoSans_Condensed_LightItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 7, 20, 6, 0, -20 },
  { 19, 7, 7, 9, 3, -20 },
  { 26, 14, 20, 13, 0, -20 },
  { 61, 12, 23, 12, 0, -21 },
  { 96, 14, 20, 18, 2, -20 },
  { 131, 12, 20, 13, 0, -20 },
  { 161, 3, 7, 5, 3, -20 },
  { 164, 8, 24, 7, 1, -20 },
  { 188, 8, 24, 7, -2, -20 },
  { 212, 9, 9, 11, 3, -21 },
  { 223, 11, 13, 13, 1, -16 },
  { 241, 4, 7, 5, -1, -3 },
  { 245, 6, 1, 8, 1, -8 },
  { 246, 3, 3, 5, 0, -3 },
  { 248, 12, 20, 9, -1, -20 },
  { 278, 11, 20, 12, 1, -20 },
  { 306, 7, 20, 12, 3, -20 },
  { 324, 13, 20, 12, -1, -20 },
  { 357, 12, 20, 12, 0, -20 },
  { 387, 12, 20, 12, 0, -20 },
  { 417, 12, 20, 12, 0, -20 },
  { 447, 11, 20, 12, 1, -20 },
  { 475, 12, 20, 12, 1, -20 },
  { 505, 12, 20, 12, 0, -20 },
  { 535, 11, 20, 12, 0, -20 },
  { 563, 5, 15, 5, 0, -15 },
  { 573, 6, 19, 5, -1, -15 },
  { 588, 11, 12, 13, 1, -16 },
  { 605, 11, 7, 13, 1, -13 },
  { 615, 11, 12, 13, 1, -16 },
  { 632, 9, 20, 9, 1, -20 },
  { 655, 16, 22, 18, 1, -20 },
  { 699, 12, 20, 12, -2, -20 },
  { 729, 13, 20, 13, 0, -20 },
  { 762, 13, 20, 12, 1, -20 },
  { 795, 14, 20, 14, 0, -20 },
  { 830, 12, 20, 11, 0, -20 },
  { 860, 12, 20, 11, 0, -20 },
  { 890, 14, 20, 15, 1, -20 },
  { 925, 15, 20, 15, 0, -20 },
  { 963, 9, 20, 7, -1, -20 },
  { 986, 10, 25, 6, -4, -20 },
  { 1018, 14, 20, 12, 0, -20 },
  { 1053, 8, 20, 10, 0, -20 },
  { 1073, 19, 20, 19, 0, -20 },
  { 1121, 16, 20, 15, 0, -20 },
  { 1161, 14, 20, 15, 1, -20 },
  { 1196, 12, 20, 12, 0, -20 },
  { 1226, 14, 25, 15, 1, -20 },
  { 1270, 12, 20, 12, 0, -20 },
  { 1300, 12, 20, 11, 0, -20 },
  { 1330, 11, 20, 10, 2, -20 },
  { 1358, 14, 20, 15, 1, -20 },
  { 1393, 12, 20, 12, 2, -20 },
  { 1423, 18, 20, 19, 3, -20 },
  { 1468, 15, 20, 11, -2, -20 },
  { 1506, 11, 20, 11, 2, -20 },
  { 1534, 13, 20, 11, -1, -20 },
  { 1567, 11, 24, 8, -1, -20 },
  { 1600, 4, 20, 9, 3, -20 },
  { 1610, 10, 24, 8, -2, -20 },
  { 1640, 11, 11, 12, 1, -20 },
  { 1656, 9, 1, 9, -2, 3 },
  { 1658, 3, 4, 7, 4, -21 },
  { 1660, 11, 15, 13, 1, -15 },
  { 1681, 12, 21, 13, 0, -21 },
  { 1713, 9, 15, 10, 1, -15 },
  { 1730, 13, 21, 13, 1, -21 },
  { 1765, 10, 15, 11, 1, -15 },
  { 1784, 14, 28, 7, -4, -21 },
  { 1833, 12, 22, 13, 0, -15 },
  { 1866, 11, 21, 12, 0, -21 },
  { 1895, 6, 20, 5, 0, -20 },
  { 1910, 10, 27, 5, -4, -20 },
  { 1944, 11, 21, 10, 0, -21 },
  { 1973, 6, 21, 5, 0, -21 },
  { 1989, 18, 15, 19, 0, -15 },
  { 2023, 11, 15, 12, 0, -15 },
  { 2044, 10, 15, 12, 1, -15 },
  { 2063, 13, 22, 13, -1, -15 },
  { 2099, 11, 22, 13, 1, -15 },
  { 2130, 9, 15, 8, 0, -15 },
  { 2147, 9, 15, 9, 0, -15 },
  { 2164, 7, 18, 7, 1, -18 },
  { 2180, 11, 15, 12, 1, -15 },
  { 2201, 9, 15, 10, 2, -15 },
  { 2218, 15, 15, 16, 2, -15 },
  { 2247, 12, 15, 10, -1, -15 },
  { 2270, 14, 22, 10, -3, -15 },
  { 2309, 10, 15, 9, -1, -15 },
  { 2328, 10, 24, 9, 1, -20 },
  { 2358, 2, 28, 12, 5, -21 },
  { 2365, 10, 24, 9, -2, -20 },
  { 2395, 11, 3, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_LightItalic28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC28PT7B_H_
