#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC72PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1F, 0x07, 0xC7, 0x81, 0xE1,
  0xE0, 0x78, 0x78, 0x1E, 0x1C, 0x07, 0x8F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0,
  0x3C, 0x38, 0x0F, 0x0E, 0x03, 0x83, 0x80, 0xE1, 0xE0, 0x78, 0x70, 0x1E,
  0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x60, 0x1C, 0x38, 0x0E, 0x00,
  0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x70,
  0x07, 0x00, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00,
  0x1E, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x3C, 0x00,
  0x00, 0xF0, 0x0E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x00, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xC3, 0x07, 0x80, 0x3E, 0x1C, 0x04, 0x01, 0xF0,
  0x70, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x1C, 0x06, 0x00, 0x00, 0xF0, 0x18,
  0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0xF0, 0x30, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x0F, 0x07, 0x00, 0x00,
  0x1E, 0x1C, 0x00, 0x00, 0x7C, 0x70, 0x00, 0x00, 0xF9, 0x80, 0x00, 0x03,
  0xF6, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0x7C, 0x00, 0x00, 0x18, 0xF8, 0x00, 0x00, 0x61, 0xE0,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x38, 0x1C, 0x00,
  0x00, 0xC0, 0x70, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x70, 0x1C, 0x00, 0x01, 0x80, 0xF0, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0xE0, 0x78, 0x08, 0x03, 0x87, 0xC0, 0x3C, 0x0C, 0x3E,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x10,
  0x03, 0xFC, 0x00, 0x03, 0x80, 0x1F, 0xF8, 0x00, 0x1E, 0x00, 0xF0, 0xE0,
  0x00, 0x70, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0x1C, 0x07, 0x00, 0x0E, 0x00,
  0xE0, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x78, 0x01, 0xE0, 0x0F, 0x01,
  0xC0, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0x70,
  0x03, 0x81, 0xE0, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x07, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0x07, 0x07, 0x00, 0x03, 0xC0,
  0x1C, 0x3C, 0x1F, 0xCE, 0x00, 0xF0, 0xE1, 0xFF, 0xB8, 0x03, 0x87, 0x87,
  0xFE, 0xE0, 0x1E, 0x1C, 0x3C, 0x3F, 0xC0, 0x70, 0xE1, 0xE0, 0x7F, 0x03,
  0xC7, 0x87, 0x01, 0xDC, 0x1E, 0x1C, 0x38, 0x07, 0x78, 0xF8, 0xF0, 0xE0,
  0x1D, 0xFF, 0xC3, 0x87, 0x80, 0x73, 0xFE, 0x1E, 0x1C, 0x01, 0xC7, 0xE0,
  0x70, 0xF0, 0x07, 0x00, 0x03, 0x83, 0x80, 0x1C, 0x00, 0x1E, 0x0E, 0x00,
  0x70, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x03, 0xC1, 0xE0, 0x0F, 0x00, 0x0E,
  0x07, 0x00, 0x3C, 0x00, 0x78, 0x1C, 0x00, 0xE0, 0x03, 0xC0, 0x70, 0x03,
  0x80, 0x0E, 0x01, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x00, 0x78, 0x01, 0xC0,
  0x3C, 0x01, 0xC0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x38, 0x00,
  0xF0, 0x1C, 0x01, 0xE0, 0x01, 0xC0, 0xF0, 0x07, 0x00, 0x07, 0x07, 0x80,
  0x3C, 0x00, 0x1F, 0x7C, 0x00, 0xE0, 0x00, 0x3F, 0xF0, 0x07, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x0F, 0x81, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x1E, 0x3E, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x81, 0xE0, 0x0E, 0x0F,
  0x00, 0xF0, 0x1E, 0x1F, 0x00, 0xF0, 0x1E, 0x1E, 0x00, 0xF8, 0x3C, 0x3C,
  0x00, 0x78, 0x3C, 0x3C, 0x00, 0x78, 0x38, 0x78, 0x00, 0x3C, 0x78, 0x78,
  0x00, 0x3C, 0xF0, 0x78, 0x00, 0x1E, 0xF0, 0x78, 0x00, 0x1F, 0xE0, 0x70,
  0x00, 0x1F, 0xE0, 0xF0, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0x0F, 0x80, 0xF0,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x1F, 0x80, 0x78, 0x00, 0x3F, 0xC0, 0x78,
  0x00, 0x7F, 0xC0, 0x7C, 0x00, 0xFB, 0xE0, 0x3E, 0x03, 0xF1, 0xE0, 0x3F,
  0xFF, 0xC1, 0xE0, 0x1F, 0xFF, 0x80, 0xF0, 0x07, 0xFF, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x78, 0x78, 0x70, 0x70, 0x70, 0x70, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x10, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xFC, 0x18,
  0x00, 0xFE, 0x30, 0x00, 0x7E, 0xE0, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xCE, 0x00,
  0x1F, 0x1C, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0x38, 0x07, 0xC0, 0x78, 0x07,
  0x00, 0x70, 0x04, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x01,
  0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03,
  0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7D, 0xFF, 0xFF, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFC, 0xFC, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x1E, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E,
  0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x3C, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x70,
  0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x07, 0x00, 0x07, 0x80, 0x78, 0x00,
  0xF0, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00,
  0x3E, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0xFE, 0x03, 0xFE, 0x07, 0xDE, 0x0F, 0x9E, 0x3F, 0x1E, 0x7C, 0x3C,
  0xF8, 0x3C, 0x70, 0x3C, 0x60, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x3E,
  0x00, 0x08, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0,
  0x07, 0x00, 0x0F, 0x80, 0x04, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x60, 0x00, 0x3E, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x70, 0x78, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x03,
  0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0, 0x00,
  0x70, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xDF, 0xE0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFC, 0x7F, 0x80, 0x01, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x08, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x87, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x0F, 0xC0, 0x03, 0xC3, 0xFF, 0x00,
  0x3C, 0xFF, 0xFC, 0x03, 0xDF, 0xFF, 0xC0, 0x7B, 0xC0, 0x3E, 0x07, 0xB8,
  0x01, 0xE0, 0x7F, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1F, 0x0E,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0,
  0x0F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C,
  0x07, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x1F, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0xC0, 0x3C, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x3C, 0x1C,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x7E, 0x0F,
  0x00, 0x03, 0xE0, 0x78, 0x00, 0x3F, 0x01, 0xE0, 0x03, 0xF8, 0x0F, 0x80,
  0x3B, 0xC0, 0x7E, 0x07, 0xDE, 0x01, 0xFF, 0xFC, 0xE0, 0x07, 0xFF, 0x8F,
  0x00, 0x1F, 0xF0, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x80, 0x3F, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x40, 0x1F,
  0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0x9F, 0xC0, 0x70,
  0x07, 0xC0, 0x80, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE7, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x70, 0x01,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00,
  0x00, 0x70, 0x1E, 0x00, 0x1F, 0xF0, 0x0E, 0x03, 0x80, 0x0F, 0xFF, 0x01,
  0xC0, 0xF0, 0x03, 0xFF, 0xE0, 0x3C, 0x1C, 0x00, 0xF0, 0x3C, 0x07, 0x07,
  0x80, 0x3C, 0x07, 0x00, 0xE0, 0xE0, 0x0F, 0x00, 0xE0, 0x1C, 0x1C, 0x03,
  0xC0, 0x3C, 0x03, 0x87, 0x00, 0x70, 0x07, 0x80, 0x70, 0xE0, 0x1E, 0x00,
  0xE0, 0x0E, 0x1C, 0x03, 0x80, 0x1C, 0x01, 0xC7, 0x80, 0xF0, 0x07, 0x80,
  0x38, 0xE0, 0x1C, 0x00, 0xF0, 0x0F, 0x1C, 0x03, 0x80, 0x1C, 0x01, 0xC3,
  0x80, 0xF0, 0x03, 0x80, 0x38, 0xF0, 0x1C, 0x00, 0xF0, 0x07, 0x1C, 0x03,
  0x80, 0x1E, 0x01, 0xE3, 0x80, 0x70, 0x03, 0x80, 0x38, 0x70, 0x1E, 0x00,
  0xF0, 0x07, 0x0E, 0x03, 0xC0, 0x1E, 0x01, 0xE1, 0xC0, 0x78, 0x03, 0xC0,
  0x38, 0x38, 0x0E, 0x00, 0xF0, 0x0F, 0x0F, 0x01, 0xC0, 0x1E, 0x01, 0xC1,
  0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x3C, 0x07, 0x80, 0xD8, 0x0E, 0x07, 0x80,
  0x70, 0x3B, 0x83, 0xC0, 0xF0, 0x0F, 0x0E, 0x70, 0xF0, 0x1E, 0x01, 0xFF,
  0x8F, 0xFC, 0x03, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x38, 0x00, 0xF8, 0x0F,
  0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x70, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x38, 0xE0,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x07, 0x87, 0x00,
  0x00, 0x0E, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x78, 0x38, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x01,
  0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x0F, 0x80, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xE3,
  0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3C, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0xF8, 0x01,
  0xC0, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0x80, 0x0F, 0xC0, 0x07, 0x80, 0x07, 0xC0, 0x07, 0x80, 0x03, 0xE0, 0x07,
  0x80, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0xFE, 0x00, 0x1F, 0xC0, 0x0C, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x38, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0xF0, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x0F,
  0xC0, 0x07, 0x80, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00,
  0x7C, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x01, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3E, 0x07, 0x80,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C,
  0x00, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1E, 0x00,
  0x1F, 0x80, 0x07, 0x80, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x7E,
  0x00, 0x01, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xF8, 0x78, 0x00,
  0x0F, 0xFF, 0x0F, 0x00, 0x03, 0xFF, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x70,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x03, 0xF0, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x00, 0x78, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x7C, 0x00, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x01, 0xE1, 0xF0, 0x00,
  0x00, 0x1E, 0x3E, 0x00, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x00, 0x3C, 0x7C,
  0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00, 0x3D, 0xF8, 0x00, 0x00, 0x03,
  0xDF, 0xC0, 0x00, 0x00, 0x7B, 0xFC, 0x00, 0x00, 0x07, 0xFB, 0xC0, 0x00,
  0x00, 0x7F, 0x3E, 0x00, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x00, 0x7C, 0x1E,
  0x00, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x7B,
  0x80, 0x00, 0x03, 0xDE, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x1C,
  0xE0, 0x00, 0x01, 0xE7, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xF7, 0x80, 0x0F,
  0x38, 0x00, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x00, 0x79, 0xE0, 0x03,
  0xCF, 0x00, 0x00, 0x78, 0xF0, 0x01, 0xC7, 0x80, 0x00, 0x3C, 0xF0, 0x01,
  0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x87, 0x80,
  0x0F, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x07, 0x83, 0x80, 0x03, 0xC1, 0xE0,
  0x03, 0x81, 0xC0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0xF0,
  0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C,
  0x00, 0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x78, 0x0E,
  0x00, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x70, 0x1E, 0x01,
  0xE0, 0x03, 0x80, 0x38, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x1C, 0x0F, 0x00,
  0xF0, 0x01, 0xE0, 0x0E, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x07, 0x80,
  0x3C, 0x00, 0x70, 0x03, 0x87, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE3, 0xC0,
  0x1E, 0x00, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x79, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3D, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x00, 0x00,
  0x78, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xC0, 0x07,
  0xF0, 0x00, 0x07, 0x80, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x3D, 0xC0, 0x00,
  0x1E, 0x00, 0x7B, 0xC0, 0x00, 0x3C, 0x00, 0xF7, 0x80, 0x00, 0xF0, 0x01,
  0xCF, 0x00, 0x01, 0xE0, 0x07, 0x8E, 0x00, 0x03, 0xC0, 0x0F, 0x1E, 0x00,
  0x07, 0x80, 0x1E, 0x3C, 0x00, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x00,
  0x70, 0x70, 0x00, 0x78, 0x01, 0xE0, 0xE0, 0x00, 0xF0, 0x03, 0xC1, 0xE0,
  0x01, 0xE0, 0x07, 0x83, 0xC0, 0x03, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x00,
  0x3C, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x03, 0x80, 0x38, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0xF0,
  0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x00,
  0x0E, 0x07, 0x00, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x38, 0x00, 0x3C, 0x3C,
  0x00, 0xF0, 0x00, 0x78, 0x78, 0x01, 0xE0, 0x00, 0x70, 0xF0, 0x03, 0xC0,
  0x00, 0xF1, 0xC0, 0x07, 0x00, 0x01, 0xE7, 0x80, 0x1E, 0x00, 0x03, 0xCF,
  0x00, 0x3C, 0x00, 0x03, 0x9E, 0x00, 0x78, 0x00, 0x07, 0xB8, 0x00, 0xF0,
  0x00, 0x0F, 0x70, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x07, 0x80, 0x00, 0x1F,
  0xC0, 0x0F, 0x00, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x01,
  0xF0, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0xFF,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xE3, 0xC0,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE3,
  0xE0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xE0, 0x3F, 0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x1E,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0x03, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1F,
  0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xE0,
  0x0F, 0x00, 0x3F, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x3C, 0x0F, 0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0x7C,
  0x7C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x00, 0x79, 0xF0,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE3, 0xE0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x3F,
  0xC0, 0x03, 0xC0, 0x0F, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0,
  0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1F, 0x01,
  0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xF0, 0x0F,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x7C, 0x01, 0xE0, 0x03, 0xF0, 0x03, 0xC0, 0x1F, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x07,
  0x80, 0x01, 0xE0, 0x0F, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x1E, 0x00,
  0x3E, 0x00, 0x04, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x80, 0x00, 0x3E, 0x00, 0xE0,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x07, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x38, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF7, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00,
  0x3E, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x07,
  0x80, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x38, 0x07, 0x80, 0x00, 0xE0,
  0x1E, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0xE0, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x0E, 0x0F, 0x00,
  0x00, 0x38, 0x38, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x78, 0xF0, 0x00,
  0x3D, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x39, 0xC0, 0x00, 0xF0, 0xF0, 0x00,
  0x39, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x73, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xC0, 0xF0, 0x00,
  0xF3, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xE3, 0xC0, 0x07, 0xC0, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xC3, 0xC0, 0x07, 0x80, 0xF0, 0x03,
  0xC3, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0x83, 0xC0, 0x0F, 0x00, 0xF0, 0x07,
  0x83, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0E,
  0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1C, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x3C,
  0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x78,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x70, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF0,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xE0,
  0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x00, 0xF1, 0xC0,
  0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x03, 0xC7, 0x00, 0x00, 0xE3, 0xC0,
  0x03, 0xCF, 0x00, 0x00, 0xE3, 0x80, 0x03, 0xCF, 0x00, 0x00, 0xE7, 0x80,
  0x03, 0xDE, 0x00, 0x00, 0xE7, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xEF, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEE, 0x00,
  0x03, 0xB8, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0x03, 0xEE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0x3C, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xF0, 0x38, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x80, 0xF0, 0x01,
  0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x07,
  0x00, 0x78, 0x00, 0xE0, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x1C,
  0x3C, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x78, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1C, 0x3C, 0x00,
  0x01, 0xE1, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x00, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0,
  0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0xF0, 0xF8, 0x78, 0x78, 0x3C, 0x1C, 0x1E, 0x0E, 0x07,
  0x07, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xC1, 0xC0, 0x0F, 0xFF, 0x0E,
  0x00, 0xFF, 0xFC, 0xF0, 0x0F, 0x80, 0xF7, 0x80, 0xF8, 0x03, 0xB8, 0x0F,
  0x80, 0x0D, 0xC0, 0x78, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x3C, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E,
  0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3C,
  0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0xFE,
  0x03, 0xC0, 0x0E, 0xE0, 0x1F, 0x00, 0xE7, 0x00, 0x7C, 0x0F, 0x38, 0x03,
  0xFF, 0xF1, 0xC0, 0x0F, 0xFF, 0x1E, 0x00, 0x3F, 0xE0, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x3E, 0x00, 0x07, 0x87, 0xFC, 0x00, 0x78, 0xFF, 0xF0, 0x03,
  0xCF, 0xDF, 0xC0, 0x1E, 0xF0, 0x1F, 0x00, 0xFF, 0x00, 0x78, 0x07, 0x70,
  0x03, 0xC0, 0x7F, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x78, 0x1F, 0x80, 0x03,
  0xC0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x78, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0xF0, 0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xE0, 0x7E, 0x00, 0x1E, 0x03,
  0xB0, 0x01, 0xF0, 0x1D, 0xC0, 0x1F, 0x00, 0xE7, 0x01, 0xF0, 0x0F, 0x3F,
  0xFF, 0x00, 0x70, 0xFF, 0xF0, 0x03, 0x83, 0xFE, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xFB,
  0xE0, 0x1F, 0x80, 0x40, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x0C, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x0F, 0xFE, 0x1C, 0x00, 0x0F,
  0xFF, 0x9E, 0x00, 0x0F, 0xFF, 0xCF, 0x00, 0x0F, 0x80, 0x77, 0x80, 0x0F,
  0x80, 0x1B, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0x80, 0x03, 0xE0, 0x07,
  0xC0, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x78, 0x01,
  0xE0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0,
  0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07,
  0x80, 0x3C, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x03,
  0xF0, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0xEF, 0x00, 0x1F, 0x00,
  0xF7, 0x00, 0x07, 0xC0, 0xF3, 0x80, 0x03, 0xFF, 0xF1, 0xC0, 0x00, 0xFF,
  0xF0, 0xE0, 0x00, 0x3F, 0xE0, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xE7, 0xE0,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x0F,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0x78, 0x00,
  0xF8, 0x3C, 0x01, 0xF8, 0x1E, 0x07, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x04,
  0x07, 0xE0, 0x0C, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xA0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x08, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x01, 0x00,
  0x03, 0xFF, 0x0E, 0x00, 0x0F, 0xFF, 0x8E, 0x00, 0x1F, 0xEF, 0x8E, 0x00,
  0x3F, 0x01, 0xDE, 0x00, 0x7C, 0x00, 0xDE, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x0F, 0xC0, 0x3C, 0x00, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0x80, 0x1E,
  0x00, 0x1F, 0x80, 0x1E, 0x00, 0x3F, 0x80, 0x1E, 0x00, 0x77, 0x80, 0x1F,
  0x00, 0xF7, 0x00, 0x0F, 0x81, 0xEF, 0x00, 0x0F, 0xFF, 0xCF, 0x00, 0x07,
  0xFF, 0x8F, 0x00, 0x03, 0xFE, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x80, 0x01, 0xF0, 0x00, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x3F, 0x00, 0x0F, 0x1F, 0xF8, 0x00, 0xE3, 0xFF, 0xC0, 0x1E, 0x7F,
  0xFE, 0x01, 0xEF, 0x01, 0xE0, 0x1F, 0xC0, 0x1F, 0x01, 0xD8, 0x00, 0xF0,
  0x3F, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x20, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0xE0, 0x01, 0xE0, 0x1E, 0x00,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x01, 0xC0, 0x1F, 0x00,
  0x3C, 0x03, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xC0,
  0xF0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x78, 0x7C, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0xF3,
  0xF0, 0x00, 0x0F, 0x7F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0E, 0xEF, 0x00,
  0x01, 0xFC, 0x78, 0x00, 0x1F, 0x87, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x3C,
  0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00,
  0xF0, 0x07, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0E, 0x1F, 0xF8, 0x0F, 0xFC, 0x01,
  0xE3, 0xFF, 0xC3, 0xFF, 0xE0, 0x1E, 0x7F, 0xFC, 0x7F, 0xFE, 0x01, 0xCE,
  0x03, 0xCF, 0x01, 0xF0, 0x1D, 0xC0, 0x1E, 0xE0, 0x0F, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x0E, 0x1F, 0xFC, 0x01, 0xE3, 0xFF, 0xC0, 0x1E, 0x7F,
  0xFE, 0x01, 0xCF, 0x03, 0xE0, 0x1D, 0xC0, 0x1F, 0x01, 0xF8, 0x00, 0xF0,
  0x3F, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x03, 0xE0,
  0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x07, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x0F, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E,
  0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x3E, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x00, 0xF0,
  0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x07, 0xFC, 0x00, 0x03, 0x8F, 0xFF, 0x00, 0x03, 0xCF, 0xCF, 0xC0,
  0x01, 0xEF, 0x01, 0xF0, 0x00, 0xE7, 0x00, 0x78, 0x00, 0x77, 0x00, 0x3C,
  0x00, 0x7F, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x03,
  0xC0, 0x0F, 0x80, 0x01, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x03, 0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x0F,
  0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xE0, 0x07, 0xE0, 0x01, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x01, 0xDC, 0x01, 0xF0, 0x00, 0xE7, 0x01, 0xF0, 0x00,
  0xF3, 0xFF, 0xF0, 0x00, 0x78, 0xFF, 0xF0, 0x00, 0x3C, 0x3F, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x04, 0x00, 0x7F, 0xF0, 0xE0, 0x03, 0xFF, 0xE3, 0x80, 0x1F, 0xEF,
  0x8E, 0x00, 0xF8, 0x0F, 0x78, 0x07, 0xC0, 0x1D, 0xE0, 0x3E, 0x00, 0x37,
  0x00, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x03, 0xC0,
  0x00, 0xF8, 0x0F, 0x00, 0x07, 0xE0, 0x1E, 0x00, 0x1F, 0x80, 0x78, 0x00,
  0xFE, 0x01, 0xE0, 0x07, 0x78, 0x07, 0xC0, 0x3D, 0xC0, 0x0F, 0x81, 0xEF,
  0x00, 0x3F, 0xFF, 0x3C, 0x00, 0x7F, 0xF8, 0xF0, 0x00, 0xFF, 0x83, 0xC0,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x01, 0xC3, 0xFC, 0x07, 0x8F,
  0xF0, 0x0F, 0x3F, 0xE0, 0x1C, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xC7, 0xF0, 0x1F, 0x00,
  0x30, 0x1F, 0x00, 0x08, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x30, 0x00, 0xF8, 0x1E, 0x00,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0xFF, 0xCF,
  0xFF, 0xE7, 0xFF, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x3C, 0x07, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0,
  0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x3C, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xF0,
  0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x7C, 0x07, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xF0,
  0x1E, 0x00, 0x1F, 0x80, 0x78, 0x01, 0xFC, 0x03, 0xC0, 0x1D, 0xC0, 0x1F,
  0x03, 0xCE, 0x00, 0xFF, 0xFC, 0x70, 0x03, 0xFF, 0xC3, 0x80, 0x0F, 0xFC,
  0x3C, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0x70, 0x03, 0xC0,
  0x70, 0x07, 0x80, 0x70, 0x07, 0x80, 0x70, 0x0F, 0x00, 0x70, 0x0F, 0x00,
  0x78, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0x78, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0x79, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0x7B, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x3B, 0xC0, 0x01,
  0xF0, 0x00, 0xF7, 0x80, 0x07, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0xC0, 0x07,
  0x9E, 0x00, 0x3F, 0x80, 0x0F, 0x3C, 0x00, 0x77, 0x00, 0x3C, 0x78, 0x01,
  0xEE, 0x00, 0x78, 0xF0, 0x03, 0x9C, 0x00, 0xF1, 0xE0, 0x07, 0x38, 0x03,
  0xC3, 0xC0, 0x1E, 0x70, 0x07, 0x87, 0x80, 0x38, 0xE0, 0x1E, 0x0F, 0x00,
  0xF1, 0xC0, 0x3C, 0x1E, 0x01, 0xC3, 0x80, 0x70, 0x3C, 0x07, 0x87, 0x01,
  0xE0, 0x78, 0x0E, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x1C, 0x0F, 0x01, 0xE0,
  0x78, 0x38, 0x1E, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x03, 0x83, 0xC0, 0xE0,
  0xF0, 0x07, 0x07, 0x01, 0xC1, 0xE0, 0x0E, 0x1E, 0x03, 0x87, 0x80, 0x1C,
  0x3C, 0x07, 0x0F, 0x00, 0x38, 0x70, 0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x1C,
  0x78, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x03,
  0x9C, 0x00, 0xE7, 0x80, 0x07, 0x78, 0x01, 0xCE, 0x00, 0x0E, 0xF0, 0x03,
  0xBC, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x00, 0x3F, 0x80, 0x0E, 0xE0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x78, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03,
  0xC1, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x78, 0x01, 0xE0, 0x00,
  0xF0, 0x07, 0x80, 0x01, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x07,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x1E, 0x00, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x08,
  0x7E, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x13, 0xFF, 0xC0, 0x01, 0x7F, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x0F,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x80, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_Condensed_LightItalic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 16, 51, 16, 1, -51 },
  { 103, 18, 18, 23, 7, -51 },
  { 144, 34, 51, 33, 1, -51 },
  { 361, 30, 59, 30, 1, -55 },
  { 583, 38, 53, 45, 4, -52 },
  { 835, 32, 53, 34, 0, -52 },
  { 1047, 8, 18, 13, 7, -51 },
  { 1065, 21, 62, 18, 2, -51 },
  { 1228, 21, 62, 18, -5, -51 },
  { 1391, 23, 25, 29, 8, -55 },
  { 1463, 28, 33, 33, 3, -42 },
  { 1579, 11, 17, 14, -3, -8 },
  { 1603, 16, 3, 20, 2, -21 },
  { 1609, 6, 6, 14, 1, -6 },
  { 1614, 31, 51, 23, -3, -51 },
  { 1812, 28, 53, 30, 2, -52 },
  { 1998, 16, 51, 30, 9, -51 },
  { 2100, 32, 52, 30, -2, -52 },
  { 2308, 31, 53, 30, -1, -52 },
  { 2514, 31, 52, 30, -1, -52 },
  { 2716, 30, 52, 30, 0, -51 },
  { 2911, 28, 53, 30, 3, -52 },
  { 3097, 29, 51, 30, 4, -51 },
  { 3282, 31, 53, 30, 0, -52 },
  { 3488, 29, 53, 30, 1, -52 },
  { 3681, 12, 39, 14, 1, -39 },
  { 3740, 16, 48, 14, -3, -39 },
  { 3836, 28, 32, 33, 3, -42 },
  { 3948, 28, 19, 33, 3, -35 },
  { 4015, 28, 32, 33, 3, -42 },
  { 4127, 23, 52, 22, 2, -52 },
  { 4277, 43, 58, 46, 2, -52 },
  { 4589, 31, 52, 30, -5, -52 },
  { 4791, 32, 51, 33, 1, -51 },
  { 4995, 32, 53, 31, 4, -52 },
  { 5207, 34, 51, 37, 1, -51 },
  { 5424, 31, 51, 29, 1, -51 },
  { 5622, 31, 51, 27, 1, -51 },
  { 5820, 35, 53, 39, 4, -52 },
  { 6052, 38, 51, 38, 1, -51 },
  { 6295, 25, 51, 17, -3, -51 },
  { 6455, 27, 64, 14, -11, -51 },
  { 6671, 36, 51, 31, 1, -51 },
  { 6901, 20, 51, 27, 1, -51 },
  { 7029, 49, 51, 49, 1, -51 },
  { 7342, 39, 51, 39, 1, -51 },
  { 7591, 35, 53, 39, 3, -52 },
  { 7823, 31, 51, 31, 1, -51 },
  { 8021, 35, 64, 39, 3, -52 },
  { 8301, 31, 51, 32, 1, -51 },
  { 8499, 32, 53, 29, -1, -52 },
  { 8711, 27, 51, 27, 6, -51 },
  { 8884, 36, 52, 37, 3, -51 },
  { 9118, 30, 51, 31, 6, -51 },
  { 9310, 48, 51, 50, 7, -51 },
  { 9616, 37, 51, 28, -4, -51 },
  { 9852, 27, 51, 27, 6, -51 },
  { 10025, 34, 51, 28, -2, -51 },
  { 10242, 26, 63, 20, -1, -52 },
  { 10447, 11, 51, 24, 7, -51 },
  { 10518, 27, 63, 20, -5, -52 },
  { 10731, 29, 27, 32, 2, -51 },
  { 10829, 23, 3, 22, -6, 7 },
  { 10838, 8, 11, 17, 11, -55 },
  { 10849, 29, 40, 32, 2, -39 },
  { 10994, 29, 56, 32, 1, -55 },
  { 11197, 23, 40, 25, 3, -39 },
  { 11312, 33, 56, 33, 2, -55 },
  { 11543, 25, 40, 29, 2, -39 },
  { 11668, 35, 72, 17, -9, -55 },
  { 11983, 32, 56, 33, 0, -39 },
  { 12207, 28, 55, 32, 1, -55 },
  { 12400, 15, 52, 14, 1, -52 },
  { 12498, 26, 69, 14, -10, -52 },
  { 12723, 28, 55, 27, 1, -55 },
  { 12916, 15, 55, 14, 1, -55 },
  { 13020, 44, 39, 48, 1, -39 },
  { 13235, 28, 39, 32, 1, -39 },
  { 13372, 27, 40, 31, 2, -39 },
  { 13507, 33, 56, 32, -3, -39 },
  { 13738, 30, 56, 33, 2, -39 },
  { 13948, 23, 39, 21, 1, -39 },
  { 14061, 25, 40, 24, -1, -39 },
  { 14186, 17, 48, 18, 2, -47 },
  { 14288, 29, 39, 32, 2, -38 },
  { 14430, 24, 38, 25, 4, -38 },
  { 14544, 39, 38, 40, 4, -38 },
  { 14730, 31, 38, 26, -3, -38 },
  { 14878, 36, 55, 25, -7, -38 },
  { 15126, 26, 38, 22, -2, -38 },
  { 15250, 26, 62, 23, 2, -51 },
  { 15452, 4, 72, 30, 13, -55 },
  { 15488, 25, 62, 23, -4, -51 },
  { 15682, 28, 7, 33, 3, -29 },
};

const GFXfont NotoSans_Condensed_LightItalic72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic72pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC72PT7B_H_
