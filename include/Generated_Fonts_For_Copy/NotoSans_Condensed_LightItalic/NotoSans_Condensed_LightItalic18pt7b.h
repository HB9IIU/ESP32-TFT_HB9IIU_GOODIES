#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC18PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x11, 0x12, 0x22, 0x22, 0x44, 0x04, 0xC0, 0x59, 0x9A, 0xA0, 0x09,
  0x04, 0x82, 0x42, 0x47, 0xF8, 0x90, 0x90, 0x48, 0xFE, 0x14, 0x12, 0x09,
  0x05, 0x80, 0x04, 0x04, 0x1F, 0x28, 0x28, 0x28, 0x38, 0x18, 0x14, 0x14,
  0x14, 0x14, 0xF8, 0x20, 0x20, 0x30, 0x92, 0x44, 0x92, 0x48, 0x92, 0x25,
  0x69, 0xA7, 0xA9, 0x14, 0x45, 0x22, 0x49, 0x12, 0x47, 0x00, 0x0C, 0x12,
  0x12, 0x22, 0x14, 0x18, 0x30, 0x49, 0x49, 0x86, 0x84, 0x8C, 0x72, 0x6A,
  0x80, 0x0C, 0x21, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08, 0x20, 0x41, 0x04,
  0x10, 0x10, 0x82, 0x10, 0x84, 0x21, 0x08, 0x84, 0x22, 0x21, 0x10, 0x10,
  0x4E, 0x0F, 0x52, 0x60, 0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10,
  0x29, 0x60, 0xF0, 0x70, 0x01, 0x02, 0x02, 0x04, 0x04, 0x08, 0x08, 0x10,
  0x10, 0x20, 0x40, 0x40, 0x80, 0x1C, 0x94, 0x51, 0x86, 0x18, 0x61, 0x86,
  0x28, 0xA4, 0xF0, 0x13, 0xD1, 0x22, 0x22, 0x24, 0x44, 0x40, 0x1E, 0x44,
  0x08, 0x10, 0x20, 0x41, 0x04, 0x10, 0x41, 0x04, 0x0F, 0xC0, 0x1E, 0x22,
  0x01, 0x02, 0x02, 0x04, 0x38, 0x04, 0x04, 0x04, 0x04, 0x0C, 0xF8, 0x02,
  0x0C, 0x18, 0x51, 0x24, 0x89, 0x22, 0x85, 0xFC, 0x20, 0x40, 0x80, 0x1F,
  0x10, 0x20, 0x20, 0x20, 0x78, 0x04, 0x04, 0x02, 0x04, 0x04, 0x0C, 0xF8,
  0x0E, 0x60, 0x82, 0x04, 0x17, 0x31, 0x42, 0x85, 0x0A, 0x24, 0x4F, 0x00,
  0x7E, 0x04, 0x10, 0x20, 0x81, 0x04, 0x08, 0x20, 0x41, 0x02, 0x08, 0x00,
  0x1E, 0x23, 0x21, 0x21, 0x22, 0x14, 0x18, 0x64, 0x44, 0x82, 0x84, 0x84,
  0x78, 0x1C, 0x44, 0x8A, 0x14, 0x28, 0x51, 0x9D, 0x02, 0x08, 0x10, 0x4F,
  0x00, 0x24, 0x00, 0x00, 0x58, 0x11, 0x00, 0x00, 0x00, 0x24, 0x48, 0x06,
  0x31, 0x84, 0x06, 0x03, 0x01, 0x81, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0xC0,
  0x60, 0x30, 0x10, 0xC6, 0x30, 0x40, 0x78, 0x42, 0x11, 0x88, 0x88, 0x44,
  0x01, 0x08, 0x00, 0x0F, 0x04, 0x22, 0x05, 0x01, 0x4F, 0x64, 0x99, 0x26,
  0x89, 0xA4, 0xA9, 0x29, 0xB2, 0x00, 0x80, 0x11, 0x03, 0x80, 0x02, 0x0C,
  0x18, 0x50, 0xA2, 0x44, 0x91, 0x3E, 0xC5, 0x0A, 0x18, 0x20, 0x1E, 0x11,
  0x21, 0x21, 0x21, 0x22, 0x3C, 0x42, 0x42, 0x42, 0x42, 0x44, 0xF8, 0x0F,
  0x30, 0x20, 0x40, 0x40, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xC0, 0x78,
  0x1E, 0x08, 0x88, 0x64, 0x12, 0x09, 0x04, 0x82, 0x82, 0x41, 0x21, 0x90,
  0x88, 0x8F, 0x80, 0x1F, 0x10, 0x20, 0x20, 0x20, 0x22, 0x3C, 0x40, 0x40,
  0x40, 0x40, 0x40, 0xF8, 0x1F, 0x10, 0x20, 0x20, 0x20, 0x20, 0x3C, 0x40,
  0x40, 0x40, 0x40, 0x40, 0x80, 0x0F, 0x18, 0x48, 0x08, 0x04, 0x04, 0x02,
  0x1D, 0x02, 0x82, 0x41, 0x20, 0x98, 0x47, 0xE0, 0x10, 0x44, 0x22, 0x08,
  0x82, 0x20, 0x88, 0x23, 0xF1, 0x04, 0x41, 0x10, 0x44, 0x11, 0x08, 0x82,
  0x00, 0x1C, 0x20, 0x82, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0xF0, 0x02,
  0x04, 0x10, 0x20, 0x40, 0x81, 0x04, 0x08, 0x10, 0x20, 0x41, 0x02, 0x04,
  0x70, 0x10, 0x88, 0x88, 0x84, 0x82, 0xC1, 0x40, 0xE0, 0xD0, 0x48, 0x22,
  0x11, 0x08, 0x88, 0x60, 0x10, 0x88, 0x42, 0x10, 0x88, 0x42, 0x10, 0x8F,
  0x80, 0x10, 0x11, 0x03, 0x28, 0x32, 0x85, 0x28, 0x52, 0x8A, 0x28, 0xA4,
  0x92, 0x49, 0x24, 0xA4, 0x4A, 0x44, 0xC4, 0x8C, 0x40, 0x10, 0x44, 0x12,
  0x84, 0xA2, 0x28, 0x8A, 0x22, 0x49, 0x12, 0x45, 0x11, 0x44, 0x31, 0x0C,
  0x82, 0x00, 0x1E, 0x31, 0x21, 0x41, 0x41, 0x81, 0x81, 0x81, 0x81, 0x82,
  0x82, 0x84, 0x78, 0x1E, 0x13, 0x21, 0x21, 0x21, 0x22, 0x26, 0x78, 0x40,
  0x40, 0x40, 0x40, 0x80, 0x1E, 0x31, 0x21, 0x41, 0x41, 0x81, 0x81, 0x81,
  0x81, 0x82, 0x82, 0x84, 0x78, 0x10, 0x08, 0x0C, 0x1E, 0x13, 0x21, 0x21,
  0x21, 0x22, 0x26, 0x58, 0x48, 0x44, 0x44, 0x44, 0x84, 0x1E, 0x21, 0x20,
  0x20, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x04, 0x04, 0x0C, 0xF8, 0xFC, 0x82,
  0x08, 0x41, 0x04, 0x10, 0x42, 0x08, 0x20, 0x80, 0x20, 0x90, 0x90, 0x48,
  0x24, 0x12, 0x09, 0x09, 0x04, 0x82, 0x41, 0x21, 0x10, 0x87, 0x80, 0x83,
  0x0A, 0x14, 0x28, 0x91, 0x24, 0x48, 0xA1, 0x43, 0x06, 0x08, 0x00, 0x84,
  0x18, 0x42, 0x8C, 0x28, 0xC4, 0x94, 0x49, 0x44, 0x94, 0x8A, 0x48, 0xA5,
  0x0C, 0x50, 0xC6, 0x08, 0x60, 0x86, 0x00, 0x10, 0x88, 0x84, 0x41, 0x40,
  0xA0, 0x60, 0x20, 0x28, 0x14, 0x12, 0x09, 0x08, 0x88, 0x20, 0x86, 0x38,
  0xA4, 0x92, 0x8A, 0x10, 0x42, 0x08, 0x20, 0x80, 0x1F, 0x80, 0x80, 0x40,
  0x40, 0x40, 0x20, 0x20, 0x10, 0x10, 0x10, 0x08, 0x08, 0x0F, 0xC0, 0x1C,
  0x42, 0x08, 0x20, 0x82, 0x10, 0x41, 0x04, 0x10, 0x82, 0x08, 0x38, 0x92,
  0x48, 0x92, 0x49, 0x22, 0x1C, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0x41,
  0x04, 0x10, 0x42, 0x38, 0x08, 0x0C, 0x14, 0x24, 0x22, 0x42, 0xC1, 0xFC,
  0xA4, 0x1A, 0xCD, 0x14, 0x28, 0x50, 0xA1, 0x44, 0x99, 0xD0, 0x10, 0x20,
  0x41, 0x02, 0xC6, 0x48, 0x91, 0x42, 0x85, 0x0A, 0x14, 0x57, 0x00, 0x1D,
  0x84, 0x20, 0x82, 0x08, 0x20, 0x83, 0xC0, 0x01, 0x01, 0x02, 0x02, 0x1A,
  0x66, 0x44, 0x84, 0x84, 0x84, 0x84, 0x88, 0x98, 0xE8, 0x19, 0x94, 0x62,
  0x9B, 0x88, 0x20, 0x83, 0xC0, 0x03, 0x04, 0x04, 0x04, 0x1E, 0x08, 0x08,
  0x08, 0x10, 0x10, 0x10, 0x10, 0x10, 0x20, 0x20, 0x20, 0x20, 0xC0, 0x0D,
  0x33, 0x22, 0x42, 0x42, 0x42, 0x46, 0x44, 0x4C, 0x74, 0x04, 0x04, 0x08,
  0xF0, 0x10, 0x20, 0x41, 0x02, 0xC6, 0x48, 0x91, 0x42, 0x85, 0x12, 0x28,
  0x50, 0x80, 0x11, 0x02, 0x22, 0x24, 0x44, 0x48, 0x80, 0x04, 0x10, 0x02,
  0x08, 0x20, 0x84, 0x10, 0x41, 0x04, 0x20, 0x82, 0x08, 0xC0, 0x10, 0x20,
  0x41, 0x02, 0x24, 0x89, 0x14, 0x50, 0xE1, 0x22, 0x48, 0x91, 0x80, 0x11,
  0x12, 0x22, 0x22, 0x44, 0x44, 0x88, 0x2C, 0xC6, 0x64, 0x88, 0x91, 0x14,
  0x22, 0x88, 0x51, 0x12, 0x22, 0x84, 0x51, 0x88, 0x2C, 0x64, 0x89, 0x14,
  0x28, 0x51, 0x22, 0x85, 0x08, 0x19, 0x94, 0x61, 0x86, 0x18, 0x62, 0x8B,
  0xC0, 0x16, 0x19, 0x11, 0x11, 0x21, 0x21, 0x21, 0x21, 0x22, 0x5C, 0x40,
  0x40, 0x40, 0x80, 0x1A, 0xCD, 0x14, 0x28, 0x50, 0xA1, 0x44, 0x99, 0xD0,
  0x20, 0x41, 0x02, 0x00, 0x2C, 0xC2, 0x08, 0x41, 0x04, 0x10, 0x82, 0x00,
  0x19, 0x94, 0x10, 0x20, 0x40, 0x82, 0x0B, 0xC0, 0x24, 0xF4, 0x44, 0x88,
  0x88, 0x8C, 0x42, 0x89, 0x14, 0x28, 0x50, 0xA2, 0x44, 0x99, 0xD0, 0x86,
  0x18, 0xA2, 0x92, 0x4A, 0x28, 0xC3, 0x00, 0x88, 0x62, 0x29, 0x4A, 0x52,
  0x95, 0x29, 0x4A, 0x63, 0x18, 0xC4, 0x21, 0x00, 0x21, 0x12, 0x12, 0x14,
  0x08, 0x18, 0x18, 0x28, 0x44, 0xC4, 0x10, 0x88, 0x44, 0x42, 0x21, 0x20,
  0x90, 0x50, 0x18, 0x08, 0x04, 0x04, 0x02, 0x03, 0x07, 0x00, 0x1E, 0x04,
  0x10, 0x40, 0x82, 0x08, 0x10, 0x41, 0xF0, 0x06, 0x10, 0x20, 0x81, 0x02,
  0x04, 0x30, 0xE0, 0x40, 0x81, 0x04, 0x08, 0x10, 0x18, 0xFF, 0xFF, 0xC0,
  0x18, 0x30, 0x42, 0x08, 0x20, 0x82, 0x0C, 0x41, 0x04, 0x20, 0x82, 0x30,
  0xF3, 0x18,
};

const GFXglyph NotoSans_Condensed_LightItalic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 13, 4, 0, -13 },
  { 8, 4, 5, 6, 2, -13 },
  { 11, 9, 13, 8, 0, -13 },
  { 26, 8, 15, 8, 0, -14 },
  { 41, 10, 13, 11, 1, -13 },
  { 58, 8, 13, 8, 0, -13 },
  { 71, 2, 5, 3, 2, -13 },
  { 73, 6, 16, 5, 0, -13 },
  { 85, 5, 16, 5, -1, -13 },
  { 95, 6, 6, 7, 2, -14 },
  { 100, 7, 9, 8, 1, -11 },
  { 108, 3, 4, 3, -1, -2 },
  { 110, 4, 1, 5, 0, -5 },
  { 111, 2, 2, 3, 0, -2 },
  { 112, 8, 13, 6, -1, -13 },
  { 125, 6, 13, 8, 1, -13 },
  { 135, 4, 13, 8, 2, -13 },
  { 142, 7, 13, 8, 0, -13 },
  { 154, 8, 13, 8, 0, -13 },
  { 167, 7, 13, 8, 0, -13 },
  { 179, 8, 13, 8, 0, -13 },
  { 192, 7, 13, 8, 1, -13 },
  { 204, 7, 13, 8, 1, -13 },
  { 216, 8, 13, 8, 0, -13 },
  { 229, 7, 13, 8, 0, -13 },
  { 241, 3, 10, 4, 0, -10 },
  { 245, 4, 12, 4, -1, -10 },
  { 251, 7, 8, 8, 1, -10 },
  { 258, 7, 5, 8, 1, -9 },
  { 263, 7, 8, 8, 1, -10 },
  { 270, 5, 13, 6, 1, -13 },
  { 279, 10, 15, 11, 1, -13 },
  { 298, 7, 13, 8, -1, -13 },
  { 310, 8, 13, 8, 0, -13 },
  { 323, 8, 13, 8, 1, -13 },
  { 336, 9, 13, 9, 0, -13 },
  { 351, 8, 13, 7, 0, -13 },
  { 364, 8, 13, 7, 0, -13 },
  { 377, 9, 13, 10, 1, -13 },
  { 392, 10, 13, 9, 0, -13 },
  { 409, 6, 13, 4, -1, -13 },
  { 419, 7, 16, 4, -3, -13 },
  { 433, 9, 13, 8, 0, -13 },
  { 448, 5, 13, 7, 0, -13 },
  { 457, 12, 13, 12, 0, -13 },
  { 477, 10, 13, 10, 0, -13 },
  { 494, 8, 13, 10, 1, -13 },
  { 507, 8, 13, 8, 0, -13 },
  { 520, 8, 16, 10, 1, -13 },
  { 536, 8, 13, 8, 0, -13 },
  { 549, 8, 13, 7, 0, -13 },
  { 562, 6, 13, 7, 2, -13 },
  { 572, 9, 13, 9, 1, -13 },
  { 587, 7, 13, 8, 2, -13 },
  { 599, 12, 13, 12, 2, -13 },
  { 619, 9, 13, 7, -1, -13 },
  { 634, 6, 13, 7, 2, -13 },
  { 644, 9, 13, 7, -1, -13 },
  { 659, 6, 16, 5, 0, -13 },
  { 671, 3, 13, 6, 2, -13 },
  { 676, 6, 16, 5, -1, -13 },
  { 688, 8, 7, 8, 0, -13 },
  { 695, 6, 1, 6, -2, 2 },
  { 696, 2, 3, 4, 3, -14 },
  { 697, 7, 10, 8, 1, -10 },
  { 706, 7, 14, 8, 0, -14 },
  { 719, 6, 10, 6, 1, -10 },
  { 727, 8, 14, 8, 1, -14 },
  { 741, 6, 10, 7, 1, -10 },
  { 749, 8, 18, 4, -2, -14 },
  { 767, 8, 14, 8, 0, -10 },
  { 781, 7, 14, 8, 0, -14 },
  { 794, 4, 13, 3, 0, -13 },
  { 801, 6, 17, 3, -2, -13 },
  { 814, 7, 14, 7, 0, -14 },
  { 827, 4, 14, 3, 0, -14 },
  { 834, 11, 10, 12, 0, -10 },
  { 848, 7, 10, 8, 0, -10 },
  { 857, 6, 10, 8, 1, -10 },
  { 865, 8, 14, 8, -1, -10 },
  { 879, 7, 14, 8, 1, -10 },
  { 892, 6, 10, 5, 0, -10 },
  { 900, 6, 10, 6, 0, -10 },
  { 908, 4, 12, 4, 1, -12 },
  { 914, 7, 10, 8, 1, -10 },
  { 923, 6, 10, 6, 1, -10 },
  { 931, 10, 10, 10, 1, -10 },
  { 944, 8, 10, 6, -1, -10 },
  { 954, 9, 14, 6, -2, -10 },
  { 970, 7, 10, 6, -1, -10 },
  { 979, 7, 16, 6, 0, -13 },
  { 993, 1, 18, 7, 3, -14 },
  { 996, 6, 16, 6, -1, -13 },
  { 1008, 7, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_LightItalic18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC18PT7B_H_
