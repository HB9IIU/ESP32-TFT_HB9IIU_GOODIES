#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC44PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x06, 0x03,
  0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x01, 0x80, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x0E, 0x07, 0x03, 0x80,
  0x38, 0xE6, 0x1C, 0xC3, 0x18, 0x63, 0x0C, 0xC3, 0x98, 0x63, 0x0C, 0x61,
  0x88, 0x33, 0x04, 0x00, 0x00, 0x18, 0x30, 0x01, 0x81, 0x00, 0x0C, 0x18,
  0x00, 0x60, 0xC0, 0x06, 0x06, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x0C,
  0x18, 0x00, 0xC1, 0x80, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x03, 0x06, 0x00,
  0x18, 0x30, 0x00, 0xC1, 0x80, 0x0C, 0x0C, 0x00, 0x60, 0xC0, 0x03, 0x06,
  0x00, 0x30, 0x30, 0x01, 0x83, 0x00, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x46,
  0x0C, 0x00, 0x30, 0x60, 0x01, 0x83, 0x00, 0x18, 0x18, 0x00, 0xC1, 0x80,
  0x06, 0x0C, 0x00, 0x60, 0x60, 0x03, 0x06, 0x00, 0x18, 0x30, 0x01, 0xC1,
  0x80, 0x00, 0x00, 0x04, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x1F, 0x00,
  0x0F, 0xFE, 0x07, 0xF7, 0x81, 0xC6, 0x10, 0x30, 0xC0, 0x06, 0x10, 0x01,
  0xC2, 0x00, 0x30, 0xC0, 0x07, 0x18, 0x00, 0xE3, 0x00, 0x0C, 0x40, 0x01,
  0xC8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x6E, 0x00, 0x0C, 0xE0, 0x01, 0x8C, 0x00, 0x21, 0x80, 0x04, 0x38, 0x01,
  0x86, 0x00, 0x30, 0xC0, 0x06, 0x38, 0x40, 0x86, 0x0E, 0x13, 0xC1, 0xFF,
  0xE0, 0x0F, 0xF0, 0x00, 0x18, 0x00, 0x02, 0x00, 0x00, 0x40, 0x00, 0x18,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80, 0x30, 0x63, 0x00,
  0xC1, 0x86, 0x01, 0x83, 0x06, 0x06, 0x0C, 0x0C, 0x1C, 0x18, 0x30, 0x30,
  0x30, 0x60, 0xC0, 0xC0, 0xC1, 0x81, 0x81, 0x86, 0x03, 0x03, 0x1C, 0x06,
  0x06, 0x30, 0x0C, 0x18, 0xC0, 0x18, 0x31, 0x8F, 0x30, 0x66, 0x3F, 0x61,
  0x8C, 0xC7, 0xC3, 0x33, 0x87, 0x8C, 0xE6, 0x0F, 0xF1, 0x9C, 0x19, 0xC6,
  0x30, 0x30, 0x0C, 0x60, 0x60, 0x30, 0xC1, 0xC0, 0x63, 0x03, 0x01, 0x86,
  0x06, 0x07, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0x60,
  0xC1, 0x80, 0xC3, 0x03, 0x01, 0x86, 0x0C, 0x03, 0xB8, 0x38, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0xE7, 0x00, 0x1C, 0x38, 0x01, 0x81,
  0x80, 0x38, 0x18, 0x03, 0x83, 0x80, 0x30, 0x38, 0x03, 0x03, 0x00, 0x38,
  0x70, 0x03, 0x86, 0x00, 0x38, 0xC0, 0x01, 0x9C, 0x00, 0x1F, 0x80, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x00, 0xE6, 0x01, 0x1C, 0x70, 0x63,
  0x83, 0x06, 0x30, 0x38, 0xE7, 0x03, 0x8C, 0x60, 0x19, 0xC6, 0x01, 0xD8,
  0xE0, 0x0F, 0x8E, 0x00, 0xF0, 0xE0, 0x0E, 0x0E, 0x00, 0xF0, 0x60, 0x1F,
  0x07, 0x07, 0x30, 0x3F, 0xE3, 0x81, 0xFC, 0x18, 0x39, 0xCC, 0x63, 0x39,
  0x8C, 0x63, 0x30, 0x00, 0x38, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x00, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x30, 0xC0, 0xE3, 0x01, 0xEC, 0x11, 0xFF, 0xC1, 0xFE, 0x0F, 0x00, 0x76,
  0x03, 0x98, 0x1C, 0x30, 0x60, 0xC0, 0x01, 0x80, 0x04, 0x00, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x1C, 0x30, 0xE1, 0x87,
  0x0C, 0x18, 0x60, 0xC3, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x60,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x7F, 0x00, 0x79, 0xC0, 0x70, 0x70, 0x70, 0x38, 0x30,
  0x0C, 0x38, 0x06, 0x18, 0x03, 0x1C, 0x01, 0x8E, 0x00, 0xC6, 0x00, 0x67,
  0x00, 0x33, 0x80, 0x19, 0x80, 0x1C, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03,
  0x30, 0x01, 0x98, 0x01, 0xCC, 0x00, 0xE6, 0x00, 0x63, 0x00, 0x33, 0x80,
  0x39, 0xC0, 0x18, 0xE0, 0x0C, 0x70, 0x0E, 0x18, 0x06, 0x0C, 0x07, 0x06,
  0x07, 0x03, 0x87, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x01, 0xC0, 0xF0, 0xFC,
  0x77, 0x39, 0xBC, 0x66, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07,
  0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01,
  0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0x0F, 0x8F, 0x00, 0xC0, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFF,
  0x87, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x7C, 0x78, 0x1C, 0x07,
  0x02, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x20, 0x1E, 0x0F, 0xFF,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0x60, 0x01, 0x98, 0x00, 0xEE, 0x00, 0x33, 0x80,
  0x18, 0xC0, 0x0E, 0x30, 0x03, 0x0C, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x30,
  0x60, 0x18, 0x18, 0x0E, 0x06, 0x03, 0x03, 0x81, 0x80, 0xC0, 0xC0, 0x30,
  0x70, 0x0C, 0x18, 0x07, 0x0C, 0x01, 0xC3, 0xFF, 0xFE, 0xFF, 0xFF, 0x80,
  0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8,
  0x03, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x08, 0x07, 0x81,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x3C, 0x20,
  0x78, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x9F, 0x81, 0xBF,
  0xE0, 0xF8, 0x38, 0xF0, 0x0C, 0x78, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCC,
  0x00, 0xE6, 0x00, 0x73, 0x00, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x0E,
  0x30, 0x06, 0x18, 0x07, 0x0E, 0x07, 0x03, 0x87, 0x81, 0xFF, 0x80, 0x7F,
  0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0x07, 0x8F, 0x01, 0xC0, 0xE0, 0x70, 0x0E, 0x0E,
  0x01, 0xC1, 0x80, 0x38, 0x30, 0x07, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x18,
  0x07, 0x03, 0x81, 0xC0, 0x38, 0x70, 0x03, 0x1C, 0x00, 0x7F, 0x00, 0x07,
  0x80, 0x03, 0xF8, 0x01, 0xE3, 0x80, 0x70, 0x70, 0x1C, 0x07, 0x03, 0x00,
  0x60, 0xE0, 0x0E, 0x18, 0x01, 0xC7, 0x00, 0x18, 0xE0, 0x03, 0x1C, 0x00,
  0xE3, 0x80, 0x1C, 0x30, 0x03, 0x07, 0x00, 0xE0, 0xF0, 0x38, 0x0F, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x78, 0x00, 0xFF, 0x00, 0xE3, 0xC0, 0xE0, 0x60,
  0xE0, 0x38, 0x60, 0x1C, 0x70, 0x06, 0x30, 0x03, 0x18, 0x01, 0x9C, 0x00,
  0xCC, 0x00, 0x66, 0x00, 0x73, 0x00, 0x39, 0x80, 0x1C, 0xC0, 0x1C, 0x70,
  0x0E, 0x38, 0x0F, 0x0E, 0x1D, 0x83, 0xFD, 0xC0, 0xF8, 0xC0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x02,
  0x07, 0x07, 0x0F, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x70, 0xF0, 0x60, 0x00,
  0x80, 0x70, 0x1C, 0x07, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x0C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0x40, 0x30,
  0x00, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x70, 0x00, 0x20, 0x00, 0x00, 0x03,
  0xE0, 0x3F, 0xE1, 0xE7, 0x84, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x40, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xE1, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x03, 0x80,
  0x60, 0x00, 0x60, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x06, 0x00, 0x00,
  0xC3, 0x00, 0xF0, 0x30, 0xC0, 0xFF, 0x0C, 0x60, 0x71, 0xC3, 0x18, 0x38,
  0x60, 0xCC, 0x0C, 0x18, 0x33, 0x06, 0x06, 0x0C, 0xC1, 0x83, 0x83, 0x60,
  0xC0, 0xC0, 0xD8, 0x30, 0x30, 0x66, 0x0C, 0x0C, 0x19, 0x86, 0x07, 0x06,
  0x61, 0x81, 0x83, 0x18, 0x60, 0x60, 0xCE, 0x18, 0x38, 0x33, 0x06, 0x0E,
  0x18, 0xC1, 0xC7, 0x8C, 0x30, 0x3F, 0x3F, 0x06, 0x07, 0x8F, 0x01, 0x80,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0x60, 0x00, 0x6C, 0x00, 0x1D, 0x80, 0x03, 0x30, 0x00, 0xE6, 0x00,
  0x18, 0xC0, 0x03, 0x18, 0x00, 0xC3, 0x00, 0x18, 0x60, 0x07, 0x0C, 0x00,
  0xC1, 0x80, 0x38, 0x30, 0x06, 0x06, 0x01, 0xC0, 0xC0, 0x30, 0x18, 0x0E,
  0x03, 0x01, 0xFF, 0xE0, 0x3F, 0xFC, 0x0E, 0x01, 0x81, 0x80, 0x30, 0x70,
  0x06, 0x0C, 0x00, 0xE3, 0x80, 0x1C, 0x60, 0x03, 0x9C, 0x00, 0x73, 0x00,
  0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x07, 0x03, 0xFF, 0x00, 0x7F,
  0xF8, 0x0C, 0x07, 0x03, 0x80, 0x70, 0x70, 0x06, 0x0C, 0x00, 0xC1, 0x80,
  0x18, 0x30, 0x03, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x30, 0x07, 0x06, 0x00,
  0xE0, 0xC0, 0x78, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x18, 0x07,
  0x07, 0x00, 0x60, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0x60, 0x07,
  0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x60, 0x03, 0x0C, 0x00, 0xE1, 0x80, 0x38,
  0x70, 0x0F, 0x0E, 0x07, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x07, 0xFF, 0x00, 0xF8, 0xE0, 0x1C, 0x02, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03,
  0x03, 0xC0, 0x70, 0x0E, 0x07, 0x00, 0x70, 0x60, 0x07, 0x06, 0x00, 0x70,
  0x60, 0x03, 0x0E, 0x00, 0x30, 0xE0, 0x03, 0x0C, 0x00, 0x30, 0xC0, 0x03,
  0x0C, 0x00, 0x31, 0xC0, 0x03, 0x1C, 0x00, 0x71, 0x80, 0x07, 0x18, 0x00,
  0x73, 0x80, 0x06, 0x38, 0x00, 0xE3, 0x00, 0x0E, 0x30, 0x00, 0xC3, 0x00,
  0x1C, 0x70, 0x01, 0xC7, 0x00, 0x38, 0x60, 0x07, 0x06, 0x00, 0x70, 0x60,
  0x0E, 0x0E, 0x03, 0xC0, 0xE0, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xF8,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x7F, 0xF8, 0x0C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x01, 0x80, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xF0,
  0x1F, 0xFC, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x0F, 0xCF, 0xC0, 0x78, 0x02, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x0F, 0xF3, 0x80,
  0x3F, 0x8E, 0x00, 0x06, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03,
  0x0E, 0x00, 0x0C, 0x38, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x06,
  0x00, 0x18, 0x1C, 0x00, 0x60, 0x38, 0x03, 0x80, 0xF0, 0x0E, 0x01, 0xFF,
  0xF0, 0x01, 0xFF, 0x80, 0x03, 0x80, 0x0E, 0x06, 0x00, 0x18, 0x0C, 0x00,
  0x30, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x81, 0x80, 0x06,
  0x03, 0x00, 0x0C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x30, 0x00, 0xC0,
  0x60, 0x01, 0x80, 0xC0, 0x03, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x18, 0x00, 0x60, 0x70, 0x00, 0xC0, 0xE0, 0x03, 0x81, 0x80,
  0x07, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x1C, 0x00, 0x70, 0x38, 0x00,
  0xE0, 0x60, 0x01, 0x80, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x38, 0x18, 0x00, 0x60, 0x30, 0x00, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00,
  0x70, 0x04, 0x70, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x03, 0x80, 0x38, 0x18,
  0x03, 0x80, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x38, 0x03, 0x01, 0xC0,
  0x18, 0x1C, 0x00, 0xC1, 0xC0, 0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x03, 0x1C,
  0x00, 0x18, 0xE0, 0x00, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0x7C, 0x00, 0x1E, 0xE0, 0x01, 0xE3, 0x00, 0x0E, 0x18, 0x00, 0x60, 0xE0,
  0x03, 0x03, 0x00, 0x18, 0x18, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x60,
  0x18, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x18, 0x0E, 0x00, 0xC0,
  0x60, 0x07, 0x03, 0x00, 0x38, 0x00, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x6C, 0x00, 0x1F, 0x03,
  0x60, 0x00, 0xD8, 0x1B, 0x00, 0x0E, 0xC0, 0xD8, 0x00, 0x6E, 0x0E, 0xC0,
  0x07, 0x70, 0x76, 0x00, 0x33, 0x03, 0x38, 0x03, 0x98, 0x19, 0xC0, 0x18,
  0xC0, 0xCE, 0x01, 0xCE, 0x0E, 0x30, 0x0C, 0x60, 0x61, 0x80, 0xE3, 0x03,
  0x0C, 0x06, 0x18, 0x18, 0x60, 0x71, 0xC1, 0xC3, 0x03, 0x0E, 0x0E, 0x18,
  0x38, 0x60, 0x60, 0xC1, 0x83, 0x03, 0x06, 0x1C, 0x18, 0x18, 0x30, 0xC1,
  0xC1, 0xC1, 0x8E, 0x0E, 0x0E, 0x0C, 0x60, 0x60, 0x60, 0x77, 0x03, 0x03,
  0x03, 0xB0, 0x18, 0x18, 0x0F, 0x81, 0xC1, 0xC0, 0x78, 0x0E, 0x0C, 0x03,
  0xC0, 0x60, 0x60, 0x1C, 0x03, 0x03, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80,
  0x07, 0x03, 0x80, 0x06, 0x03, 0xC0, 0x06, 0x07, 0xC0, 0x0E, 0x06, 0xC0,
  0x0E, 0x06, 0xC0, 0x0C, 0x06, 0xE0, 0x0C, 0x06, 0x60, 0x0C, 0x0E, 0x60,
  0x1C, 0x0E, 0x60, 0x1C, 0x0C, 0x70, 0x18, 0x0C, 0x30, 0x18, 0x0C, 0x30,
  0x18, 0x1C, 0x30, 0x38, 0x18, 0x38, 0x38, 0x18, 0x18, 0x30, 0x18, 0x18,
  0x30, 0x38, 0x18, 0x30, 0x38, 0x1C, 0x70, 0x30, 0x0C, 0x60, 0x30, 0x0C,
  0x60, 0x30, 0x0C, 0x60, 0x70, 0x0E, 0xE0, 0x70, 0x06, 0xE0, 0x60, 0x06,
  0xC0, 0x60, 0x06, 0xC0, 0x60, 0x07, 0xC0, 0xE0, 0x03, 0xC0, 0xC0, 0x03,
  0xC0, 0xC0, 0x03, 0x80, 0xC0, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x03, 0xFE,
  0x00, 0x7C, 0xF8, 0x07, 0x80, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x18, 0x38,
  0x00, 0xE1, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xC0, 0x01, 0xCE, 0x00, 0x0E,
  0x60, 0x00, 0x73, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEC, 0x00,
  0x06, 0x60, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE,
  0x00, 0x06, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x18, 0xE0, 0x01,
  0xC7, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x1C,
  0x0E, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF0,
  0x0C, 0x0F, 0x03, 0x80, 0xE0, 0x70, 0x0C, 0x0C, 0x01, 0xC1, 0x80, 0x38,
  0x30, 0x07, 0x0E, 0x00, 0xC1, 0xC0, 0x18, 0x30, 0x03, 0x06, 0x00, 0xE0,
  0xC0, 0x18, 0x38, 0x07, 0x07, 0x01, 0xC0, 0xC0, 0xF0, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xFE, 0x00, 0x7C, 0xF8, 0x07, 0x80, 0xE0, 0x70, 0x07, 0x03, 0x80,
  0x18, 0x38, 0x00, 0xE1, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xC0, 0x01, 0xCE,
  0x00, 0x0E, 0x60, 0x00, 0x73, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00,
  0xEC, 0x00, 0x06, 0x60, 0x00, 0x37, 0x00, 0x01, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0xEE, 0x00, 0x06, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x18,
  0xE0, 0x01, 0xC7, 0x00, 0x0C, 0x18, 0x00, 0xE0, 0xE0, 0x0E, 0x07, 0x00,
  0xE0, 0x1C, 0x0E, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0C, 0x0F, 0x03,
  0x80, 0xE0, 0x70, 0x0C, 0x0C, 0x01, 0x81, 0x80, 0x38, 0x30, 0x06, 0x0E,
  0x00, 0xC1, 0xC0, 0x18, 0x30, 0x07, 0x06, 0x00, 0xE0, 0xC0, 0x38, 0x38,
  0x0F, 0x07, 0x03, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0x0E, 0x00, 0xE1,
  0xC0, 0x1C, 0x18, 0x03, 0x03, 0x00, 0x60, 0x70, 0x1C, 0x0E, 0x03, 0x81,
  0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x70, 0x70, 0x0E, 0x0E, 0x00,
  0xC1, 0x80, 0x18, 0x30, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x01,
  0xFB, 0xE0, 0x3C, 0x02, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x06, 0x03, 0xC0, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x60, 0xE0, 0x01,
  0x83, 0x80, 0x0E, 0x0C, 0x00, 0x38, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x07,
  0x00, 0x1C, 0x1C, 0x00, 0x70, 0x60, 0x01, 0x81, 0x80, 0x06, 0x06, 0x00,
  0x18, 0x38, 0x00, 0xE0, 0xC0, 0x03, 0x83, 0x00, 0x0C, 0x0C, 0x00, 0x30,
  0x70, 0x00, 0xC1, 0xC0, 0x07, 0x06, 0x00, 0x1C, 0x18, 0x00, 0x60, 0x60,
  0x01, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xC0, 0xE0, 0x07,
  0x03, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x70, 0x3C, 0x00,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00,
  0x3B, 0x00, 0x0C, 0xC0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x63, 0x80, 0x38,
  0xE0, 0x0C, 0x38, 0x07, 0x0E, 0x01, 0x83, 0x80, 0xE0, 0xE0, 0x30, 0x38,
  0x1C, 0x0E, 0x06, 0x01, 0x83, 0x80, 0x60, 0xE0, 0x18, 0x30, 0x06, 0x1C,
  0x01, 0x86, 0x00, 0x63, 0x80, 0x18, 0xC0, 0x06, 0x70, 0x01, 0x98, 0x00,
  0x6E, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x1C, 0x00, 0xEE,
  0x00, 0x70, 0x03, 0x38, 0x03, 0xC0, 0x0C, 0xE0, 0x0F, 0x00, 0x73, 0x80,
  0x6C, 0x01, 0x8E, 0x01, 0xB0, 0x0E, 0x38, 0x0E, 0xC0, 0x30, 0xC0, 0x33,
  0x01, 0xC3, 0x00, 0xCC, 0x07, 0x0C, 0x06, 0x30, 0x18, 0x30, 0x18, 0xC0,
  0xE0, 0xC0, 0xE3, 0x03, 0x03, 0x03, 0x0C, 0x1C, 0x0C, 0x0C, 0x30, 0x60,
  0x30, 0x60, 0xC1, 0x80, 0xC1, 0x83, 0x0E, 0x03, 0x0E, 0x0C, 0x30, 0x0C,
  0x30, 0x31, 0xC0, 0x30, 0xC0, 0xC6, 0x00, 0xC6, 0x03, 0x18, 0x03, 0x18,
  0x0C, 0xE0, 0x0C, 0xC0, 0x33, 0x00, 0x33, 0x00, 0xDC, 0x00, 0xDC, 0x03,
  0x60, 0x03, 0x60, 0x0D, 0x80, 0x0D, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x70, 0x03, 0x01,
  0xC0, 0x06, 0x03, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x18, 0x60,
  0x00, 0x31, 0xC0, 0x00, 0x63, 0x00, 0x00, 0xEC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xB8, 0x00, 0x06, 0x70, 0x00, 0x1C,
  0x60, 0x00, 0x70, 0xC0, 0x00, 0xC1, 0x80, 0x03, 0x83, 0x00, 0x06, 0x07,
  0x00, 0x1C, 0x0E, 0x00, 0x70, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30,
  0x0E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x00, 0xC0, 0x07, 0xE0, 0x06, 0xE0,
  0x0E, 0xE0, 0x1C, 0x60, 0x1C, 0x60, 0x38, 0x60, 0x30, 0x60, 0x70, 0x60,
  0x60, 0x70, 0xE0, 0x70, 0xC0, 0x31, 0x80, 0x33, 0x80, 0x33, 0x00, 0x37,
  0x00, 0x36, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x18,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0xE0, 0xC1, 0x83,
  0x06, 0x0E, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x87, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xE1, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xC1,
  0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x80, 0x03, 0x60, 0x01, 0x98, 0x00, 0xE7, 0x00, 0x30, 0xC0, 0x1C,
  0x30, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x60, 0x0C, 0x38, 0x03,
  0x0C, 0x00, 0xE7, 0x00, 0x19, 0x80, 0x06, 0xE0, 0x00, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0xE1, 0x87, 0x0C, 0x38, 0x60, 0xC0, 0x00, 0x70, 0x00, 0x7F,
  0x30, 0x78, 0xCC, 0x1C, 0x1F, 0x0E, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x38,
  0xE0, 0x0E, 0x38, 0x03, 0x8C, 0x00, 0xC7, 0x00, 0x31, 0xC0, 0x0C, 0x60,
  0x07, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03,
  0x86, 0x01, 0xC1, 0x80, 0x70, 0x60, 0x2C, 0x1C, 0x1B, 0x03, 0xFC, 0xC0,
  0x7E, 0x60, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC7,
  0x80, 0x77, 0xF8, 0x1B, 0x8E, 0x06, 0xC1, 0xC1, 0xE0, 0x70, 0xF0, 0x0C,
  0x38, 0x03, 0x0E, 0x00, 0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x70, 0x03, 0x18,
  0x01, 0xC6, 0x00, 0x71, 0x80, 0x18, 0xE0, 0x06, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x30, 0xE0, 0x1C, 0x78, 0x06, 0x1A, 0x03, 0x86, 0xC1, 0xC1,
  0xBF, 0xE0, 0xC7, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0xF0, 0x78, 0x83, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0xC1, 0x07, 0xFC, 0x0F, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x0C,
  0x01, 0xFC, 0xC0, 0x78, 0xEC, 0x07, 0x07, 0xC0, 0xE0, 0x38, 0x1C, 0x03,
  0x81, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x30, 0x03, 0x07, 0x00,
  0x30, 0x70, 0x03, 0x06, 0x00, 0x70, 0x60, 0x07, 0x06, 0x00, 0x60, 0x60,
  0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x01, 0xE0, 0x60, 0x3C, 0x06,
  0x03, 0xC0, 0x70, 0x6C, 0x03, 0xFC, 0xC0, 0x1F, 0x98, 0x00, 0x00, 0x78,
  0x01, 0xFC, 0x03, 0x8E, 0x07, 0x06, 0x0E, 0x07, 0x1C, 0x06, 0x18, 0x06,
  0x38, 0x06, 0x30, 0x0E, 0x30, 0x1C, 0x70, 0x78, 0x7F, 0xE0, 0x7F, 0x80,
  0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x78, 0x10, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x07, 0xF0, 0x00, 0x3D, 0x80, 0x00, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xCC, 0x07, 0x1D, 0x81, 0xC1, 0xB0,
  0x70, 0x1C, 0x1C, 0x03, 0x83, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3,
  0x00, 0x30, 0xE0, 0x06, 0x1C, 0x00, 0xC3, 0x00, 0x38, 0x60, 0x07, 0x0C,
  0x00, 0xC1, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x3C, 0x18,
  0x0F, 0x03, 0x01, 0xE0, 0x70, 0x6C, 0x07, 0xFB, 0x80, 0x7E, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x04, 0x03, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01,
  0x80, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC7,
  0x80, 0x77, 0xF8, 0x1B, 0x8E, 0x07, 0x81, 0xC1, 0xC0, 0x70, 0xF0, 0x1C,
  0x38, 0x06, 0x0E, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x70, 0x0E, 0x1C,
  0x03, 0x86, 0x00, 0xC1, 0x80, 0x30, 0xE0, 0x0C, 0x38, 0x07, 0x0C, 0x01,
  0x83, 0x00, 0x60, 0xC0, 0x18, 0x70, 0x0E, 0x1C, 0x03, 0x86, 0x00, 0xC1,
  0x80, 0x30, 0xE0, 0x0C, 0x00, 0x01, 0x80, 0x70, 0x38, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30,
  0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0xE0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x10, 0x70, 0x18,
  0x18, 0x0C, 0x06, 0x07, 0x01, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0xE0, 0x0C,
  0x30, 0x03, 0x18, 0x00, 0xCE, 0x00, 0x77, 0x00, 0x1B, 0xC0, 0x07, 0xF8,
  0x01, 0xEE, 0x00, 0xF1, 0x80, 0x38, 0x60, 0x0C, 0x1C, 0x03, 0x07, 0x00,
  0xC0, 0xC0, 0x70, 0x30, 0x1C, 0x0E, 0x06, 0x03, 0x81, 0x80, 0x60, 0xE0,
  0x1C, 0x00, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x00,
  0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x00, 0x00, 0x1E, 0x07, 0x80,
  0x67, 0xF1, 0xFC, 0x06, 0xE7, 0xB9, 0xE0, 0x78, 0x3E, 0x06, 0x07, 0x01,
  0xE0, 0x70, 0xF0, 0x1C, 0x06, 0x0E, 0x01, 0x80, 0x60, 0xE0, 0x38, 0x06,
  0x0C, 0x03, 0x80, 0x60, 0xC0, 0x30, 0x0E, 0x1C, 0x03, 0x00, 0xE1, 0xC0,
  0x30, 0x0C, 0x18, 0x07, 0x00, 0xC1, 0x80, 0x70, 0x0C, 0x38, 0x06, 0x01,
  0xC3, 0x80, 0x60, 0x1C, 0x30, 0x06, 0x01, 0x83, 0x00, 0xE0, 0x18, 0x30,
  0x0C, 0x01, 0x87, 0x00, 0xC0, 0x38, 0x70, 0x0C, 0x03, 0x06, 0x01, 0xC0,
  0x30, 0x60, 0x1C, 0x03, 0x0E, 0x01, 0x80, 0x70, 0x00, 0x1E, 0x01, 0x9F,
  0xE0, 0x6F, 0x78, 0x1E, 0x07, 0x07, 0x01, 0xC3, 0xC0, 0x70, 0xE0, 0x18,
  0x38, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x61, 0xC0, 0x38, 0x60, 0x0E, 0x18,
  0x03, 0x06, 0x00, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x30, 0x06, 0x0C, 0x01,
  0x83, 0x00, 0x61, 0xC0, 0x38, 0x70, 0x0E, 0x18, 0x03, 0x06, 0x00, 0xC3,
  0x80, 0x70, 0x00, 0x78, 0x00, 0xFF, 0x01, 0xE3, 0x80, 0xE0, 0xE0, 0xE0,
  0x30, 0xE0, 0x1C, 0x60, 0x0E, 0x70, 0x07, 0x30, 0x03, 0x98, 0x01, 0xDC,
  0x00, 0xEE, 0x00, 0x66, 0x00, 0x33, 0x00, 0x19, 0x80, 0x1C, 0xC0, 0x0E,
  0xE0, 0x06, 0x70, 0x07, 0x18, 0x03, 0x0C, 0x03, 0x87, 0x03, 0x83, 0x83,
  0x80, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0x03, 0x80, 0x18, 0xFE, 0x01, 0x98,
  0xE0, 0x1B, 0x07, 0x01, 0xE0, 0x30, 0x3C, 0x03, 0x03, 0x80, 0x30, 0x38,
  0x03, 0x03, 0x80, 0x30, 0x30, 0x03, 0x07, 0x00, 0x30, 0x70, 0x03, 0x06,
  0x00, 0x70, 0x60, 0x07, 0x06, 0x00, 0x60, 0xE0, 0x06, 0x0E, 0x00, 0xE0,
  0xE0, 0x0C, 0x0E, 0x01, 0xC1, 0xE0, 0x18, 0x1E, 0x03, 0x81, 0xB0, 0x70,
  0x1B, 0xFE, 0x01, 0x9F, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00,
  0x03, 0x00, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0x30, 0x78,
  0xEC, 0x1C, 0x1B, 0x0E, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x38, 0xE0, 0x0E,
  0x38, 0x03, 0x8C, 0x00, 0xC7, 0x00, 0x31, 0xC0, 0x0C, 0x60, 0x07, 0x18,
  0x01, 0xC6, 0x00, 0x61, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x01,
  0xE1, 0x80, 0xF0, 0x60, 0x3C, 0x1C, 0x1B, 0x03, 0xFD, 0xC0, 0x7E, 0x60,
  0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x00,
  0x1E, 0x0C, 0xF8, 0x1B, 0xF0, 0x36, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x0F, 0xFC,
  0x3C, 0x70, 0xE0, 0x21, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x10,
  0x1C, 0x3F, 0xF0, 0x7F, 0xC0, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60,
  0x1C, 0x0F, 0xFB, 0xFE, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x3F, 0x07, 0xE0, 0x0E, 0x01, 0xC3,
  0x00, 0x60, 0xC0, 0x18, 0x70, 0x0E, 0x1C, 0x03, 0x86, 0x00, 0xC1, 0x80,
  0x30, 0x60, 0x0C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x00, 0x60, 0xC0, 0x18,
  0x30, 0x06, 0x1C, 0x03, 0x86, 0x00, 0xE1, 0x80, 0x30, 0x60, 0x1C, 0x18,
  0x07, 0x0E, 0x03, 0xC1, 0x81, 0xE0, 0x70, 0xD8, 0x1F, 0xF6, 0x03, 0xF1,
  0x80, 0xE0, 0x0E, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xE6, 0x01, 0x8C, 0x07,
  0x18, 0x0C, 0x30, 0x38, 0x60, 0x60, 0xC1, 0xC1, 0x83, 0x03, 0x0E, 0x06,
  0x18, 0x0C, 0x70, 0x18, 0xC0, 0x33, 0x80, 0x66, 0x00, 0xCC, 0x01, 0xB0,
  0x03, 0x60, 0x07, 0x80, 0x0F, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x1F, 0x01, 0xE0, 0x36, 0x03, 0xC0, 0xEC, 0x0D, 0x81, 0x98,
  0x1B, 0x03, 0x30, 0x66, 0x0E, 0x60, 0xCC, 0x18, 0xC3, 0x98, 0x71, 0x86,
  0x30, 0xC3, 0x0C, 0x61, 0x86, 0x30, 0xC6, 0x0C, 0x61, 0x8C, 0x19, 0x83,
  0x38, 0x33, 0x06, 0x60, 0x6E, 0x0D, 0xC0, 0xD8, 0x1B, 0x01, 0xB0, 0x36,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x00, 0x07, 0x00, 0xE0, 0x60, 0x38, 0x0E, 0x06, 0x00,
  0xC1, 0xC0, 0x18, 0x70, 0x03, 0x0C, 0x00, 0x73, 0x00, 0x06, 0xE0, 0x00,
  0xD8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x03,
  0x60, 0x00, 0xEC, 0x00, 0x39, 0x80, 0x06, 0x38, 0x01, 0xC3, 0x00, 0x70,
  0x60, 0x0C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x18, 0x38, 0x03, 0x80, 0x00,
  0xC0, 0x0E, 0x01, 0x80, 0x38, 0x03, 0x00, 0x60, 0x06, 0x01, 0xC0, 0x0C,
  0x03, 0x00, 0x18, 0x06, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x30, 0x00, 0xE0,
  0xE0, 0x01, 0xC1, 0x80, 0x01, 0x87, 0x00, 0x03, 0x0C, 0x00, 0x06, 0x38,
  0x00, 0x0C, 0x60, 0x00, 0x19, 0xC0, 0x00, 0x33, 0x00, 0x00, 0x6E, 0x00,
  0x00, 0xD8, 0x00, 0x01, 0xB0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x2F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x07, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xBF, 0xC0, 0x78,
  0xFC, 0xF0, 0x1F, 0xE8, 0x01, 0xC0,
};

const GFXglyph NotoSans_Condensed_LightItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 31, 10, 1, -31 },
  { 36, 11, 11, 14, 4, -31 },
  { 52, 21, 31, 20, 0, -31 },
  { 134, 19, 36, 19, 0, -33 },
  { 220, 23, 32, 28, 3, -32 },
  { 312, 20, 32, 21, 0, -32 },
  { 392, 5, 11, 8, 4, -31 },
  { 399, 13, 38, 11, 1, -31 },
  { 461, 13, 38, 11, -3, -31 },
  { 523, 14, 15, 18, 5, -33 },
  { 550, 17, 21, 20, 2, -26 },
  { 595, 7, 11, 8, -2, -5 },
  { 605, 10, 2, 12, 1, -13 },
  { 608, 3, 4, 9, 1, -4 },
  { 610, 19, 31, 14, -2, -31 },
  { 684, 17, 32, 19, 1, -32 },
  { 752, 10, 31, 19, 5, -31 },
  { 791, 19, 32, 19, -1, -32 },
  { 867, 18, 32, 19, 0, -32 },
  { 939, 18, 32, 19, 0, -32 },
  { 1011, 19, 31, 19, 0, -31 },
  { 1085, 17, 32, 19, 2, -32 },
  { 1153, 18, 31, 19, 2, -31 },
  { 1223, 19, 32, 19, 0, -32 },
  { 1299, 17, 32, 19, 1, -32 },
  { 1367, 8, 24, 9, 0, -24 },
  { 1391, 10, 30, 9, -2, -24 },
  { 1429, 17, 19, 20, 2, -25 },
  { 1470, 17, 11, 20, 2, -21 },
  { 1494, 17, 19, 20, 2, -25 },
  { 1535, 14, 32, 14, 1, -32 },
  { 1591, 26, 36, 28, 1, -32 },
  { 1708, 19, 32, 19, -3, -32 },
  { 1784, 19, 31, 20, 1, -31 },
  { 1858, 20, 32, 19, 2, -32 },
  { 1938, 20, 31, 22, 1, -31 },
  { 2016, 18, 31, 18, 1, -31 },
  { 2086, 19, 31, 17, 1, -31 },
  { 2160, 22, 32, 24, 2, -32 },
  { 2248, 23, 31, 23, 1, -31 },
  { 2338, 15, 31, 11, -2, -31 },
  { 2397, 17, 39, 9, -7, -31 },
  { 2480, 21, 31, 19, 1, -31 },
  { 2562, 12, 31, 16, 1, -31 },
  { 2609, 29, 31, 30, 1, -31 },
  { 2722, 24, 31, 24, 1, -31 },
  { 2815, 21, 32, 24, 2, -32 },
  { 2899, 19, 31, 19, 1, -31 },
  { 2973, 21, 39, 24, 2, -32 },
  { 3076, 19, 31, 19, 1, -31 },
  { 3150, 20, 32, 18, -1, -32 },
  { 3230, 16, 31, 16, 4, -31 },
  { 3292, 22, 31, 23, 2, -31 },
  { 3378, 18, 31, 19, 4, -31 },
  { 3448, 30, 31, 30, 4, -31 },
  { 3565, 23, 31, 17, -3, -31 },
  { 3655, 16, 31, 17, 4, -31 },
  { 3717, 20, 31, 17, -1, -31 },
  { 3795, 16, 39, 13, -1, -32 },
  { 3873, 7, 31, 15, 4, -31 },
  { 3901, 16, 39, 13, -3, -32 },
  { 3979, 18, 17, 20, 1, -31 },
  { 4018, 14, 2, 14, -4, 4 },
  { 4022, 6, 7, 10, 6, -34 },
  { 4028, 18, 24, 20, 1, -24 },
  { 4082, 18, 33, 20, 0, -33 },
  { 4157, 14, 24, 15, 2, -24 },
  { 4199, 20, 33, 20, 1, -33 },
  { 4282, 16, 24, 17, 1, -24 },
  { 4330, 22, 45, 10, -6, -34 },
  { 4454, 19, 35, 20, 0, -24 },
  { 4538, 18, 33, 19, 0, -33 },
  { 4613, 10, 32, 8, 0, -32 },
  { 4653, 16, 43, 9, -6, -32 },
  { 4739, 18, 33, 16, 0, -33 },
  { 4814, 10, 33, 8, 0, -33 },
  { 4856, 28, 24, 29, 0, -24 },
  { 4940, 18, 24, 19, 0, -24 },
  { 4994, 17, 24, 19, 1, -24 },
  { 5045, 20, 34, 20, -2, -24 },
  { 5130, 18, 34, 20, 1, -24 },
  { 5207, 15, 24, 13, 0, -24 },
  { 5252, 15, 24, 15, 0, -24 },
  { 5297, 11, 29, 11, 1, -29 },
  { 5337, 18, 23, 19, 1, -23 },
  { 5389, 15, 23, 15, 2, -23 },
  { 5433, 23, 23, 25, 3, -23 },
  { 5500, 19, 23, 16, -2, -23 },
  { 5555, 23, 34, 16, -5, -23 },
  { 5653, 16, 23, 14, -1, -23 },
  { 5699, 16, 38, 14, 1, -31 },
  { 5775, 2, 45, 18, 8, -34 },
  { 5787, 16, 38, 14, -3, -31 },
  { 5863, 17, 5, 20, 2, -18 },
};

const GFXfont NotoSans_Condensed_LightItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC44PT7B_H_
