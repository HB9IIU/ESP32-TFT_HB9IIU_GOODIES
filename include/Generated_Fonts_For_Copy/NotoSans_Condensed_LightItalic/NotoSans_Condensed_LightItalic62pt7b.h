#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC62PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic62pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0x1E, 0x0E, 0x38, 0x3C, 0x70, 0x79,
  0xE0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x0F, 0x1C, 0x1C, 0x70, 0x38, 0xE0,
  0x71, 0xC0, 0xE3, 0x81, 0x86, 0x07, 0x0C, 0x0E, 0x38, 0x1C, 0x70, 0x30,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xC0, 0x30, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38,
  0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x18,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0x80, 0x60, 0x07,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0x06, 0x01, 0xC0, 0x00, 0x70,
  0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x30,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x00, 0xC0, 0x00,
  0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0C, 0x03, 0x00, 0x00, 0xE0,
  0x38, 0x01, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x01, 0x80, 0x00,
  0x70, 0x1C, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x18, 0x06, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0xE0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xF9, 0x87, 0x80, 0xF0, 0xC0, 0x80,
  0xF0, 0x60, 0x00, 0x70, 0x30, 0x00, 0x78, 0x38, 0x00, 0x38, 0x18, 0x00,
  0x1C, 0x0C, 0x00, 0x0E, 0x06, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x00,
  0x01, 0xE1, 0x80, 0x00, 0x78, 0xC0, 0x00, 0x3C, 0x60, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x7C, 0x00, 0x01, 0x9F, 0x00, 0x00,
  0xC7, 0x80, 0x00, 0xE1, 0xE0, 0x00, 0x60, 0xF0, 0x00, 0x30, 0x38, 0x00,
  0x18, 0x1C, 0x00, 0x0C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x06, 0x07, 0x00,
  0x03, 0x03, 0x80, 0x01, 0x83, 0xC1, 0x00, 0xC3, 0xC0, 0xE0, 0xE7, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x0E, 0x01, 0xFF, 0x00, 0x0E, 0x01, 0xE3, 0xC0, 0x07,
  0x00, 0xE0, 0xE0, 0x07, 0x00, 0xE0, 0x70, 0x03, 0x80, 0x70, 0x38, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0xE0, 0x06, 0x00, 0xE0,
  0xF0, 0x07, 0x00, 0x60, 0x70, 0x03, 0x80, 0x70, 0x70, 0x01, 0xC0, 0x38,
  0x38, 0x00, 0xE0, 0x1C, 0x38, 0x00, 0x70, 0x0E, 0x1C, 0x00, 0x30, 0x0E,
  0x1C, 0x1F, 0x18, 0x07, 0x1C, 0x3F, 0xCC, 0x03, 0x8E, 0x3F, 0xF6, 0x03,
  0x8E, 0x3C, 0x3B, 0x81, 0xC7, 0x1C, 0x1D, 0xC1, 0xC7, 0x1C, 0x06, 0xE1,
  0xC3, 0x8E, 0x03, 0xBF, 0xE3, 0x8E, 0x01, 0xDF, 0xE3, 0x87, 0x00, 0xC3,
  0xC1, 0xC3, 0x80, 0xE0, 0x01, 0xC3, 0x80, 0x70, 0x00, 0xE1, 0xC0, 0x38,
  0x00, 0xE0, 0xE0, 0x1C, 0x00, 0x70, 0x70, 0x0E, 0x00, 0x70, 0x70, 0x07,
  0x00, 0x70, 0x38, 0x07, 0x00, 0x38, 0x1C, 0x03, 0x80, 0x38, 0x0E, 0x01,
  0xC0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1E, 0x01, 0xC0,
  0x70, 0x0E, 0x00, 0xE0, 0x70, 0x0E, 0x00, 0x70, 0x38, 0x07, 0x00, 0x38,
  0x38, 0x07, 0x00, 0x0E, 0x3C, 0x03, 0x80, 0x07, 0xFC, 0x03, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x0F, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x70,
  0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x1E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x07,
  0x07, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x78, 0x70,
  0x0F, 0x0F, 0x07, 0x80, 0xE1, 0xE0, 0x38, 0x1E, 0x1C, 0x03, 0xC1, 0xC3,
  0xC0, 0x3C, 0x1C, 0x38, 0x01, 0xC3, 0x87, 0x80, 0x1E, 0x38, 0x70, 0x00,
  0xE7, 0x07, 0x00, 0x0F, 0xF0, 0x70, 0x00, 0xFE, 0x0F, 0x00, 0x07, 0xE0,
  0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x7C, 0x07, 0x00,
  0x0F, 0xC0, 0x78, 0x01, 0xDE, 0x07, 0xC0, 0x79, 0xE0, 0x3F, 0x3F, 0x0F,
  0x01, 0xFF, 0xE0, 0xF0, 0x0F, 0xF8, 0x07, 0x80, 0x18, 0x00, 0x00, 0x1E,
  0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1C, 0x38, 0xE1, 0xC3, 0x87, 0x0C, 0x18,
  0x70, 0x00, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x04, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0xC6,
  0x00, 0x3F, 0x60, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x73, 0x00, 0x0E, 0x38, 0x01, 0xE1, 0x80, 0x3C, 0x1C, 0x07,
  0x81, 0xC0, 0x30, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x03, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x00, 0x7F, 0xFD, 0xFF, 0xFF,
  0xFF, 0xC0, 0x13, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0x7C, 0x00,
  0xF0, 0x1E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x03, 0xC0, 0x0E, 0x03,
  0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C,
  0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0,
  0x01, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0x80, 0x70, 0x07, 0x80, 0x78,
  0x0F, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x1F, 0x80, 0xFE,
  0x0F, 0xF8, 0x7D, 0xE3, 0xE7, 0x1E, 0x1C, 0xF0, 0x71, 0x83, 0xC4, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x0F, 0xC0,
  0x07, 0x80, 0x7C, 0x00, 0x40, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x07, 0xF0, 0x7C, 0x00, 0xE0, 0x07, 0x80, 0x30,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x80, 0x01, 0xE0, 0x30, 0x01, 0xF0, 0x0F, 0xC7,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xF0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38, 0x70, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x81,
  0xC0, 0x00, 0xE0, 0x38, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x01,
  0xC0, 0x38, 0x00, 0x78, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x01, 0xE0,
  0x03, 0x80, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0x83, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x02, 0x00, 0x0F, 0x80, 0xC0, 0x07, 0xC0, 0x3F, 0x1F, 0xE0,
  0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x20,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x0F, 0xF0, 0x07, 0x9F,
  0xFC, 0x03, 0x9F, 0xFF, 0x01, 0xDC, 0x07, 0x80, 0xFC, 0x01, 0xE0, 0xFC,
  0x00, 0x70, 0x7C, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0E,
  0x00, 0x07, 0x87, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xE1,
  0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x01, 0xC0, 0x07,
  0x80, 0xE0, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x0F, 0xCF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70,
  0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x03, 0xC0,
  0x70, 0x00, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0x87, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x03,
  0xE1, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x01, 0xE0,
  0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC3, 0xC0,
  0x00, 0x70, 0xF0, 0x00, 0x1C, 0x1C, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x3E, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x0F, 0x03, 0x80, 0x07, 0x07,
  0x80, 0x07, 0x07, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x0E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x1E,
  0x00, 0x07, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x1E,
  0x00, 0x1F, 0x1E, 0x00, 0x3E, 0x0E, 0x00, 0x3E, 0x0F, 0x00, 0x6E, 0x0F,
  0x81, 0xEE, 0x07, 0xFF, 0xDE, 0x03, 0xFF, 0x1C, 0x01, 0xFE, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0xF3, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC0,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x80, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x07,
  0xC3, 0xE0, 0xC0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x00, 0x07,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x38, 0x00, 0x00, 0x07, 0x07, 0x00, 0x1F,
  0xC0, 0x70, 0x70, 0x07, 0xFE, 0x07, 0x0E, 0x00, 0xFB, 0xE0, 0x70, 0xE0,
  0x1C, 0x0E, 0x03, 0x1C, 0x03, 0x80, 0xE0, 0x71, 0xC0, 0x70, 0x1C, 0x07,
  0x38, 0x07, 0x01, 0xC0, 0x73, 0x80, 0xE0, 0x1C, 0x07, 0x38, 0x0E, 0x01,
  0xC0, 0x73, 0x01, 0xC0, 0x38, 0x07, 0x70, 0x1C, 0x03, 0x80, 0x67, 0x03,
  0x80, 0x38, 0x0E, 0x70, 0x38, 0x03, 0x80, 0xE7, 0x03, 0x80, 0x70, 0x0E,
  0x60, 0x38, 0x07, 0x00, 0xCE, 0x03, 0x00, 0x70, 0x1C, 0xE0, 0x70, 0x0F,
  0x01, 0xCE, 0x07, 0x00, 0xE0, 0x38, 0xE0, 0x70, 0x1E, 0x03, 0x8E, 0x07,
  0x01, 0xE0, 0x70, 0xE0, 0x70, 0x36, 0x07, 0x0E, 0x03, 0x87, 0x70, 0xE0,
  0xE0, 0x3F, 0xE7, 0xBC, 0x0E, 0x01, 0xFC, 0x3F, 0x80, 0xE0, 0x0F, 0x81,
  0xF0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0xF3, 0x80, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x07, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x78,
  0x0E, 0x00, 0x1C, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x01,
  0xE0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x01, 0xE0, 0x03, 0xC0, 0x70, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x0E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC1, 0xE0, 0x00, 0x70, 0xF0,
  0x00, 0x1C, 0x3C, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x71,
  0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x03,
  0xE0, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00,
  0x0E, 0x01, 0xC0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0,
  0x38, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x80, 0x38, 0x00, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0x01, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01,
  0xE0, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x7C, 0x07,
  0x00, 0x0F, 0x80, 0x70, 0x07, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFC, 0x1E, 0x00, 0x3E, 0x00, 0x40, 0x07,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x02, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xE0, 0x1F,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x70, 0x00, 0xF0, 0x03, 0x80, 0x03, 0xC0,
  0x1C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x1E, 0x03, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1C, 0x0F, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x78,
  0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x00, 0xF0, 0x70,
  0x00, 0x07, 0x83, 0x80, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xC1, 0xE0, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x07, 0x83, 0x80, 0x00, 0x38,
  0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x1E, 0x0E, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x78, 0x0E, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xC0,
  0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0xE0, 0x0E, 0x00, 0x7E, 0x00, 0x70,
  0x1F, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xC0, 0x0F, 0x80, 0x00, 0x80, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xF8, 0x38,
  0x00, 0x3F, 0xF0, 0xF0, 0x00, 0xFF, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1C, 0x1E, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xC0, 0xF0, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x1C,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x04,
  0x1F, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC3,
  0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x39, 0xF0, 0x00, 0x00, 0x77, 0xE0, 0x00, 0x00, 0xEF, 0xC0,
  0x00, 0x03, 0xFB, 0x80, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x01, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0x0E, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0xE0, 0x07, 0x80, 0x01, 0xC0, 0x07, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x01, 0xEE, 0x00, 0x00, 0xF7,
  0x00, 0x73, 0x80, 0x00, 0x3B, 0xC0, 0x1C, 0xE0, 0x00, 0x1E, 0xF0, 0x07,
  0x38, 0x00, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x03, 0xCE, 0x00, 0xF3, 0x80,
  0x00, 0xE3, 0x80, 0x38, 0xE0, 0x00, 0x79, 0xE0, 0x0E, 0x38, 0x00, 0x1C,
  0x78, 0x03, 0x8E, 0x00, 0x0F, 0x1C, 0x00, 0xE3, 0x80, 0x03, 0x87, 0x00,
  0x78, 0xE0, 0x01, 0xE1, 0xC0, 0x1C, 0x3C, 0x00, 0x70, 0xF0, 0x07, 0x07,
  0x00, 0x3C, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0xF0, 0x70, 0x07,
  0x83, 0x80, 0x3C, 0x1C, 0x01, 0xC1, 0xE0, 0x0E, 0x07, 0x00, 0xF0, 0x78,
  0x03, 0x81, 0xC0, 0x38, 0x1C, 0x00, 0xE0, 0x70, 0x1E, 0x07, 0x00, 0x78,
  0x1C, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x03, 0xC0, 0xF0, 0x07, 0x01, 0xC0,
  0xE0, 0x3C, 0x01, 0xC0, 0x70, 0x78, 0x0E, 0x00, 0x70, 0x1C, 0x1C, 0x03,
  0x80, 0x3C, 0x07, 0x8F, 0x00, 0xE0, 0x0E, 0x00, 0xE3, 0x80, 0x78, 0x03,
  0x80, 0x39, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x70, 0x07, 0x00, 0x78, 0x03,
  0xBC, 0x01, 0xC0, 0x1E, 0x00, 0xEE, 0x00, 0xF0, 0x07, 0x00, 0x3F, 0x80,
  0x3C, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xF0, 0x03, 0x80,
  0x3C, 0x00, 0xF8, 0x00, 0xE0, 0x0E, 0x00, 0x3E, 0x00, 0x78, 0x03, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1F, 0x00, 0x00,
  0xE0, 0x07, 0xC0, 0x00, 0x38, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0xFC, 0x00,
  0x07, 0x80, 0x3F, 0x00, 0x01, 0xE0, 0x0E, 0xE0, 0x00, 0x70, 0x03, 0xB8,
  0x00, 0x1C, 0x01, 0xEE, 0x00, 0x07, 0x00, 0x73, 0x80, 0x03, 0xC0, 0x1C,
  0x70, 0x00, 0xF0, 0x07, 0x1C, 0x00, 0x38, 0x01, 0xC7, 0x00, 0x0E, 0x00,
  0xF1, 0xC0, 0x03, 0x80, 0x38, 0x78, 0x01, 0xE0, 0x0E, 0x0E, 0x00, 0x70,
  0x03, 0x83, 0x80, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x78, 0x3C, 0x03,
  0xC0, 0x1C, 0x07, 0x00, 0xF0, 0x07, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0x70,
  0x0E, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0x3C, 0x03, 0x81, 0xE0, 0x0E, 0x00,
  0xE0, 0x78, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xE0, 0x0F, 0x07, 0x00, 0x78,
  0x01, 0xC1, 0xC0, 0x1C, 0x00, 0x70, 0xF0, 0x07, 0x00, 0x1C, 0x38, 0x01,
  0xC0, 0x07, 0x8E, 0x00, 0x70, 0x00, 0xE3, 0x80, 0x3C, 0x00, 0x38, 0xE0,
  0x0E, 0x00, 0x0E, 0x78, 0x03, 0x80, 0x03, 0xDC, 0x00, 0xE0, 0x00, 0x77,
  0x00, 0x78, 0x00, 0x1D, 0xC0, 0x1E, 0x00, 0x07, 0x70, 0x07, 0x00, 0x01,
  0xFC, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x03, 0xE0, 0x0E, 0x00, 0x00, 0xF8, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x03,
  0xC0, 0x38, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x1C, 0x78, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x0E, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x1C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x0E, 0x0F, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x78, 0x0F, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x38, 0x00, 0xF0, 0x07, 0x00,
  0x0E, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80,
  0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0xF0, 0x00,
  0xF0, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0xF0, 0x1E,
  0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x0E, 0x00, 0xF8,
  0x03, 0xC0, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x00,
  0x78, 0x07, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78,
  0x3C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x03, 0x8F, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0xE3, 0x80, 0x00,
  0x07, 0x3C, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x01, 0xEE, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x78, 0xE0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x0E, 0x0F, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x0F, 0x80, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x78, 0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xC0, 0x07, 0x80, 0x38,
  0x00, 0x70, 0x07, 0x00, 0x0E, 0x01, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x3C,
  0x07, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x1C, 0x07, 0x80,
  0x03, 0x80, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80,
  0x70, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x80, 0x70, 0x03,
  0xE0, 0x0E, 0x01, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0x01, 0xC0,
  0x01, 0xE0, 0x3C, 0x00, 0x38, 0x07, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0,
  0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0xF0, 0x01, 0xE0, 0x1C, 0x00,
  0x3C, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x1E, 0x00, 0x0F, 0x03,
  0xC0, 0x01, 0xE0, 0x70, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xC3, 0xF0, 0x07, 0xC0, 0x0C,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x80, 0x01,
  0xF0, 0x1C, 0x00, 0x7C, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70,
  0x1C, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0x80,
  0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x01, 0xC0, 0x00,
  0x1C, 0x07, 0x00, 0x00, 0x70, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x01, 0xC0, 0x70,
  0x00, 0x07, 0x01, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x03, 0x80, 0xF0, 0x00, 0x0E, 0x03, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0,
  0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x71, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x3C, 0x38, 0x00,
  0x1C, 0x1C, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x03, 0x80,
  0x07, 0x81, 0xC0, 0x03, 0x80, 0xE0, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0x38,
  0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x70, 0x03,
  0xC0, 0x78, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x1E, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87, 0x80,
  0x01, 0xC3, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x39, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xDC, 0x00, 0x07, 0x80, 0x01, 0xEE, 0x00, 0x07, 0xC0, 0x00, 0xF7, 0x00,
  0x03, 0xE0, 0x00, 0x73, 0x80, 0x03, 0xF0, 0x00, 0x79, 0xC0, 0x01, 0xF8,
  0x00, 0x38, 0xE0, 0x01, 0xDC, 0x00, 0x3C, 0x70, 0x00, 0xEE, 0x00, 0x1C,
  0x38, 0x00, 0x77, 0x00, 0x1E, 0x1C, 0x00, 0x73, 0x80, 0x0F, 0x0E, 0x00,
  0x39, 0xC0, 0x07, 0x07, 0x00, 0x38, 0xE0, 0x07, 0x83, 0x80, 0x1C, 0x70,
  0x03, 0x81, 0xC0, 0x0E, 0x38, 0x03, 0xC0, 0xE0, 0x0E, 0x1C, 0x01, 0xE0,
  0x70, 0x07, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x07, 0x00, 0xF0, 0x1C, 0x03,
  0x83, 0x80, 0x70, 0x0E, 0x03, 0xC1, 0xC0, 0x78, 0x07, 0x01, 0xC0, 0xE0,
  0x38, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x01, 0xC0, 0xE0, 0x38, 0x1E, 0x00,
  0xE0, 0x70, 0x1C, 0x0E, 0x00, 0x70, 0x70, 0x0E, 0x0F, 0x00, 0x38, 0x38,
  0x07, 0x07, 0x00, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x01, 0xC3,
  0xC0, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00, 0x71, 0xE0, 0x01,
  0xC7, 0x00, 0x38, 0xE0, 0x00, 0xE7, 0x80, 0x1C, 0x70, 0x00, 0x73, 0x80,
  0x0E, 0x70, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0x1D, 0xC0, 0x03, 0xBC,
  0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x03, 0x80,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xC0,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x00, 0x38, 0x78,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0x70, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01,
  0xE0, 0xE0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x78, 0x01, 0xC0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1F,
  0x70, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0x70, 0x00, 0x38, 0x70, 0x00, 0x78,
  0x78, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x38, 0x01, 0xE0,
  0x38, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x3C, 0x07, 0x00,
  0x3C, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x3C, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x07,
  0x00, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x1E, 0x00, 0x78, 0x0E, 0x00,
  0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0xE3, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x0C, 0x0E,
  0x07, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xE1, 0xC0, 0x3F, 0xF8, 0xE0, 0x3F,
  0xBE, 0x70, 0x3E, 0x07, 0x70, 0x1E, 0x01, 0xB8, 0x1E, 0x00, 0x7C, 0x1E,
  0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x87,
  0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70,
  0xF0, 0x00, 0x38, 0x78, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0E,
  0x1E, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0x7C, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x03, 0x80, 0x37, 0x01, 0xE0,
  0x33, 0x80, 0x7C, 0xF9, 0xC0, 0x3F, 0xF8, 0xC0, 0x0F, 0xF0, 0xE0, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x02, 0x00, 0x07,
  0x0F, 0xE0, 0x07, 0x9F, 0xFC, 0x03, 0x9F, 0x7E, 0x01, 0xDC, 0x07, 0x80,
  0xFC, 0x03, 0xC0, 0xFC, 0x00, 0xE0, 0x7E, 0x00, 0x78, 0x3E, 0x00, 0x3C,
  0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03,
  0xC3, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0xF0, 0x00,
  0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0F, 0x0E, 0x00,
  0x07, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x03, 0xC3, 0x80, 0x01, 0xC1, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x78, 0x3E,
  0x00, 0x78, 0x1F, 0x00, 0x78, 0x1D, 0xC0, 0x7C, 0x0E, 0x78, 0xFC, 0x07,
  0x1F, 0xFC, 0x03, 0x07, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x02, 0x00,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xF9, 0xE0, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x08, 0x07, 0xE3, 0xC0, 0x1F, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x60, 0x38, 0x00, 0x3F, 0xC3, 0x80, 0x0F, 0xFE,
  0x38, 0x01, 0xFD, 0xF7, 0x80, 0x3E, 0x03, 0x70, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x1E, 0x00,
  0x0E, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0,
  0x38, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x1C, 0x07, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x38,
  0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xE0,
  0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x1F,
  0x00, 0xF0, 0x03, 0xF0, 0x0F, 0x00, 0x3E, 0x00, 0x70, 0x06, 0xE0, 0x07,
  0x80, 0xEE, 0x00, 0x3E, 0x7C, 0xE0, 0x03, 0xFF, 0x8E, 0x00, 0x1F, 0xE1,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0x00, 0x01, 0xFF, 0x00, 0x1F,
  0xFC, 0x03, 0xF3, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x1C, 0x1E, 0x00, 0xE1,
  0xE0, 0x07, 0x0E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00, 0x1E, 0x78, 0x00,
  0xE3, 0x80, 0x0F, 0x1C, 0x00, 0xF1, 0xE0, 0x1F, 0x0F, 0x07, 0xF0, 0x7F,
  0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x04, 0x07, 0xE1, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x08, 0x78, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFE,
  0x1C, 0x00, 0x7F, 0xE3, 0x80, 0x3F, 0xBE, 0x70, 0x0F, 0x80, 0xCC, 0x01,
  0xE0, 0x1F, 0x80, 0x78, 0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x07,
  0xC0, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0x78, 0x1C, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x38, 0x1E, 0x00,
  0x07, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81,
  0xC0, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x80, 0xF0, 0x01,
  0xF0, 0x1E, 0x00, 0x7E, 0x03, 0xC0, 0x1F, 0x80, 0x38, 0x03, 0x70, 0x07,
  0x81, 0xEE, 0x00, 0x7C, 0xFB, 0xC0, 0x0F, 0xFE, 0x78, 0x00, 0xFF, 0x0E,
  0x00, 0x03, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x08, 0x00,
  0xF0, 0x01, 0xE0, 0x7E, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x60, 0x01, 0xC7,
  0xF8, 0x03, 0xCF, 0xFE, 0x03, 0x9F, 0x7E, 0x03, 0xB8, 0x0F, 0x03, 0xF0,
  0x0F, 0x07, 0xE0, 0x0F, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0F, 0x00,
  0x0E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1E, 0x00,
  0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x3C, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x38, 0x00, 0x78, 0x78, 0x00,
  0x70, 0x78, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x00,
  0xF0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01,
  0xE0, 0x00, 0x70, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x8F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x0F, 0x03, 0xC0, 0x1E,
  0x03, 0x80, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x07, 0x80, 0xF0,
  0x07, 0x81, 0xE0, 0x07, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x07, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x0E, 0x78, 0x00,
  0x0E, 0xF8, 0x00, 0x1E, 0xFC, 0x00, 0x1D, 0xFC, 0x00, 0x1F, 0x9C, 0x00,
  0x1F, 0x1C, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x78, 0x07, 0x00, 0x78, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x70, 0x03, 0x80, 0xF0, 0x03, 0x80,
  0xF0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x80, 0x01, 0x00, 0x06, 0x1F, 0xE0, 0x7F, 0x80,
  0x38, 0xFF, 0xC3, 0xFF, 0x00, 0xE7, 0xFF, 0x1F, 0x7E, 0x03, 0xB8, 0x1E,
  0xE0, 0x78, 0x0F, 0xC0, 0x7F, 0x00, 0xF0, 0x7E, 0x00, 0xF8, 0x03, 0xC1,
  0xF0, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x70, 0x01, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x80, 0x0E, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x01, 0xE0, 0xE0, 0x01, 0xC0,
  0x07, 0x83, 0x80, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x78,
  0x00, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x80, 0x0F, 0x07, 0x00, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0xF0, 0x01, 0xC0, 0x03, 0x83, 0x80,
  0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xF0, 0x01,
  0xC1, 0xE0, 0x03, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x80, 0x0E,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0xE0, 0x01,
  0xC0, 0x07, 0x83, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x60, 0x01,
  0x87, 0xFC, 0x03, 0x8F, 0xFE, 0x03, 0x9F, 0xFE, 0x03, 0xB8, 0x1F, 0x03,
  0xF0, 0x0F, 0x07, 0xE0, 0x0F, 0x07, 0xC0, 0x0F, 0x07, 0xC0, 0x0F, 0x07,
  0x80, 0x0F, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E,
  0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1C,
  0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x3C,
  0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x38, 0x00, 0x78, 0x78,
  0x00, 0x70, 0x78, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70,
  0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xE0,
  0x01, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xEF, 0xC0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x07, 0x07, 0x80,
  0x0F, 0x0E, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xE0, 0x00,
  0x73, 0xC0, 0x00, 0xE7, 0x00, 0x01, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F,
  0x70, 0x00, 0x1E, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xEF,
  0x00, 0x03, 0xDE, 0x00, 0x07, 0x3C, 0x00, 0x0E, 0x70, 0x00, 0x3C, 0xE0,
  0x00, 0x71, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x07, 0x00,
  0x1C, 0x0F, 0x00, 0x78, 0x1F, 0x03, 0xE0, 0x1F, 0x9F, 0x80, 0x1F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x03,
  0x07, 0xF0, 0x00, 0x71, 0xFF, 0xC0, 0x07, 0x3E, 0x7C, 0x00, 0x77, 0x01,
  0xE0, 0x07, 0x60, 0x1E, 0x00, 0x7C, 0x00, 0xE0, 0x0F, 0xC0, 0x0F, 0x00,
  0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0,
  0x1C, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x0E, 0x03, 0x80,
  0x01, 0xE0, 0x38, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x1C,
  0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x38, 0x07, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0xC0, 0x7C, 0x01, 0xCF, 0x1F, 0x80, 0x1C,
  0x7F, 0xF0, 0x01, 0xC3, 0xFC, 0x00, 0x1C, 0x0C, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F,
  0xE1, 0xC0, 0x3F, 0xF8, 0xE0, 0x3F, 0xBE, 0x70, 0x3E, 0x03, 0x70, 0x1E,
  0x01, 0xF8, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x0F,
  0x00, 0x0F, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1,
  0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x0F, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xC0, 0x01, 0xE0, 0xE0, 0x00,
  0xF0, 0x70, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x7E, 0x0F, 0x00,
  0x3E, 0x03, 0x80, 0x37, 0x01, 0xE0, 0x3B, 0x80, 0xFC, 0xFB, 0xC0, 0x3F,
  0xF9, 0xE0, 0x0F, 0xF0, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x40, 0x18, 0x7F, 0x03, 0x8F,
  0xE0, 0x39, 0xFE, 0x03, 0xB8, 0x00, 0x3F, 0x00, 0x07, 0x60, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xFE, 0x07, 0xE3, 0xE0, 0x78, 0x03, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x82, 0x00, 0x78, 0x1E, 0x0F, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x03,
  0xC0, 0x00, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x1F, 0xFE, 0x7F, 0xF9, 0xFF, 0xF0, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x3E, 0x60, 0x3F, 0xC0, 0x7F, 0x80, 0x18, 0x00, 0x07, 0x80, 0x07,
  0x07, 0x00, 0x07, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x0F, 0x00, 0x0E,
  0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1E,
  0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C,
  0x1C, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78,
  0x38, 0x00, 0x78, 0x38, 0x00, 0x70, 0x78, 0x00, 0x70, 0x70, 0x00, 0x70,
  0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xE0, 0xF0, 0x0F, 0xC0,
  0xF0, 0x1D, 0xC0, 0x7C, 0xF9, 0xC0, 0x7F, 0xF1, 0xC0, 0x3F, 0xE1, 0x80,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0xE0,
  0x01, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x0E, 0x00, 0x78,
  0x70, 0x03, 0x83, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00,
  0xF0, 0x38, 0x07, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0x70, 0x3C, 0x03,
  0x81, 0xC0, 0x1C, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x0F, 0x00, 0x3C, 0x70,
  0x01, 0xE7, 0x80, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x01,
  0xE0, 0x03, 0xF8, 0x00, 0xF0, 0x01, 0xDC, 0x00, 0xF8, 0x01, 0xEE, 0x00,
  0x7C, 0x00, 0xE7, 0x00, 0x76, 0x00, 0x73, 0x80, 0x3B, 0x00, 0x79, 0xC0,
  0x1D, 0x80, 0x38, 0xE0, 0x1C, 0xC0, 0x3C, 0x70, 0x0E, 0x60, 0x1C, 0x38,
  0x0E, 0x30, 0x0E, 0x1C, 0x07, 0x18, 0x0E, 0x0E, 0x07, 0x0C, 0x07, 0x07,
  0x03, 0x86, 0x07, 0x83, 0x81, 0xC3, 0x03, 0x81, 0xC1, 0xC1, 0x83, 0xC0,
  0xE0, 0xE0, 0xC1, 0xC0, 0x70, 0xE0, 0x60, 0xE0, 0x38, 0x70, 0x30, 0xE0,
  0x1C, 0x70, 0x18, 0x70, 0x0E, 0x38, 0x0E, 0x78, 0x07, 0x1C, 0x06, 0x38,
  0x03, 0x9C, 0x03, 0x1C, 0x01, 0xCE, 0x01, 0x9C, 0x00, 0xEE, 0x00, 0xCE,
  0x00, 0x77, 0x00, 0x67, 0x00, 0x3B, 0x00, 0x37, 0x00, 0x1F, 0x80, 0x1B,
  0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x03,
  0xC0, 0x07, 0x00, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x71, 0xC0,
  0x00, 0x0E, 0x70, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x70, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x80, 0x70, 0x01, 0xE0, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x03, 0x80, 0xF0,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x70, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0E, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0,
  0x1E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x01,
  0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1C, 0x0E, 0x00, 0x00, 0x38, 0x3C,
  0x00, 0x00, 0x70, 0x70, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x03, 0x87, 0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0x0C, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x08, 0x78, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0x7F, 0xF0, 0x01,
  0xFF, 0xFC, 0x07, 0xE0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFE, 0x80, 0x03, 0xF8,
};

const GFXglyph NotoSans_Condensed_LightItalic62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 44, 14, 1, -44 },
  { 78, 15, 16, 19, 6, -44 },
  { 108, 29, 44, 29, 1, -44 },
  { 268, 25, 51, 26, 1, -47 },
  { 428, 33, 46, 39, 4, -45 },
  { 618, 28, 46, 29, 0, -45 },
  { 779, 7, 16, 11, 6, -44 },
  { 793, 18, 54, 16, 2, -44 },
  { 915, 18, 54, 16, -4, -44 },
  { 1037, 20, 21, 25, 7, -47 },
  { 1090, 24, 29, 29, 3, -36 },
  { 1177, 10, 15, 12, -3, -7 },
  { 1196, 14, 3, 17, 1, -18 },
  { 1202, 5, 6, 12, 1, -6 },
  { 1206, 27, 44, 20, -3, -44 },
  { 1355, 24, 46, 26, 2, -45 },
  { 1493, 14, 44, 26, 8, -44 },
  { 1570, 27, 45, 26, -1, -45 },
  { 1722, 26, 46, 26, 0, -45 },
  { 1872, 27, 45, 26, -1, -45 },
  { 2024, 26, 45, 26, 0, -44 },
  { 2171, 25, 46, 26, 2, -45 },
  { 2315, 25, 44, 26, 3, -44 },
  { 2453, 26, 46, 26, 0, -45 },
  { 2603, 24, 46, 26, 1, -45 },
  { 2741, 10, 33, 12, 1, -33 },
  { 2783, 15, 41, 12, -3, -33 },
  { 2860, 24, 28, 29, 3, -36 },
  { 2944, 24, 16, 29, 3, -30 },
  { 2992, 24, 28, 29, 3, -36 },
  { 3076, 19, 45, 19, 2, -45 },
  { 3183, 36, 49, 39, 2, -44 },
  { 3404, 26, 44, 26, -4, -44 },
  { 3547, 28, 44, 29, 1, -44 },
  { 3701, 28, 46, 27, 3, -45 },
  { 3862, 29, 44, 32, 1, -44 },
  { 4022, 26, 44, 25, 1, -44 },
  { 4165, 27, 44, 23, 1, -44 },
  { 4314, 31, 46, 33, 3, -45 },
  { 4493, 32, 44, 33, 1, -44 },
  { 4669, 21, 44, 15, -2, -44 },
  { 4785, 23, 55, 12, -9, -44 },
  { 4944, 31, 44, 27, 1, -44 },
  { 5115, 17, 44, 23, 1, -44 },
  { 5209, 42, 44, 42, 1, -44 },
  { 5440, 34, 44, 34, 1, -44 },
  { 5627, 29, 46, 34, 3, -45 },
  { 5794, 27, 44, 27, 1, -44 },
  { 5943, 29, 56, 34, 3, -45 },
  { 6146, 27, 44, 27, 1, -44 },
  { 6295, 27, 46, 25, -1, -45 },
  { 6451, 23, 44, 23, 5, -44 },
  { 6578, 30, 45, 32, 3, -44 },
  { 6747, 25, 44, 26, 6, -44 },
  { 6885, 41, 44, 43, 6, -44 },
  { 7111, 33, 44, 24, -4, -44 },
  { 7293, 24, 44, 23, 5, -44 },
  { 7425, 29, 44, 24, -2, -44 },
  { 7585, 23, 54, 18, -1, -44 },
  { 7741, 10, 44, 20, 6, -44 },
  { 7796, 23, 54, 18, -4, -44 },
  { 7952, 25, 24, 28, 2, -44 },
  { 8027, 20, 2, 19, -5, 6 },
  { 8032, 8, 9, 15, 9, -47 },
  { 8041, 25, 35, 28, 2, -34 },
  { 8151, 25, 48, 28, 1, -47 },
  { 8301, 21, 35, 21, 2, -34 },
  { 8393, 28, 48, 28, 2, -47 },
  { 8561, 21, 35, 25, 2, -34 },
  { 8653, 30, 62, 14, -8, -47 },
  { 8886, 27, 49, 28, 0, -34 },
  { 9052, 24, 47, 27, 1, -47 },
  { 9193, 13, 45, 12, 1, -45 },
  { 9267, 22, 60, 12, -8, -45 },
  { 9432, 24, 47, 23, 1, -47 },
  { 9573, 13, 47, 12, 1, -47 },
  { 9650, 38, 34, 41, 1, -34 },
  { 9812, 24, 34, 27, 1, -34 },
  { 9914, 23, 35, 27, 2, -34 },
  { 10015, 28, 48, 28, -2, -34 },
  { 10183, 25, 49, 28, 2, -34 },
  { 10337, 20, 34, 18, 1, -34 },
  { 10422, 21, 35, 21, 0, -34 },
  { 10514, 15, 42, 15, 2, -41 },
  { 10593, 24, 34, 27, 2, -33 },
  { 10695, 21, 33, 21, 3, -33 },
  { 10782, 33, 33, 35, 4, -33 },
  { 10919, 27, 33, 22, -3, -33 },
  { 11031, 31, 48, 22, -6, -33 },
  { 11217, 23, 33, 19, -2, -33 },
  { 11312, 22, 54, 20, 2, -44 },
  { 11461, 3, 62, 25, 12, -47 },
  { 11485, 22, 54, 20, -4, -44 },
  { 11634, 24, 6, 29, 3, -25 },
};

const GFXfont NotoSans_Condensed_LightItalic62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic62pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC62PT7B_H_
