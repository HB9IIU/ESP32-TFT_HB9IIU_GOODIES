#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC12PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0x24, 0x90, 0x80, 0x76, 0xD0, 0x14, 0xA2, 0x9F, 0x31, 0x4F,
  0x94, 0xA0, 0x11, 0xD4, 0xC2, 0x18, 0xD6, 0x42, 0x00, 0x46, 0xAA, 0xAC,
  0xEE, 0xD5, 0x55, 0x98, 0x11, 0x52, 0x62, 0x36, 0x72, 0xE8, 0xF0, 0x12,
  0x44, 0x48, 0x88, 0x88, 0x40, 0x21, 0x11, 0x11, 0x22, 0x24, 0x80, 0x2F,
  0x6A, 0x44, 0xF4, 0x44, 0x58, 0xE0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82,
  0x10, 0xC0, 0x11, 0x52, 0x98, 0xC6, 0x52, 0x60, 0x2E, 0x92, 0x92, 0x40,
  0x32, 0x42, 0x11, 0x11, 0x08, 0xF0, 0x32, 0x42, 0x13, 0x08, 0x42, 0xE0,
  0x08, 0xC6, 0x55, 0x4B, 0xE2, 0x20, 0x39, 0x10, 0x87, 0x08, 0x42, 0xE0,
  0x19, 0x10, 0x87, 0x46, 0x32, 0x70, 0xF1, 0x12, 0x24, 0x48, 0x80, 0x32,
  0x52, 0x93, 0x2A, 0x32, 0x70, 0x32, 0x52, 0x94, 0xBC, 0x42, 0xE0, 0x40,
  0x20, 0x20, 0x00, 0x94, 0x16, 0x84, 0x30, 0xF0, 0xF0, 0x86, 0x12, 0xC0,
  0x61, 0x11, 0x24, 0x40, 0x80, 0x0C, 0x65, 0x0A, 0xF6, 0x75, 0x6A, 0xCA,
  0x80, 0xF0, 0x08, 0x46, 0x32, 0x9D, 0x29, 0x88, 0x38, 0x94, 0x52, 0x71,
  0x24, 0xA2, 0xF0, 0x3A, 0x21, 0x08, 0x42, 0x10, 0xE0, 0x30, 0xB4, 0x51,
  0x45, 0x14, 0xA2, 0xF0, 0x39, 0x10, 0x87, 0x21, 0x10, 0xF0, 0x39, 0x10,
  0x87, 0x21, 0x10, 0x80, 0x3D, 0x08, 0x20, 0x92, 0x28, 0xA4, 0xF0, 0x24,
  0x94, 0x51, 0x7D, 0x14, 0xA2, 0x88, 0x72, 0x24, 0x44, 0x48, 0xC0, 0x08,
  0x44, 0x21, 0x08, 0x44, 0x21, 0x30, 0x24, 0xA4, 0x94, 0x61, 0x45, 0x24,
  0x90, 0x22, 0x44, 0x44, 0x48, 0xF0, 0x21, 0x21, 0x23, 0x63, 0x65, 0x66,
  0x5A, 0x92, 0x92, 0x22, 0x45, 0x92, 0xA5, 0x4A, 0x95, 0x44, 0x88, 0x32,
  0x63, 0x18, 0xC6, 0x32, 0xE0, 0x31, 0x52, 0x95, 0xB1, 0x10, 0x80, 0x32,
  0x63, 0x18, 0xC6, 0x32, 0xE1, 0x08, 0x31, 0x52, 0x94, 0xB9, 0x52, 0x90,
  0x3A, 0x10, 0x82, 0x08, 0x42, 0xE0, 0xF2, 0x44, 0x44, 0x88, 0x80, 0x4A,
  0x63, 0x18, 0xC6, 0x52, 0xE0, 0x8C, 0x65, 0x2A, 0x53, 0x18, 0x80, 0x89,
  0x91, 0x92, 0xAA, 0xAA, 0xAC, 0xCC, 0xC8, 0x88, 0x22, 0x48, 0x60, 0xC1,
  0x02, 0x0C, 0x24, 0x88, 0x8C, 0xA5, 0x4C, 0x21, 0x10, 0x80, 0x78, 0x44,
  0x22, 0x21, 0x10, 0xF0, 0x32, 0x44, 0x44, 0x48, 0x88, 0xC0, 0xAA, 0x55,
  0x40, 0x38, 0x44, 0x21, 0x08, 0x44, 0x21, 0x30, 0x11, 0x8C, 0x98, 0x80,
  0xF0, 0xC0, 0x7A, 0x63, 0x19, 0x38, 0x21, 0x14, 0xD4, 0xA6, 0x32, 0xF0,
  0x74, 0x88, 0x86, 0x04, 0x13, 0x92, 0x4A, 0x28, 0xA4, 0x70, 0x7A, 0x7D,
  0x08, 0x38, 0x0C, 0x21, 0x84, 0x10, 0x41, 0x08, 0x20, 0x82, 0x30, 0x7A,
  0x63, 0x19, 0x38, 0x42, 0xE0, 0x21, 0x14, 0xD4, 0xA6, 0x52, 0x90, 0x20,
  0x24, 0xA4, 0x80, 0x08, 0x00, 0x21, 0x08, 0x84, 0x21, 0x09, 0x80, 0x21,
  0x12, 0xA6, 0x31, 0x94, 0x90, 0x25, 0x24, 0xA4, 0x80, 0x7F, 0x49, 0x4A,
  0x92, 0x92, 0x92, 0x13, 0x52, 0x99, 0x4A, 0x40, 0x7A, 0x63, 0x19, 0x38,
  0x7A, 0x53, 0x19, 0x7A, 0x10, 0x80, 0x7A, 0x63, 0x19, 0x38, 0x42, 0x10,
  0x74, 0x48, 0x88, 0x74, 0x42, 0x2E, 0x2D, 0x25, 0x26, 0x4A, 0x53, 0x29,
  0x38, 0xBA, 0xAC, 0x88, 0xA6, 0x9D, 0xB6, 0x92, 0x40, 0x2C, 0xA1, 0x0C,
  0x53, 0x40, 0x24, 0xA2, 0x8C, 0x30, 0x82, 0x10, 0x80, 0x72, 0x24, 0x8E,
  0x19, 0x08, 0x42, 0x61, 0x08, 0x42, 0x18, 0xFF, 0xF0, 0x20, 0x84, 0x21,
  0x0C, 0x84, 0x21, 0x30, 0xF0,
};

const GFXglyph NotoSans_Condensed_LightItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 4, 4, 1, -9 },
  { 7, 6, 9, 6, 0, -9 },
  { 14, 5, 10, 5, 0, -9 },
  { 21, 6, 9, 8, 1, -9 },
  { 28, 5, 9, 6, 0, -9 },
  { 34, 1, 4, 2, 1, -9 },
  { 35, 4, 11, 3, 0, -9 },
  { 41, 4, 11, 3, -1, -9 },
  { 47, 4, 4, 5, 1, -9 },
  { 49, 4, 6, 6, 1, -7 },
  { 52, 2, 3, 2, -1, -1 },
  { 53, 3, 1, 3, 0, -4 },
  { 54, 1, 1, 2, 0, -1 },
  { 55, 6, 9, 4, -1, -9 },
  { 62, 5, 9, 5, 0, -9 },
  { 68, 3, 9, 5, 1, -9 },
  { 72, 5, 9, 5, 0, -9 },
  { 78, 5, 9, 5, 0, -9 },
  { 84, 5, 9, 5, 0, -9 },
  { 90, 5, 9, 5, 0, -9 },
  { 96, 5, 9, 5, 0, -9 },
  { 102, 4, 9, 5, 1, -9 },
  { 107, 5, 9, 5, 0, -9 },
  { 113, 5, 9, 5, 0, -9 },
  { 119, 2, 6, 2, 0, -6 },
  { 121, 3, 8, 2, -1, -6 },
  { 124, 4, 5, 6, 1, -7 },
  { 127, 4, 3, 6, 1, -6 },
  { 129, 4, 5, 6, 1, -7 },
  { 132, 4, 9, 4, 0, -9 },
  { 137, 7, 10, 8, 0, -9 },
  { 146, 5, 9, 5, -1, -9 },
  { 152, 6, 9, 6, 0, -9 },
  { 159, 5, 9, 5, 1, -9 },
  { 165, 6, 9, 6, 0, -9 },
  { 172, 5, 9, 5, 0, -9 },
  { 178, 5, 9, 5, 0, -9 },
  { 184, 6, 9, 6, 1, -9 },
  { 191, 6, 9, 6, 0, -9 },
  { 198, 4, 9, 3, 0, -9 },
  { 203, 5, 11, 2, -2, -9 },
  { 210, 6, 9, 5, 0, -9 },
  { 217, 4, 9, 4, 0, -9 },
  { 222, 8, 9, 8, 0, -9 },
  { 231, 7, 9, 7, 0, -9 },
  { 239, 5, 9, 7, 1, -9 },
  { 245, 5, 9, 5, 0, -9 },
  { 251, 5, 11, 7, 1, -9 },
  { 258, 5, 9, 5, 0, -9 },
  { 264, 5, 9, 5, 0, -9 },
  { 270, 4, 9, 4, 1, -9 },
  { 275, 5, 9, 6, 1, -9 },
  { 281, 5, 9, 5, 1, -9 },
  { 287, 8, 9, 8, 1, -9 },
  { 296, 7, 9, 5, -1, -9 },
  { 304, 5, 9, 5, 1, -9 },
  { 310, 5, 9, 5, 0, -9 },
  { 316, 4, 11, 3, 0, -9 },
  { 322, 2, 9, 4, 1, -9 },
  { 325, 5, 11, 3, -1, -9 },
  { 332, 5, 5, 5, 0, -9 },
  { 336, 4, 1, 4, -1, 1 },
  { 337, 1, 2, 3, 2, -9 },
  { 338, 5, 6, 5, 0, -6 },
  { 342, 5, 9, 5, 0, -9 },
  { 348, 4, 6, 4, 0, -6 },
  { 351, 6, 9, 5, 0, -9 },
  { 358, 5, 6, 5, 0, -6 },
  { 362, 6, 12, 3, -2, -9 },
  { 371, 5, 9, 5, 0, -6 },
  { 377, 5, 9, 5, 0, -9 },
  { 383, 3, 9, 2, 0, -9 },
  { 387, 5, 12, 2, -2, -9 },
  { 395, 5, 9, 4, 0, -9 },
  { 401, 3, 9, 2, 0, -9 },
  { 405, 8, 6, 8, 0, -6 },
  { 411, 5, 7, 5, 0, -7 },
  { 416, 5, 6, 5, 0, -6 },
  { 420, 5, 9, 5, 0, -6 },
  { 426, 5, 9, 5, 0, -6 },
  { 432, 4, 6, 4, 0, -6 },
  { 435, 4, 6, 4, 0, -6 },
  { 438, 3, 8, 3, 0, -8 },
  { 441, 5, 6, 5, 0, -6 },
  { 445, 4, 6, 4, 1, -6 },
  { 448, 6, 6, 7, 1, -6 },
  { 453, 6, 6, 4, -1, -6 },
  { 458, 6, 9, 4, -1, -6 },
  { 465, 4, 6, 4, 0, -6 },
  { 468, 5, 11, 4, 0, -9 },
  { 475, 1, 12, 5, 2, -9 },
  { 477, 5, 11, 4, -1, -9 },
  { 484, 4, 1, 6, 1, -5 },
};

const GFXfont NotoSans_Condensed_LightItalic12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC12PT7B_H_
