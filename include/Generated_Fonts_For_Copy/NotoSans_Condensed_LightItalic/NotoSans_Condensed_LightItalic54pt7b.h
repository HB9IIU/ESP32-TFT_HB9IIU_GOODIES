#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC54PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x00,
  0x1C, 0x3C, 0x70, 0xE3, 0xC3, 0x8E, 0x0E, 0x38, 0x38, 0xE1, 0xC3, 0x87,
  0x0C, 0x1C, 0x70, 0x71, 0xC1, 0x86, 0x06, 0x18, 0x38, 0x60, 0xE3, 0x83,
  0x00, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x00, 0x03, 0x01, 0x80, 0x01,
  0x81, 0xC0, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x70, 0x00,
  0x70, 0x38, 0x00, 0x30, 0x18, 0x00, 0x18, 0x0C, 0x00, 0x1C, 0x0E, 0x00,
  0x0E, 0x06, 0x01, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x03, 0x81, 0x80,
  0x01, 0x80, 0xC0, 0x00, 0xC0, 0xE0, 0x00, 0xE0, 0x60, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x18, 0x0C, 0x00, 0x0C, 0x06,
  0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x00, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x01, 0xC0, 0xC0, 0x00, 0xC0, 0x60, 0x00, 0x60, 0x70, 0x00, 0x70,
  0x38, 0x00, 0x30, 0x18, 0x00, 0x18, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E,
  0x06, 0x00, 0x06, 0x03, 0x00, 0x03, 0x03, 0x80, 0x03, 0x81, 0x80, 0x01,
  0x81, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80,
  0xF9, 0x8E, 0x01, 0xC3, 0x04, 0x07, 0x06, 0x00, 0x0E, 0x18, 0x00, 0x38,
  0x30, 0x00, 0x70, 0x60, 0x00, 0xE0, 0xC0, 0x01, 0xC1, 0x80, 0x03, 0x86,
  0x00, 0x03, 0x8C, 0x00, 0x07, 0x98, 0x00, 0x07, 0xB0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x33, 0xC0, 0x00, 0x63, 0x80, 0x00, 0xC3, 0x80, 0x01, 0x87, 0x00,
  0x03, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x18, 0x38, 0x00, 0x30, 0x70, 0x00,
  0x60, 0xC0, 0x00, 0x83, 0x81, 0x03, 0x0E, 0x03, 0x86, 0x7C, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0xE0, 0x3F, 0xC0, 0x06, 0x03, 0xCE, 0x00, 0x70, 0x1C, 0x30, 0x07,
  0x01, 0xC1, 0xC0, 0x38, 0x0C, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x18, 0x06,
  0x03, 0x81, 0xC0, 0x30, 0x18, 0x0C, 0x03, 0x80, 0xC0, 0xE0, 0x1C, 0x06,
  0x0E, 0x00, 0xC0, 0x30, 0x70, 0x06, 0x03, 0x87, 0x00, 0x70, 0x1C, 0x30,
  0x03, 0x80, 0xC3, 0x80, 0x1C, 0x06, 0x18, 0x10, 0xE0, 0x71, 0xC7, 0xE7,
  0x03, 0x1C, 0x7F, 0xB8, 0x38, 0xC7, 0x0D, 0xC1, 0xCE, 0x30, 0x7E, 0x1C,
  0x63, 0x83, 0xB9, 0xC7, 0x18, 0x1D, 0xFC, 0x31, 0xC0, 0xE7, 0xC3, 0x8C,
  0x07, 0x00, 0x38, 0x60, 0x38, 0x01, 0x87, 0x01, 0x80, 0x1C, 0x38, 0x0C,
  0x00, 0xC1, 0x80, 0x60, 0x0E, 0x0C, 0x07, 0x00, 0xE0, 0xE0, 0x38, 0x07,
  0x07, 0x01, 0x80, 0x70, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0xE0, 0x38, 0x0E,
  0x06, 0x01, 0x80, 0x70, 0x70, 0x1C, 0x03, 0x83, 0x01, 0xC0, 0x0C, 0x38,
  0x0E, 0x00, 0x7F, 0x80, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x70, 0x70, 0x00,
  0x70, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00,
  0xC0, 0x30, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0x70, 0x00, 0xC0, 0xE0, 0x00,
  0xE0, 0xE0, 0x00, 0xE1, 0xC0, 0x00, 0xE3, 0x80, 0x00, 0xE7, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0x1C, 0x00, 0x0E, 0x1C, 0x07, 0x1C, 0x0E, 0x0E, 0x3C,
  0x0E, 0x0E, 0x38, 0x07, 0x0E, 0x70, 0x07, 0x1C, 0x70, 0x07, 0x1C, 0x70,
  0x03, 0xB8, 0xE0, 0x03, 0xB8, 0xE0, 0x01, 0xF0, 0xE0, 0x01, 0xE0, 0xE0,
  0x01, 0xE0, 0xE0, 0x03, 0xE0, 0x70, 0x07, 0xE0, 0x70, 0x0F, 0x70, 0x7C,
  0x3E, 0x70, 0x3F, 0xF8, 0x38, 0x1F, 0xF0, 0x38, 0x01, 0x80, 0x00, 0x39,
  0xCE, 0xE7, 0x39, 0xCC, 0x67, 0x39, 0x8C, 0x60, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x04, 0x0C, 0x07, 0x06, 0x03, 0xE3, 0x00, 0x7D,
  0x87, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0xF0, 0x00, 0xFC, 0x00, 0xE6, 0x00,
  0xE3, 0x80, 0xE0, 0xC0, 0xE0, 0x70, 0x20, 0x38, 0x00, 0x0E, 0x00, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00,
  0x06, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x07, 0x0F, 0x0E, 0x0E,
  0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x60, 0xE0, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x6F, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x06, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x1E, 0x0E, 0x03, 0xC0, 0x70, 0x38,
  0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x1C,
  0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x07, 0x38, 0x00, 0x73,
  0x80, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0E,
  0x70, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01,
  0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0,
  0x1C, 0x07, 0x03, 0x80, 0x78, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xE0, 0x7E, 0x0F, 0xE1, 0xEE, 0x78,
  0xEF, 0x0C, 0xE1, 0xC4, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x07, 0x01,
  0xE0, 0x0C, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x1E, 0x01, 0xE0, 0x18, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x04, 0x00,
  0x78, 0x0E, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x06, 0xE0, 0x00, 0x1D, 0x80, 0x00, 0x37, 0x00, 0x00, 0xEE,
  0x00, 0x03, 0x9C, 0x00, 0x0E, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x71, 0xC0,
  0x01, 0xC3, 0x80, 0x03, 0x07, 0x00, 0x0E, 0x0C, 0x00, 0x38, 0x38, 0x00,
  0x60, 0x70, 0x01, 0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x0C, 0x03, 0x00, 0x38,
  0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x1C, 0x01,
  0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC,
  0x03, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x1C, 0x3F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x04, 0x00,
  0x78, 0x0E, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x1F, 0x00, 0x39, 0xFF, 0x00,
  0xCF, 0xFE, 0x07, 0x70, 0x3C, 0x1F, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xE0,
  0x07, 0x07, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x07,
  0x0E, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E,
  0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x07, 0x00,
  0xF0, 0x1C, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x40,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFB, 0xE0, 0x07, 0x81, 0xE0, 0x1C, 0x01,
  0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x70, 0x00, 0xF3, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0xF0,
  0xF0, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0xE0, 0x3C, 0x00, 0xE0, 0x70, 0x01,
  0xC1, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x87, 0x00, 0x07, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC1,
  0xC0, 0x07, 0x03, 0xC0, 0x1E, 0x03, 0xE0, 0xF8, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x7F,
  0xF8, 0x03, 0x81, 0xE0, 0x38, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0xE1,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x00,
  0x71, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x00, 0x0F, 0x1C,
  0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x03, 0xE1, 0xE0, 0x3F,
  0x07, 0xC7, 0xB8, 0x1F, 0xF9, 0x80, 0x7F, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x08, 0x1F, 0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x01,
  0x00, 0x00, 0x01, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1E, 0x07, 0x83,
  0xE0, 0x70, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0x80, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0x07,
  0xFF, 0xC1, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0x06, 0x03, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0C, 0x18, 0x00, 0x00,
  0x18, 0x70, 0x07, 0xE0, 0x30, 0xC0, 0x3F, 0xF0, 0x63, 0x80, 0xF1, 0xC0,
  0xC6, 0x03, 0x83, 0x81, 0x9C, 0x06, 0x07, 0x03, 0x38, 0x1C, 0x0E, 0x06,
  0x60, 0x70, 0x18, 0x0D, 0xC0, 0xC0, 0x70, 0x3B, 0x83, 0x80, 0xE0, 0x76,
  0x07, 0x01, 0xC0, 0xEC, 0x0C, 0x03, 0x01, 0xB8, 0x38, 0x0E, 0x03, 0x70,
  0x70, 0x1C, 0x0E, 0xE0, 0xE0, 0x30, 0x19, 0x81, 0x80, 0xE0, 0x33, 0x03,
  0x01, 0xC0, 0xE6, 0x06, 0x03, 0x81, 0x8C, 0x0C, 0x0F, 0x07, 0x18, 0x1C,
  0x36, 0x1C, 0x30, 0x3C, 0xEE, 0x70, 0x60, 0x3F, 0x8F, 0xC0, 0xC0, 0x3C,
  0x0F, 0x01, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x20, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0x18, 0x00, 0x1C,
  0x60, 0x00, 0x61, 0x80, 0x03, 0x86, 0x00, 0x0E, 0x18, 0x00, 0x70, 0x60,
  0x01, 0xC1, 0x80, 0x0E, 0x06, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x70, 0x07,
  0x01, 0xC0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x01,
  0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x0E, 0x00, 0x70, 0x70, 0x01, 0xC1,
  0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x00,
  0x07, 0x1C, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x07,
  0x70, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x01, 0xC0, 0x3E, 0x01, 0xC0, 0x1E,
  0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07,
  0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x1E, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x07, 0x00, 0xF0,
  0x0E, 0x0F, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x0E, 0x03, 0xE0,
  0x0C, 0x00, 0xF0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x78, 0x1C, 0x00, 0x38,
  0x1C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x38,
  0x38, 0x00, 0x78, 0x38, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0,
  0x70, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0x70, 0x07, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0xF8, 0x06, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x07, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x38, 0x1F, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0x78, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x03, 0x81, 0xC0,
  0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x70, 0x00, 0x38, 0x38,
  0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x70,
  0x60, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x87, 0x00, 0x03, 0x83, 0x80, 0x03,
  0xC1, 0xC0, 0x01, 0xC0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0x70, 0x01,
  0xE0, 0x38, 0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x0C, 0x03, 0xE0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xE0, 0x07, 0x01, 0xF0, 0x00, 0x80, 0xF0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x0F, 0xF8, 0xE0,
  0x03, 0xFE, 0x38, 0x00, 0xFF, 0x8E, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x38,
  0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0x83, 0x80,
  0x00, 0xE0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x00,
  0xF0, 0x01, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xA0, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0,
  0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00,
  0x01, 0xC0, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38,
  0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x38,
  0x00, 0x0E, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01,
  0xC0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x07,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00,
  0x30, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x3F, 0xF8, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x0C,
  0x00, 0x78, 0x07, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x1C, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x03, 0x80, 0xF0, 0x00, 0xE0, 0x78,
  0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC3,
  0xC0, 0x00, 0x71, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x06, 0x38, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0xEF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xB8, 0x00,
  0x07, 0xC7, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1E,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38,
  0x07, 0x00, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x1E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x07,
  0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0x7E, 0x01, 0xB8, 0x00, 0x07, 0xE0, 0x3B, 0x80, 0x00,
  0xEE, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x3B, 0x80, 0x01, 0xDC, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x33, 0x80, 0x03, 0x9C, 0x07, 0x38, 0x00, 0x39, 0xC0,
  0x73, 0x80, 0x07, 0x1C, 0x07, 0x38, 0x00, 0x73, 0x80, 0x71, 0x80, 0x0E,
  0x38, 0x06, 0x18, 0x00, 0xE3, 0x80, 0xE1, 0x80, 0x1C, 0x38, 0x0E, 0x18,
  0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x01,
  0xC1, 0xC0, 0x70, 0x70, 0x1C, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0xE0,
  0x60, 0x1C, 0x1C, 0x0E, 0x0E, 0x01, 0xC1, 0xC1, 0xC0, 0xE0, 0x38, 0x1C,
  0x1C, 0x0E, 0x03, 0x80, 0xC3, 0x80, 0xE0, 0x38, 0x0C, 0x38, 0x1C, 0x03,
  0x80, 0xC7, 0x01, 0xC0, 0x30, 0x0C, 0x70, 0x1C, 0x07, 0x00, 0xCE, 0x01,
  0xC0, 0x70, 0x0E, 0xE0, 0x1C, 0x07, 0x00, 0xFC, 0x03, 0x80, 0x70, 0x0F,
  0xC0, 0x38, 0x0E, 0x00, 0xF8, 0x03, 0x80, 0xE0, 0x0F, 0x80, 0x38, 0x0E,
  0x00, 0xF0, 0x03, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x70,
  0x1F, 0x00, 0x03, 0x00, 0xFC, 0x00, 0x38, 0x06, 0xE0, 0x01, 0xC0, 0x77,
  0x00, 0x0E, 0x03, 0xB8, 0x00, 0x70, 0x1C, 0xC0, 0x07, 0x00, 0xE7, 0x00,
  0x38, 0x06, 0x38, 0x01, 0xC0, 0x71, 0xC0, 0x0E, 0x03, 0x86, 0x00, 0x70,
  0x1C, 0x38, 0x07, 0x00, 0xE1, 0xC0, 0x38, 0x06, 0x0E, 0x01, 0xC0, 0x70,
  0x30, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0x1C, 0x0E, 0x07, 0x00, 0xE0, 0x70,
  0x38, 0x0E, 0x01, 0x81, 0xC0, 0x70, 0x0E, 0x0E, 0x03, 0x80, 0x70, 0xE0,
  0x1C, 0x03, 0x87, 0x00, 0xC0, 0x0C, 0x38, 0x0E, 0x00, 0x71, 0xC0, 0x70,
  0x03, 0x8E, 0x03, 0x80, 0x1C, 0xE0, 0x1C, 0x00, 0x67, 0x00, 0xC0, 0x03,
  0xB8, 0x0E, 0x00, 0x1D, 0xC0, 0x70, 0x00, 0xEC, 0x03, 0x80, 0x03, 0x60,
  0x1C, 0x00, 0x1F, 0x01, 0xC0, 0x00, 0xF8, 0x0E, 0x00, 0x07, 0xC0, 0x70,
  0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1E, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x1C,
  0x00, 0x38, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8F,
  0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x73, 0x80, 0x00, 0x39,
  0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x1E, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x07, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x03, 0x8E, 0x00,
  0x01, 0xC7, 0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xE0, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x0F, 0x00, 0xF8, 0x03,
  0xE1, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0E, 0x07, 0xC0,
  0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x81, 0xC0, 0x07, 0x03,
  0x80, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x70,
  0x00, 0xE0, 0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x06, 0x00,
  0x38, 0x1C, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0x70, 0x0F, 0x00, 0xE3, 0xFC,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x1E, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x1C, 0x00, 0x38,
  0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x0E, 0x00, 0x03, 0x8F, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x73, 0x80, 0x00, 0x39, 0xC0, 0x00,
  0x1C, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0x70,
  0x00, 0x07, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x03, 0x8E, 0x00, 0x01, 0xC7,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x0F, 0x00, 0xF8, 0x03, 0xE1, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0E, 0x07, 0xC0, 0x1C,
  0x03, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80,
  0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0xE0, 0x03, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x38,
  0x1C, 0x00, 0xF0, 0x38, 0x07, 0xC0, 0x70, 0x3F, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38,
  0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07,
  0x01, 0xC0, 0x0E, 0x03, 0x00, 0x1E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x70, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0x00, 0xF8, 0x06, 0x01, 0xE0, 0x02, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0xC0, 0x07, 0x80, 0xF8, 0x3F, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x00, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C,
  0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00,
  0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x0C, 0x0E, 0x00, 0x07, 0x03,
  0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x38, 0x00,
  0x0E, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38,
  0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0x7C, 0x1F,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xCE, 0x00, 0x0F, 0x38, 0x00, 0x38, 0xE0, 0x01, 0xE3,
  0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80,
  0x1C, 0x0E, 0x00, 0x70, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x78,
  0x0E, 0x01, 0xC0, 0x18, 0x07, 0x00, 0x60, 0x38, 0x01, 0x80, 0xE0, 0x06,
  0x07, 0x00, 0x18, 0x1C, 0x00, 0x60, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1C,
  0x00, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00,
  0x1D, 0xC0, 0x00, 0x77, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0x00, 0x0E, 0xE0, 0x01, 0xF0, 0x00, 0xEE, 0x00, 0x1F,
  0x00, 0x1C, 0xE0, 0x03, 0xF0, 0x01, 0xCE, 0x00, 0x37, 0x00, 0x38, 0xE0,
  0x03, 0x70, 0x03, 0x8E, 0x00, 0x77, 0x00, 0x38, 0xE0, 0x06, 0x70, 0x07,
  0x0E, 0x00, 0xE7, 0x00, 0x70, 0xE0, 0x0E, 0x70, 0x0E, 0x0E, 0x01, 0xC7,
  0x00, 0xE0, 0xE0, 0x1C, 0x70, 0x1E, 0x0E, 0x01, 0x87, 0x01, 0xC0, 0xE0,
  0x38, 0x70, 0x1C, 0x0E, 0x03, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x70, 0x38,
  0x0E, 0x07, 0x07, 0x07, 0x00, 0xE0, 0x60, 0x70, 0x70, 0x0E, 0x0E, 0x07,
  0x07, 0x00, 0xE0, 0xC0, 0x70, 0xE0, 0x0E, 0x1C, 0x07, 0x0E, 0x00, 0xE1,
  0xC0, 0x71, 0xC0, 0x0E, 0x38, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x71, 0x80,
  0x0E, 0x30, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x0E, 0x60, 0x06,
  0x70, 0x00, 0xEE, 0x00, 0x67, 0x00, 0x0E, 0xE0, 0x06, 0x60, 0x00, 0xEC,
  0x00, 0x6E, 0x00, 0x0F, 0xC0, 0x06, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x70, 0x00, 0x70, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x03,
  0x80, 0x03, 0x80, 0x38, 0x00, 0x38, 0x07, 0x00, 0x01, 0x80, 0xF0, 0x00,
  0x1C, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC3,
  0x80, 0x00, 0x0C, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x73, 0x80, 0x00, 0x0F,
  0x18, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1C, 0x1C, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x38, 0x1C, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x0E,
  0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x03,
  0xCE, 0x00, 0x38, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x00,
  0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0x30, 0x38, 0x03, 0x87, 0x00, 0x38,
  0x70, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x01,
  0xB8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xC0, 0xC0, 0xC0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x70, 0x70, 0x70, 0x70, 0x30,
  0x30, 0x30, 0x38, 0x38, 0x38, 0x38, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x06, 0x07, 0x07,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xDC, 0x00, 0x07, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xC1,
  0x80, 0x07, 0x07, 0x00, 0x18, 0x1C, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x30, 0x60,
  0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x07, 0xF0, 0x00, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xE3, 0xC7, 0x0C, 0x38, 0x61, 0xC3, 0x00, 0x7E, 0x1C,
  0x07, 0xFC, 0x60, 0x3E, 0x79, 0x81, 0xE0, 0x6E, 0x0F, 0x00, 0xF8, 0x38,
  0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03,
  0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x8F,
  0x00, 0x0E, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00,
  0x1C, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x78,
  0x38, 0x03, 0xE0, 0xE0, 0x1B, 0x01, 0xC0, 0xEC, 0x07, 0x87, 0x70, 0x0F,
  0xF9, 0xC0, 0x1F, 0xC7, 0x00, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x30, 0xFC, 0x03, 0x8F, 0xF0, 0x1D, 0xE7, 0xC0,
  0xEC, 0x0F, 0x06, 0xC0, 0x38, 0x3C, 0x01, 0xC3, 0xE0, 0x0E, 0x1E, 0x00,
  0x70, 0xF0, 0x03, 0x87, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0x80, 0x07, 0x1C,
  0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x07,
  0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0xC0,
  0x07, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x87, 0x80, 0x38, 0x76, 0x03, 0x83,
  0xB8, 0x7C, 0x18, 0xFF, 0x80, 0xC3, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0x38, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0xC1, 0x80,
  0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x7E, 0x1C, 0x01, 0xFF,
  0x18, 0x03, 0xE7, 0xB8, 0x07, 0x81, 0xF8, 0x0F, 0x00, 0xF8, 0x0E, 0x00,
  0xF8, 0x1E, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00,
  0x70, 0x38, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00,
  0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x01,
  0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x07,
  0x80, 0xE0, 0x07, 0x80, 0xE0, 0x0F, 0x80, 0xE0, 0x1B, 0x80, 0xF0, 0x3B,
  0x00, 0x78, 0x73, 0x00, 0x3F, 0xE7, 0x00, 0x1F, 0xC7, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x3E, 0x3C, 0x1E, 0x07, 0x0F, 0x01,
  0xC3, 0x80, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0x79, 0xC0, 0x3C, 0x70, 0x3E, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFC,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x01, 0x07,
  0xC0, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0x88, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x87, 0x00, 0x7F, 0xC6, 0x00,
  0xF9, 0xE6, 0x01, 0xE0, 0x7E, 0x03, 0xC0, 0x3E, 0x03, 0x80, 0x3E, 0x07,
  0x80, 0x1C, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x0E,
  0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x38,
  0x00, 0xF0, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x38,
  0x01, 0xE0, 0x38, 0x03, 0xE0, 0x38, 0x07, 0xE0, 0x3C, 0x0E, 0xC0, 0x1E,
  0x1D, 0xC0, 0x0F, 0xF9, 0xC0, 0x07, 0xF1, 0xC0, 0x00, 0x81, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0xC0,
  0x3C, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0xFC, 0x03, 0x9F, 0xF0,
  0x1D, 0xF7, 0xC0, 0xFC, 0x0E, 0x06, 0xC0, 0x38, 0x3C, 0x01, 0xC3, 0xC0,
  0x0E, 0x1E, 0x00, 0x60, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x78, 0x01, 0xC3,
  0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0xE0, 0x07, 0x06, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x00,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x03,
  0x80, 0xE0, 0x38, 0x07, 0x03, 0xC0, 0x30, 0x3C, 0x03, 0x81, 0xC0, 0x1C,
  0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0x9E, 0x00,
  0x1C, 0xE0, 0x00, 0xEF, 0x80, 0x06, 0xFC, 0x00, 0x7E, 0xE0, 0x03, 0xE7,
  0x00, 0x1E, 0x1C, 0x00, 0xE0, 0xE0, 0x06, 0x07, 0x00, 0x70, 0x38, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xE0, 0x70, 0x07,
  0x03, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x03, 0x0F, 0xC0, 0xFC, 0x03, 0x9F,
  0xF0, 0xFF, 0x81, 0xDE, 0x79, 0xE7, 0xC0, 0xFC, 0x1E, 0xC0, 0xF0, 0x6C,
  0x07, 0xC0, 0x38, 0x3C, 0x03, 0xC0, 0x1C, 0x3C, 0x01, 0xE0, 0x0E, 0x1E,
  0x00, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x03, 0x07, 0x00, 0x38, 0x03, 0x87,
  0x80, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x00, 0x30, 0x70, 0x03, 0x00, 0x38, 0x70, 0x03, 0x80, 0x1C,
  0x38, 0x01, 0xC0, 0x0E, 0x1C, 0x00, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0x07,
  0x07, 0x00, 0x70, 0x03, 0x87, 0x00, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x00,
  0xE1, 0xC0, 0x0E, 0x00, 0x60, 0xE0, 0x06, 0x00, 0x70, 0x60, 0x07, 0x00,
  0x38, 0x70, 0x03, 0x80, 0x1C, 0x38, 0x01, 0xC0, 0x0E, 0x1C, 0x00, 0xE0,
  0x06, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x03, 0x0F, 0xC0, 0x39, 0xFF, 0x01,
  0xDF, 0x7C, 0x0F, 0xC0, 0xE0, 0x6C, 0x03, 0x83, 0xC0, 0x1C, 0x3C, 0x00,
  0xE1, 0xE0, 0x06, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x87, 0x80, 0x1C, 0x38,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x87, 0x00, 0x1C,
  0x38, 0x00, 0xE1, 0xC0, 0x06, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x87, 0x00,
  0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x87,
  0x00, 0x1C, 0x38, 0x00, 0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xE7, 0xC0, 0x78, 0x1E, 0x0F, 0x00, 0xE0,
  0xE0, 0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x38, 0x00, 0x73, 0x80, 0x07,
  0x78, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00,
  0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x70, 0xF0,
  0x0F, 0x07, 0x01, 0xE0, 0x78, 0x3C, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x10, 0x00, 0x00, 0x61, 0xF8, 0x00, 0xE3, 0xFC, 0x00, 0xE7, 0x3E, 0x00,
  0xEC, 0x0F, 0x00, 0xD8, 0x07, 0x00, 0xF0, 0x07, 0x01, 0xF0, 0x07, 0x01,
  0xE0, 0x07, 0x01, 0xE0, 0x03, 0x01, 0xC0, 0x03, 0x01, 0xC0, 0x07, 0x03,
  0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x07,
  0x00, 0x07, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x1E, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x38, 0x0F,
  0x00, 0x78, 0x0F, 0x00, 0x70, 0x1D, 0x80, 0xE0, 0x1D, 0xC3, 0xE0, 0x1C,
  0xFF, 0xC0, 0x1C, 0x7F, 0x00, 0x18, 0x08, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x1C, 0x07,
  0xFC, 0x60, 0x3E, 0x79, 0x81, 0xE0, 0x7E, 0x0F, 0x00, 0xF8, 0x38, 0x03,
  0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x01, 0xC3,
  0x80, 0x07, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00,
  0x0E, 0x38, 0x00, 0x30, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C,
  0x38, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80, 0x1E, 0x0E, 0x00, 0x78, 0x38,
  0x03, 0xE0, 0xE0, 0x1F, 0x83, 0xC0, 0xEC, 0x07, 0x87, 0x70, 0x1F, 0xF9,
  0xC0, 0x3F, 0xC7, 0x00, 0x08, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x0F, 0x83, 0x9F, 0xC1, 0xDF, 0xC0, 0xDC,
  0x00, 0x6C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7C,
  0x7C, 0x3C, 0x02, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x20, 0x0F, 0x0E, 0x07, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x01,
  0x00, 0x00, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x1F,
  0xF7, 0xFF, 0x7F, 0xF0, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x0E, 0x00, 0xE1, 0x0F, 0xE0, 0x7E, 0x00, 0x80, 0x0E, 0x00, 0x38, 0x70,
  0x01, 0xC3, 0x80, 0x0C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xC0, 0x07, 0x0E, 0x00,
  0x38, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x0E,
  0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x07,
  0x0E, 0x00, 0x78, 0x70, 0x03, 0x83, 0x80, 0x3C, 0x1C, 0x01, 0xE0, 0xE0,
  0x1F, 0x07, 0x01, 0xB8, 0x3C, 0x3D, 0x80, 0xFF, 0xCC, 0x03, 0xF8, 0x60,
  0x02, 0x00, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80, 0x0E,
  0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x1C, 0x38,
  0x07, 0x0E, 0x03, 0x81, 0x80, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x06, 0x07,
  0x01, 0x83, 0x80, 0x60, 0xE0, 0x18, 0x70, 0x07, 0x1C, 0x01, 0xCE, 0x00,
  0x73, 0x80, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x07, 0x00,
  0x3F, 0x00, 0x38, 0x01, 0xF8, 0x03, 0xC0, 0x0F, 0xC0, 0x1E, 0x00, 0xEE,
  0x00, 0xF0, 0x07, 0x70, 0x0F, 0x80, 0x73, 0x80, 0x6C, 0x03, 0x9C, 0x07,
  0x70, 0x38, 0xE0, 0x33, 0x81, 0xC7, 0x03, 0x9C, 0x0E, 0x38, 0x1C, 0xE0,
  0xE1, 0xC0, 0xC7, 0x07, 0x0E, 0x0E, 0x38, 0x70, 0x70, 0x61, 0xC3, 0x83,
  0x87, 0x0E, 0x18, 0x1C, 0x30, 0x71, 0xC0, 0xE3, 0x83, 0x8E, 0x07, 0x1C,
  0x1C, 0xE0, 0x38, 0xC0, 0xE7, 0x01, 0xCE, 0x07, 0x30, 0x0E, 0x60, 0x3B,
  0x80, 0x77, 0x01, 0xDC, 0x03, 0xB0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x03, 0x60, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x0E, 0x03, 0x80,
  0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x1C, 0x1E,
  0x00, 0x38, 0x38, 0x00, 0x70, 0xE0, 0x00, 0x63, 0x80, 0x00, 0xE7, 0x00,
  0x01, 0xDC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0x30, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xE1, 0xC0, 0x03, 0x81,
  0xC0, 0x07, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x70, 0x06, 0x01, 0xE0, 0x0E,
  0x03, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x30, 0x00, 0x70, 0x03,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x01,
  0xC0, 0x03, 0x80, 0x38, 0x00, 0x38, 0x03, 0x80, 0x03, 0x80, 0x70, 0x00,
  0x38, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80,
  0xE0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x38, 0x00,
  0x03, 0x83, 0x80, 0x00, 0x38, 0x70, 0x00, 0x01, 0x87, 0x00, 0x00, 0x18,
  0xE0, 0x00, 0x01, 0x8E, 0x00, 0x00, 0x19, 0xC0, 0x00, 0x01, 0x9C, 0x00,
  0x00, 0x1B, 0x80, 0x00, 0x01, 0xB8, 0x00, 0x00, 0x1B, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x04, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x06,
  0x00, 0x00, 0x0F, 0x80, 0x09, 0xFF, 0x00, 0x5F, 0xFE, 0x07, 0xC0, 0xFF,
  0xFC, 0x01, 0xFF, 0x40, 0x01, 0xE0,
};

const GFXglyph NotoSans_Condensed_LightItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 39, 12, 1, -39 },
  { 60, 14, 14, 17, 5, -39 },
  { 85, 25, 39, 25, 1, -39 },
  { 207, 23, 44, 23, 0, -41 },
  { 334, 29, 40, 34, 3, -39 },
  { 479, 24, 40, 25, 0, -39 },
  { 599, 5, 14, 9, 6, -39 },
  { 608, 16, 48, 14, 1, -39 },
  { 704, 16, 48, 14, -4, -39 },
  { 800, 17, 18, 22, 6, -41 },
  { 839, 21, 26, 25, 2, -32 },
  { 908, 8, 13, 10, -2, -6 },
  { 921, 12, 3, 15, 1, -16 },
  { 926, 4, 5, 10, 1, -5 },
  { 929, 23, 39, 17, -2, -39 },
  { 1042, 20, 40, 23, 2, -39 },
  { 1142, 12, 39, 23, 7, -39 },
  { 1201, 23, 39, 23, -1, -39 },
  { 1314, 23, 40, 23, 0, -39 },
  { 1429, 23, 39, 23, -1, -39 },
  { 1542, 23, 40, 23, 0, -39 },
  { 1657, 22, 40, 23, 2, -39 },
  { 1767, 21, 39, 23, 3, -39 },
  { 1870, 23, 40, 23, 0, -39 },
  { 1985, 21, 40, 23, 1, -39 },
  { 2090, 10, 29, 11, 0, -29 },
  { 2127, 13, 36, 11, -3, -29 },
  { 2186, 21, 24, 25, 2, -31 },
  { 2249, 20, 14, 25, 3, -26 },
  { 2284, 21, 24, 25, 2, -31 },
  { 2347, 17, 39, 17, 2, -39 },
  { 2430, 31, 44, 34, 2, -39 },
  { 2601, 22, 39, 23, -3, -39 },
  { 2709, 24, 39, 25, 1, -39 },
  { 2826, 24, 40, 23, 3, -39 },
  { 2946, 25, 39, 27, 1, -39 },
  { 3068, 23, 39, 22, 1, -39 },
  { 3181, 23, 39, 20, 1, -39 },
  { 3294, 26, 40, 29, 3, -39 },
  { 3424, 28, 39, 28, 1, -39 },
  { 3561, 18, 39, 13, -2, -39 },
  { 3649, 20, 49, 11, -8, -39 },
  { 3772, 26, 39, 23, 1, -39 },
  { 3899, 15, 39, 20, 1, -39 },
  { 3973, 36, 39, 37, 1, -39 },
  { 4149, 29, 39, 30, 1, -39 },
  { 4291, 25, 40, 29, 3, -39 },
  { 4416, 23, 39, 23, 1, -39 },
  { 4529, 25, 48, 29, 3, -39 },
  { 4679, 23, 39, 24, 1, -39 },
  { 4792, 24, 40, 22, -1, -39 },
  { 4912, 19, 39, 20, 5, -39 },
  { 5005, 26, 40, 28, 3, -39 },
  { 5135, 22, 39, 23, 5, -39 },
  { 5243, 36, 39, 37, 5, -39 },
  { 5419, 28, 39, 21, -3, -39 },
  { 5556, 20, 39, 20, 5, -39 },
  { 5654, 26, 39, 21, -2, -39 },
  { 5781, 20, 48, 15, -1, -39 },
  { 5901, 8, 39, 18, 6, -39 },
  { 5940, 20, 48, 15, -4, -39 },
  { 6060, 22, 21, 24, 1, -39 },
  { 6118, 17, 2, 17, -4, 5 },
  { 6123, 6, 8, 13, 8, -41 },
  { 6129, 22, 30, 24, 2, -29 },
  { 6212, 21, 42, 24, 1, -41 },
  { 6323, 18, 30, 18, 2, -29 },
  { 6391, 24, 42, 24, 2, -41 },
  { 6517, 18, 30, 21, 2, -29 },
  { 6585, 26, 54, 13, -7, -41 },
  { 6761, 24, 42, 24, 0, -29 },
  { 6887, 21, 41, 24, 1, -41 },
  { 6995, 11, 39, 10, 1, -39 },
  { 7049, 19, 52, 10, -7, -39 },
  { 7173, 21, 41, 20, 1, -41 },
  { 7281, 11, 41, 10, 1, -41 },
  { 7338, 33, 29, 36, 1, -29 },
  { 7458, 21, 29, 24, 1, -29 },
  { 7535, 20, 30, 24, 2, -29 },
  { 7610, 24, 42, 24, -2, -29 },
  { 7736, 22, 42, 24, 2, -29 },
  { 7852, 17, 29, 16, 1, -29 },
  { 7914, 18, 30, 18, 0, -29 },
  { 7982, 12, 36, 13, 2, -35 },
  { 8036, 21, 30, 24, 2, -29 },
  { 8115, 18, 29, 19, 3, -29 },
  { 8181, 29, 29, 30, 3, -29 },
  { 8287, 23, 29, 19, -2, -29 },
  { 8371, 28, 42, 19, -6, -29 },
  { 8518, 20, 29, 17, -2, -29 },
  { 8591, 20, 48, 18, 1, -39 },
  { 8711, 3, 54, 22, 10, -41 },
  { 8732, 19, 48, 18, -3, -39 },
  { 8846, 21, 6, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_LightItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC54PT7B_H_
