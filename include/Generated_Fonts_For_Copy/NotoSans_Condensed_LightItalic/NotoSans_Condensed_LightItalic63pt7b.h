#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC63PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0x1E, 0x0F, 0x1C, 0x0E,
  0x1C, 0x0E, 0x1C, 0x1E, 0x3C, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C,
  0x38, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0x60, 0x30,
  0x60, 0x70, 0xE0, 0x70, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0xE0, 0x38, 0x00, 0x06, 0x01, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x70, 0x1C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x38, 0x0E, 0x00,
  0x01, 0xC0, 0x70, 0x07, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xFF, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0x60, 0x00, 0x1C, 0x07,
  0x00, 0x00, 0xE0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x18, 0x07, 0x00, 0x01, 0xC0, 0x30, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x38, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C,
  0x07, 0x00, 0x00, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0x80, 0x00, 0x70, 0x1C,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x60, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x18, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xDF, 0x80, 0x7C, 0x70, 0x60, 0x3C, 0x18, 0x00,
  0x0E, 0x06, 0x00, 0x03, 0x81, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x30,
  0x00, 0x1C, 0x0C, 0x00, 0x07, 0x03, 0x00, 0x01, 0xC0, 0xC0, 0x00, 0x78,
  0x70, 0x00, 0x0E, 0x18, 0x00, 0x03, 0xC6, 0x00, 0x00, 0x79, 0x80, 0x00,
  0x1F, 0x60, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x19, 0xE0, 0x00, 0x06,
  0x3C, 0x00, 0x01, 0x87, 0x80, 0x00, 0x61, 0xE0, 0x00, 0x38, 0x38, 0x00,
  0x0C, 0x0E, 0x00, 0x03, 0x03, 0x80, 0x00, 0xC0, 0xE0, 0x00, 0x30, 0x38,
  0x00, 0x1C, 0x0E, 0x00, 0x06, 0x07, 0x00, 0x01, 0x83, 0xC0, 0x80, 0x61,
  0xE0, 0x3C, 0x39, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x00, 0xFF, 0x00,
  0x07, 0x00, 0xE3, 0xC0, 0x07, 0x00, 0xE0, 0xE0, 0x03, 0x80, 0xE0, 0x70,
  0x03, 0x80, 0x70, 0x18, 0x01, 0xC0, 0x70, 0x0C, 0x01, 0xC0, 0x38, 0x06,
  0x01, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x01,
  0xC0, 0x70, 0x07, 0x00, 0xE0, 0x70, 0x03, 0x00, 0x70, 0x38, 0x03, 0x80,
  0x38, 0x38, 0x01, 0xC0, 0x38, 0x3C, 0x00, 0xE0, 0x1C, 0x1C, 0x00, 0x70,
  0x0E, 0x1C, 0x00, 0x38, 0x07, 0x0E, 0x06, 0x1C, 0x07, 0x0E, 0x1F, 0xCE,
  0x03, 0x87, 0x1F, 0xF6, 0x01, 0xC7, 0x1E, 0x3B, 0x81, 0xC7, 0x0E, 0x0F,
  0xC0, 0xE3, 0x8E, 0x07, 0xE0, 0xE3, 0x87, 0x03, 0xF8, 0xE1, 0xC7, 0x01,
  0xDF, 0xE1, 0xC3, 0x80, 0xE7, 0xE0, 0xE3, 0x80, 0x70, 0xC0, 0xE1, 0xC0,
  0x38, 0x00, 0xE0, 0xE0, 0x1C, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0x70, 0x70,
  0x06, 0x00, 0x38, 0x38, 0x07, 0x00, 0x38, 0x1C, 0x03, 0x80, 0x3C, 0x0E,
  0x01, 0xC0, 0x1C, 0x06, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x0E, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0x70, 0x1C, 0x07, 0x80, 0x38, 0x1C, 0x03, 0x80, 0x0E, 0x1E, 0x03, 0x80,
  0x07, 0x1E, 0x01, 0xC0, 0x03, 0xFE, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x38, 0x07, 0x00, 0x07, 0x80, 0x70, 0x00, 0x70, 0x07, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x70, 0x0E,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x07, 0x87,
  0x80, 0xF0, 0xF0, 0x78, 0x0E, 0x1E, 0x03, 0xC0, 0xE1, 0xC0, 0x3C, 0x1E,
  0x3C, 0x01, 0xC1, 0xC3, 0x80, 0x1E, 0x3C, 0x78, 0x00, 0xE3, 0x87, 0x00,
  0x0F, 0x78, 0x70, 0x00, 0xF7, 0x0F, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x7E,
  0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0x70,
  0x00, 0xFE, 0x07, 0x80, 0x1F, 0xE0, 0x7C, 0x07, 0xCE, 0x03, 0xF3, 0xF8,
  0xF0, 0x1F, 0xFE, 0x07, 0x00, 0xFF, 0xC0, 0x78, 0x01, 0xE0, 0x00, 0x00,
  0x1E, 0x3C, 0x70, 0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E,
  0x18, 0x70, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x30, 0x04, 0x03,
  0x00, 0x70, 0x70, 0x0F, 0xC7, 0x00, 0x7E, 0x60, 0x10, 0xFE, 0x7F, 0x03,
  0xFF, 0xF0, 0x0F, 0xFC, 0x01, 0xF0, 0x00, 0x3B, 0x00, 0x07, 0x38, 0x00,
  0xE1, 0x80, 0x3C, 0x1C, 0x07, 0x81, 0xC0, 0x30, 0x0E, 0x01, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x38,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x38,
  0x1C, 0x0E, 0x00, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF7, 0xFF, 0xE0, 0x33,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x0E, 0x01,
  0xE0, 0x0F, 0x01, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x07,
  0x80, 0x07, 0x07, 0x00, 0x07, 0x0F, 0x00, 0x07, 0x0E, 0x00, 0x07, 0x0E,
  0x00, 0x07, 0x1E, 0x00, 0x07, 0x1C, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x78,
  0x00, 0x0E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70,
  0x00, 0x1C, 0x70, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0,
  0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0,
  0x03, 0xC0, 0xF0, 0x03, 0x80, 0x70, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x78,
  0x1E, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF8, 0x3E,
  0xE1, 0xE7, 0x9F, 0x1C, 0xF8, 0x73, 0x81, 0xC4, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0x07,
  0x80, 0x7C, 0x00, 0xE0, 0x07, 0x80, 0x08, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFD, 0xFC, 0x01, 0xF0,
  0x07, 0x80, 0x30, 0x00, 0xF0, 0x08, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x20, 0x00,
  0x78, 0x0C, 0x00, 0x7C, 0x03, 0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3B, 0x80, 0x00, 0x0E, 0x70, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x1C, 0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xE3, 0xC0, 0x00,
  0x38, 0x70, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x70, 0x38,
  0x00, 0x1E, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x3C,
  0x07, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0x00,
  0x0E, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xF0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x78, 0x00, 0x70, 0x0E,
  0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF2, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x04, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x80, 0x01, 0xE0, 0x18, 0x00, 0xF8, 0x03,
  0xF1, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x01, 0xFC, 0xF0, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x07,
  0xE0, 0x03, 0x8F, 0xFC, 0x03, 0xCF, 0xFF, 0x01, 0xCF, 0x0F, 0x80, 0xEE,
  0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x7E, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xE3,
  0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1C,
  0x3C, 0x00, 0x0E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03,
  0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x01, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x01,
  0xE0, 0x0F, 0x01, 0xE0, 0x07, 0xE7, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC0,
  0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x01,
  0xE0, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x07, 0x80, 0xE0, 0x00,
  0xF0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x78, 0x00, 0xF0, 0x0F,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0xF8,
  0x00, 0x3C, 0x3E, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x1E, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x78, 0x00,
  0x78, 0x0E, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1E, 0x0E,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x38, 0x0F, 0x80, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xC7, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xCF, 0xC0,
  0x0F, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x0E,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0xF0, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0x3C, 0x00,
  0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xC3, 0xC0,
  0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0xFC, 0x1E,
  0x00, 0x7E, 0x0F, 0x00, 0xFE, 0x03, 0xE1, 0xF7, 0x01, 0xFF, 0xF3, 0x80,
  0x7F, 0xE3, 0xC0, 0x0F, 0xC1, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x1E, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x01, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0xC0, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x30, 0x3C, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x00, 0x00, 0x0C, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0E, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x0F, 0x80, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x0F,
  0x00, 0x00, 0x03, 0x80, 0x70, 0x00, 0x00, 0x0C, 0x07, 0x00, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x20, 0x03, 0x83, 0x80, 0x1F, 0xF8, 0x1C, 0x38, 0x01,
  0xFF, 0xC0, 0xE1, 0xC0, 0x1E, 0x1C, 0x07, 0x0C, 0x01, 0xC0, 0xE0, 0x38,
  0xE0, 0x1C, 0x07, 0x01, 0xC7, 0x01, 0xC0, 0x38, 0x0E, 0x70, 0x0E, 0x03,
  0x80, 0x73, 0x80, 0xE0, 0x1C, 0x03, 0x9C, 0x07, 0x00, 0xE0, 0x38, 0xC0,
  0x70, 0x07, 0x01, 0xCE, 0x03, 0x80, 0x70, 0x0E, 0x70, 0x18, 0x03, 0x80,
  0x73, 0x81, 0xC0, 0x1C, 0x03, 0x1C, 0x0E, 0x00, 0xE0, 0x38, 0xC0, 0x70,
  0x0E, 0x01, 0xCE, 0x03, 0x80, 0x70, 0x0C, 0x70, 0x18, 0x03, 0x80, 0xE3,
  0x80, 0xC0, 0x3C, 0x07, 0x1C, 0x06, 0x01, 0xE0, 0x70, 0xE0, 0x38, 0x1F,
  0x03, 0x87, 0x01, 0xC1, 0xF8, 0x38, 0x38, 0x0E, 0x1C, 0xC3, 0x81, 0xC0,
  0x7F, 0xC7, 0xF8, 0x0E, 0x01, 0xFC, 0x3F, 0x80, 0x70, 0x07, 0xC0, 0xF8,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E,
  0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1E, 0x70, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x87,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x01, 0xE0, 0x01, 0xE0, 0x3C,
  0x00, 0x38, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x03, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x70, 0x1E, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0xC0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x07,
  0x80, 0x00, 0xE0, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x70, 0xE0, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0x00, 0xFC, 0x00,
  0xF0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00,
  0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0xF0,
  0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x0E, 0x03, 0xC0,
  0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x78,
  0x03, 0x80, 0x0F, 0x00, 0x78, 0x07, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x70, 0x1E,
  0x00, 0x07, 0x01, 0xE0, 0x00, 0x78, 0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00,
  0x78, 0x1C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x0F, 0x03,
  0x80, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x07, 0x80, 0x07, 0xC0, 0x70, 0x00, 0xF8, 0x07, 0x00, 0x7F, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0x7F, 0x00, 0x3F, 0x00, 0x60, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x20, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1C, 0x07, 0xF0, 0x00,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00,
  0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x3C,
  0x0E, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0x78, 0x1C, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x70, 0x38, 0x00, 0x03, 0xC0, 0xE0, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x07, 0xC0, 0x1E, 0x00,
  0x3E, 0x00, 0x70, 0x03, 0xF0, 0x01, 0xC0, 0x7F, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xDF, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x0F, 0x80, 0x00,
  0x80, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xF8, 0x70, 0x00,
  0x7F, 0xF1, 0xE0, 0x01, 0xFF, 0xC3, 0xC0, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0x80,
  0x3C, 0x00, 0x07, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x3C, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03,
  0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00,
  0x70, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x03, 0x80,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x07,
  0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x1E, 0x00, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38,
  0x03, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x01,
  0xC0, 0x1E, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0xF0, 0x00, 0x78, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x70,
  0x03, 0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x0E, 0x03, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0x87, 0xC0,
  0x00, 0x07, 0x1F, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x00, 0xEF, 0xC0, 0x00, 0x01, 0xDF, 0xC0, 0x00,
  0x07, 0xF7, 0x80, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0x1F, 0x0E, 0x00, 0x00,
  0x3C, 0x1E, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xC0,
  0x07, 0x00, 0x03, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0xF0, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x01,
  0xDC, 0x00, 0x00, 0x3F, 0x00, 0x3B, 0x80, 0x00, 0x0E, 0xE0, 0x07, 0x70,
  0x00, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x80, 0x3D, 0xC0, 0x00,
  0x0E, 0xF0, 0x07, 0xB8, 0x00, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x00, 0x73,
  0x80, 0x1C, 0xE0, 0x00, 0x1C, 0xF0, 0x03, 0x9C, 0x00, 0x03, 0x9E, 0x00,
  0xF3, 0x80, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x00, 0x1C, 0x70, 0x03, 0x8F,
  0x00, 0x07, 0x0E, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x0E, 0x1C, 0x00,
  0x38, 0x78, 0x03, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x01, 0xC1,
  0xC0, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0F, 0x00,
  0x78, 0x38, 0x01, 0xC1, 0xE0, 0x0F, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC0,
  0xE0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x07, 0x03, 0x80,
  0x70, 0x3C, 0x01, 0xE0, 0x70, 0x1C, 0x07, 0x80, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x1C, 0x07, 0x80,
  0x1C, 0x03, 0x87, 0x00, 0xF0, 0x07, 0x80, 0x70, 0xE0, 0x1C, 0x00, 0xE0,
  0x0E, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC7, 0x00, 0x70, 0x03, 0x80, 0x39,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xEE, 0x00,
  0x70, 0x03, 0x80, 0x1D, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xF0, 0x01, 0xC0,
  0x0E, 0x00, 0x7E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x1F, 0x00, 0x00, 0x70, 0x07, 0xC0, 0x00, 0x3C, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0xFC, 0x00, 0x03, 0x80, 0x3F, 0x80, 0x00, 0xE0,
  0x0E, 0xE0, 0x00, 0x38, 0x03, 0xB8, 0x00, 0x1E, 0x00, 0xEE, 0x00, 0x07,
  0x80, 0x7B, 0xC0, 0x01, 0xC0, 0x1C, 0x70, 0x00, 0x70, 0x07, 0x1C, 0x00,
  0x1C, 0x01, 0xC7, 0x00, 0x0F, 0x00, 0x71, 0xE0, 0x03, 0x80, 0x3C, 0x38,
  0x00, 0xE0, 0x0E, 0x0E, 0x00, 0x38, 0x03, 0x83, 0x80, 0x1E, 0x00, 0xE0,
  0xF0, 0x07, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0x1E, 0x07, 0x00, 0x70, 0x07,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x70, 0x0E, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0xE0, 0x0F, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x3C, 0x0E,
  0x00, 0xE0, 0x0F, 0x07, 0x80, 0x38, 0x01, 0xC1, 0xE0, 0x1E, 0x00, 0x70,
  0x70, 0x07, 0x80, 0x1E, 0x1C, 0x01, 0xC0, 0x07, 0x87, 0x00, 0x70, 0x00,
  0xE3, 0xC0, 0x1C, 0x00, 0x38, 0xE0, 0x0F, 0x00, 0x0F, 0x38, 0x03, 0x80,
  0x03, 0xCE, 0x00, 0xE0, 0x00, 0x73, 0x80, 0x38, 0x00, 0x1D, 0xE0, 0x1E,
  0x00, 0x07, 0x70, 0x07, 0x80, 0x01, 0xFC, 0x01, 0xC0, 0x00, 0x3F, 0x00,
  0x70, 0x00, 0x0F, 0xC0, 0x1C, 0x00, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0xF8,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x07,
  0x80, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x38,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1C, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCE, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x03,
  0x9E, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x1F, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x38, 0x0F, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x00, 0xE0,
  0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xE0, 0x00, 0xF0,
  0x1C, 0x00, 0x1E, 0x03, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x03,
  0xC0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x01, 0xC0, 0x1F,
  0x00, 0x78, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x38, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x00, 0xE7, 0x80, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x79, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0E, 0x3C,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x3C, 0x07, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x38, 0x0F, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0x78, 0x07, 0x00, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1E, 0x03, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x70, 0x1E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0xC0, 0x70,
  0x00, 0x70, 0x0E, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x01, 0xF0,
  0x0E, 0x00, 0x7C, 0x01, 0xC1, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x01,
  0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x0E,
  0x00, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0x3C,
  0x03, 0xC0, 0x03, 0x80, 0x70, 0x00, 0x78, 0x0E, 0x00, 0x0F, 0x03, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x7E, 0x00, 0xE0, 0x0F, 0x80, 0x02, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x08, 0x00, 0x0F, 0x00,
  0xF0, 0x03, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80, 0x00, 0x38,
  0x07, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1C, 0x07,
  0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0x80,
  0x00, 0x3C, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x01, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0E, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x8E, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x0F, 0x0E,
  0x00, 0x07, 0x83, 0x80, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x3C,
  0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xC0, 0x3C, 0x00,
  0xF0, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x3C,
  0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x1E, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x78,
  0x00, 0x1C, 0x1C, 0x00, 0x07, 0x0F, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71,
  0xE0, 0x00, 0x1C, 0x78, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xCF, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3B, 0x80, 0x00,
  0xF8, 0x00, 0x1E, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0x38, 0x00, 0x1F, 0x80,
  0x03, 0xCE, 0x00, 0x07, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0xB8, 0x00, 0x38,
  0xE0, 0x00, 0xEE, 0x00, 0x1E, 0x38, 0x00, 0x3B, 0x80, 0x07, 0x0E, 0x00,
  0x1C, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x8E,
  0x00, 0x78, 0x38, 0x00, 0xE3, 0x80, 0x1E, 0x0E, 0x00, 0x78, 0xE0, 0x07,
  0x03, 0x80, 0x1C, 0x38, 0x03, 0xC0, 0xE0, 0x07, 0x0E, 0x00, 0xE0, 0x38,
  0x03, 0x83, 0x80, 0x78, 0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x03, 0x80, 0x78,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x0E, 0x03, 0xC0, 0x38, 0x07, 0x03, 0x80,
  0xE0, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x00,
  0xE0, 0x70, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x03, 0x83, 0xC0, 0x0E, 0x0F,
  0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x38, 0x78, 0x00, 0xE0, 0xE0, 0x0E,
  0x1C, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0xE3, 0xC0,
  0x03, 0x8F, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x0E, 0x78, 0x00, 0x38,
  0xE0, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00,
  0x33, 0x80, 0x00, 0xEE, 0x00, 0x0C, 0xE0, 0x00, 0x3B, 0x80, 0x03, 0x78,
  0x00, 0x0E, 0xE0, 0x00, 0xDC, 0x00, 0x03, 0xF0, 0x00, 0x37, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x01, 0xC0,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x70, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x00, 0x70, 0x78, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x1C, 0x3C,
  0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00,
  0xF0, 0x70, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F,
  0x70, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x70, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xE0,
  0x38, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80,
  0x1C, 0x07, 0x00, 0x1C, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x1E, 0x00,
  0x1C, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80,
  0x10, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70, 0x00,
  0x78, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x07, 0x80, 0x1C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0x39, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x06,
  0x03, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF1, 0xC0, 0x3F, 0xFC, 0xE0, 0x3E,
  0x0E, 0x70, 0x3E, 0x03, 0xB8, 0x3E, 0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x1E,
  0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0x87,
  0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE1, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0x38, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x1C, 0x00, 0x0F,
  0x1E, 0x00, 0x07, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0x7C, 0x1E, 0x00, 0x3E, 0x07, 0x00, 0x3F, 0x03, 0xC0, 0x37, 0x01, 0xE0,
  0x3B, 0x80, 0x7E, 0xF9, 0xC0, 0x3F, 0xF8, 0xE0, 0x0F, 0xF0, 0x60, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x07, 0xE0, 0x03, 0x8F, 0xF8, 0x03, 0xCF, 0xFE, 0x01, 0xCE, 0x0F, 0x80,
  0xEE, 0x03, 0xC0, 0x7E, 0x00, 0xF0, 0x7E, 0x00, 0x78, 0x3E, 0x00, 0x1C,
  0x1F, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x80, 0x03, 0x87, 0x80, 0x01,
  0xC3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x78, 0x70, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x0E, 0x00,
  0x07, 0x87, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xC3, 0xC0, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0xE0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x38, 0x3E,
  0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x0F, 0xC0, 0x3E, 0x0E, 0x60, 0x3E, 0x07,
  0x3E, 0x7E, 0x03, 0x8F, 0xFE, 0x01, 0xC3, 0xFC, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xE0, 0x20,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x08, 0x07, 0xE3,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x7E, 0x0F, 0x00, 0x0F, 0xFC, 0x70, 0x00, 0xFF, 0xF3, 0x80, 0x0F,
  0x83, 0x9C, 0x00, 0xF8, 0x0E, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x78, 0x01,
  0xF0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0,
  0x1C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x70, 0x0F, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x3C, 0x03, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x01,
  0xF0, 0x07, 0x80, 0x1F, 0x80, 0x3C, 0x00, 0xDC, 0x00, 0xF0, 0x0F, 0xC0,
  0x07, 0x80, 0xEE, 0x00, 0x1F, 0xBE, 0x70, 0x00, 0xFF, 0xE3, 0x80, 0x03,
  0xFE, 0x1C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x7C, 0x1E, 0x03, 0xC0, 0x38, 0x1E, 0x00, 0xF0,
  0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x38, 0x78, 0x00, 0xE1, 0xC0,
  0x07, 0x8F, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x07, 0x87, 0x80, 0x7C,
  0x1E, 0x3F, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x18, 0x0F, 0xC3, 0xE0, 0x1F,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x43, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x10, 0x01, 0xFF, 0x86,
  0x00, 0x3F, 0xFC, 0xE0, 0x07, 0xC1, 0xCE, 0x00, 0xF8, 0x0E, 0xE0, 0x1F,
  0x00, 0x6E, 0x01, 0xE0, 0x07, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03,
  0xC0, 0x78, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x38, 0x0F,
  0x00, 0x03, 0x80, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x70, 0x1C, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xE0, 0x3C, 0x00,
  0x1E, 0x03, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0,
  0x3C, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0xC0, 0x3C, 0x00, 0xDC, 0x01, 0xE0,
  0x1F, 0x80, 0x1E, 0x03, 0xB8, 0x00, 0xFD, 0xF3, 0x80, 0x0F, 0xFE, 0x38,
  0x00, 0x7F, 0xC7, 0x80, 0x00, 0xC0, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x80, 0x07, 0x80, 0x0E, 0x01, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC1, 0xF8, 0x01, 0xC7, 0xFC, 0x03, 0xCF, 0xFE,
  0x03, 0x9C, 0x1F, 0x03, 0xB8, 0x0F, 0x03, 0xF0, 0x07, 0x03, 0xE0, 0x07,
  0x07, 0xC0, 0x07, 0x07, 0x80, 0x07, 0x07, 0x80, 0x07, 0x07, 0x80, 0x0F,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x38, 0x78, 0x00, 0x78, 0x78, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0, 0x00, 0x30, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x02, 0x03,
  0x80, 0x1E, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x0F, 0x00,
  0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7, 0x80,
  0x01, 0xC7, 0x80, 0x00, 0xE7, 0x80, 0x00, 0x77, 0xE0, 0x00, 0x7B, 0xF0,
  0x00, 0x3B, 0xB8, 0x00, 0x1F, 0x9C, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0x87,
  0x80, 0x07, 0x81, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x78, 0x00, 0xE0,
  0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03,
  0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0x00, 0x43, 0xF0, 0x07, 0xE0, 0x06, 0x3F, 0xF0, 0x7F, 0xE0, 0x39, 0xFF,
  0xC3, 0xFF, 0x80, 0xEF, 0x07, 0x9E, 0x1F, 0x03, 0xB0, 0x1E, 0xE0, 0x3C,
  0x0F, 0x80, 0x3F, 0x00, 0x70, 0x7C, 0x00, 0xF8, 0x01, 0xC1, 0xF0, 0x03,
  0xE0, 0x07, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x70, 0x00, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x1E,
  0x00, 0x38, 0x38, 0x00, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x03, 0x83,
  0x80, 0x07, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0,
  0x01, 0xC1, 0xC0, 0x03, 0x80, 0x07, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x00,
  0x0E, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x00, 0xE1, 0xE0,
  0x03, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x80, 0x07, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0x03,
  0x83, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x01, 0xC1, 0xF8, 0x01, 0x87, 0xFE,
  0x03, 0x9F, 0xFE, 0x03, 0x9C, 0x1F, 0x03, 0xB8, 0x0F, 0x03, 0xF0, 0x07,
  0x07, 0xE0, 0x07, 0x07, 0xC0, 0x07, 0x07, 0x80, 0x07, 0x07, 0x80, 0x07,
  0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1C,
  0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xF0,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0x83, 0xE0,
  0x3C, 0x03, 0xC0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x0E,
  0x00, 0x0E, 0x3C, 0x00, 0x1C, 0x70, 0x00, 0x39, 0xE0, 0x00, 0x73, 0xC0,
  0x00, 0xE7, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x70, 0x00,
  0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xEF, 0x00, 0x01,
  0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0xF0, 0x00, 0x79,
  0xE0, 0x00, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x0F,
  0x00, 0x78, 0x1F, 0x01, 0xE0, 0x1F, 0x9F, 0x80, 0x1F, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x3F, 0x00, 0x03, 0x0F, 0xF8,
  0x00, 0x71, 0xFF, 0xC0, 0x07, 0x38, 0x3E, 0x00, 0x77, 0x01, 0xE0, 0x07,
  0xE0, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x0F, 0xC0, 0x07, 0x00, 0xF8, 0x00,
  0x70, 0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x70, 0x1F, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0,
  0x38, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1C, 0x07, 0x80,
  0x01, 0xC0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x03, 0x80, 0x78, 0x00, 0x78,
  0x0F, 0x80, 0x07, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0xFC,
  0x03, 0xE0, 0x1E, 0xC0, 0x7C, 0x01, 0xEF, 0x9F, 0x80, 0x1C, 0x7F, 0xF0,
  0x01, 0xC3, 0xFC, 0x00, 0x1C, 0x06, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x40, 0x1F, 0xF8, 0x60, 0x0F, 0xFF, 0x38, 0x07, 0xC1, 0xCE, 0x03, 0xE0,
  0x3B, 0x81, 0xE0, 0x07, 0xE0, 0x78, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x0E,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x38,
  0x3C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00,
  0x70, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1F,
  0x03, 0xC0, 0x0F, 0xC0, 0xF0, 0x03, 0x70, 0x1C, 0x01, 0xF8, 0x07, 0x80,
  0xEE, 0x00, 0xFD, 0xF3, 0x80, 0x3F, 0xF9, 0xE0, 0x07, 0xF8, 0x78, 0x00,
  0x30, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x18, 0x7F, 0x03, 0x9F, 0xE0, 0x39, 0xE2, 0x03,
  0xB8, 0x00, 0x3F, 0x00, 0x07, 0x60, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0x80,
  0xE0, 0x78, 0x01, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x40, 0x07, 0x83, 0x00, 0x7C, 0x1F,
  0x0F, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x3F, 0xFE, 0x7F, 0xF9, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x60, 0x3F,
  0xC0, 0x7F, 0x80, 0x38, 0x00, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0x81,
  0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xF0, 0x78, 0x00, 0x70,
  0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x03, 0x80,
  0x07, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x78,
  0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0xFC, 0x0F, 0x00, 0xEE, 0x07,
  0xC0, 0xEE, 0x01, 0xFB, 0xE7, 0x00, 0xFF, 0xE3, 0x80, 0x1F, 0xE1, 0xC0,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x3D, 0xC0, 0x01, 0xE7, 0x00, 0x07,
  0x1C, 0x00, 0x3C, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1E, 0x1C,
  0x00, 0x70, 0x70, 0x03, 0xC1, 0xC0, 0x0E, 0x07, 0x00, 0x78, 0x1C, 0x01,
  0xC0, 0x70, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x1C, 0x07, 0x00,
  0x70, 0x3C, 0x01, 0xC0, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x78,
  0xF0, 0x00, 0xE3, 0x80, 0x03, 0x9E, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xC0,
  0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0xEE, 0x00, 0x3E, 0x00, 0x7B,
  0x80, 0x1F, 0x80, 0x1C, 0xE0, 0x07, 0xE0, 0x0F, 0x38, 0x01, 0xB8, 0x03,
  0x8E, 0x00, 0xEE, 0x01, 0xE3, 0x80, 0x3B, 0x80, 0x70, 0xE0, 0x1C, 0xE0,
  0x1C, 0x38, 0x07, 0x38, 0x0F, 0x0E, 0x03, 0x8E, 0x03, 0x83, 0x80, 0xE3,
  0x81, 0xE0, 0xE0, 0x78, 0xE0, 0x70, 0x38, 0x1C, 0x38, 0x1C, 0x0E, 0x07,
  0x0E, 0x0F, 0x03, 0x83, 0x83, 0x83, 0x80, 0xE0, 0xE0, 0xE1, 0xE0, 0x38,
  0x70, 0x38, 0x70, 0x0E, 0x1C, 0x0E, 0x1C, 0x03, 0x8F, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0xE3, 0x80, 0x38, 0xE0, 0x39, 0xE0, 0x0E, 0x70, 0x0E, 0x70,
  0x03, 0x9C, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x3B,
  0x80, 0x0E, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xF0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x00, 0x78, 0x00, 0x78,
  0x07, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x3C, 0x38, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0xE1, 0xC0, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0x38, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0x70, 0x07, 0x80, 0x07, 0x80,
  0xF0, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0xE0,
  0x00, 0x0E, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x0E, 0x03, 0xC0,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x0E, 0x07, 0x00,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x0E, 0x0E, 0x00,
  0x00, 0x0E, 0x1E, 0x00, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0x70, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0x7F, 0xF8, 0x03, 0xF9,
  0xFE, 0x07, 0xE0, 0x3F, 0xFF, 0x80, 0x0F, 0xFE, 0x80, 0x01, 0xF8,
};

const GFXglyph NotoSans_Condensed_LightItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 14, 45, 14, 1, -45 },
  { 80, 16, 16, 20, 6, -45 },
  { 112, 29, 45, 29, 1, -45 },
  { 276, 26, 52, 27, 1, -48 },
  { 445, 33, 47, 40, 4, -46 },
  { 639, 28, 47, 29, 0, -46 },
  { 804, 7, 16, 11, 6, -45 },
  { 818, 18, 55, 16, 2, -45 },
  { 942, 18, 55, 16, -4, -45 },
  { 1066, 20, 22, 25, 7, -48 },
  { 1121, 24, 29, 29, 3, -37 },
  { 1208, 10, 15, 12, -3, -7 },
  { 1227, 15, 4, 17, 1, -19 },
  { 1235, 5, 6, 12, 1, -6 },
  { 1239, 28, 45, 20, -3, -45 },
  { 1397, 24, 47, 27, 2, -46 },
  { 1538, 14, 45, 27, 8, -45 },
  { 1617, 27, 46, 27, -1, -46 },
  { 1773, 26, 47, 27, 0, -46 },
  { 1926, 27, 45, 27, -1, -45 },
  { 2078, 27, 46, 27, 0, -45 },
  { 2234, 25, 47, 27, 2, -46 },
  { 2381, 26, 45, 27, 3, -45 },
  { 2528, 27, 47, 27, 0, -46 },
  { 2687, 25, 47, 27, 1, -46 },
  { 2834, 10, 34, 12, 1, -34 },
  { 2877, 15, 42, 12, -3, -34 },
  { 2956, 24, 27, 29, 3, -36 },
  { 3037, 24, 16, 29, 3, -30 },
  { 3085, 24, 27, 29, 3, -36 },
  { 3166, 20, 46, 20, 2, -46 },
  { 3281, 37, 51, 40, 2, -45 },
  { 3517, 27, 45, 27, -4, -45 },
  { 3669, 28, 45, 29, 1, -45 },
  { 3827, 28, 47, 27, 3, -46 },
  { 3992, 30, 45, 32, 1, -45 },
  { 4161, 27, 45, 25, 1, -45 },
  { 4313, 27, 45, 24, 1, -45 },
  { 4465, 31, 47, 34, 3, -46 },
  { 4648, 33, 45, 33, 1, -45 },
  { 4834, 22, 45, 15, -3, -45 },
  { 4958, 23, 56, 13, -9, -45 },
  { 5119, 31, 45, 27, 1, -45 },
  { 5294, 18, 45, 23, 1, -45 },
  { 5396, 43, 45, 43, 1, -45 },
  { 5638, 34, 45, 35, 1, -45 },
  { 5830, 30, 47, 34, 3, -46 },
  { 6007, 27, 45, 27, 1, -45 },
  { 6159, 30, 57, 34, 3, -46 },
  { 6373, 27, 45, 28, 1, -45 },
  { 6525, 28, 47, 25, -1, -46 },
  { 6690, 23, 45, 23, 5, -45 },
  { 6820, 31, 46, 33, 3, -45 },
  { 6999, 26, 45, 27, 6, -45 },
  { 7146, 42, 45, 43, 6, -45 },
  { 7383, 33, 45, 24, -4, -45 },
  { 7569, 24, 45, 24, 5, -45 },
  { 7704, 30, 45, 24, -2, -45 },
  { 7873, 23, 55, 18, -1, -45 },
  { 8032, 10, 45, 21, 6, -45 },
  { 8089, 23, 55, 18, -4, -45 },
  { 8248, 25, 24, 28, 2, -45 },
  { 8323, 20, 3, 20, -5, 6 },
  { 8331, 8, 10, 15, 9, -48 },
  { 8341, 25, 35, 28, 2, -34 },
  { 8451, 25, 49, 28, 1, -48 },
  { 8605, 21, 35, 21, 2, -34 },
  { 8697, 29, 49, 28, 2, -48 },
  { 8875, 22, 35, 25, 2, -34 },
  { 8972, 30, 63, 15, -8, -48 },
  { 9209, 28, 49, 28, 0, -34 },
  { 9381, 24, 48, 28, 1, -48 },
  { 9525, 13, 46, 12, 1, -46 },
  { 9600, 22, 61, 12, -8, -46 },
  { 9768, 25, 48, 23, 1, -48 },
  { 9918, 13, 48, 12, 1, -48 },
  { 9996, 38, 34, 42, 1, -34 },
  { 10158, 24, 34, 28, 1, -34 },
  { 10260, 23, 35, 28, 2, -34 },
  { 10361, 28, 49, 28, -2, -34 },
  { 10533, 26, 49, 29, 2, -34 },
  { 10693, 20, 34, 18, 1, -34 },
  { 10778, 21, 35, 21, 0, -34 },
  { 10870, 15, 42, 15, 2, -41 },
  { 10949, 25, 34, 28, 2, -33 },
  { 11056, 22, 33, 22, 3, -33 },
  { 11147, 34, 33, 35, 4, -33 },
  { 11288, 28, 33, 23, -3, -33 },
  { 11404, 32, 48, 22, -7, -33 },
  { 11596, 23, 33, 20, -2, -33 },
  { 11691, 22, 55, 20, 2, -45 },
  { 11843, 3, 63, 26, 12, -48 },
  { 11867, 23, 55, 20, -4, -45 },
  { 12026, 24, 7, 29, 3, -26 },
};

const GFXfont NotoSans_Condensed_LightItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC63PT7B_H_
