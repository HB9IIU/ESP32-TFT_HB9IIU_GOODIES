#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC15PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x22, 0x24, 0x44, 0x00, 0x80, 0xB6, 0xD0, 0x0A, 0x24, 0x53,
  0xF2, 0x45, 0x0A, 0x7E, 0x48, 0xA2, 0x40, 0x08, 0xF5, 0x14, 0x30, 0x41,
  0x8A, 0x2B, 0xE2, 0x08, 0x62, 0x52, 0x94, 0x94, 0xAA, 0xB5, 0xD9, 0x29,
  0x29, 0x4A, 0xCE, 0x18, 0x48, 0x91, 0x43, 0x06, 0x14, 0xC6, 0x8D, 0x11,
  0xD0, 0xF0, 0x08, 0x88, 0x44, 0x21, 0x10, 0x84, 0x20, 0x84, 0x00, 0x11,
  0x11, 0x11, 0x11, 0x12, 0x24, 0xC0, 0x2A, 0x5A, 0x20, 0x20, 0x82, 0x3F,
  0x20, 0x82, 0x00, 0x29, 0x40, 0xF0, 0x80, 0x02, 0x08, 0x10, 0x40, 0x82,
  0x04, 0x10, 0x20, 0x82, 0x00, 0x18, 0x92, 0x51, 0x45, 0x14, 0x61, 0x89,
  0x27, 0x00, 0x2E, 0x94, 0x92, 0x52, 0x00, 0x18, 0x90, 0x41, 0x04, 0x21,
  0x08, 0x41, 0x0F, 0x80, 0x18, 0x90, 0x41, 0x08, 0xC0, 0x82, 0x08, 0x2F,
  0x00, 0x04, 0x30, 0xC5, 0x29, 0x24, 0xA2, 0xFC, 0x41, 0x00, 0x3C, 0x82,
  0x10, 0x71, 0x20, 0x81, 0x08, 0x2F, 0x00, 0x1C, 0x84, 0x20, 0xB3, 0x28,
  0xA2, 0x8A, 0x4E, 0x00, 0x7C, 0x20, 0x84, 0x10, 0x82, 0x10, 0x42, 0x08,
  0x00, 0x1C, 0x92, 0x49, 0x28, 0xC4, 0xA2, 0x86, 0x27, 0x00, 0x18, 0x94,
  0x51, 0x45, 0x33, 0x42, 0x08, 0x4E, 0x00, 0x20, 0x00, 0x04, 0x10, 0x00,
  0x00, 0x24, 0x48, 0x04, 0x66, 0x20, 0x60, 0x40, 0xC0, 0xF8, 0x01, 0xF0,
  0x83, 0x03, 0x03, 0x11, 0x88, 0x00, 0x78, 0x42, 0x11, 0x10, 0x88, 0x00,
  0x30, 0x0F, 0x08, 0x48, 0x24, 0xD4, 0xAA, 0x95, 0x4B, 0x29, 0x9D, 0x41,
  0x10, 0x07, 0x80, 0x04, 0x30, 0xC5, 0x14, 0x93, 0xC9, 0x45, 0x18, 0x40,
  0x3C, 0x44, 0x89, 0x12, 0x4F, 0x11, 0x22, 0x45, 0x0B, 0xE0, 0x1C, 0x84,
  0x20, 0x82, 0x08, 0x20, 0x82, 0x07, 0x00, 0x3C, 0x44, 0x89, 0x14, 0x28,
  0x50, 0xA1, 0x45, 0x13, 0xC0, 0x3E, 0x40, 0x81, 0x04, 0x0F, 0x10, 0x20,
  0x41, 0x03, 0xE0, 0x3E, 0x40, 0x81, 0x04, 0x0F, 0x10, 0x20, 0x41, 0x02,
  0x00, 0x1E, 0x41, 0x04, 0x08, 0x11, 0x21, 0x42, 0x85, 0x09, 0xE0, 0x21,
  0x21, 0x21, 0x22, 0x42, 0x7E, 0x42, 0x42, 0x44, 0x84, 0x84, 0x1C, 0x41,
  0x04, 0x10, 0x82, 0x08, 0x20, 0x8E, 0x00, 0x08, 0x42, 0x10, 0x88, 0x42,
  0x11, 0x08, 0x42, 0x60, 0x23, 0x22, 0x24, 0x28, 0x50, 0x70, 0x50, 0x48,
  0x48, 0x88, 0x88, 0x22, 0x22, 0x44, 0x44, 0x48, 0xF0, 0x30, 0x4C, 0x13,
  0x0C, 0xC5, 0x51, 0x54, 0xA5, 0x29, 0x52, 0x54, 0xA6, 0x28, 0x90, 0x21,
  0x31, 0x31, 0x31, 0x49, 0x4A, 0x4A, 0x4A, 0x46, 0x84, 0x84, 0x1C, 0x49,
  0x0C, 0x18, 0x30, 0x61, 0x42, 0x85, 0x11, 0xC0, 0x38, 0x48, 0x89, 0x14,
  0x49, 0x9C, 0x20, 0x41, 0x02, 0x00, 0x1C, 0x49, 0x0C, 0x18, 0x30, 0x61,
  0x42, 0x85, 0x11, 0xC0, 0x81, 0x02, 0x00, 0x38, 0x48, 0x89, 0x14, 0x49,
  0x9C, 0x24, 0x49, 0x12, 0x20, 0x1C, 0x84, 0x10, 0x20, 0xC0, 0x82, 0x08,
  0x2F, 0x00, 0xFC, 0x82, 0x08, 0x21, 0x04, 0x10, 0x41, 0x08, 0x00, 0x42,
  0x85, 0x0A, 0x28, 0x50, 0xA1, 0x42, 0x89, 0x13, 0xC0, 0x83, 0x0A, 0x14,
  0x48, 0x92, 0x24, 0x50, 0x60, 0x81, 0x00, 0x84, 0x61, 0x18, 0xC6, 0x32,
  0x94, 0xA5, 0x4A, 0x52, 0x94, 0xA6, 0x31, 0x8C, 0x40, 0x11, 0x12, 0x12,
  0x14, 0x08, 0x08, 0x18, 0x28, 0x28, 0x44, 0x84, 0x86, 0x24, 0x94, 0x51,
  0x84, 0x10, 0x41, 0x08, 0x00, 0x3E, 0x08, 0x10, 0x41, 0x02, 0x08, 0x20,
  0x41, 0x03, 0xE0, 0x39, 0x08, 0x44, 0x21, 0x08, 0x44, 0x21, 0x0E, 0x00,
  0xAA, 0xAA, 0x54, 0x1C, 0x20, 0x82, 0x08, 0x21, 0x04, 0x10, 0x42, 0x08,
  0xE0, 0x10, 0x62, 0x89, 0x47, 0x10, 0xF8, 0xD0, 0x75, 0x28, 0xA2, 0x8A,
  0x49, 0x3C, 0x20, 0x82, 0x0F, 0x25, 0x14, 0x51, 0x47, 0x2B, 0x00, 0x74,
  0x88, 0x88, 0x8E, 0x02, 0x04, 0x09, 0xD2, 0x48, 0x91, 0x42, 0x89, 0x11,
  0xE0, 0x72, 0x65, 0xE8, 0x42, 0x1C, 0x06, 0x10, 0x20, 0xE0, 0x82, 0x04,
  0x08, 0x10, 0x40, 0x81, 0x02, 0x08, 0x20, 0x00, 0x3A, 0x49, 0x12, 0x24,
  0x51, 0x22, 0x3C, 0x08, 0x12, 0x43, 0x00, 0x20, 0x82, 0x0F, 0x25, 0x14,
  0x51, 0x4A, 0x28, 0x80, 0x20, 0x14, 0x92, 0x52, 0x00, 0x08, 0x00, 0x11,
  0x08, 0x42, 0x11, 0x08, 0x42, 0x22, 0x00, 0x20, 0x82, 0x09, 0x49, 0x46,
  0x14, 0x52, 0x48, 0x80, 0x24, 0x94, 0x92, 0x52, 0x00, 0x3F, 0x92, 0x51,
  0x28, 0x94, 0x8A, 0x46, 0x25, 0x12, 0x3C, 0x94, 0x51, 0x45, 0x28, 0xA2,
  0x72, 0x63, 0x18, 0xC6, 0x5C, 0x1E, 0x24, 0x89, 0x12, 0x24, 0x59, 0x2C,
  0x40, 0x83, 0x00, 0x3A, 0x49, 0x12, 0x24, 0x51, 0x22, 0x3C, 0x08, 0x10,
  0x40, 0x80, 0x39, 0x10, 0x84, 0x22, 0x10, 0x3A, 0x10, 0xC1, 0x08, 0x5C,
  0x22, 0x74, 0x44, 0x44, 0x86, 0x4C, 0x63, 0x18, 0xCA, 0x5E, 0x8C, 0xA5,
  0x4A, 0x63, 0x10, 0x91, 0x92, 0xAA, 0xAA, 0xCC, 0xCC, 0x88, 0x88, 0x22,
  0x48, 0x60, 0x81, 0x05, 0x12, 0x64, 0x11, 0x12, 0x12, 0x14, 0x14, 0x14,
  0x18, 0x18, 0x10, 0x10, 0x20, 0xC0, 0x78, 0x84, 0x44, 0x22, 0x1E, 0x0C,
  0x41, 0x04, 0x20, 0x8C, 0x10, 0x21, 0x04, 0x10, 0x60, 0xFF, 0xFE, 0x10,
  0x42, 0x11, 0x08, 0x22, 0x11, 0x08, 0x4C, 0x00, 0xFC,
};

const GFXglyph NotoSans_Condensed_LightItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 11, 3, 0, -11 },
  { 7, 3, 4, 5, 2, -11 },
  { 9, 7, 11, 7, 0, -11 },
  { 19, 6, 12, 6, 0, -11 },
  { 28, 8, 11, 9, 1, -11 },
  { 39, 7, 11, 7, 0, -11 },
  { 49, 1, 4, 3, 2, -11 },
  { 50, 5, 13, 4, 0, -11 },
  { 59, 4, 13, 4, -1, -11 },
  { 66, 4, 5, 6, 2, -11 },
  { 69, 6, 7, 7, 1, -9 },
  { 75, 3, 4, 3, -1, -2 },
  { 77, 4, 1, 4, 0, -5 },
  { 78, 1, 1, 3, 0, -1 },
  { 79, 7, 11, 5, -1, -11 },
  { 89, 6, 11, 6, 0, -11 },
  { 98, 3, 11, 6, 2, -11 },
  { 103, 6, 11, 6, 0, -11 },
  { 112, 6, 11, 6, 0, -11 },
  { 121, 6, 11, 6, 0, -11 },
  { 130, 6, 11, 6, 0, -11 },
  { 139, 6, 11, 6, 1, -11 },
  { 148, 6, 11, 6, 1, -11 },
  { 157, 6, 11, 6, 0, -11 },
  { 166, 6, 11, 6, 0, -11 },
  { 175, 3, 8, 3, 0, -8 },
  { 178, 4, 10, 3, -1, -8 },
  { 183, 6, 7, 7, 1, -9 },
  { 189, 5, 4, 7, 1, -7 },
  { 192, 6, 7, 7, 1, -9 },
  { 198, 5, 11, 5, 0, -11 },
  { 205, 9, 12, 10, 0, -11 },
  { 219, 6, 11, 6, -1, -11 },
  { 228, 7, 11, 7, 0, -11 },
  { 238, 6, 11, 6, 1, -11 },
  { 247, 7, 11, 8, 0, -11 },
  { 257, 7, 11, 6, 0, -11 },
  { 267, 7, 11, 6, 0, -11 },
  { 277, 7, 11, 8, 1, -11 },
  { 287, 8, 11, 8, 0, -11 },
  { 298, 6, 11, 4, -1, -11 },
  { 307, 5, 14, 3, -2, -11 },
  { 316, 8, 11, 6, 0, -11 },
  { 327, 4, 11, 6, 0, -11 },
  { 333, 10, 11, 10, 0, -11 },
  { 347, 8, 11, 8, 0, -11 },
  { 358, 7, 11, 8, 1, -11 },
  { 368, 7, 11, 7, 0, -11 },
  { 378, 7, 14, 8, 1, -11 },
  { 391, 7, 11, 7, 0, -11 },
  { 401, 6, 11, 6, 0, -11 },
  { 410, 6, 11, 6, 1, -11 },
  { 419, 7, 11, 8, 1, -11 },
  { 429, 7, 11, 6, 1, -11 },
  { 439, 10, 11, 10, 1, -11 },
  { 453, 8, 11, 6, -1, -11 },
  { 464, 6, 11, 6, 1, -11 },
  { 473, 7, 11, 6, 0, -11 },
  { 483, 5, 13, 4, 0, -11 },
  { 492, 2, 11, 5, 2, -11 },
  { 495, 6, 13, 4, -1, -11 },
  { 505, 6, 6, 7, 0, -11 },
  { 510, 5, 1, 5, -1, 1 },
  { 511, 2, 2, 4, 2, -11 },
  { 512, 6, 8, 7, 1, -8 },
  { 518, 6, 11, 7, 0, -11 },
  { 527, 4, 8, 5, 1, -8 },
  { 531, 7, 11, 7, 0, -11 },
  { 541, 5, 8, 6, 1, -8 },
  { 546, 7, 15, 3, -2, -11 },
  { 560, 7, 12, 7, 0, -8 },
  { 571, 6, 11, 7, 0, -11 },
  { 580, 3, 11, 3, 0, -11 },
  { 585, 5, 15, 3, -2, -11 },
  { 595, 6, 11, 6, 0, -11 },
  { 604, 3, 11, 3, 0, -11 },
  { 609, 9, 8, 10, 0, -8 },
  { 618, 6, 8, 7, 0, -8 },
  { 624, 5, 8, 7, 1, -8 },
  { 629, 7, 11, 7, -1, -8 },
  { 639, 7, 12, 7, 0, -8 },
  { 650, 5, 8, 4, 0, -8 },
  { 655, 5, 8, 5, 0, -8 },
  { 660, 4, 10, 4, 0, -10 },
  { 665, 5, 8, 7, 1, -8 },
  { 670, 5, 8, 5, 1, -8 },
  { 675, 8, 8, 8, 1, -8 },
  { 683, 7, 8, 5, -1, -8 },
  { 690, 8, 12, 5, -2, -8 },
  { 702, 5, 8, 5, 0, -8 },
  { 707, 6, 13, 5, 0, -11 },
  { 717, 1, 15, 6, 3, -11 },
  { 719, 5, 13, 5, -1, -11 },
  { 728, 6, 1, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_LightItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC15PT7B_H_
