#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC57PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x00, 0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x38, 0x39,
  0xC1, 0xC7, 0x07, 0x1C, 0x1C, 0x70, 0x71, 0x81, 0x86, 0x0E, 0x38, 0x38,
  0xE0, 0xE3, 0x03, 0x0C, 0x0C, 0x00, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80,
  0xE0, 0x00, 0x60, 0x30, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x01, 0x80, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x18, 0x0E, 0x00,
  0x0E, 0x03, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xC0, 0x70, 0x0F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0xC0, 0x00, 0xE0,
  0x30, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x07, 0x01, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0x60, 0x38, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x01, 0xC0, 0x01, 0xC0, 0x60, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0x06, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x30,
  0x1C, 0x00, 0x1C, 0x06, 0x00, 0x07, 0x03, 0x80, 0x01, 0x80, 0xE0, 0x00,
  0x60, 0x30, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x07, 0x00, 0x03, 0x01, 0x80,
  0x01, 0xC0, 0x60, 0x00, 0x70, 0x38, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x38, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xF9, 0x9F, 0x03, 0xC3, 0x04, 0x07, 0x0E,
  0x00, 0x1C, 0x18, 0x00, 0x38, 0x30, 0x00, 0x60, 0x60, 0x00, 0xC0, 0xC0,
  0x01, 0x83, 0x00, 0x03, 0x86, 0x00, 0x07, 0x0C, 0x00, 0x0F, 0x18, 0x00,
  0x0E, 0x30, 0x00, 0x1E, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x6F, 0x80, 0x00,
  0xC7, 0x00, 0x01, 0x8F, 0x00, 0x06, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x18,
  0x38, 0x00, 0x30, 0x70, 0x00, 0x60, 0xE0, 0x01, 0x81, 0xC0, 0x03, 0x07,
  0x00, 0x06, 0x1E, 0x08, 0x0C, 0x78, 0x1F, 0x3F, 0xE0, 0x3F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x38, 0x07, 0xF0, 0x00, 0xE0, 0x1C, 0x70, 0x03, 0x80, 0x70, 0x60, 0x07,
  0x00, 0xC0, 0xC0, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x06, 0x03, 0x80, 0xE0,
  0x1C, 0x07, 0x01, 0x80, 0x38, 0x0C, 0x07, 0x00, 0x60, 0x18, 0x1C, 0x01,
  0xC0, 0x30, 0x38, 0x03, 0x80, 0xE0, 0xE0, 0x07, 0x01, 0xC1, 0xC0, 0x0C,
  0x03, 0x87, 0x00, 0x18, 0x06, 0x0C, 0x00, 0x70, 0x0C, 0x38, 0x00, 0xE0,
  0x38, 0xE0, 0xF1, 0xC0, 0x71, 0xC7, 0xF3, 0x81, 0xC7, 0x1F, 0xF7, 0x03,
  0x8C, 0x70, 0xEE, 0x0E, 0x38, 0xE0, 0xCC, 0x1C, 0x63, 0x81, 0xDC, 0x71,
  0xC6, 0x03, 0xBF, 0xC7, 0x1C, 0x07, 0x3F, 0x0E, 0x38, 0x0E, 0x00, 0x38,
  0x60, 0x18, 0x00, 0x61, 0xC0, 0x30, 0x01, 0xC3, 0x80, 0xE0, 0x07, 0x07,
  0x01, 0xC0, 0x0E, 0x0C, 0x03, 0x80, 0x38, 0x18, 0x06, 0x00, 0x70, 0x70,
  0x0C, 0x01, 0xC0, 0xE0, 0x38, 0x03, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0xC0, 0x38, 0x07, 0x03, 0x80, 0x70, 0x0E, 0x06, 0x01, 0xC0, 0x1C, 0x1C,
  0x03, 0x80, 0x1C, 0x70, 0x0E, 0x00, 0x3F, 0xC0, 0x38, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0x9E, 0x00, 0x07, 0x07, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x03,
  0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x1C, 0x00,
  0x38, 0x0E, 0x00, 0x1C, 0x0F, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x87, 0x80, 0x00, 0xE7, 0x80, 0x00, 0x77, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0xE0,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x1C, 0x07, 0x1E, 0x0F, 0x03, 0x8E, 0x03,
  0x83, 0x8E, 0x01, 0xC1, 0xC7, 0x00, 0x71, 0xC7, 0x00, 0x38, 0xE3, 0x80,
  0x1E, 0xE1, 0xC0, 0x07, 0x71, 0xE0, 0x03, 0xF0, 0xE0, 0x00, 0xF8, 0x70,
  0x00, 0x78, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x3E, 0x07, 0x00, 0x3F, 0x83,
  0xC0, 0x79, 0xC0, 0xF8, 0x78, 0xF0, 0x7F, 0xF8, 0x38, 0x0F, 0xF0, 0x1E,
  0x01, 0x80, 0x00, 0x00, 0x3C, 0xE3, 0x8E, 0x39, 0xC7, 0x1C, 0x71, 0x86,
  0x38, 0xE3, 0x0C, 0x00, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x04,
  0x06, 0x00, 0xE0, 0xC0, 0x3F, 0x18, 0x01, 0xF3, 0x07, 0x07, 0xFF, 0xE0,
  0x3F, 0xFC, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x73, 0x00, 0x1C, 0x60, 0x07,
  0x0E, 0x03, 0xC0, 0xC0, 0x30, 0x1C, 0x02, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x0F, 0x0F, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0x70, 0xE0,
  0xC0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFE, 0x77, 0xFD, 0xEF, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x38, 0x0F, 0x00, 0xE0,
  0x38, 0x03, 0x81, 0xC0, 0x0F, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0,
  0x01, 0xC7, 0x80, 0x07, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0xE3, 0xC0, 0x03,
  0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0x9C,
  0x00, 0x0E, 0x70, 0x00, 0x79, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x3C, 0x00,
  0x1C, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x38,
  0xE0, 0x01, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0,
  0x03, 0x83, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x03, 0x80, 0x70, 0x1E,
  0x01, 0xC0, 0xF0, 0x07, 0xC7, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x7C, 0x07, 0xE0, 0x7F, 0x0F,
  0xB8, 0xF1, 0xCF, 0x1C, 0xF0, 0xE2, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x1E, 0x03, 0xE0, 0x04,
  0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xE0, 0x1E, 0x01, 0x80, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x80, 0x0F,
  0x80, 0xF0, 0x3F, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xB8, 0x00,
  0x01, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x01, 0xC7, 0x00, 0x00, 0xE3, 0x80,
  0x00, 0xE3, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x70, 0x70,
  0x00, 0x70, 0x70, 0x00, 0x30, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x0E,
  0x00, 0x38, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF9, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x18,
  0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0x07, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x80, 0x0F, 0x80, 0xF0, 0x3F, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0x70, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x7F, 0x00, 0x73, 0xFF, 0x00, 0xEF, 0xBF, 0x03, 0xB8,
  0x0F, 0x07, 0xE0, 0x0E, 0x0F, 0x80, 0x1C, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x78, 0x70, 0x00, 0x71, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0xC7, 0x00, 0x07,
  0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70, 0x00, 0xF0,
  0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0F, 0x03, 0x80, 0x1C, 0x07,
  0x00, 0x70, 0x0F, 0x01, 0xE0, 0x0F, 0x0F, 0x80, 0x0F, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x7E,
  0x00, 0xF0, 0x1E, 0x00, 0xE0, 0x0F, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07,
  0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07,
  0x03, 0x80, 0x0F, 0x03, 0xC0, 0x0E, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0x1C,
  0x00, 0xE0, 0x38, 0x00, 0xF0, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF7, 0x80, 0x07, 0xC3, 0xC0,
  0x0F, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x3C, 0x00, 0xF0, 0x38, 0x00, 0x70,
  0x78, 0x00, 0x70, 0x70, 0x00, 0x78, 0x70, 0x00, 0x38, 0x70, 0x00, 0x38,
  0xF0, 0x00, 0x38, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x70,
  0x70, 0x00, 0xF0, 0x78, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x3F, 0x0F, 0x80,
  0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xC0,
  0x01, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x78, 0x1E, 0x03, 0xC0, 0x38, 0x0E,
  0x00, 0x70, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x1C, 0x70, 0x00, 0x71,
  0xC0, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x3C, 0x70, 0x00, 0xF1, 0xC0,
  0x07, 0xC7, 0x00, 0x1E, 0x1E, 0x00, 0xF8, 0x38, 0x07, 0xE0, 0xF8, 0x7B,
  0x81, 0xFF, 0xCE, 0x03, 0xFC, 0x70, 0x00, 0x81, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x60, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x0C, 0x1F, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0x80, 0x00, 0x20, 0x00, 0x00, 0x01, 0x01, 0xC1, 0xE0, 0xF0, 0x78, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1E,
  0x0F, 0x07, 0x83, 0x80, 0x00, 0x10, 0x00, 0xE0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xFF,
  0xC1, 0xFF, 0xF8, 0x30, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x03, 0xC0, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x1C, 0x03, 0xC0,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0xE0, 0xE0, 0x00, 0x00, 0x70, 0xE0, 0x0F, 0xF8, 0x18, 0x60,
  0x0F, 0xFC, 0x0C, 0x70, 0x0E, 0x0E, 0x06, 0x38, 0x0E, 0x06, 0x03, 0x18,
  0x0E, 0x07, 0x01, 0x9C, 0x0E, 0x03, 0x81, 0xCC, 0x07, 0x01, 0xC0, 0xE6,
  0x07, 0x00, 0xC0, 0x77, 0x03, 0x80, 0xE0, 0x3B, 0x81, 0x80, 0x70, 0x19,
  0x81, 0xC0, 0x38, 0x0C, 0xC0, 0xE0, 0x18, 0x0E, 0xE0, 0x60, 0x1C, 0x07,
  0x70, 0x30, 0x0E, 0x03, 0x38, 0x18, 0x07, 0x03, 0x9C, 0x1C, 0x07, 0x01,
  0x8E, 0x0E, 0x03, 0x81, 0xC7, 0x07, 0x03, 0xC0, 0xC3, 0x81, 0x81, 0xE0,
  0xE1, 0xC0, 0xE1, 0xB8, 0xE0, 0xE0, 0x7F, 0x8F, 0xE0, 0x70, 0x1F, 0x87,
  0xE0, 0x38, 0x03, 0x00, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x04, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xB8, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x70, 0x60, 0x00, 0x38, 0x30, 0x00,
  0x1C, 0x18, 0x00, 0x1C, 0x0C, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x03, 0x80,
  0x07, 0x01, 0xC0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x03, 0xC0, 0x38,
  0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0x70, 0x1C, 0x00,
  0x38, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x87, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xE3, 0xC0, 0x00, 0x71, 0xC0,
  0x00, 0x38, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1C, 0x07,
  0xE0, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x0E, 0x03, 0x80,
  0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x70, 0x38, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x0E,
  0x00, 0x1C, 0x07, 0x00, 0x3C, 0x03, 0x80, 0x3C, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x70, 0x0F, 0x80, 0x38, 0x01, 0xE0,
  0x1C, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07,
  0x03, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00,
  0x70, 0x70, 0x00, 0x78, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x1C, 0x00,
  0x1E, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x1E, 0x03, 0x80, 0x3E, 0x03, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0x80, 0x20, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x04, 0x00, 0x7E, 0x1E, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x70, 0x3F, 0x80, 0x0E,
  0x00, 0xF0, 0x03, 0x80, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x1E,
  0x01, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x81, 0xC0,
  0x00, 0xF0, 0x38, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x38, 0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x07, 0x07, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83,
  0x80, 0x00, 0xF0, 0x70, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x83, 0x80, 0x00,
  0xF0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0x70,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0x38, 0x00, 0x3C,
  0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0xF0, 0x07, 0x00,
  0x7C, 0x00, 0xE0, 0x3F, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xC0, 0x0E,
  0x00, 0xF8, 0x00, 0x20, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0x8E,
  0x00, 0x1F, 0xF8, 0xE0, 0x01, 0xFF, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE0,
  0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C,
  0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x03, 0xE0, 0x03, 0x80, 0x1F,
  0xC3, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0x40,
  0x00, 0x00, 0xF0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0,
  0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x0F,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80,
  0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x78, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x78, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x38, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x80, 0x70,
  0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x3C, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xE0,
  0x1C, 0x00, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x0E,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78,
  0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x00, 0xE0, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x01, 0xC0, 0x1E, 0x00, 0x1C,
  0x03, 0xC0, 0x01, 0xC0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x38, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x07,
  0x87, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x07, 0x78, 0x00, 0x00, 0xE7, 0xC0, 0x00, 0x0E, 0xFC, 0x00, 0x00,
  0xFD, 0xC0, 0x00, 0x0F, 0x9C, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x0E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x3C, 0x07, 0x00, 0x03, 0x80, 0x78, 0x00, 0x38, 0x07, 0x80, 0x03, 0x80,
  0x38, 0x00, 0x38, 0x03, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x76, 0x00, 0x00, 0xEE, 0x01, 0xD8,
  0x00, 0x03, 0xB8, 0x0E, 0x70, 0x00, 0x1D, 0xC0, 0x39, 0xC0, 0x00, 0x77,
  0x00, 0xE7, 0x00, 0x03, 0x9C, 0x03, 0x9C, 0x00, 0x0E, 0x70, 0x0E, 0x70,
  0x00, 0x71, 0xC0, 0x71, 0xC0, 0x01, 0xCE, 0x01, 0xC7, 0x00, 0x0E, 0x38,
  0x07, 0x1C, 0x00, 0x38, 0xE0, 0x1C, 0x70, 0x01, 0xC3, 0x80, 0x71, 0xC0,
  0x07, 0x1E, 0x03, 0x87, 0x00, 0x38, 0x70, 0x0E, 0x0C, 0x00, 0xE1, 0xC0,
  0x38, 0x30, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80,
  0xE0, 0xE0, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0x70, 0x38, 0x1C, 0x0E, 0x01,
  0xC0, 0xE0, 0x70, 0x38, 0x07, 0x03, 0x83, 0x80, 0xE0, 0x38, 0x0E, 0x0E,
  0x07, 0x00, 0xE0, 0x38, 0x70, 0x1C, 0x03, 0x80, 0xE1, 0xC0, 0x70, 0x0E,
  0x03, 0x8E, 0x01, 0xC0, 0x38, 0x0E, 0x38, 0x0F, 0x01, 0xC0, 0x19, 0xC0,
  0x38, 0x07, 0x00, 0x67, 0x00, 0xE0, 0x1C, 0x01, 0xF8, 0x03, 0x80, 0x70,
  0x07, 0xE0, 0x0E, 0x01, 0xC0, 0x1F, 0x00, 0x78, 0x0E, 0x00, 0x7C, 0x01,
  0xC0, 0x38, 0x01, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x78, 0x07,
  0xC0, 0x00, 0xE0, 0x0F, 0x80, 0x01, 0xC0, 0x3F, 0x00, 0x03, 0x80, 0x76,
  0x00, 0x07, 0x00, 0xEE, 0x00, 0x1C, 0x01, 0xDC, 0x00, 0x38, 0x07, 0x38,
  0x00, 0x70, 0x0E, 0x70, 0x00, 0xE0, 0x1C, 0x70, 0x01, 0xC0, 0x38, 0xE0,
  0x07, 0x00, 0x71, 0xC0, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0x03, 0x83, 0x80,
  0x38, 0x07, 0x07, 0x00, 0xF0, 0x0E, 0x0E, 0x01, 0xC0, 0x1C, 0x1C, 0x03,
  0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x38,
  0x03, 0x80, 0xE0, 0x70, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x01, 0xC1, 0xC0,
  0x38, 0x03, 0x83, 0x80, 0x70, 0x07, 0x0E, 0x00, 0xE0, 0x07, 0x1C, 0x03,
  0x80, 0x0E, 0x38, 0x07, 0x00, 0x1C, 0x70, 0x0E, 0x00, 0x38, 0xE0, 0x1C,
  0x00, 0x3B, 0x80, 0x38, 0x00, 0x77, 0x00, 0xE0, 0x00, 0xEE, 0x01, 0xC0,
  0x01, 0xDC, 0x03, 0x80, 0x01, 0xF0, 0x07, 0x00, 0x03, 0xE0, 0x0E, 0x00,
  0x07, 0xC0, 0x38, 0x00, 0x0F, 0x80, 0x70, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFC,
  0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0xE0,
  0x00, 0x70, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C,
  0x38, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x78, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x1D, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x03, 0x9C, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x03,
  0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0,
  0x38, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0xC7,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xE0, 0x7E,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07,
  0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07,
  0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0E,
  0x07, 0x00, 0x0E, 0x07, 0x00, 0x1E, 0x07, 0x00, 0x3C, 0x0E, 0x00, 0x78,
  0x0E, 0x01, 0xF0, 0x0E, 0x1F, 0xE0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80,
  0xE0, 0x00, 0x70, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x3C, 0x38, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1C, 0x70, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03, 0x87,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x03, 0xC0, 0x01,
  0xE0, 0x38, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x07, 0xC0, 0x0F,
  0xC7, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xE0, 0x7E, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x0F, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01,
  0xC0, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03, 0x80, 0x07, 0x03,
  0x80, 0x07, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1E, 0x07,
  0x00, 0x1C, 0x07, 0x00, 0x3C, 0x0F, 0x00, 0xF8, 0x0E, 0x07, 0xF0, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C,
  0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x38,
  0x07, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78,
  0x03, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70,
  0x01, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0x00, 0x60,
  0x0F, 0x00, 0x10, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x06, 0x00, 0x3E, 0x03, 0xF0, 0xFE,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0,
  0x70, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x3C, 0x0E, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x38,
  0x1C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xE0, 0x70,
  0x00, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1C, 0x0E, 0x00, 0x01,
  0xC0, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x38, 0x0E,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00,
  0xE0, 0x0E, 0x00, 0x0E, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x7C, 0x00,
  0x7F, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x38, 0xE0,
  0x00, 0x78, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xE0, 0x70,
  0x01, 0xE0, 0x70, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x03, 0x80, 0x70,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x70,
  0x0E, 0x00, 0x70, 0x1E, 0x00, 0x70, 0x1C, 0x00, 0x70, 0x3C, 0x00, 0x70,
  0x38, 0x00, 0x70, 0x38, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70,
  0xE0, 0x00, 0x70, 0xE0, 0x00, 0x71, 0xC0, 0x00, 0x71, 0xC0, 0x00, 0x73,
  0xC0, 0x00, 0x73, 0x80, 0x00, 0x73, 0x80, 0x00, 0x77, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0x00,
  0x70, 0x00, 0x3B, 0x80, 0x01, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xC0, 0x01,
  0xCE, 0x00, 0x0F, 0x80, 0x03, 0x9C, 0x00, 0x1F, 0x00, 0x0F, 0x38, 0x00,
  0x7E, 0x00, 0x1C, 0x70, 0x00, 0xFC, 0x00, 0x78, 0xE0, 0x01, 0xB8, 0x00,
  0xE1, 0xC0, 0x07, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0xE0, 0x07, 0x07, 0x00,
  0x39, 0xC0, 0x0E, 0x0E, 0x00, 0x73, 0x80, 0x3C, 0x1C, 0x00, 0xC7, 0x00,
  0x70, 0x38, 0x03, 0x8E, 0x00, 0xE0, 0x70, 0x07, 0x1C, 0x03, 0x80, 0xE0,
  0x1C, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0xE0,
  0x38, 0x07, 0x01, 0xC1, 0xC0, 0xF0, 0x0E, 0x03, 0x83, 0x81, 0xC0, 0x1C,
  0x0E, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x1C,
  0x1C, 0x00, 0xE0, 0xE0, 0x38, 0x78, 0x01, 0xC1, 0x80, 0x70, 0xE0, 0x03,
  0x87, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0x0E, 0x38, 0x03,
  0x8E, 0x00, 0x1C, 0x70, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x00,
  0x73, 0x80, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00,
  0x77, 0x00, 0x03, 0xB8, 0x00, 0xEC, 0x00, 0x07, 0x60, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x38, 0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0,
  0x78, 0x00, 0x03, 0x83, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE3, 0xC0,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x00, 0xEE, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xB8, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x1C, 0x70, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0xE0,
  0x70, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x78, 0x07, 0x80, 0x03, 0x80, 0x1C, 0x00, 0x3C, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x1D, 0xE0, 0x01, 0xE7, 0x00, 0x0E, 0x38, 0x00, 0xE1, 0xC0, 0x0F,
  0x0E, 0x00, 0x70, 0x70, 0x07, 0x83, 0x80, 0x38, 0x0E, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x81, 0xC0, 0x1C, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x0F, 0x00,
  0x38, 0x70, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x3B, 0x80, 0x01, 0xDC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x60,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x60, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0xE1, 0xC0, 0x01, 0xC1, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x07, 0x00, 0x38,
  0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x0E, 0x00,
  0x38, 0x38, 0x00, 0x38, 0x70, 0x00, 0x71, 0xC0, 0x00, 0xE7, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0xE1, 0xC1, 0xC3, 0x83, 0x87, 0x07, 0x06, 0x00, 0x1E, 0x00, 0x01, 0xFF,
  0x1C, 0x07, 0xFF, 0x38, 0x1F, 0x0E, 0x60, 0x78, 0x0F, 0xC0, 0xE0, 0x0F,
  0x83, 0x80, 0x1F, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x70,
  0xE0, 0x00, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x0E, 0x00, 0x0E, 0x1C,
  0x00, 0x1C, 0x38, 0x00, 0x38, 0xF0, 0x00, 0xF1, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0xF0, 0x70, 0x01, 0xE0, 0xE0, 0x07, 0xC1, 0xC0, 0x0F, 0x83, 0xC0, 0x36,
  0x03, 0x80, 0xDC, 0x07, 0xC7, 0xB8, 0x07, 0xFC, 0x70, 0x07, 0xF0, 0xE0,
  0x01, 0x00, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x3C, 0x00, 0x71, 0xFE, 0x00, 0xE7, 0xFE, 0x03, 0x9C,
  0x3E, 0x07, 0x60, 0x3C, 0x0F, 0x80, 0x38, 0x1F, 0x00, 0x78, 0x3C, 0x00,
  0xF0, 0xF0, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x03, 0x87, 0x00, 0x0F,
  0x0E, 0x00, 0x1E, 0x38, 0x00, 0x38, 0x70, 0x00, 0x70, 0xE0, 0x00, 0xE1,
  0xC0, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38,
  0x00, 0x38, 0x70, 0x00, 0xE1, 0xE0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80,
  0x0E, 0x0F, 0x00, 0x3C, 0x1B, 0x00, 0xF0, 0x76, 0x03, 0xC0, 0xEF, 0x0F,
  0x01, 0x8F, 0xFC, 0x03, 0x0F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x0F, 0xFC, 0x07, 0xFF, 0x01, 0xF0, 0x20, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x02, 0x03, 0xC1, 0xC0, 0x7F, 0xF8, 0x03, 0xFE, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x1E, 0x0E, 0x00, 0x3F, 0xE3, 0x80,
  0x1F, 0xFC, 0xE0, 0x0F, 0x83, 0x70, 0x07, 0x80, 0x7C, 0x01, 0xC0, 0x1F,
  0x00, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x0F, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x1C,
  0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0xF0,
  0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x01,
  0xE0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x0F, 0x00, 0xE0,
  0x07, 0xC0, 0x38, 0x01, 0xF0, 0x0F, 0x00, 0xDC, 0x01, 0xC0, 0x66, 0x00,
  0x7C, 0x7B, 0x80, 0x0F, 0xFC, 0xE0, 0x01, 0xFC, 0x38, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0x01, 0xE0, 0xF0, 0x78,
  0x0E, 0x1E, 0x01, 0xC3, 0x80, 0x38, 0xF0, 0x07, 0x1C, 0x00, 0xE7, 0x00,
  0x1C, 0xE0, 0x07, 0x1C, 0x01, 0xE7, 0x00, 0x78, 0xE0, 0x3E, 0x1F, 0xFF,
  0x87, 0xFF, 0xC0, 0xFF, 0x80, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x01, 0x03, 0xC0, 0xE0, 0x3F, 0xFC,
  0x03, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1E, 0x20, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0xF1, 0xC0, 0x1F, 0xFC, 0xE0, 0x1F, 0x06, 0x60, 0x1E, 0x01,
  0xF0, 0x0E, 0x00, 0xF8, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x00,
  0x0E, 0x07, 0x80, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x03, 0xC1, 0xE0,
  0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00, 0x38, 0x3C,
  0x00, 0x3C, 0x1C, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03,
  0x80, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x03, 0xC0, 0x70, 0x01, 0xE0,
  0x38, 0x01, 0xF0, 0x1C, 0x01, 0xF8, 0x0F, 0x00, 0xDC, 0x03, 0x80, 0xFC,
  0x01, 0xF1, 0xEE, 0x00, 0x7F, 0xE7, 0x00, 0x1F, 0xC3, 0x80, 0x01, 0x83,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1E, 0x00, 0x80, 0x1E, 0x00, 0x70, 0x3E, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x83, 0xC0, 0x0E, 0x3F, 0xC0, 0x3B, 0xFF, 0x81,
  0xDE, 0x1E, 0x07, 0x60, 0x3C, 0x1F, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xE0,
  0x07, 0x0F, 0x00, 0x1C, 0x3C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E,
  0x0E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0xE0, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x38, 0x70, 0x01, 0xC1,
  0xC0, 0x07, 0x07, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80,
  0x0E, 0x0E, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x01, 0x0F, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0xF0, 0x38, 0x07, 0x81, 0xC0, 0x1C, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x0E, 0x0F,
  0x00, 0x38, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00,
  0x73, 0xC0, 0x01, 0xDF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0x38, 0x00, 0xFC,
  0xE0, 0x03, 0xE3, 0x80, 0x0F, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0xE0, 0x70,
  0x07, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x00, 0x87, 0xC0, 0x1E, 0x00,
  0x63, 0xFC, 0x0F, 0xF0, 0x0C, 0xFF, 0xC7, 0xFF, 0x03, 0xB8, 0x3D, 0xE1,
  0xE0, 0x76, 0x03, 0xB0, 0x1C, 0x0F, 0x80, 0x7C, 0x03, 0xC1, 0xE0, 0x0F,
  0x00, 0x38, 0x3C, 0x01, 0xE0, 0x0F, 0x0F, 0x00, 0x38, 0x01, 0xC1, 0xE0,
  0x07, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0xE0, 0x07, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0x07, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0xE0, 0x07, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0x03, 0x87, 0x80, 0x1C,
  0x00, 0x70, 0xE0, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x70, 0x03, 0x83, 0x80,
  0x1C, 0x00, 0x70, 0x70, 0x03, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0x03, 0xC3,
  0x80, 0x0E, 0x00, 0x70, 0x70, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x01,
  0xC1, 0xC0, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x38,
  0x01, 0xC1, 0xC0, 0x0F, 0x00, 0x38, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x00,
  0x83, 0xE0, 0x0C, 0x3F, 0xC0, 0x33, 0xFF, 0x81, 0xDE, 0x1E, 0x07, 0x60,
  0x3C, 0x1F, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xE0, 0x07, 0x0F, 0x00, 0x1C,
  0x3C, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x70,
  0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xF0, 0x01,
  0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0x87,
  0x00, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00,
  0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80, 0x0E, 0x0E, 0x00, 0x38,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0x83, 0xC0,
  0x78, 0x07, 0x07, 0x80, 0x38, 0x38, 0x01, 0xE3, 0xC0, 0x07, 0x1C, 0x00,
  0x39, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x77, 0x80, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x01, 0xEE, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x00, 0x03,
  0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xEE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80,
  0x07, 0x9C, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x80, 0x1C, 0x1C, 0x01, 0xC0,
  0xF0, 0x1E, 0x03, 0xC3, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x60,
  0x00, 0x00, 0x10, 0x78, 0x00, 0x18, 0x7F, 0x80, 0x06, 0x3F, 0xF0, 0x03,
  0x9C, 0x1E, 0x00, 0xEE, 0x03, 0x80, 0x3F, 0x00, 0xE0, 0x0F, 0x80, 0x3C,
  0x03, 0xC0, 0x07, 0x01, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x1E, 0x00,
  0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xE0, 0x38,
  0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x00, 0xE0,
  0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x03,
  0x80, 0xF0, 0x00, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1C, 0x03, 0xC0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x76, 0x03, 0xC0, 0x1D, 0xE3, 0xE0, 0x07,
  0x3F, 0xF0, 0x01, 0xC7, 0xF8, 0x00, 0x70, 0x60, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x01, 0xFF, 0x1C, 0x07, 0xFF, 0x38, 0x1F, 0x0E, 0x60,
  0x78, 0x07, 0xC0, 0xE0, 0x0F, 0x83, 0x80, 0x1F, 0x0F, 0x00, 0x1E, 0x1C,
  0x00, 0x38, 0x78, 0x00, 0x70, 0xE0, 0x00, 0xE1, 0xC0, 0x01, 0xC7, 0x80,
  0x07, 0x8E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xF0, 0x00,
  0x71, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x07, 0x0E, 0x00, 0x1E,
  0x1C, 0x00, 0x3C, 0x38, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xE0, 0x07, 0xC1,
  0xC0, 0x0F, 0x83, 0xC0, 0x37, 0x03, 0x80, 0xDC, 0x07, 0xC7, 0xB8, 0x07,
  0xFE, 0x70, 0x07, 0xF0, 0xE0, 0x01, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0xC7, 0xF0,
  0x33, 0xF8, 0x1D, 0xE1, 0x07, 0x60, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x0F, 0xFF,
  0x83, 0xC0, 0x60, 0xF0, 0x04, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x40, 0x1E, 0x0E,
  0x07, 0xC1, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x58, 0x00, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x0F, 0xFF, 0x7F, 0xF8,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x3C, 0x41, 0xFE, 0x07, 0xF0, 0x06, 0x00, 0x07,
  0x00, 0x1C, 0x3C, 0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x0E, 0x0E, 0x00,
  0x38, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x1C, 0x00, 0x70,
  0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0xE0, 0xE0,
  0x03, 0x83, 0x80, 0x0E, 0x1E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x07,
  0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x0E,
  0x00, 0x78, 0x38, 0x01, 0xE0, 0xE0, 0x0F, 0x83, 0x80, 0x7E, 0x0F, 0x03,
  0xB8, 0x3E, 0x1C, 0xC0, 0x7F, 0xE3, 0x00, 0xFF, 0x1C, 0x00, 0x40, 0x00,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0x70, 0x01, 0xEE, 0x00,
  0x39, 0xC0, 0x07, 0x38, 0x01, 0xC3, 0x00, 0x38, 0x60, 0x0E, 0x0E, 0x01,
  0xC1, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x1C,
  0x03, 0x83, 0x80, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0xE0,
  0x07, 0x3C, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0xB8, 0x00, 0x77, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x39, 0x80, 0x1F, 0x00,
  0x73, 0x00, 0x3E, 0x00, 0xE6, 0x00, 0xFC, 0x03, 0x8C, 0x01, 0xB8, 0x07,
  0x18, 0x07, 0x70, 0x1C, 0x30, 0x0E, 0xE0, 0x38, 0x60, 0x39, 0xC0, 0xF0,
  0xC0, 0x73, 0x81, 0xC1, 0x80, 0xC7, 0x03, 0x83, 0x03, 0x8E, 0x0E, 0x06,
  0x07, 0x1C, 0x1C, 0x0C, 0x1C, 0x38, 0x70, 0x18, 0x38, 0x70, 0xE0, 0x30,
  0xE0, 0xE1, 0xC0, 0x61, 0xC1, 0xC7, 0x00, 0xC3, 0x03, 0x8E, 0x01, 0x8E,
  0x07, 0x38, 0x03, 0x1C, 0x0E, 0x70, 0x06, 0x70, 0x1C, 0xC0, 0x0C, 0xE0,
  0x3B, 0x80, 0x19, 0x80, 0x77, 0x00, 0x37, 0x00, 0xFC, 0x00, 0x6C, 0x01,
  0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x0F,
  0x80, 0x07, 0x80, 0x1E, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x0F, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x3C, 0x00, 0xE0,
  0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0x71,
  0xC0, 0x00, 0x73, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xCE, 0x00, 0x03, 0x87,
  0x00, 0x07, 0x87, 0x00, 0x07, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x1E, 0x03,
  0x80, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x70, 0x01,
  0xC0, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0xE0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0x70, 0x00, 0x38, 0x03,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x1C, 0x00,
  0x03, 0x80, 0xE0, 0x00, 0x0C, 0x0F, 0x00, 0x00, 0x60, 0x70, 0x00, 0x03,
  0x07, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x0E, 0x70, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x87, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0x80, 0x05, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xF0, 0x1F, 0xFE, 0x80, 0x1F,
  0xF2, 0x00, 0x0F, 0x00,
};

const GFXglyph NotoSans_Condensed_LightItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 41, 13, 1, -41 },
  { 63, 14, 15, 18, 6, -41 },
  { 90, 26, 41, 27, 1, -41 },
  { 224, 23, 46, 24, 1, -43 },
  { 357, 31, 42, 36, 3, -41 },
  { 520, 25, 42, 27, 0, -41 },
  { 652, 6, 15, 10, 6, -41 },
  { 664, 17, 50, 14, 1, -41 },
  { 771, 17, 50, 14, -4, -41 },
  { 878, 19, 19, 23, 6, -43 },
  { 924, 22, 26, 26, 3, -33 },
  { 996, 8, 13, 11, -2, -6 },
  { 1009, 13, 3, 16, 1, -17 },
  { 1014, 5, 5, 11, 1, -5 },
  { 1018, 25, 41, 18, -3, -41 },
  { 1147, 22, 42, 24, 2, -41 },
  { 1263, 13, 41, 24, 7, -41 },
  { 1330, 25, 41, 24, -1, -41 },
  { 1459, 24, 42, 24, 0, -41 },
  { 1585, 25, 41, 24, -1, -41 },
  { 1714, 24, 42, 24, 0, -41 },
  { 1840, 23, 42, 24, 2, -41 },
  { 1961, 23, 41, 24, 3, -41 },
  { 2079, 24, 42, 24, 0, -41 },
  { 2205, 22, 42, 24, 1, -41 },
  { 2321, 9, 31, 11, 1, -31 },
  { 2356, 14, 38, 11, -3, -31 },
  { 2423, 22, 25, 26, 3, -33 },
  { 2492, 22, 14, 26, 3, -27 },
  { 2531, 22, 25, 26, 3, -33 },
  { 2600, 18, 41, 18, 2, -41 },
  { 2693, 33, 46, 36, 2, -41 },
  { 2883, 25, 41, 24, -4, -41 },
  { 3012, 25, 41, 26, 1, -41 },
  { 3141, 25, 42, 25, 3, -41 },
  { 3273, 27, 41, 29, 1, -41 },
  { 3412, 24, 41, 23, 1, -41 },
  { 3535, 24, 41, 21, 1, -41 },
  { 3658, 28, 42, 31, 3, -41 },
  { 3805, 30, 41, 30, 1, -41 },
  { 3959, 19, 41, 14, -2, -41 },
  { 4057, 22, 51, 11, -9, -41 },
  { 4198, 28, 41, 24, 1, -41 },
  { 4342, 16, 41, 21, 1, -41 },
  { 4424, 38, 41, 39, 1, -41 },
  { 4619, 31, 41, 31, 1, -41 },
  { 4778, 27, 42, 31, 3, -41 },
  { 4920, 24, 41, 25, 1, -41 },
  { 5043, 27, 51, 31, 3, -41 },
  { 5216, 24, 41, 25, 1, -41 },
  { 5339, 25, 42, 23, -1, -41 },
  { 5471, 21, 41, 21, 5, -41 },
  { 5579, 28, 42, 30, 3, -41 },
  { 5726, 24, 41, 24, 5, -41 },
  { 5849, 39, 41, 39, 5, -41 },
  { 6049, 29, 41, 22, -3, -41 },
  { 6198, 21, 41, 21, 5, -41 },
  { 6306, 27, 41, 22, -2, -41 },
  { 6445, 21, 50, 16, -1, -41 },
  { 6577, 9, 41, 19, 6, -41 },
  { 6624, 21, 50, 16, -4, -41 },
  { 6756, 23, 22, 25, 1, -41 },
  { 6820, 18, 3, 18, -5, 5 },
  { 6827, 7, 9, 13, 8, -44 },
  { 6835, 23, 32, 26, 2, -31 },
  { 6927, 23, 44, 26, 1, -43 },
  { 7054, 19, 32, 19, 2, -31 },
  { 7130, 26, 44, 26, 2, -43 },
  { 7273, 19, 32, 23, 2, -31 },
  { 7349, 27, 58, 13, -7, -44 },
  { 7545, 25, 45, 26, 0, -31 },
  { 7686, 22, 43, 25, 1, -43 },
  { 7805, 11, 41, 11, 1, -41 },
  { 7862, 21, 55, 11, -8, -41 },
  { 8007, 22, 43, 21, 1, -43 },
  { 8126, 12, 43, 11, 1, -43 },
  { 8191, 35, 31, 38, 1, -31 },
  { 8327, 22, 31, 25, 1, -31 },
  { 8413, 21, 32, 25, 2, -31 },
  { 8497, 26, 44, 26, -2, -31 },
  { 8640, 23, 44, 26, 2, -31 },
  { 8767, 18, 31, 17, 1, -31 },
  { 8837, 19, 32, 19, 0, -31 },
  { 8913, 13, 38, 14, 2, -37 },
  { 8975, 22, 31, 25, 2, -30 },
  { 9061, 19, 30, 20, 3, -30 },
  { 9133, 31, 30, 32, 3, -30 },
  { 9250, 24, 30, 21, -2, -30 },
  { 9340, 29, 44, 20, -6, -30 },
  { 9500, 21, 30, 18, -2, -30 },
  { 9579, 21, 50, 19, 1, -41 },
  { 9711, 2, 57, 23, 11, -43 },
  { 9726, 20, 50, 18, -3, -41 },
  { 9851, 22, 6, 26, 3, -23 },
};

const GFXfont NotoSans_Condensed_LightItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC57PT7B_H_
