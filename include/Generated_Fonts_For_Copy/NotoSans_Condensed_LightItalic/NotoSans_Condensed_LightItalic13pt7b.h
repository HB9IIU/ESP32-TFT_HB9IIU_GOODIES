#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC13PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xA4, 0x90, 0x80, 0x76, 0x80, 0x14, 0x97, 0xCA, 0x2B, 0xE5,
  0x14, 0xA0, 0x10, 0xF5, 0x14, 0x20, 0x42, 0x8A, 0xB1, 0x84, 0x00, 0xE5,
  0x52, 0xA5, 0xAD, 0xA5, 0x54, 0xAA, 0x9C, 0x38, 0xA2, 0x8C, 0x62, 0x59,
  0xA2, 0xF8, 0x68, 0x12, 0x44, 0x48, 0x88, 0x88, 0x40, 0x31, 0x11, 0x11,
  0x12, 0x24, 0x80, 0x27, 0x0E, 0xA1, 0x00, 0x21, 0x09, 0xF2, 0x10, 0x58,
  0xE0, 0x80, 0x04, 0x20, 0x84, 0x10, 0x82, 0x10, 0xC0, 0x3A, 0x52, 0x98,
  0xC6, 0x32, 0x60, 0x79, 0x25, 0x24, 0x80, 0x38, 0x42, 0x11, 0x11, 0x08,
  0xF0, 0x78, 0x42, 0x13, 0x04, 0x22, 0xF0, 0x08, 0xCA, 0x54, 0xCB, 0xE2,
  0x10, 0x3C, 0x84, 0x1C, 0x08, 0x20, 0x84, 0xF0, 0x1C, 0x84, 0x1C, 0x4A,
  0x28, 0xA2, 0x70, 0xF8, 0x84, 0x42, 0x21, 0x10, 0x80, 0x39, 0x14, 0x8A,
  0x72, 0x28, 0xA2, 0x70, 0x3A, 0x52, 0x95, 0x94, 0x22, 0xE0, 0x40, 0x08,
  0x20, 0x00, 0x12, 0x80, 0x09, 0x91, 0x06, 0x0C, 0xF8, 0x3E, 0x86, 0x08,
  0x36, 0x40, 0x70, 0x44, 0x22, 0x21, 0x00, 0x80, 0x1E, 0x21, 0x4D, 0x55,
  0xA5, 0xA5, 0xAA, 0x94, 0x40, 0x78, 0x08, 0x51, 0x45, 0x24, 0xF4, 0x51,
  0x84, 0x3C, 0x94, 0x52, 0x79, 0x24, 0xA2, 0xF0, 0x3A, 0x21, 0x08, 0x42,
  0x10, 0xF0, 0x3C, 0x94, 0x51, 0x45, 0x14, 0x62, 0xF0, 0x3C, 0x84, 0x10,
  0x79, 0x04, 0x20, 0xF0, 0x3C, 0x84, 0x10, 0x79, 0x04, 0x20, 0x80, 0x3D,
  0x08, 0x20, 0x9A, 0x28, 0xA2, 0xF0, 0x22, 0x45, 0x0A, 0x27, 0xC8, 0x91,
  0x42, 0x88, 0x38, 0x84, 0x42, 0x10, 0x84, 0xE0, 0x08, 0x44, 0x21, 0x08,
  0x44, 0x21, 0x30, 0x26, 0x51, 0x42, 0x86, 0x0A, 0x14, 0x48, 0x88, 0x22,
  0x44, 0x44, 0x48, 0xF0, 0x20, 0x90, 0xD4, 0xAA, 0x65, 0x52, 0xA9, 0x65,
  0x34, 0x92, 0x00, 0x22, 0x45, 0x4A, 0x95, 0x49, 0x93, 0x46, 0x88, 0x39,
  0x18, 0x61, 0x86, 0x28, 0xA2, 0xF0, 0x38, 0x94, 0x51, 0x79, 0x04, 0x20,
  0x80, 0x39, 0x18, 0x61, 0x86, 0x28, 0xA2, 0xF0, 0x81, 0x00, 0x38, 0x94,
  0x52, 0x79, 0x45, 0x24, 0x88, 0x3D, 0x04, 0x10, 0x30, 0x40, 0x84, 0xF0,
  0xF9, 0x10, 0x84, 0x21, 0x10, 0x80, 0x45, 0x18, 0x62, 0x8A, 0x28, 0xA4,
  0xE0, 0x8E, 0x29, 0x24, 0x92, 0x8A, 0x30, 0xC0, 0x88, 0xC4, 0xA6, 0x55,
  0x2A, 0xA5, 0x53, 0x31, 0x98, 0x88, 0x00, 0x22, 0x28, 0x60, 0xC1, 0x05,
  0x0A, 0x24, 0x88, 0x8C, 0xA4, 0xC4, 0x21, 0x10, 0x80, 0x3C, 0x21, 0x04,
  0x21, 0x04, 0x20, 0xF0, 0x39, 0x10, 0x84, 0x21, 0x10, 0x84, 0x30, 0xA5,
  0x55, 0x40, 0x38, 0x44, 0x21, 0x08, 0x44, 0x21, 0x38, 0x10, 0xA4, 0x92,
  0x84, 0xF0, 0xC0, 0x35, 0x24, 0xA2, 0x8A, 0x66, 0x80, 0x21, 0x08, 0xF4,
  0xA5, 0x29, 0x8F, 0x80, 0x3A, 0x11, 0x08, 0x41, 0xC0, 0x04, 0x10, 0x4F,
  0x49, 0x28, 0xA2, 0x99, 0xA0, 0x3A, 0x52, 0xE8, 0x41, 0xC0, 0x06, 0x10,
  0x20, 0xE1, 0x02, 0x04, 0x08, 0x20, 0x40, 0x81, 0x0C, 0x00, 0x3D, 0x24,
  0xA2, 0x8A, 0x67, 0x04, 0x13, 0x80, 0x21, 0x08, 0xF4, 0xA5, 0x29, 0x8C,
  0x80, 0x21, 0x24, 0x94, 0x80, 0x08, 0x04, 0x21, 0x08, 0x44, 0x21, 0x09,
  0x80, 0x21, 0x08, 0x95, 0x31, 0x8C, 0x94, 0x80, 0x24, 0xA4, 0x92, 0x90,
  0x7F, 0x49, 0x49, 0x49, 0x49, 0x92, 0x92, 0x7A, 0x52, 0x94, 0xC6, 0x40,
  0x3A, 0x53, 0x18, 0xC5, 0xC0, 0x5B, 0x52, 0x94, 0xC7, 0xD0, 0x84, 0x00,
  0x3D, 0x24, 0xA2, 0x8A, 0x67, 0x04, 0x10, 0x40, 0x74, 0x44, 0x48, 0x80,
  0x74, 0x42, 0x11, 0xE0, 0x25, 0xA4, 0xA4, 0xC0, 0x45, 0x24, 0x92, 0x8A,
  0x47, 0x00, 0x99, 0xAA, 0xCC, 0x80, 0x93, 0x6A, 0xD6, 0xAD, 0x93, 0x24,
  0x00, 0x24, 0xA1, 0x04, 0x31, 0x4C, 0x80, 0x24, 0x92, 0x8A, 0x30, 0xC2,
  0x08, 0x43, 0x00, 0x71, 0x22, 0x48, 0xE0, 0x19, 0x08, 0x42, 0x61, 0x08,
  0x42, 0x18, 0xFF, 0xF8, 0x30, 0x84, 0x21, 0x0C, 0x84, 0x21, 0x30, 0xF8,
};

const GFXglyph NotoSans_Condensed_LightItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 9, 3, 0, -9 },
  { 5, 3, 3, 4, 1, -9 },
  { 7, 6, 9, 6, 0, -9 },
  { 14, 6, 11, 5, 0, -10 },
  { 23, 7, 9, 8, 1, -9 },
  { 31, 6, 9, 6, 0, -9 },
  { 38, 2, 3, 2, 1, -9 },
  { 39, 4, 11, 3, 0, -9 },
  { 45, 4, 11, 3, -1, -9 },
  { 51, 5, 5, 5, 1, -10 },
  { 55, 5, 6, 6, 1, -8 },
  { 59, 2, 3, 2, -1, -1 },
  { 60, 3, 1, 4, 0, -4 },
  { 61, 1, 1, 3, 0, -1 },
  { 62, 6, 9, 4, -1, -9 },
  { 69, 5, 9, 5, 0, -9 },
  { 75, 3, 9, 5, 2, -9 },
  { 79, 5, 9, 5, 0, -9 },
  { 85, 5, 9, 5, 0, -9 },
  { 91, 5, 9, 5, 0, -9 },
  { 97, 6, 9, 5, 0, -9 },
  { 104, 6, 9, 5, 0, -9 },
  { 111, 5, 9, 5, 1, -9 },
  { 117, 6, 9, 5, 0, -9 },
  { 124, 5, 9, 5, 0, -9 },
  { 130, 2, 7, 3, 0, -7 },
  { 132, 3, 9, 3, -1, -7 },
  { 136, 5, 6, 6, 1, -8 },
  { 140, 5, 3, 6, 1, -6 },
  { 142, 5, 6, 6, 1, -8 },
  { 146, 5, 9, 4, 0, -9 },
  { 152, 8, 10, 8, 0, -9 },
  { 162, 6, 9, 5, -1, -9 },
  { 169, 6, 9, 6, 0, -9 },
  { 176, 5, 9, 6, 1, -9 },
  { 182, 6, 9, 7, 0, -9 },
  { 189, 6, 9, 5, 0, -9 },
  { 196, 6, 9, 5, 0, -9 },
  { 203, 6, 9, 7, 1, -9 },
  { 210, 7, 9, 7, 0, -9 },
  { 218, 5, 9, 3, -1, -9 },
  { 224, 5, 11, 3, -2, -9 },
  { 231, 7, 9, 6, 0, -9 },
  { 239, 4, 9, 5, 0, -9 },
  { 244, 9, 9, 9, 0, -9 },
  { 255, 7, 9, 7, 0, -9 },
  { 263, 6, 9, 7, 1, -9 },
  { 270, 6, 9, 6, 0, -9 },
  { 277, 6, 11, 7, 1, -9 },
  { 286, 6, 9, 6, 0, -9 },
  { 293, 6, 9, 5, 0, -9 },
  { 300, 5, 9, 5, 1, -9 },
  { 306, 6, 9, 7, 1, -9 },
  { 313, 6, 9, 6, 1, -9 },
  { 320, 9, 9, 9, 1, -9 },
  { 331, 7, 9, 5, -1, -9 },
  { 339, 5, 9, 5, 1, -9 },
  { 345, 6, 9, 5, 0, -9 },
  { 352, 5, 11, 4, 0, -9 },
  { 359, 2, 9, 4, 1, -9 },
  { 362, 5, 11, 4, -1, -9 },
  { 369, 6, 5, 6, 0, -9 },
  { 373, 4, 1, 4, -1, 1 },
  { 374, 1, 2, 3, 2, -10 },
  { 375, 6, 7, 6, 0, -7 },
  { 381, 5, 10, 6, 0, -10 },
  { 388, 5, 7, 4, 0, -7 },
  { 393, 6, 10, 6, 0, -10 },
  { 401, 5, 7, 5, 0, -7 },
  { 406, 7, 13, 3, -2, -10 },
  { 418, 6, 10, 6, 0, -7 },
  { 426, 5, 10, 6, 0, -10 },
  { 433, 3, 9, 2, 0, -9 },
  { 437, 5, 12, 3, -2, -9 },
  { 445, 5, 10, 5, 0, -10 },
  { 452, 3, 10, 2, 0, -10 },
  { 456, 8, 7, 9, 0, -7 },
  { 463, 5, 7, 6, 0, -7 },
  { 468, 5, 7, 6, 0, -7 },
  { 473, 5, 10, 6, 0, -7 },
  { 480, 6, 10, 6, 0, -7 },
  { 488, 4, 7, 4, 0, -7 },
  { 492, 4, 7, 4, 0, -7 },
  { 496, 3, 9, 3, 0, -9 },
  { 500, 6, 7, 6, 0, -7 },
  { 506, 4, 7, 4, 1, -7 },
  { 510, 7, 7, 7, 1, -7 },
  { 517, 6, 7, 5, -1, -7 },
  { 523, 6, 10, 5, -1, -7 },
  { 531, 4, 7, 4, 0, -7 },
  { 535, 5, 11, 4, 0, -9 },
  { 542, 1, 13, 5, 2, -10 },
  { 544, 5, 11, 4, -1, -9 },
  { 551, 5, 1, 6, 1, -5 },
};

const GFXfont NotoSans_Condensed_LightItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC13PT7B_H_
