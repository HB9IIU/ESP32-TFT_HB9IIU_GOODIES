#pragma once

// Auto-generated by fontMaker.py
#include <TFT_eSPI.h>

struct FontEntry
{
  const GFXfont *font;
  uint16_t sizePt;
  const char *name;
};

// Includes are in all_fonts.h (include that before this file)
static const FontEntry kFonts[] = {
  { &NotoSans_Condensed_LightItalic6pt7b, 6, "NotoSans_Condensed_LightItalic6pt7b" },
  { &NotoSans_Condensed_LightItalic7pt7b, 7, "NotoSans_Condensed_LightItalic7pt7b" },
  { &NotoSans_Condensed_LightItalic8pt7b, 8, "NotoSans_Condensed_LightItalic8pt7b" },
  { &NotoSans_Condensed_LightItalic9pt7b, 9, "NotoSans_Condensed_LightItalic9pt7b" },
  { &NotoSans_Condensed_LightItalic10pt7b, 10, "NotoSans_Condensed_LightItalic10pt7b" },
  { &NotoSans_Condensed_LightItalic11pt7b, 11, "NotoSans_Condensed_LightItalic11pt7b" },
  { &NotoSans_Condensed_LightItalic12pt7b, 12, "NotoSans_Condensed_LightItalic12pt7b" },
  { &NotoSans_Condensed_LightItalic13pt7b, 13, "NotoSans_Condensed_LightItalic13pt7b" },
  { &NotoSans_Condensed_LightItalic14pt7b, 14, "NotoSans_Condensed_LightItalic14pt7b" },
  { &NotoSans_Condensed_LightItalic15pt7b, 15, "NotoSans_Condensed_LightItalic15pt7b" },
  { &NotoSans_Condensed_LightItalic16pt7b, 16, "NotoSans_Condensed_LightItalic16pt7b" },
  { &NotoSans_Condensed_LightItalic17pt7b, 17, "NotoSans_Condensed_LightItalic17pt7b" },
  { &NotoSans_Condensed_LightItalic18pt7b, 18, "NotoSans_Condensed_LightItalic18pt7b" },
  { &NotoSans_Condensed_LightItalic19pt7b, 19, "NotoSans_Condensed_LightItalic19pt7b" },
  { &NotoSans_Condensed_LightItalic20pt7b, 20, "NotoSans_Condensed_LightItalic20pt7b" },
  { &NotoSans_Condensed_LightItalic21pt7b, 21, "NotoSans_Condensed_LightItalic21pt7b" },
  { &NotoSans_Condensed_LightItalic22pt7b, 22, "NotoSans_Condensed_LightItalic22pt7b" },
  { &NotoSans_Condensed_LightItalic23pt7b, 23, "NotoSans_Condensed_LightItalic23pt7b" },
  { &NotoSans_Condensed_LightItalic24pt7b, 24, "NotoSans_Condensed_LightItalic24pt7b" },
  { &NotoSans_Condensed_LightItalic25pt7b, 25, "NotoSans_Condensed_LightItalic25pt7b" },
  { &NotoSans_Condensed_LightItalic26pt7b, 26, "NotoSans_Condensed_LightItalic26pt7b" },
  { &NotoSans_Condensed_LightItalic27pt7b, 27, "NotoSans_Condensed_LightItalic27pt7b" },
  { &NotoSans_Condensed_LightItalic28pt7b, 28, "NotoSans_Condensed_LightItalic28pt7b" },
  { &NotoSans_Condensed_LightItalic29pt7b, 29, "NotoSans_Condensed_LightItalic29pt7b" },
  { &NotoSans_Condensed_LightItalic30pt7b, 30, "NotoSans_Condensed_LightItalic30pt7b" },
  { &NotoSans_Condensed_LightItalic31pt7b, 31, "NotoSans_Condensed_LightItalic31pt7b" },
  { &NotoSans_Condensed_LightItalic32pt7b, 32, "NotoSans_Condensed_LightItalic32pt7b" },
  { &NotoSans_Condensed_LightItalic33pt7b, 33, "NotoSans_Condensed_LightItalic33pt7b" },
  { &NotoSans_Condensed_LightItalic34pt7b, 34, "NotoSans_Condensed_LightItalic34pt7b" },
  { &NotoSans_Condensed_LightItalic35pt7b, 35, "NotoSans_Condensed_LightItalic35pt7b" },
  { &NotoSans_Condensed_LightItalic36pt7b, 36, "NotoSans_Condensed_LightItalic36pt7b" },
  { &NotoSans_Condensed_LightItalic37pt7b, 37, "NotoSans_Condensed_LightItalic37pt7b" },
  { &NotoSans_Condensed_LightItalic38pt7b, 38, "NotoSans_Condensed_LightItalic38pt7b" },
  { &NotoSans_Condensed_LightItalic39pt7b, 39, "NotoSans_Condensed_LightItalic39pt7b" },
  { &NotoSans_Condensed_LightItalic40pt7b, 40, "NotoSans_Condensed_LightItalic40pt7b" },
  { &NotoSans_Condensed_LightItalic41pt7b, 41, "NotoSans_Condensed_LightItalic41pt7b" },
  { &NotoSans_Condensed_LightItalic42pt7b, 42, "NotoSans_Condensed_LightItalic42pt7b" },
  { &NotoSans_Condensed_LightItalic43pt7b, 43, "NotoSans_Condensed_LightItalic43pt7b" },
  { &NotoSans_Condensed_LightItalic44pt7b, 44, "NotoSans_Condensed_LightItalic44pt7b" },
  { &NotoSans_Condensed_LightItalic45pt7b, 45, "NotoSans_Condensed_LightItalic45pt7b" },
  { &NotoSans_Condensed_LightItalic46pt7b, 46, "NotoSans_Condensed_LightItalic46pt7b" },
  { &NotoSans_Condensed_LightItalic47pt7b, 47, "NotoSans_Condensed_LightItalic47pt7b" },
  { &NotoSans_Condensed_LightItalic48pt7b, 48, "NotoSans_Condensed_LightItalic48pt7b" },
  { &NotoSans_Condensed_LightItalic49pt7b, 49, "NotoSans_Condensed_LightItalic49pt7b" },
  { &NotoSans_Condensed_LightItalic50pt7b, 50, "NotoSans_Condensed_LightItalic50pt7b" },
  { &NotoSans_Condensed_LightItalic51pt7b, 51, "NotoSans_Condensed_LightItalic51pt7b" },
  { &NotoSans_Condensed_LightItalic52pt7b, 52, "NotoSans_Condensed_LightItalic52pt7b" },
  { &NotoSans_Condensed_LightItalic53pt7b, 53, "NotoSans_Condensed_LightItalic53pt7b" },
  { &NotoSans_Condensed_LightItalic54pt7b, 54, "NotoSans_Condensed_LightItalic54pt7b" },
  { &NotoSans_Condensed_LightItalic55pt7b, 55, "NotoSans_Condensed_LightItalic55pt7b" },
  { &NotoSans_Condensed_LightItalic56pt7b, 56, "NotoSans_Condensed_LightItalic56pt7b" },
  { &NotoSans_Condensed_LightItalic57pt7b, 57, "NotoSans_Condensed_LightItalic57pt7b" },
  { &NotoSans_Condensed_LightItalic58pt7b, 58, "NotoSans_Condensed_LightItalic58pt7b" },
  { &NotoSans_Condensed_LightItalic59pt7b, 59, "NotoSans_Condensed_LightItalic59pt7b" },
  { &NotoSans_Condensed_LightItalic60pt7b, 60, "NotoSans_Condensed_LightItalic60pt7b" },
  { &NotoSans_Condensed_LightItalic61pt7b, 61, "NotoSans_Condensed_LightItalic61pt7b" },
  { &NotoSans_Condensed_LightItalic62pt7b, 62, "NotoSans_Condensed_LightItalic62pt7b" },
  { &NotoSans_Condensed_LightItalic63pt7b, 63, "NotoSans_Condensed_LightItalic63pt7b" },
  { &NotoSans_Condensed_LightItalic64pt7b, 64, "NotoSans_Condensed_LightItalic64pt7b" },
  { &NotoSans_Condensed_LightItalic65pt7b, 65, "NotoSans_Condensed_LightItalic65pt7b" },
  { &NotoSans_Condensed_LightItalic66pt7b, 66, "NotoSans_Condensed_LightItalic66pt7b" },
  { &NotoSans_Condensed_LightItalic67pt7b, 67, "NotoSans_Condensed_LightItalic67pt7b" },
  { &NotoSans_Condensed_LightItalic68pt7b, 68, "NotoSans_Condensed_LightItalic68pt7b" },
  { &NotoSans_Condensed_LightItalic69pt7b, 69, "NotoSans_Condensed_LightItalic69pt7b" },
  { &NotoSans_Condensed_LightItalic70pt7b, 70, "NotoSans_Condensed_LightItalic70pt7b" },
  { &NotoSans_Condensed_LightItalic71pt7b, 71, "NotoSans_Condensed_LightItalic71pt7b" },
  { &NotoSans_Condensed_LightItalic72pt7b, 72, "NotoSans_Condensed_LightItalic72pt7b" },
};
static constexpr size_t kFontCount = sizeof(kFonts) / sizeof(kFonts[0]);
