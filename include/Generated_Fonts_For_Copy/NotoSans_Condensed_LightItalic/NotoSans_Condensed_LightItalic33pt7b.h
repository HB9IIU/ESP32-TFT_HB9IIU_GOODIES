#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC33PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x06, 0x18, 0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0x41, 0x83,
  0x06, 0x08, 0x10, 0x60, 0xC0, 0x00, 0x00, 0x18, 0x30, 0x60, 0x33, 0x23,
  0x63, 0x63, 0x62, 0x42, 0x46, 0x46, 0xC4, 0x00, 0xC2, 0x00, 0x86, 0x00,
  0x84, 0x01, 0x84, 0x01, 0x0C, 0x01, 0x0C, 0x03, 0x08, 0x1F, 0xFF, 0x1F,
  0xFF, 0x06, 0x10, 0x06, 0x10, 0x04, 0x30, 0x04, 0x20, 0x0C, 0x20, 0x08,
  0x60, 0xFF, 0xFC, 0xFF, 0xFC, 0x18, 0xC0, 0x10, 0xC0, 0x30, 0x80, 0x31,
  0x80, 0x21, 0x80, 0x21, 0x00, 0x63, 0x00, 0x00, 0x60, 0x01, 0x00, 0x04,
  0x00, 0xFE, 0x06, 0x5C, 0x33, 0x01, 0x88, 0x06, 0x20, 0x18, 0x80, 0x62,
  0x00, 0xD8, 0x03, 0xC0, 0x07, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x98, 0x02,
  0x30, 0x08, 0xC0, 0x23, 0x01, 0x88, 0x04, 0x63, 0x13, 0x0F, 0xF8, 0x03,
  0x00, 0x0C, 0x00, 0x20, 0x00, 0x80, 0x00, 0x0E, 0x01, 0x0F, 0x81, 0x8C,
  0xC1, 0x8C, 0x20, 0xC6, 0x10, 0xC2, 0x08, 0x43, 0x0C, 0x61, 0x86, 0x20,
  0xC3, 0x30, 0x41, 0x30, 0x21, 0x93, 0xF0, 0xD9, 0x3C, 0xC9, 0x8F, 0xCD,
  0x85, 0xC4, 0xC2, 0x06, 0x41, 0x06, 0x20, 0x82, 0x30, 0xC3, 0x18, 0x61,
  0x0C, 0x21, 0x86, 0x31, 0x83, 0x18, 0xC1, 0x98, 0xC0, 0x78, 0x00, 0xE0,
  0x07, 0xE0, 0x18, 0x60, 0x30, 0xC0, 0x61, 0x80, 0x82, 0x01, 0x0C, 0x02,
  0x18, 0x06, 0x60, 0x0D, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x30,
  0xCC, 0x61, 0x30, 0x46, 0x60, 0xC9, 0x81, 0xB3, 0x01, 0xC6, 0x03, 0x8C,
  0x07, 0x18, 0x1E, 0x1C, 0xE4, 0x1F, 0x8C, 0x33, 0x66, 0x66, 0x44, 0xC0,
  0x00, 0xC0, 0x60, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x60, 0x30, 0x0C,
  0x02, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x20,
  0x00, 0x02, 0x01, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x80,
  0x40, 0x20, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40,
  0x60, 0x30, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x00, 0x06, 0x01,
  0x08, 0x43, 0x10, 0x7C, 0xC7, 0xF1, 0xC0, 0xD0, 0x66, 0x30, 0xC0, 0x30,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x19,
  0x8C, 0x66, 0x33, 0x10, 0xFF, 0xFC, 0xFC, 0x00, 0x06, 0x00, 0x08, 0x00,
  0x30, 0x00, 0x40, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x04, 0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x3F, 0x83, 0x8C, 0x18, 0x21, 0x81,
  0x8C, 0x0C, 0xC0, 0x66, 0x03, 0x20, 0x1B, 0x00, 0x98, 0x0C, 0xC0, 0x64,
  0x03, 0x60, 0x1B, 0x00, 0xD8, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x31, 0x81,
  0x8C, 0x18, 0x20, 0xC1, 0xDC, 0x07, 0xC0, 0x03, 0x06, 0x1E, 0x36, 0x66,
  0xC4, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x10, 0x30,
  0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x00, 0xF0, 0x07, 0xF0, 0x18,
  0x30, 0x00, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x10, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0xE0, 0x3F, 0xE0, 0xC1, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x03,
  0xE0, 0x0F, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x18, 0x00, 0x62, 0x03, 0x0C, 0x78, 0x3F, 0xC0, 0x00, 0x1C,
  0x00, 0x60, 0x02, 0x80, 0x1E, 0x00, 0x58, 0x03, 0x60, 0x19, 0x00, 0x4C,
  0x03, 0x30, 0x18, 0xC0, 0xC3, 0x02, 0x08, 0x18, 0x60, 0xC1, 0x82, 0x06,
  0x18, 0x18, 0xC0, 0x43, 0xFF, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x07, 0xFC, 0x1F, 0xF0, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x02, 0x00, 0x18, 0x00, 0x60, 0x01, 0xFC, 0x06,
  0x78, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x62, 0x03, 0x0C, 0x38, 0x3F, 0xC0, 0x00, 0x78,
  0x0F, 0xC1, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30,
  0x01, 0x0C, 0x1B, 0xF0, 0xF0, 0xC7, 0x06, 0x30, 0x1B, 0x80, 0xD8, 0x06,
  0xC0, 0x26, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0C, 0x30, 0xE1, 0xCE, 0x07,
  0xE0, 0x3F, 0xFB, 0xFF, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30, 0x01,
  0x00, 0x18, 0x00, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x20, 0x03, 0x00,
  0x10, 0x01, 0x80, 0x08, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x02, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0x61, 0xC3, 0x03, 0x0C,
  0x0C, 0x20, 0x30, 0x80, 0xC3, 0x02, 0x0C, 0x18, 0x30, 0xC0, 0x6E, 0x00,
  0xE0, 0x0F, 0xC0, 0x63, 0x83, 0x06, 0x18, 0x0C, 0x40, 0x33, 0x00, 0xCC,
  0x03, 0x30, 0x0C, 0xC0, 0x21, 0x81, 0x87, 0x1C, 0x0F, 0xE0, 0x01, 0xE0,
  0x1F, 0xC0, 0xE1, 0x83, 0x06, 0x18, 0x08, 0x60, 0x31, 0x00, 0xCC, 0x02,
  0x30, 0x08, 0xC0, 0x63, 0x01, 0x8C, 0x0E, 0x18, 0x78, 0x7F, 0x60, 0xF9,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06,
  0x08, 0x70, 0x3F, 0x00, 0x08, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0xE3, 0x80, 0x01, 0x03, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x18, 0x18, 0x10,
  0x30, 0x20, 0x60, 0xC0, 0x00, 0x10, 0x07, 0x01, 0xE0, 0x78, 0x0E, 0x03,
  0x80, 0xE0, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x08, 0x00, 0x80, 0x00, 0x0F, 0x0F, 0xF2, 0x0C, 0x03, 0x00, 0x40, 0x10,
  0x0C, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0,
  0x20, 0x18, 0x00, 0x00, 0x00, 0x00, 0x18, 0x0E, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x1F, 0xF0, 0x06, 0x07, 0x03, 0x80, 0x20, 0x40, 0x06, 0x18, 0x00,
  0x46, 0x00, 0x08, 0x81, 0xF1, 0x30, 0xC4, 0x24, 0x30, 0x85, 0x84, 0x30,
  0xB1, 0x86, 0x14, 0x20, 0x86, 0x8C, 0x10, 0xF1, 0x86, 0x16, 0x30, 0xC2,
  0xC6, 0x18, 0xD8, 0xC6, 0x13, 0x19, 0xE4, 0x61, 0xE7, 0x8C, 0x00, 0x01,
  0x80, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0x30, 0x00, 0x03, 0xDE, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0x60, 0x0C, 0x80, 0x62, 0x01, 0x88, 0x04, 0x20, 0x30, 0x80, 0x82,
  0x06, 0x08, 0x18, 0x20, 0xFF, 0x83, 0xFF, 0x18, 0x0C, 0x60, 0x33, 0x00,
  0xCC, 0x03, 0x20, 0x0D, 0x80, 0x36, 0x00, 0xF0, 0x03, 0x07, 0xE0, 0x0F,
  0xF8, 0x18, 0x38, 0x30, 0x30, 0x40, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x03,
  0x0C, 0x0C, 0x10, 0x18, 0x60, 0xE0, 0xFF, 0x01, 0x8F, 0x03, 0x03, 0x0C,
  0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x30, 0x80, 0x63, 0x00, 0xC6, 0x03,
  0x0C, 0x0E, 0x1F, 0xF8, 0x7F, 0xC0, 0x00, 0xF8, 0x0F, 0xF0, 0x70, 0x43,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x88, 0x0F, 0xE0,
  0x07, 0xC0, 0x07, 0xF8, 0x06, 0x1C, 0x06, 0x06, 0x04, 0x07, 0x0C, 0x03,
  0x0C, 0x03, 0x0C, 0x03, 0x0C, 0x03, 0x08, 0x03, 0x18, 0x03, 0x18, 0x03,
  0x18, 0x03, 0x18, 0x06, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x0C,
  0x20, 0x18, 0x60, 0x18, 0x60, 0x30, 0x60, 0xE0, 0x7F, 0xC0, 0xFF, 0x00,
  0x07, 0xFE, 0x0F, 0xF8, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xFF, 0x81, 0x80,
  0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F,
  0xF8, 0x18, 0x00, 0x30, 0x00, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x10, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xFF, 0x03, 0xFC, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x60, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0x02,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0xFC, 0xC0, 0xFC, 0xC0, 0x0C,
  0x80, 0x08, 0x80, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x10,
  0x60, 0x30, 0x38, 0x70, 0x1F, 0xE0, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60,
  0x08, 0x18, 0x06, 0x04, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x0C,
  0x0C, 0x03, 0x02, 0x00, 0xC1, 0x80, 0x30, 0x7F, 0xF8, 0x18, 0x06, 0x06,
  0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x04, 0x0C, 0x03, 0x02, 0x00,
  0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x02, 0x06, 0x01, 0x83, 0x00, 0x60,
  0x07, 0xE1, 0xFC, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x07, 0xE0, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0xFC, 0x0F, 0x00, 0x06, 0x01, 0x83, 0x01, 0x81, 0x81,
  0x80, 0xC1, 0x80, 0x41, 0x80, 0x61, 0xC0, 0x30, 0xC0, 0x18, 0xC0, 0x0C,
  0xC0, 0x04, 0xC0, 0x06, 0xE0, 0x03, 0x60, 0x01, 0xD8, 0x00, 0xCC, 0x00,
  0xC6, 0x00, 0x61, 0x80, 0x30, 0xC0, 0x18, 0x60, 0x08, 0x10, 0x0C, 0x0C,
  0x06, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC1, 0x80, 0x60, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x18,
  0x07, 0xFF, 0xFF, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x70,
  0x28, 0x00, 0xE0, 0x50, 0x03, 0xC1, 0xA0, 0x05, 0x83, 0x40, 0x1B, 0x06,
  0xC0, 0x24, 0x0D, 0x80, 0xD8, 0x13, 0x01, 0x30, 0x66, 0x06, 0x60, 0xCC,
  0x08, 0x81, 0x98, 0x33, 0x02, 0x30, 0x46, 0x0C, 0x61, 0x8C, 0x18, 0x42,
  0x18, 0x30, 0x8C, 0x20, 0x61, 0x10, 0xC0, 0x82, 0x61, 0x83, 0x04, 0x83,
  0x06, 0x0F, 0x06, 0x0C, 0x1C, 0x08, 0x18, 0x38, 0x30, 0x60, 0x60, 0x60,
  0x07, 0x00, 0x60, 0xE0, 0x08, 0x1C, 0x03, 0x02, 0x80, 0x60, 0x50, 0x0C,
  0x1B, 0x01, 0x03, 0x60, 0x60, 0x64, 0x0C, 0x0C, 0x81, 0x81, 0x18, 0x30,
  0x63, 0x04, 0x0C, 0x61, 0x81, 0x84, 0x30, 0x20, 0xC6, 0x0C, 0x18, 0xC1,
  0x83, 0x10, 0x30, 0x26, 0x06, 0x06, 0xC0, 0x80, 0xD8, 0x30, 0x1A, 0x06,
  0x01, 0x40, 0xC0, 0x38, 0x18, 0x07, 0x06, 0x00, 0xE0, 0x01, 0xF0, 0x0F,
  0xF0, 0x38, 0x30, 0xE0, 0x31, 0x80, 0x66, 0x00, 0xCC, 0x01, 0xB0, 0x03,
  0x60, 0x06, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xB0,
  0x03, 0x40, 0x06, 0x80, 0x0D, 0x00, 0x33, 0x00, 0x66, 0x01, 0x8C, 0x07,
  0x1C, 0x0C, 0x1C, 0x70, 0x1F, 0xC0, 0x07, 0xC0, 0x0F, 0xF0, 0x18, 0x70,
  0x30, 0x60, 0x40, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x0C, 0x10,
  0x18, 0x60, 0x70, 0xC0, 0xC1, 0x87, 0x03, 0xF8, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x60, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x38, 0x30, 0xE0, 0x31, 0x80,
  0x66, 0x00, 0xCC, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xB0, 0x03, 0x40, 0x06, 0x80, 0x0D, 0x00,
  0x33, 0x00, 0x66, 0x01, 0x8C, 0x07, 0x1C, 0x0C, 0x1C, 0x70, 0x1F, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x07, 0xC0, 0x0F, 0xF0, 0x18, 0x70, 0x30, 0x60, 0x40, 0x61, 0x80, 0xC3,
  0x01, 0x86, 0x03, 0x0C, 0x0C, 0x10, 0x18, 0x60, 0x60, 0xC1, 0xC1, 0xFF,
  0x03, 0xF0, 0x0C, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x61, 0x80, 0x81, 0x83,
  0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x08, 0x60, 0x18, 0x01, 0xF0, 0x1F,
  0xF0, 0xE0, 0x87, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x62, 0x03, 0x0E,
  0x78, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0x18, 0x03, 0x18, 0x02, 0x18, 0x06, 0x10, 0x06, 0x30,
  0x06, 0x30, 0x06, 0x30, 0x04, 0x30, 0x0C, 0x20, 0x0C, 0x60, 0x0C, 0x60,
  0x0C, 0x60, 0x08, 0x60, 0x18, 0xC0, 0x18, 0xC0, 0x18, 0xC0, 0x10, 0xC0,
  0x30, 0xC0, 0x30, 0x80, 0x30, 0x80, 0x60, 0xC0, 0x60, 0xC0, 0xC0, 0x73,
  0x80, 0x3F, 0x00, 0xC0, 0x0F, 0x00, 0x6C, 0x01, 0xB0, 0x0C, 0xC0, 0x33,
  0x01, 0x8C, 0x06, 0x30, 0x10, 0xC0, 0xC3, 0x03, 0x0C, 0x18, 0x30, 0x60,
  0xC3, 0x03, 0x0C, 0x0C, 0x60, 0x11, 0x80, 0x4C, 0x01, 0x30, 0x04, 0x80,
  0x16, 0x00, 0x50, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x30, 0x0F,
  0x00, 0xC0, 0x3C, 0x07, 0x01, 0xB0, 0x1C, 0x06, 0xC0, 0x50, 0x1B, 0x03,
  0x40, 0xCC, 0x0B, 0x03, 0x30, 0x6C, 0x18, 0xC1, 0xB0, 0x63, 0x04, 0xC1,
  0x8C, 0x33, 0x0C, 0x30, 0x8C, 0x30, 0xC6, 0x31, 0x83, 0x18, 0xC6, 0x0C,
  0xC3, 0x10, 0x33, 0x0C, 0xC0, 0xC8, 0x33, 0x03, 0x60, 0xD8, 0x0D, 0x83,
  0x60, 0x3C, 0x0D, 0x00, 0xF0, 0x3C, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80,
  0x30, 0x0E, 0x00, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0xC0, 0x60, 0xC0,
  0x10, 0x60, 0x0C, 0x60, 0x06, 0x20, 0x03, 0x30, 0x01, 0xB0, 0x00, 0x58,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0D, 0x80, 0x0C,
  0xC0, 0x06, 0x60, 0x06, 0x30, 0x03, 0x08, 0x03, 0x06, 0x03, 0x03, 0x01,
  0x81, 0x81, 0x80, 0xC1, 0x80, 0x60, 0xC0, 0x3C, 0x03, 0xC0, 0x6C, 0x06,
  0xC0, 0xC4, 0x18, 0x61, 0x86, 0x30, 0x63, 0x06, 0x60, 0x64, 0x02, 0xC0,
  0x38, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x18,
  0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x3F,
  0xF8, 0x7F, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0xC0, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x04, 0x00, 0x20, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x80,
  0x0F, 0xE0, 0x00, 0xC2, 0x10, 0x86, 0x31, 0x8C, 0x21, 0x08, 0x63, 0x18,
  0xC2, 0x10, 0x86, 0x31, 0x8C, 0x21, 0x03, 0xF0, 0x3F, 0x00, 0x30, 0x02,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0xFC, 0x00, 0x01, 0x00, 0x1C, 0x00, 0xE0, 0x0D, 0x80, 0x4C, 0x06, 0x20,
  0x21, 0x83, 0x0C, 0x30, 0x21, 0x81, 0x98, 0x0C, 0xC0, 0x3C, 0x01, 0x80,
  0xFF, 0xE0, 0xC4, 0x62, 0x30, 0x03, 0x88, 0x7E, 0x47, 0x0E, 0x30, 0x73,
  0x03, 0x98, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x36, 0x01, 0x30, 0x19, 0x80,
  0xCC, 0x06, 0x60, 0x73, 0x03, 0x18, 0x28, 0x62, 0xC1, 0xE6, 0x00, 0x02,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x38, 0x0D, 0xF8, 0x28, 0x61, 0xC0, 0xC7, 0x03, 0x18, 0x0C, 0x60, 0x31,
  0x00, 0xCC, 0x02, 0x30, 0x18, 0xC0, 0x63, 0x01, 0x88, 0x04, 0x60, 0x31,
  0xC1, 0xC5, 0x06, 0x16, 0x70, 0xCF, 0x80, 0x03, 0xC1, 0xFC, 0x70, 0x0C,
  0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x71, 0x07, 0xE0, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x20, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x01, 0xC4, 0x0F,
  0xD8, 0x38, 0x70, 0x60, 0xE1, 0x81, 0xC3, 0x03, 0x0C, 0x06, 0x18, 0x0C,
  0x20, 0x18, 0xC0, 0x31, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x0C, 0x0E, 0x18,
  0x1C, 0x30, 0x50, 0x31, 0xA0, 0x3C, 0xC0, 0x03, 0xC1, 0xFC, 0x71, 0x8C,
  0x13, 0x02, 0x40, 0xD8, 0x1B, 0x0E, 0x7F, 0x9F, 0x83, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x71, 0x87, 0xF0, 0x00, 0x1F, 0x00, 0x3A,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x40, 0x00, 0xF8,
  0x03, 0xF8, 0x00, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x02, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x18, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x01, 0xC4, 0x1F, 0x90, 0xE1, 0xC3, 0x07, 0x18, 0x1C, 0x60,
  0x63, 0x01, 0x8C, 0x06, 0x20, 0x19, 0x80, 0x66, 0x03, 0x18, 0x0C, 0x60,
  0x31, 0x81, 0xC6, 0x07, 0x18, 0x28, 0x31, 0xE0, 0x79, 0x80, 0x06, 0x00,
  0x10, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x20, 0x60, 0xFF, 0x01, 0xF0, 0x00,
  0x02, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01,
  0x9E, 0x0D, 0xF8, 0x50, 0xC7, 0x06, 0x38, 0x31, 0x81, 0x8C, 0x0C, 0x40,
  0x66, 0x02, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0x40, 0x66, 0x02, 0x30, 0x31,
  0x81, 0x88, 0x0C, 0xC0, 0x60, 0x06, 0x0C, 0x18, 0x00, 0x00, 0x03, 0x06,
  0x08, 0x30, 0x60, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C,
  0x10, 0x60, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x30, 0x04, 0x01, 0x80, 0x30, 0x3C, 0x07, 0x00, 0x02, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x40, 0x06, 0x00, 0x30, 0x01, 0x83, 0x0C,
  0x18, 0x41, 0x86, 0x18, 0x31, 0x81, 0x98, 0x0D, 0x80, 0x4C, 0x06, 0xE0,
  0x3F, 0x01, 0xD8, 0x0C, 0x60, 0x43, 0x06, 0x18, 0x30, 0xC1, 0x83, 0x08,
  0x18, 0xC0, 0xC0, 0x02, 0x0C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x10,
  0x60, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x60, 0xC1, 0x06, 0x0C, 0x18, 0x20,
  0xC0, 0x0C, 0xE0, 0xE0, 0x5F, 0x9F, 0x82, 0x87, 0x8E, 0x38, 0x38, 0x31,
  0x81, 0x81, 0x8C, 0x0C, 0x08, 0x60, 0x40, 0xC2, 0x06, 0x06, 0x30, 0x30,
  0x31, 0x81, 0x81, 0x8C, 0x0C, 0x08, 0x60, 0x40, 0xC2, 0x06, 0x06, 0x30,
  0x30, 0x31, 0x81, 0x81, 0x8C, 0x0C, 0x08, 0x40, 0x40, 0xC6, 0x06, 0x06,
  0x00, 0x0C, 0xF0, 0x4F, 0xC2, 0x86, 0x38, 0x31, 0xC1, 0x8C, 0x0C, 0x60,
  0x62, 0x03, 0x30, 0x11, 0x81, 0x8C, 0x0C, 0x60, 0x66, 0x03, 0x30, 0x11,
  0x81, 0x8C, 0x0C, 0x40, 0x66, 0x03, 0x00, 0x03, 0xC0, 0xFE, 0x1C, 0x31,
  0x83, 0x30, 0x32, 0x01, 0x60, 0x36, 0x03, 0x40, 0x3C, 0x03, 0xC0, 0x3C,
  0x02, 0xC0, 0x6C, 0x06, 0xC0, 0xC4, 0x1C, 0x73, 0x83, 0xF0, 0x06, 0x70,
  0x09, 0xF8, 0x14, 0x30, 0x70, 0x30, 0xE0, 0x61, 0x80, 0xC3, 0x01, 0x86,
  0x03, 0x18, 0x04, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x61, 0x00, 0x86, 0x03,
  0x0E, 0x06, 0x1C, 0x18, 0x2C, 0xE0, 0xCF, 0x81, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x08, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x03,
  0x88, 0x7E, 0x47, 0x0E, 0x30, 0x73, 0x03, 0x98, 0x19, 0x80, 0xCC, 0x06,
  0x60, 0x36, 0x01, 0xB0, 0x19, 0x80, 0xCC, 0x06, 0x60, 0x73, 0x03, 0x98,
  0x28, 0x63, 0xC1, 0xE6, 0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x00, 0x18, 0x00, 0x08, 0xE1, 0x3C, 0x28, 0x0E, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x00, 0x07, 0x83, 0xFC, 0x60, 0x98,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x18, 0xC7, 0x1F, 0xC0, 0x0C, 0x08, 0x08, 0x18,
  0x1F, 0x7F, 0x10, 0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x60, 0x60, 0x40,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC8, 0x78, 0x18, 0x18, 0xC0, 0xC4, 0x06, 0x60,
  0x23, 0x03, 0x18, 0x18, 0x80, 0xCC, 0x06, 0x60, 0x23, 0x03, 0x18, 0x18,
  0x80, 0xCC, 0x0C, 0x60, 0x63, 0x07, 0x18, 0x38, 0xE6, 0xC3, 0xE4, 0x00,
  0xC0, 0x78, 0x0F, 0x03, 0x60, 0x6C, 0x19, 0x83, 0x30, 0xC6, 0x18, 0xC6,
  0x18, 0xC3, 0x30, 0x66, 0x0D, 0x81, 0xB0, 0x34, 0x03, 0x80, 0x60, 0x0C,
  0x00, 0xC0, 0xC0, 0xF0, 0x30, 0x2C, 0x1C, 0x1B, 0x07, 0x06, 0xC3, 0xC3,
  0x30, 0xB0, 0xCC, 0x6C, 0x23, 0x1B, 0x18, 0xC4, 0xC4, 0x33, 0x33, 0x0C,
  0x8C, 0xC3, 0x63, 0x60, 0xD0, 0xD8, 0x3C, 0x34, 0x0F, 0x0F, 0x03, 0x83,
  0xC0, 0xE0, 0xE0, 0x30, 0x38, 0x00, 0x08, 0x0C, 0x30, 0x60, 0xC1, 0x83,
  0x0C, 0x04, 0x60, 0x19, 0x00, 0x6C, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x60, 0x19, 0x80, 0x66, 0x03, 0x08, 0x18, 0x30, 0x60, 0xC3,
  0x03, 0x00, 0x06, 0x03, 0x06, 0x03, 0x06, 0x02, 0x06, 0x06, 0x06, 0x04,
  0x06, 0x0C, 0x02, 0x08, 0x02, 0x18, 0x02, 0x18, 0x02, 0x30, 0x02, 0x30,
  0x02, 0x60, 0x02, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x00, 0x03, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x60, 0x06,
  0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x02, 0x00, 0x60, 0x0C, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x10, 0x1E,
  0x03, 0x80, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0xE0, 0x0F, 0x00, 0x30, 0x01, 0x00,
  0x10, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x02, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x03, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x02, 0x00, 0x3C, 0x00, 0xC0, 0x04, 0x00, 0x40, 0x04, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x70, 0x0F, 0x01, 0x80, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0C, 0x03, 0x80, 0xF0, 0x00, 0xFC, 0x1C,
  0xFF, 0x81, 0xE0,
};

const GFXglyph NotoSans_Condensed_LightItalic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 24, 7, 1, -24 },
  { 22, 8, 9, 10, 3, -24 },
  { 31, 16, 24, 15, 0, -24 },
  { 79, 14, 27, 14, 0, -25 },
  { 127, 17, 24, 21, 2, -24 },
  { 178, 15, 24, 15, 0, -24 },
  { 223, 4, 9, 6, 3, -24 },
  { 228, 10, 29, 8, 1, -24 },
  { 265, 9, 29, 8, -2, -24 },
  { 298, 10, 11, 13, 4, -25 },
  { 312, 12, 15, 15, 2, -19 },
  { 335, 5, 8, 6, -1, -4 },
  { 340, 7, 2, 9, 1, -10 },
  { 342, 2, 3, 6, 1, -3 },
  { 343, 15, 24, 11, -2, -24 },
  { 388, 13, 24, 14, 1, -24 },
  { 427, 8, 24, 14, 4, -24 },
  { 451, 15, 24, 14, -1, -24 },
  { 496, 14, 24, 14, 0, -24 },
  { 538, 14, 24, 14, 0, -24 },
  { 580, 14, 24, 14, 0, -24 },
  { 622, 13, 24, 14, 1, -24 },
  { 661, 13, 24, 14, 2, -24 },
  { 700, 14, 24, 14, 0, -24 },
  { 742, 14, 24, 14, 0, -24 },
  { 784, 6, 18, 6, 0, -18 },
  { 798, 8, 22, 6, -2, -18 },
  { 820, 12, 15, 15, 2, -19 },
  { 843, 12, 9, 15, 2, -16 },
  { 857, 12, 15, 15, 2, -19 },
  { 880, 10, 24, 10, 1, -24 },
  { 910, 19, 27, 21, 1, -24 },
  { 975, 14, 24, 14, -2, -24 },
  { 1017, 15, 24, 15, 0, -24 },
  { 1062, 14, 24, 14, 2, -24 },
  { 1104, 16, 24, 17, 0, -24 },
  { 1152, 15, 24, 13, 0, -24 },
  { 1197, 15, 24, 12, 0, -24 },
  { 1242, 16, 24, 18, 2, -24 },
  { 1290, 18, 24, 17, 0, -24 },
  { 1344, 11, 24, 8, -1, -24 },
  { 1377, 12, 30, 7, -5, -24 },
  { 1422, 17, 24, 14, 0, -24 },
  { 1473, 10, 24, 12, 0, -24 },
  { 1503, 23, 24, 22, 0, -24 },
  { 1572, 19, 24, 18, 0, -24 },
  { 1629, 15, 24, 18, 2, -24 },
  { 1674, 15, 24, 14, 0, -24 },
  { 1719, 15, 30, 18, 2, -24 },
  { 1776, 15, 24, 15, 0, -24 },
  { 1821, 14, 24, 13, 0, -24 },
  { 1863, 12, 24, 12, 3, -24 },
  { 1899, 16, 24, 17, 2, -24 },
  { 1947, 14, 24, 14, 3, -24 },
  { 1989, 22, 24, 23, 3, -24 },
  { 2055, 17, 24, 13, -2, -24 },
  { 2106, 12, 24, 12, 3, -24 },
  { 2142, 15, 24, 13, -1, -24 },
  { 2187, 13, 29, 9, -1, -24 },
  { 2235, 5, 24, 11, 3, -24 },
  { 2250, 12, 29, 9, -2, -24 },
  { 2294, 13, 13, 15, 1, -24 },
  { 2316, 11, 1, 10, -3, 3 },
  { 2318, 4, 5, 8, 5, -25 },
  { 2321, 13, 18, 15, 1, -18 },
  { 2351, 14, 25, 15, 0, -25 },
  { 2395, 11, 18, 11, 1, -18 },
  { 2420, 15, 25, 15, 1, -25 },
  { 2467, 11, 18, 13, 1, -18 },
  { 2492, 16, 33, 8, -4, -25 },
  { 2558, 14, 26, 15, 0, -18 },
  { 2604, 13, 25, 14, 0, -25 },
  { 2645, 7, 24, 6, 0, -24 },
  { 2666, 11, 32, 6, -4, -24 },
  { 2710, 13, 25, 12, 0, -25 },
  { 2751, 7, 25, 6, 0, -25 },
  { 2773, 21, 18, 22, 0, -18 },
  { 2821, 13, 18, 14, 0, -18 },
  { 2851, 12, 18, 14, 1, -18 },
  { 2878, 15, 26, 15, -1, -18 },
  { 2927, 13, 26, 15, 1, -18 },
  { 2970, 11, 18, 10, 0, -18 },
  { 2995, 11, 18, 11, 0, -18 },
  { 3020, 8, 22, 8, 1, -22 },
  { 3042, 13, 18, 15, 1, -18 },
  { 3072, 11, 18, 11, 2, -18 },
  { 3097, 18, 18, 18, 2, -18 },
  { 3138, 14, 18, 12, -1, -18 },
  { 3170, 16, 26, 12, -3, -18 },
  { 3222, 12, 18, 10, -1, -18 },
  { 3249, 12, 29, 11, 1, -24 },
  { 3293, 2, 33, 14, 6, -25 },
  { 3302, 12, 29, 11, -2, -24 },
  { 3346, 12, 3, 15, 2, -13 },
};

const GFXfont NotoSans_Condensed_LightItalic33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC33PT7B_H_
