#ifndef _NOTOSANS_CONDENSED_LIGHTITALIC67PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHTITALIC67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-LightItalic.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_LightItalic67pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0E, 0x3C, 0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x78, 0x1C, 0x78,
  0x1C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0xE0,
  0x30, 0xE0, 0x70, 0xE0, 0x70, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x07, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x01,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03,
  0x80, 0xE0, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38,
  0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80,
  0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0x01, 0xC0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00,
  0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x07, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x38, 0x07, 0x00, 0x00,
  0x70, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x03, 0x80, 0x70, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xCE, 0x1E, 0x01, 0xF0,
  0xE0, 0x40, 0x1E, 0x0C, 0x00, 0x03, 0xC0, 0xC0, 0x00, 0x38, 0x0C, 0x00,
  0x03, 0x81, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x81, 0x80, 0x00, 0x78,
  0x18, 0x00, 0x03, 0x81, 0x80, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x3E, 0x30, 0x00, 0x01, 0xE3, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0C, 0xF8, 0x00,
  0x00, 0xC7, 0xC0, 0x00, 0x0C, 0x3C, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C,
  0x1E, 0x00, 0x01, 0x81, 0xE0, 0x00, 0x18, 0x1E, 0x00, 0x03, 0x81, 0xE0,
  0x00, 0x38, 0x1C, 0x00, 0x03, 0x01, 0xC0, 0x00, 0x30, 0x3C, 0x00, 0x03,
  0x03, 0xC0, 0x80, 0x70, 0x78, 0x0C, 0x07, 0x0F, 0x00, 0xFC, 0x6F, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x0F, 0xF8, 0x00,
  0x1C, 0x03, 0xEF, 0x80, 0x07, 0x80, 0x70, 0x70, 0x00, 0xE0, 0x1C, 0x0E,
  0x00, 0x3C, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1E, 0x03, 0xC0,
  0x1C, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x1E, 0x00, 0xE0, 0x0E, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xF0, 0x0F,
  0x07, 0x00, 0x1C, 0x01, 0xC1, 0xE0, 0x03, 0x80, 0x38, 0x38, 0x00, 0x70,
  0x07, 0x0F, 0x00, 0x0E, 0x01, 0xE1, 0xC1, 0xF9, 0xC0, 0x38, 0x70, 0xFF,
  0xB8, 0x07, 0x1E, 0x3F, 0xFF, 0x01, 0xC3, 0x87, 0x0F, 0xE0, 0x38, 0xF1,
  0xC0, 0xFC, 0x0E, 0x1C, 0x78, 0x1F, 0xC3, 0xC7, 0x0E, 0x03, 0xBD, 0xF0,
  0xE3, 0xC0, 0x77, 0xFC, 0x38, 0x70, 0x0E, 0x7F, 0x0F, 0x0E, 0x01, 0xC1,
  0x01, 0xC3, 0xC0, 0x38, 0x00, 0x78, 0x70, 0x07, 0x00, 0x0E, 0x0E, 0x00,
  0xE0, 0x03, 0x81, 0xC0, 0x1C, 0x00, 0x70, 0x78, 0x03, 0x80, 0x1C, 0x0E,
  0x00, 0xE0, 0x07, 0x81, 0xC0, 0x1C, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x3C,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x70, 0x1C, 0x03, 0xC0, 0x0E, 0x03,
  0x80, 0x70, 0x01, 0xC0, 0xE0, 0x1E, 0x00, 0x38, 0x3C, 0x03, 0x80, 0x07,
  0x8F, 0x00, 0xE0, 0x00, 0x7F, 0xC0, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78,
  0x0F, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF0, 0xE0, 0x0F,
  0x07, 0x83, 0xC0, 0x38, 0x3C, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x07, 0x87,
  0x80, 0x78, 0x1C, 0x3C, 0x00, 0xF0, 0xF0, 0xE0, 0x03, 0xC3, 0x87, 0x80,
  0x0F, 0x1E, 0x1E, 0x00, 0x1E, 0x70, 0x70, 0x00, 0x7B, 0xC1, 0xC0, 0x00,
  0xFE, 0x0F, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xF8, 0x07, 0x00, 0x07, 0xF0, 0x1E, 0x00, 0x3F, 0xC0,
  0x78, 0x01, 0xF7, 0x80, 0xF0, 0x0F, 0x1E, 0x03, 0xFF, 0xF8, 0x38, 0x07,
  0xFF, 0xC0, 0xF0, 0x0F, 0xFE, 0x03, 0xE0, 0x07, 0x40, 0x00, 0x00, 0x1E,
  0x38, 0xF1, 0xE3, 0xC7, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0C, 0x38,
  0x70, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x01, 0x00, 0x60, 0x07, 0x03, 0x80, 0x1F, 0x0E,
  0x00, 0xFE, 0x38, 0x00, 0x7E, 0xE0, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3D, 0xC0, 0x01, 0xE7, 0x00, 0x0F,
  0x0E, 0x00, 0x78, 0x38, 0x07, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x10, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xF7, 0xFF, 0xE0, 0x39, 0xEF, 0xFE, 0xFB, 0xC0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0xF1, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x8F,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07,
  0x9E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x78, 0x00,
  0x0F, 0x1C, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0xF0,
  0x00, 0x1E, 0x3C, 0x00, 0x07, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03,
  0xC0, 0xF0, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x07, 0x00, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0xFB, 0x83, 0xE7, 0x0F,
  0x9E, 0x7C, 0x3D, 0xF0, 0x71, 0xC0, 0xE1, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1C,
  0x00, 0xF8, 0x00, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x1E, 0x00,
  0x40, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x80, 0x01, 0xF0, 0x0E, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x1C,
  0x78, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70, 0x78, 0x00, 0x07, 0x03, 0x80, 0x00,
  0x78, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x38, 0x0F, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x1E, 0x01, 0xE0,
  0x01, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x70, 0x03, 0x80, 0x03, 0x80, 0x38, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x39, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xC1, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x08, 0x00, 0x1F,
  0x00, 0xE0, 0x07, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x02,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x03, 0xC0, 0x01, 0xC3, 0xFF, 0x00, 0x38, 0xFF, 0xF0, 0x0F, 0x3F, 0x7F,
  0x01, 0xEE, 0x03, 0xE0, 0x3B, 0x80, 0x3E, 0x07, 0xE0, 0x03, 0xC1, 0xF8,
  0x00, 0x78, 0x3E, 0x00, 0x07, 0x07, 0xC0, 0x00, 0xE0, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x38, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x70, 0x00,
  0x78, 0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xE0, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x1E, 0x00,
  0x0E, 0x00, 0xF0, 0x00, 0x70, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0xE0, 0x1E, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x78, 0x07,
  0x80, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7E, 0x3C, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x78, 0x00, 0x78,
  0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xC0, 0xE0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x70, 0x38, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x1C, 0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0x70, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x7C, 0x03,
  0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x7C, 0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x1E, 0x00,
  0x07, 0x07, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x3C,
  0x00, 0x07, 0x0E, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x71, 0xE0, 0x00, 0x3C,
  0x78, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xF0, 0xE0, 0x00,
  0x7C, 0x38, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x83, 0xC0, 0x0E, 0xE0, 0x78,
  0x07, 0xF8, 0x1F, 0x8F, 0xDE, 0x03, 0xFF, 0xC7, 0x00, 0x7F, 0xE3, 0xC0,
  0x07, 0xE0, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x20, 0x0F, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xC0, 0x3C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x02, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x70, 0x1F, 0x02, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00,
  0x1C, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x00, 0x38, 0x0E,
  0x00, 0x00, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x30,
  0x01, 0xC1, 0xE0, 0x07, 0xFF, 0x03, 0x83, 0x80, 0x1F, 0xFE, 0x07, 0x0F,
  0x00, 0x78, 0x38, 0x0E, 0x1C, 0x01, 0xE0, 0x70, 0x1C, 0x38, 0x07, 0x80,
  0xE0, 0x38, 0xE0, 0x1E, 0x03, 0xC0, 0x71, 0xC0, 0x38, 0x07, 0x00, 0xE3,
  0x80, 0xE0, 0x0E, 0x01, 0xCE, 0x01, 0xC0, 0x1C, 0x03, 0x9C, 0x07, 0x00,
  0x78, 0x07, 0x38, 0x0E, 0x00, 0xE0, 0x1E, 0xE0, 0x1C, 0x01, 0xC0, 0x39,
  0xC0, 0x70, 0x03, 0x80, 0x73, 0x80, 0xE0, 0x0F, 0x00, 0xE7, 0x01, 0xC0,
  0x1C, 0x03, 0x8E, 0x03, 0x80, 0x38, 0x07, 0x1C, 0x0F, 0x00, 0xF0, 0x0E,
  0x78, 0x1C, 0x01, 0xE0, 0x38, 0xE0, 0x38, 0x03, 0x80, 0x71, 0xC0, 0x70,
  0x0F, 0x01, 0xC3, 0x80, 0xE0, 0x1E, 0x03, 0x87, 0x01, 0xE0, 0x6C, 0x0E,
  0x0E, 0x01, 0xC1, 0xDC, 0x3C, 0x1C, 0x03, 0xC7, 0x3C, 0xF0, 0x38, 0x03,
  0xFC, 0x3F, 0xC0, 0x70, 0x07, 0xF0, 0x7F, 0x00, 0xF0, 0x01, 0x00, 0x10,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x02, 0x00, 0x00, 0x1F, 0x80, 0x3C,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x0E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x1C,
  0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0xF0, 0x0E, 0x00, 0x1E,
  0x00, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x7F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x1E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1E, 0x07, 0xFC, 0x00, 0x78, 0x01, 0xF8,
  0x01, 0xE0, 0x01, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x38,
  0x00, 0x0F, 0x00, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xE0, 0x1E, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0x80, 0x0F, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0x83, 0xFE, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0x70, 0x00, 0xF8, 0x03, 0xC0,
  0x01, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xE0, 0x38,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x1E, 0x00,
  0x3F, 0x00, 0x70, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x38,
  0x00, 0xFC, 0x00, 0x20, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xC0, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x78, 0x03, 0xF0, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0x80, 0x00,
  0x1E, 0x03, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xFC, 0x00, 0x78, 0x03, 0xF8, 0x00, 0x70, 0x3F, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x0F, 0xFF, 0x07, 0x80, 0x03, 0xFF, 0x81, 0xC0, 0x00, 0xFF, 0xE0,
  0x70, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x00, 0xE0, 0x1C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xC0, 0x1F, 0x00, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x03, 0xF0, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x1C, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x70, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00,
  0x38, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x00,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0xE0, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x43, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1C,
  0x00, 0x07, 0x80, 0x0E, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x00,
  0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0x1C, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x01, 0xC1, 0xF0, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x1C, 0xF8, 0x00,
  0x00, 0x1E, 0xFC, 0x00, 0x00, 0x0F, 0x7E, 0x00, 0x00, 0x07, 0xF7, 0x80,
  0x00, 0x03, 0xF3, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x01, 0xF0, 0x78,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x38, 0x07,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x01, 0xE0, 0x03, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x00, 0x01, 0xE0, 0x07,
  0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0xF7, 0x00, 0x00, 0x0E, 0xF0, 0x07, 0xB8, 0x00,
  0x00, 0xF7, 0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x00,
  0x7B, 0xC0, 0x1E, 0x70, 0x00, 0x03, 0x9E, 0x00, 0xF3, 0x80, 0x00, 0x3C,
  0xE0, 0x07, 0x9C, 0x00, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x00, 0x1E, 0x78,
  0x01, 0xC7, 0x80, 0x00, 0xE3, 0xC0, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0xF1, 0xE0, 0x00, 0x70, 0xE0, 0x07, 0x8F, 0x00, 0x07, 0x87, 0x00, 0x38,
  0x78, 0x00, 0x38, 0x78, 0x01, 0xC1, 0xC0, 0x03, 0xC3, 0xC0, 0x1E, 0x0E,
  0x00, 0x1C, 0x1E, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0x80,
  0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x78, 0x01, 0xC0, 0xE0, 0x07,
  0x03, 0xC0, 0x1E, 0x07, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x38, 0x03, 0x80,
  0xE0, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x38, 0x0F, 0x01, 0xC0, 0x78,
  0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0xE0, 0x1C, 0x00,
  0xF0, 0x1E, 0x0F, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x70, 0x0F, 0x00, 0x38,
  0x03, 0x87, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xE3, 0xC0, 0x1C, 0x00, 0xF0, 0x07, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x39,
  0xE0, 0x0F, 0x00, 0x38, 0x01, 0xCE, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0x7F, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xF8, 0x00,
  0xE0, 0x07, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x78,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x0F, 0x80,
  0x00, 0x1C, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0x00,
  0x3F, 0x80, 0x00, 0x70, 0x01, 0xFC, 0x00, 0x03, 0x80, 0x0E, 0xE0, 0x00,
  0x3C, 0x00, 0xF7, 0x00, 0x01, 0xE0, 0x07, 0xBC, 0x00, 0x0F, 0x00, 0x39,
  0xE0, 0x00, 0x70, 0x01, 0xC7, 0x00, 0x03, 0x80, 0x1E, 0x38, 0x00, 0x3C,
  0x00, 0xF1, 0xC0, 0x01, 0xE0, 0x07, 0x8F, 0x00, 0x0F, 0x00, 0x38, 0x78,
  0x00, 0x70, 0x01, 0xC1, 0xC0, 0x03, 0x80, 0x1E, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x78, 0x01, 0xE0, 0x07, 0x83, 0xC0, 0x0E, 0x00, 0x38, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x70, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x3C, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x03, 0x80, 0x70,
  0x01, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x03,
  0x81, 0xE0, 0x07, 0x00, 0x1C, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x70, 0x03,
  0xC0, 0x07, 0x87, 0x80, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0x00, 0xE1,
  0xE0, 0x07, 0x00, 0x07, 0x8E, 0x00, 0x38, 0x00, 0x3C, 0x70, 0x03, 0xC0,
  0x00, 0xE7, 0x80, 0x1E, 0x00, 0x07, 0x3C, 0x00, 0xF0, 0x00, 0x3D, 0xC0,
  0x07, 0x00, 0x01, 0xEE, 0x00, 0x38, 0x00, 0x07, 0x70, 0x03, 0xC0, 0x00,
  0x3F, 0x80, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x07,
  0x00, 0x00, 0x3E, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F, 0x07, 0x80,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x0E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1C, 0x70, 0x00,
  0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00,
  0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xF0, 0x7F, 0x80, 0x07, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0xF8,
  0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07,
  0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07,
  0x80, 0x03, 0xC0, 0x38, 0x00, 0x3E, 0x01, 0xC0, 0x01, 0xE0, 0x1E, 0x00,
  0x1E, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x7E, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1C,
  0x70, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x70, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xF0, 0xFF, 0x80, 0x07,
  0x80, 0x3E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07,
  0x80, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0xF0, 0x1E, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x38, 0x00, 0x3C,
  0x01, 0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x3E, 0x00, 0xF0, 0x07, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x38, 0x07, 0x80,
  0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x07,
  0x80, 0x3C, 0x00, 0x38, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x78,
  0x03, 0xC0, 0x01, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07,
  0x00, 0x03, 0xC0, 0x38, 0x00, 0x0E, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x40, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0xC0,
  0x00, 0xF8, 0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xC0, 0x3C,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1E, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0x80,
  0x78, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x38, 0x07, 0x80, 0x00, 0x1C,
  0x03, 0xC0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x03, 0x80, 0x78, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x01,
  0xE0, 0x1C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x38, 0x07, 0x80, 0x00, 0x3C, 0x03, 0x80, 0x00, 0x1E, 0x01, 0xC0, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x78, 0x00,
  0x03, 0xC0, 0x38, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xE0, 0x1E, 0x00,
  0x00, 0x70, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x03,
  0xE0, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0x78, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0F,
  0x00, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0x70, 0x00,
  0x78, 0x07, 0x00, 0x07, 0x80, 0x70, 0x00, 0x70, 0x07, 0x00, 0x0F, 0x00,
  0x70, 0x00, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x00, 0x78, 0x00, 0x70, 0x07, 0x80,
  0x07, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70,
  0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x3D, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0x9E, 0x00, 0x07, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xC7,
  0x80, 0x03, 0xBC, 0x00, 0x1C, 0x3C, 0x00, 0x1D, 0xE0, 0x01, 0xE1, 0xE0,
  0x01, 0xEF, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x78, 0x00, 0xF0, 0x78, 0x00,
  0x73, 0xC0, 0x07, 0x83, 0xC0, 0x07, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x38,
  0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x07, 0x80, 0x1C, 0x3C,
  0x01, 0xE0, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x01, 0xE0, 0x0E, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0x70, 0x78, 0x07, 0x80, 0x78, 0x07, 0x83, 0xC0, 0x38,
  0x03, 0xC0, 0x38, 0x1E, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0xE0, 0x1E, 0x00,
  0xF0, 0x1C, 0x07, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x38, 0x0F, 0x00, 0x3C,
  0x0F, 0x01, 0xC0, 0x70, 0x01, 0xE0, 0x70, 0x0E, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x70, 0x3C, 0x00, 0x78, 0x38, 0x03, 0x83, 0xC0, 0x03, 0xC3, 0xC0,
  0x1C, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x07,
  0x0F, 0x00, 0x07, 0x8F, 0x00, 0x38, 0x70, 0x00, 0x3C, 0x70, 0x01, 0xC7,
  0x80, 0x01, 0xE7, 0x80, 0x0E, 0x3C, 0x00, 0x0F, 0x38, 0x00, 0x71, 0xC0,
  0x00, 0x79, 0xC0, 0x03, 0x9E, 0x00, 0x03, 0xDE, 0x00, 0x1C, 0xE0, 0x00,
  0x1E, 0xE0, 0x00, 0xEF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0x78, 0x00, 0x07,
  0xF0, 0x00, 0x3B, 0x80, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x0E, 0x1C,
  0x00, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x00,
  0x3C, 0x1C, 0x00, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x78, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x03,
  0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00,
  0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x87, 0x80, 0x01,
  0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xE0, 0x10, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F,
  0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0,
  0x1C, 0x07, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x38, 0x70, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x1E, 0x03, 0xC0, 0x03, 0x80, 0x38, 0x00, 0xF0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0xE0,
  0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xDE,
  0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0xF0, 0x78, 0x78, 0x38, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x00, 0x0F,
  0xE0, 0xE0, 0x07, 0xFE, 0x1C, 0x01, 0xFF, 0xE3, 0x80, 0x7C, 0x1E, 0xF0,
  0x1F, 0x01, 0xDC, 0x07, 0x80, 0x1B, 0x81, 0xF0, 0x01, 0xF0, 0x3C, 0x00,
  0x3E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0E, 0x0F, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x80,
  0xE0, 0x03, 0xF0, 0x1E, 0x00, 0x6E, 0x03, 0xC0, 0x1B, 0xC0, 0x7C, 0x0F,
  0x70, 0x07, 0xFF, 0xCE, 0x00, 0x7F, 0xF1, 0xC0, 0x07, 0xF8, 0x38, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x07, 0xF0, 0x01, 0xE3, 0xFF,
  0x00, 0x38, 0xFF, 0xF0, 0x07, 0x3C, 0x3E, 0x01, 0xEE, 0x01, 0xE0, 0x3F,
  0x80, 0x3C, 0x07, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x0F,
  0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x70,
  0x70, 0x00, 0x0E, 0x0E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xC0, 0xFC,
  0x00, 0xF0, 0x1D, 0x80, 0x3E, 0x07, 0xB8, 0x0F, 0x80, 0xE3, 0xFF, 0xE0,
  0x1C, 0x7F, 0xF8, 0x03, 0x87, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3E, 0x02, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x01, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x70, 0x00, 0x3F, 0xF0, 0xE0, 0x00,
  0xFF, 0xF3, 0xC0, 0x03, 0xE0, 0xF7, 0x80, 0x0F, 0x80, 0x6E, 0x00, 0x3C,
  0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xF0, 0x07, 0x80,
  0x03, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00,
  0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0xF8, 0x03,
  0xC0, 0x03, 0xF0, 0x07, 0x80, 0x07, 0xC0, 0x0F, 0x00, 0x1F, 0x80, 0x0F,
  0x00, 0x77, 0x00, 0x1E, 0x01, 0xCE, 0x00, 0x3E, 0x07, 0xBC, 0x00, 0x3F,
  0xFE, 0x70, 0x00, 0x3F, 0xF8, 0xE0, 0x00, 0x3F, 0xC1, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0,
  0x07, 0xC1, 0xF0, 0x1E, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x03, 0x83,
  0xC0, 0x07, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xE0,
  0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0E, 0x00, 0x7C, 0x3C, 0x03,
  0xF0, 0x79, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x03, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0xC0, 0x3F, 0x9F, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0x82, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x8F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x38, 0x00, 0x7F,
  0xE1, 0xC0, 0x07, 0xFF, 0x8E, 0x00, 0x7C, 0x1E, 0x70, 0x07, 0xC0, 0x37,
  0x80, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x3E, 0x03,
  0xC0, 0x01, 0xF0, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07,
  0x01, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x78, 0x1E, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x7E, 0x03,
  0xC0, 0x03, 0xE0, 0x1E, 0x00, 0x3F, 0x00, 0x78, 0x03, 0xB8, 0x03, 0xC0,
  0x3F, 0xC0, 0x1F, 0x03, 0xDE, 0x00, 0x7F, 0xFC, 0xE0, 0x01, 0xFF, 0xC7,
  0x00, 0x07, 0xF8, 0x78, 0x00, 0x06, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x10, 0x00, 0xF8, 0x00,
  0xF0, 0x1F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x87, 0xF8, 0x01, 0xE3, 0xFF, 0x00, 0x73,
  0xFF, 0xE0, 0x1D, 0xE0, 0xF8, 0x0F, 0x70, 0x1F, 0x03, 0xF0, 0x03, 0xC0,
  0xFC, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x03,
  0xC1, 0xE0, 0x00, 0xE0, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E,
  0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x38,
  0x1C, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x18, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x87, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x01, 0xE0,
  0x07, 0x80, 0x70, 0x01, 0xE0, 0x1C, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x0E, 0x03, 0xC0,
  0x07, 0x81, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x78, 0x00, 0x1C, 0x3C,
  0x00, 0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x39,
  0xF8, 0x00, 0x0E, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFC, 0xE0, 0x00,
  0x7E, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0x70,
  0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x03, 0x80,
  0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x70, 0x07,
  0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x38,
  0x0E, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x01, 0xC1,
  0xFC, 0x01, 0xFC, 0x00, 0xE3, 0xFF, 0x03, 0xFF, 0x00, 0x73, 0xFF, 0xC3,
  0xFF, 0xC0, 0x3B, 0xC1, 0xE3, 0xC3, 0xE0, 0x3F, 0x80, 0x7B, 0x80, 0xF8,
  0x1D, 0x80, 0x3F, 0x80, 0x3C, 0x0F, 0x80, 0x1F, 0x80, 0x1E, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC0,
  0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xE0,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x78, 0x00, 0x78, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x01, 0xC1, 0xFE, 0x00, 0x71, 0xFF, 0xC0, 0x1C, 0xFF,
  0xF8, 0x07, 0x78, 0x3E, 0x03, 0xFC, 0x07, 0xC0, 0xEE, 0x00, 0xF0, 0x3F,
  0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0,
  0x78, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x03, 0x80,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0E, 0x07,
  0x00, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x03, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0,
  0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x70,
  0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xCE,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x39,
  0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x0F,
  0x1E, 0x00, 0x07, 0x07, 0x00, 0x07, 0x83, 0x80, 0x07, 0x81, 0xE0, 0x03,
  0xC0, 0xF8, 0x03, 0xC0, 0x3E, 0x07, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x1F, 0xC0,
  0x00, 0xE1, 0xFF, 0x80, 0x03, 0x8F, 0xFF, 0x00, 0x0E, 0x70, 0x3C, 0x00,
  0x7B, 0x80, 0x78, 0x01, 0xDC, 0x01, 0xE0, 0x07, 0x60, 0x03, 0xC0, 0x1F,
  0x00, 0x0F, 0x00, 0x7C, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0xF0, 0x0F, 0x80,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0, 0x00,
  0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x38,
  0x07, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x78, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xC0, 0x3E, 0x00, 0x1E,
  0x00, 0xFC, 0x00, 0xF0, 0x03, 0xB0, 0x07, 0xC0, 0x0E, 0xE0, 0x3E, 0x00,
  0x79, 0xFF, 0xF0, 0x01, 0xE7, 0xFF, 0x80, 0x07, 0x0F, 0xF8, 0x00, 0x1C,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0xE0, 0x07, 0xFE, 0x1C, 0x01, 0xFF, 0xE3, 0x80, 0x7C, 0x1E,
  0x70, 0x1E, 0x00, 0xDC, 0x07, 0x80, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x3C,
  0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xC1, 0xC0, 0x00, 0x38, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E,
  0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x7E, 0x0F, 0x00, 0x0F,
  0x81, 0xE0, 0x03, 0xF0, 0x1E, 0x00, 0xEE, 0x03, 0xC0, 0x3F, 0xC0, 0x7C,
  0x0F, 0x78, 0x07, 0xFF, 0xCE, 0x00, 0x7F, 0xF1, 0xC0, 0x07, 0xF8, 0x78,
  0x00, 0x18, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC1, 0xF8, 0x0E, 0x3F,
  0xC0, 0x73, 0xFE, 0x03, 0xBF, 0x10, 0x39, 0xC0, 0x01, 0xDC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0x01, 0xE0, 0x78, 0x00, 0x80, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x40,
  0x03, 0xC0, 0xC0, 0x1F, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xFD, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x0E, 0x00, 0x03,
  0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x1C, 0x00,
  0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x38,
  0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x07,
  0x00, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF0, 0x01, 0xF8, 0x3C, 0x00, 0x7C,
  0x0F, 0x00, 0x3F, 0x03, 0xC0, 0x1D, 0xC0, 0x78, 0x0E, 0x70, 0x1F, 0xFF,
  0x38, 0x03, 0xFF, 0x8E, 0x00, 0x7F, 0xC3, 0x80, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xB8, 0x00, 0x1E, 0xE0,
  0x00, 0x73, 0x80, 0x03, 0xCE, 0x00, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x83,
  0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0x80, 0xF0, 0x1E, 0x01, 0xC0,
  0x70, 0x07, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x78, 0x01, 0xC1, 0xC0,
  0x07, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0x71, 0xE0, 0x01, 0xC7, 0x00, 0x07,
  0x3C, 0x00, 0x1C, 0xF0, 0x00, 0x73, 0x80, 0x01, 0xDE, 0x00, 0x07, 0x70,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0xF0, 0x01, 0xF0, 0x00, 0xEF, 0x00, 0x1F, 0x00, 0x1E, 0xF0, 0x01, 0xF0,
  0x01, 0xEF, 0x00, 0x3F, 0x00, 0x3C, 0xF0, 0x03, 0xF0, 0x03, 0xCF, 0x00,
  0x77, 0x00, 0x38, 0xF0, 0x07, 0x70, 0x07, 0x8F, 0x00, 0xF7, 0x00, 0x70,
  0xF0, 0x0E, 0x70, 0x0F, 0x0F, 0x00, 0xE7, 0x00, 0xF0, 0xF0, 0x1C, 0x70,
  0x0E, 0x0F, 0x01, 0xC7, 0x01, 0xE0, 0xF0, 0x38, 0x70, 0x1C, 0x0F, 0x03,
  0x87, 0x03, 0xC0, 0xF0, 0x78, 0x70, 0x38, 0x0F, 0x07, 0x07, 0x03, 0x80,
  0xF0, 0x70, 0x70, 0x78, 0x0F, 0x0E, 0x07, 0x07, 0x00, 0xF0, 0xE0, 0x70,
  0xF0, 0x0F, 0x1C, 0x07, 0x0E, 0x00, 0xF1, 0xC0, 0x71, 0xE0, 0x0F, 0x3C,
  0x07, 0x1E, 0x00, 0xF3, 0x80, 0x71, 0xC0, 0x0F, 0x38, 0x07, 0x3C, 0x00,
  0xF7, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x07, 0x38, 0x00, 0xEF, 0x00, 0x77,
  0x00, 0x0E, 0xE0, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x78, 0x03, 0x80, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x3C, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x07, 0x8F,
  0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x07, 0x78, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x78, 0x38, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x3C, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x01, 0xE0, 0x01, 0xC0,
  0x1E, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x0F, 0x00, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x38, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF0, 0x0E, 0x00,
  0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x00, 0x1C,
  0x78, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x00,
  0x73, 0xC0, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x83, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x4F, 0xFE, 0x00, 0x17, 0xFF, 0xE0, 0x1F, 0xC0, 0xFF, 0x1F, 0xE0, 0x0F,
  0xFF, 0xA0, 0x00, 0xFF, 0xC8, 0x00, 0x07, 0xC0,
};

const GFXglyph NotoSans_Condensed_LightItalic67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 15, 48, 15, 1, -48 },
  { 91, 16, 17, 21, 7, -48 },
  { 125, 31, 48, 31, 1, -48 },
  { 311, 28, 55, 28, 1, -51 },
  { 504, 35, 50, 42, 4, -49 },
  { 723, 30, 50, 31, 0, -49 },
  { 911, 7, 17, 12, 7, -48 },
  { 926, 19, 59, 17, 2, -48 },
  { 1067, 20, 59, 17, -5, -48 },
  { 1215, 22, 23, 27, 7, -51 },
  { 1279, 26, 31, 31, 3, -39 },
  { 1380, 10, 16, 13, -3, -7 },
  { 1400, 15, 4, 18, 2, -20 },
  { 1408, 6, 6, 13, 1, -6 },
  { 1413, 29, 48, 21, -3, -48 },
  { 1587, 26, 50, 28, 2, -49 },
  { 1750, 15, 48, 28, 8, -48 },
  { 1840, 29, 49, 28, -1, -49 },
  { 2018, 28, 50, 28, 0, -49 },
  { 2193, 29, 48, 28, -1, -48 },
  { 2367, 28, 49, 28, 0, -48 },
  { 2539, 27, 50, 28, 2, -49 },
  { 2708, 26, 48, 28, 4, -48 },
  { 2864, 29, 50, 28, 0, -49 },
  { 3046, 26, 50, 28, 1, -49 },
  { 3209, 11, 36, 13, 1, -36 },
  { 3259, 15, 45, 13, -3, -36 },
  { 3344, 26, 30, 31, 3, -39 },
  { 3442, 26, 17, 31, 3, -32 },
  { 3498, 26, 30, 31, 3, -39 },
  { 3596, 21, 49, 21, 2, -49 },
  { 3725, 39, 54, 43, 2, -48 },
  { 3989, 28, 48, 28, -4, -48 },
  { 4157, 30, 48, 31, 1, -48 },
  { 4337, 30, 50, 29, 3, -49 },
  { 4525, 32, 48, 34, 1, -48 },
  { 4717, 29, 48, 27, 1, -48 },
  { 4891, 29, 48, 25, 1, -48 },
  { 5065, 34, 50, 36, 3, -49 },
  { 5278, 35, 48, 35, 1, -48 },
  { 5488, 23, 48, 16, -3, -48 },
  { 5626, 25, 60, 13, -10, -48 },
  { 5814, 33, 48, 29, 1, -48 },
  { 6012, 19, 48, 25, 1, -48 },
  { 6126, 45, 48, 46, 1, -48 },
  { 6396, 37, 48, 37, 1, -48 },
  { 6618, 32, 50, 37, 3, -49 },
  { 6818, 29, 48, 29, 1, -48 },
  { 6992, 32, 60, 37, 3, -49 },
  { 7232, 29, 48, 30, 1, -48 },
  { 7406, 30, 50, 27, -1, -49 },
  { 7594, 24, 48, 25, 6, -48 },
  { 7738, 33, 49, 35, 3, -48 },
  { 7941, 28, 48, 28, 6, -48 },
  { 8109, 45, 48, 46, 6, -48 },
  { 8379, 35, 48, 26, -4, -48 },
  { 8589, 25, 48, 25, 6, -48 },
  { 8739, 31, 48, 26, -2, -48 },
  { 8925, 25, 59, 19, -1, -48 },
  { 9110, 10, 48, 22, 7, -48 },
  { 9170, 24, 59, 19, -4, -48 },
  { 9347, 27, 26, 30, 2, -48 },
  { 9435, 22, 3, 21, -6, 6 },
  { 9444, 8, 10, 16, 10, -51 },
  { 9454, 27, 37, 30, 2, -36 },
  { 9579, 27, 52, 30, 1, -51 },
  { 9755, 22, 37, 23, 2, -36 },
  { 9857, 31, 52, 30, 2, -51 },
  { 10059, 23, 37, 27, 2, -36 },
  { 10166, 32, 67, 16, -8, -51 },
  { 10434, 29, 52, 30, 0, -36 },
  { 10623, 26, 51, 29, 1, -51 },
  { 10789, 14, 49, 13, 1, -49 },
  { 10875, 24, 65, 13, -9, -49 },
  { 11070, 26, 51, 25, 1, -51 },
  { 11236, 14, 51, 13, 1, -51 },
  { 11326, 41, 36, 44, 1, -36 },
  { 11511, 26, 36, 29, 1, -36 },
  { 11628, 25, 37, 29, 2, -36 },
  { 11744, 30, 52, 30, -2, -36 },
  { 11939, 27, 52, 30, 2, -36 },
  { 12115, 21, 36, 20, 1, -36 },
  { 12210, 23, 37, 22, 0, -36 },
  { 12317, 16, 45, 16, 2, -44 },
  { 12407, 26, 37, 29, 2, -36 },
  { 12528, 22, 36, 23, 4, -36 },
  { 12627, 36, 36, 37, 4, -36 },
  { 12789, 29, 36, 24, -3, -36 },
  { 12920, 34, 52, 24, -7, -36 },
  { 13141, 24, 36, 21, -2, -36 },
  { 13249, 24, 59, 22, 2, -48 },
  { 13426, 3, 67, 28, 13, -51 },
  { 13452, 24, 59, 22, -4, -48 },
  { 13629, 26, 7, 31, 3, -27 },
};

const GFXfont NotoSans_Condensed_LightItalic67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_LightItalic67pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_LightItalic67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_CONDENSED_LIGHTITALIC67PT7B_H_
