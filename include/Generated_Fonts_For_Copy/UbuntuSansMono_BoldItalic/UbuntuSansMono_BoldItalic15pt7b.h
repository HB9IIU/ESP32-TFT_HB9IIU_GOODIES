#ifndef _UBUNTUSANSMONO_BOLDITALIC15PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x67, 0x30, 0x08, 0xE7, 0x00, 0xDF, 0x6D, 0xA4, 0x0D,
  0x8D, 0x9F, 0xEF, 0xF3, 0x61, 0x23, 0xFC, 0xD8, 0x48, 0x6C, 0x00, 0x06,
  0x06, 0x1F, 0x3F, 0x30, 0x30, 0x3C, 0x0E, 0x06, 0x46, 0xFE, 0x7C, 0x30,
  0x30, 0x08, 0x23, 0x98, 0x92, 0x16, 0x83, 0xA0, 0x2C, 0x03, 0xE0, 0xD4,
  0x16, 0x84, 0xB3, 0x1C, 0x00, 0x0C, 0x1E, 0x32, 0x36, 0x3C, 0x3A, 0x7B,
  0xCE, 0xC6, 0xCE, 0x7B, 0x7B, 0x68, 0x04, 0x33, 0x8C, 0x63, 0x8C, 0x30,
  0xC3, 0x0C, 0x30, 0xC1, 0x82, 0x00, 0x08, 0x38, 0x30, 0x30, 0x60, 0xC1,
  0x83, 0x0C, 0x18, 0x61, 0xC7, 0x1C, 0x10, 0x00, 0x18, 0xB7, 0xF8, 0xC7,
  0xE4, 0x80, 0x0C, 0x0C, 0x08, 0x7F, 0x98, 0x18, 0x30, 0x37, 0x73, 0xE8,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x00, 0x18,
  0x7D, 0x9F, 0x3D, 0x7A, 0xF5, 0xC3, 0xCD, 0xFB, 0xE0, 0x0E, 0x7C, 0xF0,
  0x60, 0xC1, 0x87, 0x0C, 0x7F, 0xFC, 0x0E, 0x3F, 0x33, 0x03, 0x03, 0x0E,
  0x1C, 0x30, 0x60, 0xFE, 0xFE, 0x0C, 0x3F, 0x23, 0x03, 0x06, 0x1C, 0x0E,
  0x06, 0x06, 0xCE, 0xFC, 0x07, 0x87, 0x86, 0xC2, 0x62, 0x63, 0x33, 0xFD,
  0xFE, 0x0C, 0x06, 0x00, 0x1F, 0x88, 0x0C, 0x06, 0x03, 0xE0, 0x70, 0x18,
  0x0C, 0xFE, 0x7E, 0x00, 0x1F, 0x38, 0x60, 0xC8, 0xFC, 0xC6, 0xC6, 0xC6,
  0xFC, 0x78, 0x7F, 0x07, 0x0E, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x60, 0xE0,
  0x0E, 0x1F, 0x33, 0x33, 0x33, 0x1E, 0x7E, 0x67, 0xC7, 0x6E, 0x7C, 0x0C,
  0x3F, 0x33, 0x63, 0x63, 0x77, 0x3F, 0x07, 0x0E, 0x7C, 0xF0, 0x37, 0x70,
  0x06, 0xEE, 0x19, 0xCE, 0x00, 0x19, 0xCE, 0x37, 0x20, 0x02, 0x3D, 0xF7,
  0x0F, 0x07, 0x83, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFE, 0x20, 0x78, 0x1E,
  0x07, 0x1F, 0xF8, 0xC0, 0x39, 0xF4, 0xC3, 0x18, 0xC6, 0x00, 0x43, 0x8C,
  0x00, 0x06, 0x0F, 0x8C, 0x6C, 0x36, 0xFA, 0xCB, 0x6D, 0xB6, 0xDB, 0x6F,
  0x10, 0x0C, 0x03, 0xC0, 0x07, 0x07, 0x0F, 0x1B, 0x1B, 0x33, 0x3F, 0x7F,
  0x63, 0xE3, 0x04, 0x3F, 0x33, 0x33, 0x33, 0x7E, 0x67, 0x63, 0x63, 0xFE,
  0xFC, 0x0E, 0x3F, 0x72, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0x7C,
  0x08, 0x3E, 0x33, 0x33, 0x63, 0x63, 0x63, 0x67, 0xE6, 0xFC, 0xF8, 0x1F,
  0x98, 0x0C, 0x06, 0x03, 0xE3, 0x01, 0x80, 0xC0, 0x7E, 0x7F, 0x00, 0x1F,
  0x98, 0x0C, 0x06, 0x03, 0xF3, 0xF1, 0x80, 0xC0, 0x60, 0x70, 0x00, 0x0E,
  0x3F, 0x72, 0x60, 0xC0, 0xC0, 0xC6, 0xCE, 0xCC, 0xFC, 0x7C, 0x31, 0x98,
  0xCC, 0xEC, 0x67, 0xF3, 0x19, 0x9D, 0x8C, 0xC6, 0x63, 0x00, 0x3F, 0x86,
  0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0xFE, 0x7F, 0x00, 0x1F, 0x81,
  0x80, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0xFC, 0x3C, 0x00, 0x33, 0xCC,
  0xC3, 0x61, 0xF0, 0x78, 0x1F, 0x06, 0xC3, 0xB8, 0xC6, 0x31, 0x80, 0x38,
  0x60, 0xC1, 0x87, 0x0C, 0x18, 0x30, 0xFF, 0xFC, 0x18, 0xC6, 0x71, 0xDC,
  0xFA, 0x3E, 0x8B, 0x66, 0x19, 0x86, 0x61, 0x30, 0xC0, 0x31, 0x9C, 0xCE,
  0x4D, 0x66, 0xB3, 0x79, 0x3D, 0x8C, 0xC6, 0x63, 0x00, 0x0E, 0x1F, 0x33,
  0x73, 0x63, 0x63, 0x63, 0x63, 0xE6, 0x7E, 0x7C, 0x04, 0x1F, 0x8C, 0xE6,
  0x33, 0x3B, 0x39, 0xF8, 0xC0, 0x60, 0x60, 0x30, 0x00, 0x1C, 0x7D, 0x9F,
  0x3C, 0x78, 0xF1, 0xE3, 0xCD, 0xFB, 0xE3, 0x03, 0x83, 0x00, 0x08, 0x3F,
  0x33, 0x33, 0x73, 0x7F, 0x7C, 0x6C, 0x66, 0xC6, 0xC6, 0x0E, 0x1F, 0xCC,
  0x46, 0x03, 0x81, 0xE0, 0x38, 0x0C, 0x06, 0x7F, 0x3F, 0x00, 0xFF, 0x30,
  0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xC0, 0x31, 0x98, 0xCC, 0xCC,
  0x66, 0x33, 0x19, 0x99, 0xCC, 0x7E, 0x3E, 0x00, 0xC7, 0xC6, 0xCC, 0xCC,
  0xD8, 0xD8, 0xD0, 0xF0, 0xE0, 0xE0, 0x30, 0xC8, 0x66, 0x19, 0xB6, 0x7D,
  0x17, 0xC7, 0x73, 0x98, 0xE6, 0x31, 0x80, 0x18, 0xE1, 0xB0, 0x3C, 0x07,
  0x80, 0x60, 0x1C, 0x06, 0xC1, 0xD8, 0x33, 0x1C, 0x60, 0xC7, 0xCE, 0xCC,
  0xD8, 0x70, 0x70, 0x60, 0x60, 0x60, 0xC0, 0x3F, 0x81, 0x81, 0x81, 0xC1,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0x7F, 0x00, 0x1F, 0x1F, 0x18, 0x18, 0x30,
  0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xC0, 0xF8, 0xF8, 0xDB, 0x6D,
  0xB6, 0x6D, 0xB6, 0xD8, 0x1F, 0x1E, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C,
  0x0C, 0x0C, 0x18, 0x18, 0x18, 0xF8, 0xF0, 0x1C, 0x79, 0xFB, 0x3C, 0x68,
  0x80, 0xFF, 0xFE, 0x4E, 0x71, 0x1F, 0x3F, 0x63, 0x66, 0xE6, 0xE6, 0x7E,
  0x7E, 0x08, 0x18, 0x30, 0x30, 0x3E, 0x3F, 0x63, 0x63, 0x63, 0x66, 0xFE,
  0xFC, 0x3E, 0xFF, 0x86, 0x0C, 0x18, 0x3F, 0x3E, 0x00, 0x80, 0xC0, 0x60,
  0x61, 0xF1, 0xF9, 0x8C, 0xCC, 0xE6, 0x73, 0x1F, 0x8F, 0xC0, 0x3C, 0xFF,
  0x1E, 0x7F, 0xD8, 0x3F, 0x3E, 0x01, 0xC1, 0xF0, 0x60, 0x18, 0x1F, 0x8F,
  0xE0, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x3C, 0x0E, 0x00,
  0x0F, 0x8F, 0xCC, 0x66, 0x33, 0x31, 0x98, 0xFC, 0x06, 0x06, 0x3F, 0x3E,
  0x00, 0x08, 0x18, 0x30, 0x30, 0x3E, 0x3F, 0x73, 0x67, 0x66, 0x66, 0xE6,
  0xCE, 0x18, 0x61, 0x80, 0x7B, 0xE3, 0x0C, 0x30, 0xC3, 0xCF, 0x01, 0x01,
  0xC0, 0xC0, 0x01, 0xF0, 0xF8, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x81, 0xC4,
  0xC7, 0xE1, 0xE0, 0x08, 0x0C, 0x06, 0x06, 0x03, 0x39, 0xB8, 0xF8, 0xF0,
  0x7C, 0x36, 0x19, 0x98, 0xC0, 0xF7, 0x8C, 0x67, 0x31, 0x8C, 0xE6, 0x3E,
  0xF0, 0x3F, 0x7F, 0x6B, 0x4B, 0x5B, 0xC2, 0xC2, 0xC6, 0x3E, 0x3F, 0x73,
  0x67, 0x66, 0x66, 0xE6, 0xCE, 0x1E, 0x3F, 0x63, 0x63, 0x63, 0xE6, 0x7E,
  0x7C, 0x1F, 0x0F, 0xCC, 0x66, 0x33, 0x19, 0x99, 0xFC, 0xFC, 0x60, 0x30,
  0x30, 0x00, 0x3E, 0xFF, 0x1E, 0x3C, 0xD9, 0xBF, 0x7E, 0x18, 0x30, 0x60,
  0x3E, 0xFD, 0x83, 0x0C, 0x18, 0x30, 0x60, 0x1F, 0x3E, 0x30, 0x38, 0x1E,
  0x06, 0x7E, 0xFC, 0x18, 0x61, 0xFF, 0xF3, 0x0C, 0x18, 0x30, 0x7C, 0x78,
  0x67, 0xCF, 0x1E, 0x6C, 0xD9, 0xBF, 0x7E, 0xC7, 0xC6, 0xC6, 0xCC, 0x7C,
  0x78, 0x70, 0x70, 0x61, 0xB0, 0xD2, 0x4B, 0x65, 0xF3, 0xF3, 0xB9, 0x98,
  0x73, 0x9B, 0x8D, 0x83, 0x81, 0xC1, 0xE1, 0x99, 0x8C, 0x31, 0xCC, 0x63,
  0x98, 0x6C, 0x1B, 0x07, 0x81, 0xE0, 0x70, 0x18, 0x3C, 0x0E, 0x00, 0x3F,
  0x3F, 0x0E, 0x1C, 0x38, 0x30, 0x7E, 0xFE, 0x07, 0x0F, 0x18, 0x18, 0x18,
  0x10, 0x30, 0xE0, 0x60, 0x30, 0x60, 0x60, 0x60, 0x78, 0x38, 0x0C, 0x31,
  0x86, 0x18, 0x63, 0x8C, 0x30, 0xC7, 0x18, 0x61, 0x8E, 0x00, 0x0E, 0x1E,
  0x03, 0x06, 0x06, 0x06, 0x06, 0x03, 0x0E, 0x0C, 0x0C, 0x08, 0x18, 0x78,
  0xF0, 0x31, 0x7F, 0xCE,
};

const GFXglyph UbuntuSansMono_BoldItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 10, 8, 2, -10 },
  { 8, 6, 4, 8, 3, -11 },
  { 11, 9, 10, 8, 0, -10 },
  { 23, 8, 14, 8, 0, -12 },
  { 37, 11, 11, 8, -1, -11 },
  { 53, 8, 11, 8, 0, -11 },
  { 64, 3, 5, 8, 4, -11 },
  { 66, 6, 15, 8, 2, -12 },
  { 78, 7, 15, 8, 0, -12 },
  { 92, 7, 6, 8, 1, -10 },
  { 98, 8, 7, 8, 0, -8 },
  { 105, 4, 6, 8, 1, -3 },
  { 108, 5, 2, 8, 2, -5 },
  { 110, 3, 3, 8, 2, -3 },
  { 112, 10, 15, 8, -1, -12 },
  { 131, 7, 11, 8, 1, -11 },
  { 141, 7, 10, 8, 0, -10 },
  { 150, 8, 11, 8, 0, -11 },
  { 161, 8, 11, 8, 0, -11 },
  { 172, 9, 10, 8, 0, -10 },
  { 184, 9, 10, 8, 0, -10 },
  { 196, 8, 10, 8, 1, -10 },
  { 206, 8, 10, 8, 1, -10 },
  { 216, 8, 11, 8, 0, -11 },
  { 227, 8, 11, 8, 0, -11 },
  { 238, 4, 8, 8, 2, -8 },
  { 242, 5, 11, 8, 1, -8 },
  { 249, 7, 7, 8, 1, -8 },
  { 256, 8, 5, 8, 0, -7 },
  { 261, 8, 7, 8, 0, -8 },
  { 268, 6, 11, 8, 2, -11 },
  { 277, 9, 13, 8, 0, -11 },
  { 292, 8, 10, 8, -1, -10 },
  { 302, 8, 11, 8, 0, -11 },
  { 313, 8, 11, 8, 1, -11 },
  { 324, 8, 11, 8, 0, -11 },
  { 335, 9, 10, 8, 0, -10 },
  { 347, 9, 10, 8, 0, -10 },
  { 359, 8, 11, 8, 1, -11 },
  { 370, 9, 10, 8, 0, -10 },
  { 382, 9, 10, 8, 0, -10 },
  { 394, 9, 10, 8, 0, -10 },
  { 406, 10, 10, 8, 0, -10 },
  { 419, 7, 10, 8, 0, -10 },
  { 428, 10, 10, 8, -1, -10 },
  { 441, 9, 10, 8, 0, -10 },
  { 453, 8, 11, 8, 0, -11 },
  { 464, 9, 11, 8, 0, -11 },
  { 477, 7, 14, 8, 1, -11 },
  { 490, 8, 11, 8, 0, -11 },
  { 501, 9, 11, 8, 0, -11 },
  { 514, 8, 10, 8, 2, -10 },
  { 524, 9, 10, 8, 0, -10 },
  { 536, 8, 10, 8, 2, -10 },
  { 546, 10, 10, 8, 0, -10 },
  { 559, 11, 10, 8, -1, -10 },
  { 573, 8, 10, 8, 2, -10 },
  { 583, 9, 10, 8, 0, -10 },
  { 595, 8, 15, 8, 1, -12 },
  { 610, 3, 15, 8, 3, -12 },
  { 616, 8, 15, 8, 0, -12 },
  { 631, 7, 6, 8, 1, -10 },
  { 637, 8, 2, 8, -1, 1 },
  { 639, 4, 4, 8, 3, -12 },
  { 641, 8, 8, 8, 0, -8 },
  { 649, 8, 12, 8, 0, -12 },
  { 661, 7, 8, 8, 1, -8 },
  { 668, 9, 12, 8, 0, -12 },
  { 682, 7, 8, 8, 1, -8 },
  { 689, 10, 15, 8, -1, -12 },
  { 708, 9, 11, 8, -1, -8 },
  { 721, 8, 12, 8, 0, -12 },
  { 733, 6, 12, 8, 1, -12 },
  { 742, 9, 15, 8, -1, -12 },
  { 759, 9, 12, 8, 0, -12 },
  { 773, 5, 12, 8, 2, -12 },
  { 781, 8, 8, 8, 0, -8 },
  { 789, 8, 8, 8, 0, -8 },
  { 797, 8, 8, 8, 0, -8 },
  { 805, 9, 11, 8, -1, -8 },
  { 818, 7, 11, 8, 1, -8 },
  { 828, 7, 8, 8, 1, -8 },
  { 835, 8, 8, 8, 0, -8 },
  { 843, 7, 10, 8, 1, -10 },
  { 852, 7, 8, 8, 1, -8 },
  { 859, 8, 8, 8, 1, -8 },
  { 867, 9, 8, 8, 0, -8 },
  { 876, 9, 8, 8, 0, -8 },
  { 885, 10, 11, 8, -1, -8 },
  { 899, 8, 8, 8, 0, -8 },
  { 907, 8, 15, 8, 1, -12 },
  { 922, 6, 15, 8, 1, -12 },
  { 934, 8, 15, 8, -1, -12 },
  { 949, 8, 3, 8, 0, -6 },
};

const GFXfont UbuntuSansMono_BoldItalic15pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic15pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic15pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _UBUNTUSANSMONO_BOLDITALIC15PT7B_H_
