#ifndef _UBUNTUSANSMONO_BOLDITALIC39PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xC0, 0xF8, 0x02, 0x00, 0x7E, 0x3F, 0x7E, 0x3E, 0x7E,
  0x7E, 0x7C, 0x7E, 0xFC, 0x7E, 0xFC, 0x7C, 0xF8, 0x7C, 0xF8, 0x7C, 0xF8,
  0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xE0, 0xF0, 0xE0, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0x87, 0x80,
  0x1F, 0x1F, 0x00, 0x3C, 0x3C, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0xF8,
  0xF8, 0x01, 0xE1, 0xE0, 0x07, 0xC7, 0xC0, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x83, 0xE3, 0xE0, 0x07, 0x87, 0x80,
  0x0F, 0x0F, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x78, 0x01, 0xF1, 0xF0, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFE, 0x07, 0xF0, 0x70, 0x1F, 0x00, 0x40, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x08, 0x01, 0xF8, 0x38, 0x0F, 0xE1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x3F, 0x80, 0x78, 0x1F,
  0xF0, 0x3C, 0x0F, 0x3C, 0x1E, 0x03, 0xCF, 0x0F, 0x00, 0xE3, 0xC3, 0x80,
  0x38, 0xE1, 0xE0, 0x1E, 0x38, 0xF0, 0x07, 0x9E, 0x78, 0x01, 0xFF, 0x3C,
  0x00, 0x3F, 0xDE, 0x00, 0x0F, 0xEF, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xF8, 0x00, 0x3C, 0xFF, 0x00,
  0x1E, 0x7B, 0xC0, 0x07, 0x9C, 0x70, 0x03, 0xCF, 0x1C, 0x01, 0xE3, 0xC7,
  0x00, 0xF0, 0xE3, 0xC0, 0x78, 0x38, 0xF0, 0x3C, 0x0E, 0x38, 0x0F, 0x03,
  0xFE, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x3F,
  0x3E, 0x01, 0xF0, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0xC3, 0xE0,
  0x3E, 0x3E, 0x01, 0xF3, 0xE0, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x01, 0xFE,
  0x20, 0x1F, 0xC1, 0xE1, 0xFF, 0x0F, 0x1F, 0xFC, 0xF9, 0xF3, 0xE7, 0x9F,
  0x0F, 0xFC, 0xF0, 0x7F, 0xCF, 0x81, 0xFC, 0x7C, 0x07, 0xE3, 0xE0, 0x3F,
  0x1F, 0x83, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFE, 0xF8, 0x3F,
  0xC3, 0xE0, 0x7E, 0xFD, 0xFB, 0xEF, 0xDF, 0xBF, 0x7C, 0xF9, 0xE3, 0xC7,
  0x8E, 0x00, 0x00, 0x01, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x01, 0xF8,
  0x00, 0x78, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x01, 0x07, 0x80, 0x71, 0xE3, 0x1F, 0x73, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0x7F, 0xFF, 0xC0, 0xF8, 0x00, 0x7F, 0x00, 0x3D, 0xF0, 0x1F, 0x7E, 0x0F,
  0xCF, 0xC3, 0xE3, 0xE0, 0x38, 0x70, 0x04, 0x18, 0x00, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x87, 0xF1,
  0xFC, 0x7F, 0x3F, 0xC7, 0xF1, 0xFC, 0x1E, 0x07, 0x87, 0xCF, 0xE3, 0xF0,
  0xF0, 0x20, 0x00, 0x3F, 0xFD, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0xFF, 0xF8,
  0x3E, 0x7F, 0x7F, 0x7F, 0xFF, 0x7F, 0x7E, 0x10, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0xFF, 0x07, 0xF0, 0xF8, 0x3E, 0x07, 0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF9,
  0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x61, 0xF7, 0xE7, 0x8F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x71, 0xF3, 0xE0, 0x1F, 0x1E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7C, 0x3E, 0x07, 0xE1, 0xF0, 0x3E,
  0x0F, 0xC7, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF8,
  0x03, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F,
  0x3F, 0x03, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x05, 0xFF, 0xFE, 0x7F,
  0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0x87, 0xE0, 0x30,
  0x0F, 0xC0, 0x80, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF1, 0x00, 0x1F, 0x8E,
  0x03, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80,
  0x1F, 0x7C, 0x00, 0xF9, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x01, 0xF0,
  0xF8, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3E, 0x0F, 0x81, 0xF0,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x08, 0x00, 0xFC, 0x1C, 0x07,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xF0, 0x3F, 0x1F, 0x00, 0xF8, 0xF8, 0x07,
  0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7E,
  0x07, 0xE3, 0xF8, 0x7E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xE0, 0x7F, 0xFF, 0x87, 0xE0, 0xFC, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x7C, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0xCF, 0xC0, 0x7F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0x1F, 0xC1, 0xF0,
  0x7E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3,
  0xF0, 0x1F, 0x1F, 0x81, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xC1, 0xF8, 0x7C,
  0x07, 0xC7, 0xE0, 0x3F, 0x3E, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E,
  0x7C, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0xC3, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xFC,
  0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xC1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x1F, 0xC3, 0xF8, 0x7F, 0x1F, 0xE1, 0xFC, 0x3F,
  0x01, 0x00, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC,
  0x07, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x78,
  0x03, 0xC0, 0x7C, 0x1F, 0xC0, 0xFC, 0x07, 0x80, 0x20, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xF0, 0x3F,
  0xFE, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x02, 0x00, 0x1F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x08, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00,
  0x1F, 0xE0, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F,
  0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF0,
  0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF1, 0xC1, 0xFC, 0x80,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x01, 0x00, 0x00,
  0x00, 0x06, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07,
  0xF0, 0xF8, 0x3F, 0x01, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00,
  0x7C, 0xF0, 0x7F, 0xF3, 0xC3, 0xFF, 0x9E, 0x1F, 0xFE, 0x78, 0xFF, 0xF9,
  0xE3, 0xE3, 0xEF, 0x9F, 0x0F, 0x3C, 0x7C, 0x3C, 0xF1, 0xE1, 0xF3, 0xC7,
  0x87, 0xCF, 0x1E, 0x1E, 0x3C, 0xF8, 0x78, 0xF3, 0xE3, 0xE3, 0xC7, 0x8F,
  0x8F, 0x1F, 0xFE, 0x3C, 0x7F, 0xF0, 0xF0, 0xFF, 0xC3, 0xC1, 0xFF, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x04, 0x03, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF8, 0x03, 0xC7,
  0xC0, 0x3E, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x0F,
  0x83, 0xE0, 0x7C, 0x1F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0x80, 0x7C, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0x7E, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3E, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xE1, 0xFC, 0x1F,
  0x03, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0xF8, 0x3E, 0x07,
  0xE0, 0xF8, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01,
  0xFF, 0xFE, 0x07, 0xC1, 0xFC, 0x3F, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0xC7, 0xC1, 0xFE,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xF8, 0x38, 0x3F, 0x00, 0x43, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x04,
  0x0F, 0xE0, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x1F,
  0xFC, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0x7C, 0x7F, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xE1,
  0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3F, 0x01,
  0xF1, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x07, 0xE7, 0xE0, 0x3F, 0x3F,
  0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xFC, 0xFC, 0x0F, 0xC7, 0xE0, 0xFE,
  0x3E, 0x0F, 0xE1, 0xF3, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x07, 0xF8, 0x38, 0x7F, 0x00, 0x43, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x1F, 0x9F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E,
  0x3E, 0x03, 0xF1, 0xF0, 0x1F, 0x8F, 0x80, 0xF8, 0x7E, 0x07, 0xC3, 0xF0,
  0x7E, 0x1F, 0xC3, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x01,
  0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x03, 0xE0,
  0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x04, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x06, 0x03, 0xF0, 0x1E, 0x0F, 0xE0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0xF0, 0x3F, 0x81, 0xF0, 0x3F, 0x80, 0xF8, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x1F, 0x1F, 0xC0, 0x1F,
  0x8F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07, 0xCF, 0xC0, 0x03, 0xEF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x87, 0xC0,
  0x07, 0xC3, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7E, 0x01, 0xF0, 0x3F,
  0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x1F, 0xE3,
  0xFC, 0x0F, 0x71, 0xFC, 0x07, 0xB9, 0xFE, 0x07, 0xDC, 0xEF, 0x03, 0xCE,
  0xF7, 0x81, 0xE7, 0x77, 0xC0, 0xF3, 0xF3, 0xC0, 0xF9, 0xF9, 0xE0, 0x78,
  0xF8, 0xF0, 0x3C, 0x7C, 0xF8, 0x3E, 0x3C, 0x7C, 0x1F, 0x00, 0x3C, 0x0F,
  0x80, 0x1E, 0x07, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xFC,
  0x03, 0xC0, 0x7F, 0x03, 0xE0, 0x3F, 0x81, 0xF0, 0x1F, 0xC0, 0xF8, 0x1F,
  0xE0, 0x78, 0x0F, 0xF8, 0x7C, 0x07, 0xFC, 0x3E, 0x03, 0xDE, 0x1F, 0x03,
  0xE7, 0x8F, 0x01, 0xF3, 0xCF, 0x80, 0xF9, 0xE7, 0xC0, 0x78, 0xF3, 0xE0,
  0x7C, 0x39, 0xE0, 0x3E, 0x1F, 0xF0, 0x1F, 0x0F, 0xF8, 0x0F, 0x87, 0xFC,
  0x07, 0x83, 0xFC, 0x07, 0xC0, 0xFE, 0x03, 0xE0, 0x7F, 0x01, 0xF0, 0x3F,
  0x80, 0xF0, 0x1F, 0xC0, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF1, 0xF8, 0x3F, 0x07, 0xE3,
  0xF0, 0x3F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03,
  0xF7, 0xE0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x03, 0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x0F, 0xC7, 0xF0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7E, 0x3F,
  0xC0, 0xFC, 0x1F, 0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x3F, 0x83,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xF1, 0xF8, 0x3F, 0x07, 0xE3, 0xF0,
  0x3F, 0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xF7,
  0xE0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x03,
  0xF7, 0xE0, 0x1F, 0xBF, 0x00, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E,
  0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0xC7, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x20, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07,
  0xE1, 0xF8, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0,
  0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x9F, 0xF0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xF8,
  0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xE0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x8F,
  0x80, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0x80, 0xC0, 0x7C, 0x01, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x82, 0x00, 0x7E, 0x1E, 0x03, 0xF0, 0x7F, 0xFF, 0xC3,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x0F,
  0xC3, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF8,
  0x3E, 0x03, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0x1F, 0x83, 0xE0, 0x3F, 0x07,
  0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0xF8,
  0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x83,
  0xF0, 0x3F, 0x8F, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x7D, 0xF8, 0x07, 0xEF, 0xC0, 0x3E, 0x7E, 0x03, 0xF3, 0xF0,
  0x1F, 0x1F, 0x80, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x3F, 0x07, 0xC0,
  0xF8, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x8F,
  0x80, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC1, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80,
  0x1E, 0x07, 0x8F, 0x8F, 0x03, 0xC7, 0xCF, 0x83, 0xE7, 0xE7, 0xC1, 0xF3,
  0xF3, 0xC0, 0xF3, 0xF9, 0xE0, 0x79, 0xDD, 0xF0, 0x3D, 0xCE, 0xF0, 0x1E,
  0xE7, 0x78, 0x1E, 0xE3, 0xBC, 0x0F, 0x71, 0xDE, 0x07, 0xF0, 0xFE, 0x03,
  0xF8, 0x7F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x01, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC3, 0xF0,
  0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x01,
  0xF9, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x03, 0xF8,
  0x03, 0xE0, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80,
  0xFC, 0xF8, 0x0F, 0xCF, 0xC1, 0xF8, 0x7C, 0x1F, 0x07, 0xC3, 0xF0, 0x7C,
  0x7E, 0x07, 0xC7, 0xC0, 0x3E, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x40,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xF8, 0x7E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xC7, 0xE1,
  0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFC, 0x7E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0xC7,
  0xE1, 0xF0, 0xF8, 0x7C, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xEF, 0x80, 0xFC, 0xFC, 0x0F, 0xC7, 0xC1, 0xF8, 0x7C, 0x3F, 0x07, 0xE7,
  0xE0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x3F, 0x38, 0x01, 0xC1, 0x00, 0x10,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x20,
  0x3C, 0x1F, 0x1F, 0xC7, 0xF8, 0xFC, 0x1C, 0x02, 0x00, 0x7F, 0x80, 0x1F,
  0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xF8, 0x3E, 0x3F,
  0x03, 0xE7, 0xE0, 0x7E, 0x7C, 0x07, 0xE7, 0xC0, 0x7C, 0xFC, 0x07, 0xCF,
  0xC0, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xFC, 0x0F, 0x8F, 0xC1, 0xF8,
  0xFE, 0x3F, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0x7C, 0x1F, 0xE7,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7D, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0x83, 0xF1, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01,
  0xF3, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x3F, 0x3E, 0x03, 0xE7, 0xE0,
  0x7E, 0x7E, 0x0F, 0xC7, 0xC1, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0xFE, 0x07, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0x07, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xE0, 0xF8, 0x1F, 0x81, 0xF0, 0x7E, 0x07,
  0xE0, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C,
  0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x81,
  0xFC, 0x7F, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0x7C, 0x03,
  0xFC, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xF3, 0xFC, 0x7E, 0x7E, 0x07, 0xDF, 0x80, 0xFB, 0xE0, 0x1F, 0xF8, 0x07,
  0xFF, 0x07, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFE, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x03, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0x8C, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFF,
  0xFE, 0x03, 0xFE, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x23,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x20, 0x0F, 0xC0, 0x3C, 0x3F,
  0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0x83, 0xF0, 0xF8, 0x1F, 0x1F, 0x81, 0xF1, 0xF8, 0x3F, 0x1F, 0x03,
  0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0,
  0x7C, 0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7, 0xC0, 0xF8, 0x7C,
  0x0F, 0x8F, 0xC1, 0xF8, 0x00, 0x30, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xC3, 0xFF, 0x87, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x08, 0x7F, 0xF0, 0xFF, 0xE0, 0xFF,
  0xC0, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFE,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x20, 0x3F, 0x00, 0xF3, 0xF8,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x03, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x0F, 0x87, 0xE0,
  0x3E, 0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x1F, 0x7E, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xF0,
  0x03, 0xE7, 0xE0, 0x1F, 0x8F, 0x80, 0x7C, 0x3F, 0x01, 0xF0, 0x7C, 0x07,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3F, 0x00, 0x7F,
  0xF7, 0xFF, 0x3F, 0xF9, 0xFF, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xF0, 0xDF, 0xFE, 0xFF, 0xF3, 0xFF, 0x8F, 0xF8,
  0x00, 0xF0, 0x70, 0x1F, 0xF7, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F,
  0x9F, 0x3C, 0x3C, 0x78, 0xF0, 0xF1, 0xE3, 0xC3, 0xC7, 0x8F, 0x1F, 0x3E,
  0x7C, 0x78, 0xF1, 0xF1, 0xE3, 0xC7, 0x87, 0x8F, 0x1E, 0x3E, 0x7C, 0xF8,
  0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x7C, 0x00, 0xF1, 0xF0,
  0x07, 0xC7, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0xF8, 0x03, 0xE0, 0x00, 0xFF,
  0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xF8,
  0x3F, 0x0F, 0x81, 0xF1, 0xF8, 0x1F, 0x1F, 0x83, 0xF1, 0xF0, 0x3F, 0x1F,
  0x03, 0xE1, 0xF0, 0x3E, 0x3F, 0x07, 0xE3, 0xE0, 0x7E, 0x3E, 0x07, 0xC3,
  0xE0, 0x7C, 0x7E, 0x07, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0x87, 0xC0, 0xF8,
  0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF,
  0xF1, 0xFF, 0xFE, 0x7F, 0x0F, 0xCF, 0xC0, 0xFB, 0xF0, 0x1F, 0x7C, 0x03,
  0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xBF, 0x03, 0xF7, 0xE0, 0x7E, 0xFE, 0x3F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8,
  0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFB, 0xFC, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC1, 0xF8, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0,
  0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0, 0xF8,
  0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x0F, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0xFF, 0xE3, 0xF0, 0x7E, 0x7E, 0x07, 0xC7, 0xC0, 0x7C, 0xFC, 0x07, 0xCF,
  0x80, 0xFC, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81, 0xF8,
  0xF8, 0x1F, 0x8F, 0x81, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE,
  0x07, 0xE0, 0x10, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF,
  0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xF3, 0xE0, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC2, 0x00, 0x7C, 0x38,
  0x0F, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0x2E, 0x00, 0x00, 0x10, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFF, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE1, 0x81, 0xFF, 0xF0, 0x1F,
  0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F, 0x03, 0xE7, 0xE0, 0x7C,
  0xFC, 0x1F, 0x9F, 0x03, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x9F, 0x83, 0xF3,
  0xE0, 0x7E, 0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xF0, 0x3E, 0x7E, 0x0F, 0xCF,
  0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xC1, 0xF8, 0xFC, 0xFF, 0x1F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xFC, 0xF8, 0xFC, 0x03, 0xFF,
  0xC0, 0x7E, 0xFC, 0x07, 0xEF, 0xC0, 0x7C, 0xFC, 0x0F, 0xCF, 0xC0, 0xF8,
  0xFC, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3F, 0x07, 0xC3, 0xE0, 0x7C, 0x7E,
  0x07, 0xC7, 0xC0, 0x7C, 0xFC, 0x07, 0xEF, 0x80, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x79, 0xF0, 0x01, 0xF3, 0xE0,
  0x03, 0xE7, 0xC0, 0x07, 0x8F, 0x8F, 0x0F, 0x1E, 0x1E, 0x3E, 0x3C, 0x7C,
  0x78, 0x78, 0xF8, 0xF0, 0xF3, 0xF1, 0xE1, 0xE7, 0xE7, 0x83, 0xDF, 0xCF,
  0x0F, 0x3B, 0x9E, 0x1E, 0xF7, 0x78, 0x3D, 0xCF, 0xF0, 0x7F, 0x9F, 0xC0,
  0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F,
  0x81, 0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0xFC, 0x1F, 0x83, 0xF0,
  0x1F, 0x07, 0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x7E, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xE7,
  0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x0F, 0xC0, 0xFC, 0x1F, 0x83, 0xF0, 0x1F,
  0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x7E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x87, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0x00, 0x00, 0xFE, 0x07,
  0xCF, 0xFC, 0x3C, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xC1,
  0xFF, 0x1E, 0x07, 0xE0,
};

const GFXglyph UbuntuSansMono_BoldItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 12, 28, 22, 6, -27 },
  { 43, 16, 13, 22, 7, -30 },
  { 69, 23, 27, 22, 0, -27 },
  { 147, 22, 34, 22, 0, -30 },
  { 241, 26, 29, 22, -1, -28 },
  { 336, 21, 28, 22, 0, -28 },
  { 410, 7, 13, 22, 11, -30 },
  { 422, 18, 38, 22, 4, -31 },
  { 508, 18, 38, 22, 0, -31 },
  { 594, 18, 17, 22, 4, -27 },
  { 633, 20, 19, 22, 1, -21 },
  { 681, 10, 14, 22, 3, -7 },
  { 699, 14, 5, 22, 4, -14 },
  { 708, 8, 8, 22, 5, -7 },
  { 716, 26, 38, 22, -2, -31 },
  { 840, 21, 29, 22, 1, -28 },
  { 917, 18, 27, 22, 1, -27 },
  { 978, 22, 28, 22, 0, -28 },
  { 1055, 21, 29, 22, 0, -28 },
  { 1132, 22, 27, 22, 0, -27 },
  { 1207, 23, 28, 22, 0, -27 },
  { 1288, 21, 28, 22, 2, -27 },
  { 1362, 20, 27, 22, 4, -27 },
  { 1430, 21, 29, 22, 1, -28 },
  { 1507, 21, 28, 22, 1, -28 },
  { 1581, 11, 21, 22, 5, -20 },
  { 1610, 13, 27, 22, 3, -20 },
  { 1654, 20, 19, 22, 2, -21 },
  { 1702, 22, 13, 22, 0, -18 },
  { 1738, 20, 19, 22, 1, -21 },
  { 1786, 17, 29, 22, 5, -28 },
  { 1848, 22, 34, 22, 1, -28 },
  { 1942, 21, 27, 22, -2, -27 },
  { 2013, 22, 27, 22, 0, -27 },
  { 2088, 21, 29, 22, 2, -28 },
  { 2165, 21, 27, 22, 0, -27 },
  { 2236, 22, 27, 22, 1, -27 },
  { 2311, 23, 27, 22, 1, -27 },
  { 2389, 21, 29, 22, 2, -28 },
  { 2466, 25, 27, 22, -1, -27 },
  { 2551, 24, 27, 22, 0, -27 },
  { 2632, 23, 28, 22, 0, -27 },
  { 2713, 25, 27, 22, 0, -27 },
  { 2798, 18, 27, 22, 0, -27 },
  { 2859, 25, 27, 22, -1, -27 },
  { 2944, 25, 27, 22, -1, -27 },
  { 3029, 21, 29, 22, 1, -28 },
  { 3106, 23, 27, 22, 0, -27 },
  { 3184, 21, 35, 22, 1, -28 },
  { 3276, 22, 27, 22, 0, -27 },
  { 3351, 22, 29, 22, 0, -28 },
  { 3431, 21, 27, 22, 4, -27 },
  { 3502, 23, 28, 22, 1, -27 },
  { 3583, 21, 27, 22, 4, -27 },
  { 3654, 25, 27, 22, 0, -27 },
  { 3739, 27, 27, 22, -2, -27 },
  { 3831, 20, 27, 22, 5, -27 },
  { 3899, 23, 27, 22, 0, -27 },
  { 3977, 21, 38, 22, 2, -31 },
  { 4077, 9, 38, 22, 7, -31 },
  { 4120, 21, 38, 22, -1, -31 },
  { 4220, 20, 16, 22, 2, -27 },
  { 4260, 21, 4, 22, -3, 3 },
  { 4271, 9, 8, 22, 9, -30 },
  { 4280, 20, 21, 22, 1, -21 },
  { 4333, 20, 31, 22, 0, -30 },
  { 4411, 20, 21, 22, 2, -21 },
  { 4464, 23, 30, 22, 1, -30 },
  { 4551, 19, 22, 22, 2, -21 },
  { 4604, 27, 37, 22, -3, -30 },
  { 4729, 24, 28, 22, -2, -21 },
  { 4813, 20, 30, 22, 0, -30 },
  { 4888, 15, 31, 22, 3, -31 },
  { 4947, 22, 38, 22, -2, -31 },
  { 5052, 22, 30, 22, 1, -30 },
  { 5135, 13, 30, 22, 5, -30 },
  { 5184, 22, 21, 22, -1, -21 },
  { 5242, 20, 21, 22, 0, -21 },
  { 5295, 19, 22, 22, 1, -21 },
  { 5348, 22, 28, 22, -2, -21 },
  { 5425, 20, 28, 22, 2, -21 },
  { 5495, 21, 21, 22, 1, -21 },
  { 5551, 20, 22, 22, 0, -21 },
  { 5606, 19, 27, 22, 3, -27 },
  { 5671, 19, 21, 22, 2, -21 },
  { 5721, 20, 21, 22, 3, -21 },
  { 5774, 23, 21, 22, 1, -21 },
  { 5835, 23, 21, 22, -1, -21 },
  { 5896, 26, 28, 22, -4, -21 },
  { 5987, 22, 21, 22, 0, -21 },
  { 6045, 21, 38, 22, 3, -31 },
  { 6145, 14, 38, 22, 4, -31 },
  { 6212, 20, 38, 22, -1, -31 },
  { 6307, 21, 8, 22, 1, -16 },
};

const GFXfont UbuntuSansMono_BoldItalic39pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic39pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic39pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _UBUNTUSANSMONO_BOLDITALIC39PT7B_H_
