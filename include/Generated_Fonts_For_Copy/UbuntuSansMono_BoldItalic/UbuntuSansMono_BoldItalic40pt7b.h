#ifndef _UBUNTUSANSMONO_BOLDITALIC40PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xE0,
  0xFE, 0x0F, 0xC0, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81,
  0xF0, 0x1F, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFC, 0x07, 0xC0, 0x10, 0x00, 0x7E, 0x3F, 0x7E,
  0x3F, 0x7E, 0x3F, 0x7C, 0x3E, 0x7C, 0x7E, 0xFC, 0x7E, 0xF8, 0x7C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0xE0, 0x70, 0x00, 0x1E, 0x1F,
  0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x7C,
  0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x03, 0xE3, 0xE0,
  0x03, 0xC3, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0x87, 0xC0, 0x0F, 0x87, 0x80,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0x3E, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x7C, 0x00,
  0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFD, 0xF8, 0x1F, 0x80,
  0x40, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x20, 0x03, 0xE0, 0xE0, 0x1F, 0x87, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0xF0, 0x1F, 0xC0, 0x1E, 0x03, 0xFE, 0x03, 0xC0, 0x3D, 0xE0, 0x78,
  0x07, 0x8E, 0x0F, 0x00, 0x71, 0xE1, 0xE0, 0x07, 0x1E, 0x3C, 0x00, 0x71,
  0xE3, 0xC0, 0x0F, 0x1C, 0x78, 0x00, 0xF3, 0xCF, 0x00, 0x07, 0xF9, 0xE0,
  0x00, 0x7F, 0xBC, 0x00, 0x03, 0xF7, 0x80, 0x00, 0x08, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x3C, 0xFE, 0x00, 0x07, 0x9F,
  0xF0, 0x00, 0xF3, 0xCF, 0x00, 0x0F, 0x3C, 0xF0, 0x01, 0xE3, 0x8F, 0x00,
  0x3C, 0x78, 0xF0, 0x07, 0x87, 0x8E, 0x00, 0xF0, 0x79, 0xE0, 0x1E, 0x07,
  0x9E, 0x01, 0xE0, 0x7F, 0xC0, 0x3C, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x7F, 0xFC, 0x03, 0xE1, 0xF0, 0x0F, 0x87, 0xC0, 0x3C, 0x1F, 0x00,
  0xF0, 0x78, 0x07, 0xC3, 0xE0, 0x0F, 0x1F, 0x00, 0x3C, 0xF8, 0x00, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0xE0, 0x7F, 0x87, 0xC3, 0xFF, 0x1E,
  0x1F, 0x7C, 0xF8, 0xF8, 0xFB, 0xE7, 0xC3, 0xFF, 0x1F, 0x07, 0xF8, 0xF8,
  0x0F, 0xE3, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x3F, 0x07, 0xF8, 0x7F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0x9F, 0x07, 0xF8, 0x7C, 0x7F, 0x7E, 0x7E,
  0x7E, 0x7C, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8, 0xF0, 0xF0, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00,
  0x30, 0x00, 0x04, 0x00, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x61, 0xE1, 0x9E, 0x79, 0xE7,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0x00, 0x1F,
  0xE0, 0x0F, 0xFE, 0x07, 0xCF, 0x83, 0xF3, 0xF0, 0x78, 0x78, 0x0E, 0x1C,
  0x01, 0x02, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F, 0xF1, 0xFC,
  0x3F, 0x83, 0xF0, 0x3E, 0x07, 0x83, 0xF3, 0xFC, 0x7F, 0x0F, 0x81, 0x80,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xEF, 0xFF, 0x00, 0x7E, 0xFE,
  0xFE, 0xFF, 0xFE, 0xFE, 0x7C, 0x10, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xE7, 0xF1, 0xF8,
  0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0, 0x1F, 0x7C,
  0x01, 0xF7, 0xC7, 0x1F, 0xFC, 0xF9, 0xFF, 0x8F, 0x9F, 0xF9, 0xF1, 0xFF,
  0x8F, 0x3E, 0xF8, 0x43, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF, 0x80, 0x7C,
  0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x8F, 0xC7, 0xF0, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xFF,
  0xE1, 0xFF, 0xF8, 0x3F, 0xFC, 0x0F, 0x9F, 0x03, 0x8F, 0xC0, 0x83, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x81, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0xFB, 0xFC, 0x0E, 0x03, 0xF0, 0x30, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xE1, 0xFC, 0x04, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x84, 0x00, 0x7E, 0x1C, 0x07,
  0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F,
  0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xE0, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x10, 0x01, 0xF8, 0x3C, 0x0F, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x83, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFB, 0xFE, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0x80, 0xFC, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0x3E,
  0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03, 0xE3, 0xF0, 0x3F,
  0x0F, 0xC3, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xE1, 0xF8, 0x3F, 0x03, 0xE0,
  0xF8, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xE0, 0xFC,
  0x3F, 0x01, 0xFD, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x07, 0xFF, 0xE0, 0x3F, 0x1F, 0xC1, 0xF8, 0x1F, 0x87, 0xC0, 0x7E, 0x3F,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0x03,
  0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE1, 0xFC, 0x7F, 0x0F, 0xC0, 0xFC, 0x7C, 0x07, 0xE7, 0xE0, 0x1F,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7E, 0x01, 0xF3, 0xF0,
  0x0F, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFE, 0x07, 0xFD, 0xF0,
  0x02, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0x83, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x87, 0xF0, 0xFE, 0x1F, 0xE3, 0xF8, 0x7F, 0x07, 0xC0, 0x20, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x1F,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFC, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x00, 0x78, 0x07, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0x80, 0x30,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x0F,
  0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0x00, 0x03,
  0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE0,
  0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xF3, 0xE3, 0xF8,
  0x80, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0x80,
  0x01, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0xFF, 0xFF, 0x07, 0xE0, 0x7C, 0x3E, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0xC0,
  0x0F, 0x3E, 0x07, 0xFC, 0xF0, 0x7F, 0xF3, 0xC3, 0xFF, 0xDE, 0x1F, 0xFF,
  0x78, 0xFE, 0xF9, 0xE3, 0xE3, 0xEF, 0x9F, 0x0F, 0xBC, 0x7C, 0x3E, 0xF1,
  0xE0, 0xF3, 0xC7, 0x87, 0xCF, 0x1E, 0x1F, 0x3C, 0x78, 0x7C, 0xF1, 0xE1,
  0xE3, 0xC7, 0xC7, 0x8F, 0x1F, 0xFE, 0x3C, 0x7F, 0xF8, 0xF0, 0xFF, 0xC3,
  0xE1, 0xFF, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xBE, 0x00,
  0x3E, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3E, 0x3E, 0x00, 0xF8,
  0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3E, 0x00, 0xFD, 0xF8, 0x03,
  0xF7, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7C,
  0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0xFC, 0x1F,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x1F, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0x80,
  0x7E, 0x3E, 0x01, 0xF9, 0xF8, 0x07, 0xC7, 0xE0, 0x3F, 0x1F, 0x87, 0xFC,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFD,
  0xF8, 0x3F, 0x80, 0x40, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x08, 0x1F, 0xE1, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0x87, 0xE0,
  0x7C, 0x0F, 0xC1, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xF8,
  0x0F, 0xC3, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF0, 0x0F,
  0xC7, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xE0, 0x1F, 0x8F,
  0x80, 0xFC, 0x7E, 0x07, 0xF1, 0xF8, 0x3F, 0x87, 0xC1, 0xFE, 0x1F, 0x3F,
  0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xFD, 0xF8, 0x3F,
  0x80, 0x41, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x0F, 0x8F,
  0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x0F, 0x80,
  0x7C, 0x3E, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8,
  0x3F, 0xC7, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80,
  0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x0C, 0x07, 0xF0, 0x3E, 0x1F, 0xC0, 0x7F, 0xFF, 0x81,
  0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x38, 0x00, 0x00,
  0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0xC0, 0x7C, 0x0F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0x8F,
  0xE0, 0x0F, 0xCF, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xE7, 0xE0, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3E,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xC7, 0xE0, 0x07,
  0xC3, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x1F, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xFF,
  0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xF0,
  0x3F, 0x83, 0xF8, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x0F, 0x71, 0xFE,
  0x07, 0xB8, 0xEF, 0x03, 0xDC, 0xF7, 0x83, 0xEE, 0x77, 0xC1, 0xE7, 0x7B,
  0xC0, 0xF3, 0xB9, 0xE0, 0x79, 0xFC, 0xF0, 0x7C, 0xFC, 0xF8, 0x3E, 0x7E,
  0x7C, 0x1E, 0x3E, 0x3C, 0x1F, 0x1F, 0x1E, 0x0F, 0x80, 0x1F, 0x07, 0xC0,
  0x0F, 0x83, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0xF8,
  0x01, 0xF0, 0x78, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x80,
  0xF8, 0x0F, 0xE0, 0x3E, 0x03, 0xF8, 0x0F, 0x80, 0xFE, 0x07, 0xC0, 0x3F,
  0xC1, 0xF0, 0x1F, 0xF0, 0x7C, 0x07, 0xFC, 0x1F, 0x01, 0xFF, 0x0F, 0x80,
  0x7D, 0xE3, 0xE0, 0x3E, 0x78, 0xF8, 0x0F, 0x9E, 0x3E, 0x03, 0xE7, 0x8F,
  0x00, 0xF8, 0xF7, 0xC0, 0x7C, 0x3D, 0xF0, 0x1F, 0x0F, 0x7C, 0x07, 0xC3,
  0xDE, 0x01, 0xF0, 0x7F, 0x80, 0x78, 0x1F, 0xE0, 0x3E, 0x07, 0xF8, 0x0F,
  0x81, 0xFC, 0x03, 0xE0, 0x7F, 0x00, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0x07, 0xE1, 0xF8, 0x0F, 0x87, 0xE0, 0x3E, 0x1F, 0x00, 0xFC, 0xFC,
  0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x7E, 0x00, 0xF9, 0xF8, 0x03,
  0xE7, 0xC0, 0x1F, 0x9F, 0x00, 0x7E, 0x7C, 0x01, 0xF3, 0xF0, 0x07, 0xCF,
  0xC0, 0x3F, 0x3F, 0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x87, 0xC0,
  0xFC, 0x1F, 0x8F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFC, 0x1F, 0xC1,
  0xF8, 0x1F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0x7C, 0x3F,
  0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xF8, 0x0F, 0xC1, 0xF0, 0xFF, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0x40,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0xE0, 0xFC, 0x3E, 0x03, 0xE3, 0xF0, 0x1F,
  0x1F, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x01, 0xF7, 0xE0,
  0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xF7,
  0xE0, 0x0F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xCF, 0xC0, 0x7E, 0x7E, 0x03,
  0xE1, 0xF0, 0x3F, 0x0F, 0xC7, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x08, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x0F, 0xC1, 0xF0, 0x1F,
  0x0F, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0xC3, 0xE0, 0x7E, 0x0F,
  0x83, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xE0, 0x3E, 0x0F, 0x81,
  0xF8, 0x3F, 0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xE3, 0xF0,
  0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F, 0x07, 0x80, 0xFC, 0x01,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x08, 0x01,
  0xF8, 0x3E, 0x07, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC1,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3E,
  0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x07, 0xC0,
  0x7E, 0x0F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C, 0x1F, 0x81, 0xF8,
  0x3F, 0x03, 0xF0, 0x3F, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E, 0xFC, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xC1, 0xF0, 0x3F,
  0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0xFC, 0x07,
  0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xCF,
  0x80, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8,
  0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01,
  0xF0, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x81, 0xF1,
  0xE3, 0xE0, 0x78, 0xF8, 0xF8, 0x1E, 0x3E, 0x3C, 0x0F, 0x9F, 0x8F, 0x03,
  0xE7, 0xE7, 0xC0, 0xF3, 0xF9, 0xE0, 0x3C, 0xEE, 0x78, 0x0F, 0x7B, 0x9E,
  0x03, 0xDC, 0xEF, 0x81, 0xEF, 0x3B, 0xC0, 0x7B, 0x8F, 0xF0, 0x1F, 0xE3,
  0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xF8, 0x00,
  0x7C, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x7E,
  0x1F, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0xF8,
  0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0xF8,
  0x01, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0xFD, 0xF0, 0x0F, 0xCF, 0xC0, 0x7C,
  0x3E, 0x07, 0xE1, 0xF0, 0x7E, 0x0F, 0x83, 0xE0, 0x7C, 0x3F, 0x03, 0xE3,
  0xF0, 0x0F, 0x9F, 0x00, 0x7D, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0xF8,
  0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xFC, 0xFC, 0xFC, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3F, 0x3F, 0x3F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7E, 0xFC, 0x0F, 0xC7, 0xC1, 0xF8, 0x7E, 0x3F, 0x87,
  0xE3, 0xF0, 0x3E, 0x7E, 0x03, 0xFF, 0xC0, 0x3F, 0x78, 0x01, 0xF1, 0x80,
  0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0,
  0x20, 0x0E, 0x07, 0xC3, 0xF8, 0xFF, 0x8F, 0xF0, 0xF8, 0x0C, 0x00, 0x04,
  0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F,
  0xF1, 0xF8, 0xFE, 0x0F, 0xC7, 0xE0, 0x7E, 0x7E, 0x03, 0xE3, 0xF0, 0x1F,
  0x1F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7C, 0x7E, 0x03, 0xE3, 0xF0,
  0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC3, 0xF1, 0xFE, 0x1F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xF3, 0xF0, 0x00, 0x78, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0x8F, 0xC1,
  0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0x7E, 0x3E, 0x03,
  0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xF8, 0xFC, 0x07, 0xC7, 0xC0, 0x7E, 0x7E,
  0x07, 0xE3, 0xF0, 0x7F, 0x1F, 0x87, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x30, 0x00, 0x00, 0x0D, 0x00, 0x0F,
  0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE1, 0xFE, 0x0C, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xF8, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0x80, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xF8, 0xFC, 0x1F, 0xC1,
  0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF8, 0x0F, 0x83, 0xE0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xF9, 0xF8, 0x00, 0x00, 0x0C, 0x00,
  0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xF8, 0x3F,
  0x3E, 0x03, 0xF7, 0xE0, 0x3F, 0x7C, 0x03, 0xEF, 0xC0, 0xFE, 0xF8, 0xFF,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0x80, 0xFA, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x30, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xF8, 0x3E, 0x07, 0xF0, 0x3E, 0x07, 0xE0, 0x7E,
  0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0xFC,
  0x0F, 0x80, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC1, 0xF8,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x23, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x20, 0x07, 0xE0,
  0x3C, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x30, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0x8F, 0xE1, 0xF8, 0x3F,
  0x0F, 0x81, 0xF8, 0x7C, 0x0F, 0x87, 0xE0, 0x7C, 0x3F, 0x03, 0xE1, 0xF0,
  0x3F, 0x0F, 0x81, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x3E, 0x07, 0xE1,
  0xF0, 0x3F, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x07,
  0xE3, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0xF0, 0x7F, 0xF0, 0xFF, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE3, 0x0F, 0xFF,
  0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x20, 0x3F, 0x00, 0x70, 0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xF8, 0x7E, 0x0F, 0xC0, 0xFC, 0x3F,
  0x01, 0xF0, 0xFC, 0x03, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x0F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xF0, 0x7E, 0x03, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0x81,
  0xF8, 0x3E, 0x01, 0xF8, 0x00, 0x7F, 0xF1, 0xFF, 0xCF, 0xFF, 0x3F, 0xF8,
  0xFF, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xF1, 0x9F, 0xFF, 0x3F, 0xFC, 0xFF, 0xF1, 0xFF, 0x80,
  0x03, 0xFC, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xF9, 0xF3, 0xE1, 0xE3, 0xE7, 0xC3, 0xC7, 0x8F, 0x8F, 0x8F, 0x1F, 0x1F,
  0x1E, 0x3C, 0x3E, 0x7C, 0x78, 0x78, 0xF1, 0xF0, 0xF1, 0xE3, 0xE3, 0xE3,
  0xC7, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x7C, 0x00,
  0xF0, 0xF8, 0x01, 0xE1, 0xE0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1E,
  0x00, 0x00, 0x04, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x07, 0xF1, 0xFC, 0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x81,
  0xF0, 0xFC, 0x0F, 0x87, 0xE0, 0x7C, 0x3E, 0x07, 0xE1, 0xF0, 0x3F, 0x1F,
  0x81, 0xF0, 0xFC, 0x0F, 0x87, 0xC0, 0xFC, 0x3E, 0x07, 0xE3, 0xF0, 0x3E,
  0x1F, 0x81, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0xFC, 0x7E, 0x07, 0xC0, 0x00,
  0x0C, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1,
  0xFC, 0x7F, 0x3F, 0x03, 0xF3, 0xF0, 0x3F, 0x7E, 0x03, 0xF7, 0xE0, 0x3F,
  0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07,
  0xEF, 0xC0, 0x7C, 0xFC, 0x0F, 0xC7, 0xE3, 0xF8, 0x7F, 0xFF, 0x87, 0xFF,
  0xF0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x00, 0x03, 0x00,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0,
  0x7E, 0x1F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x3E, 0x0F,
  0xC0, 0xFC, 0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xF0, 0xFC, 0x07, 0xC1, 0xF8,
  0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xC0, 0xFC, 0x1F, 0x83, 0xF8, 0x3F, 0x3F,
  0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFC, 0x3E,
  0x3F, 0x03, 0xE7, 0xE0, 0x7E, 0x7C, 0x07, 0xEF, 0xC0, 0x7C, 0xFC, 0x07,
  0xCF, 0x80, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x81,
  0xF8, 0xFC, 0x1F, 0x8F, 0xE3, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x1F, 0xFE, 0x03,
  0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x0C, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x40, 0x0F,
  0x87, 0x81, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF,
  0xC0, 0x01, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xF3, 0xC1, 0xFF,
  0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x1F, 0x03, 0xF3,
  0xF0, 0x3E, 0x3F, 0x03, 0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xE3, 0xE0, 0x7E,
  0x7E, 0x07, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0xC7, 0xC0, 0xFC, 0xFC, 0x0F,
  0x8F, 0xC0, 0xF8, 0xF8, 0x1F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F, 0x8F, 0x83,
  0xF0, 0xFE, 0x7F, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xCF, 0x80, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xEF, 0xC0, 0x7E,
  0xFC, 0x07, 0xCF, 0xC0, 0xFC, 0x7C, 0x0F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F,
  0x07, 0xC3, 0xF0, 0x7C, 0x3E, 0x07, 0xE7, 0xE0, 0x7E, 0xFC, 0x03, 0xEF,
  0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x3E, 0x78, 0x00,
  0x7D, 0xF0, 0x00, 0xF3, 0xE0, 0x03, 0xE7, 0xC3, 0x87, 0xCF, 0x8F, 0x8F,
  0x1E, 0x1F, 0x1E, 0x3C, 0x7E, 0x7C, 0x78, 0xFC, 0xF0, 0xF3, 0xF9, 0xE1,
  0xE7, 0xF3, 0xC3, 0xDF, 0xEF, 0x0F, 0x3B, 0xDE, 0x1E, 0xF3, 0xBC, 0x3D,
  0xC7, 0xF0, 0x7F, 0x8F, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0xF8, 0x03, 0xF1, 0xF8, 0x01,
  0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x80, 0x03, 0xEF, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xC7, 0xE0, 0x1F,
  0x87, 0xE0, 0x3F, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x07,
  0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0,
  0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x01, 0x0F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x80,
  0x40, 0xFF, 0x03, 0xCF, 0xFE, 0x3E, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x7C,
  0xFF, 0xF3, 0xC1, 0xFF, 0x0E, 0x03, 0xF0,
};

const GFXglyph UbuntuSansMono_BoldItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 12, 29, 22, 6, -28 },
  { 45, 16, 12, 22, 7, -30 },
  { 69, 24, 28, 22, 0, -28 },
  { 153, 22, 35, 22, 0, -31 },
  { 250, 28, 29, 22, -2, -28 },
  { 352, 22, 28, 22, 0, -28 },
  { 429, 8, 13, 22, 11, -30 },
  { 442, 18, 40, 22, 4, -32 },
  { 532, 18, 40, 22, 0, -32 },
  { 622, 18, 18, 22, 4, -28 },
  { 663, 20, 20, 22, 1, -22 },
  { 713, 11, 14, 22, 3, -7 },
  { 733, 13, 5, 22, 5, -14 },
  { 742, 8, 8, 22, 6, -7 },
  { 750, 26, 38, 22, -2, -31 },
  { 874, 20, 29, 22, 2, -28 },
  { 947, 18, 28, 22, 1, -28 },
  { 1010, 22, 28, 22, 0, -28 },
  { 1087, 22, 29, 22, 0, -28 },
  { 1167, 23, 28, 22, 0, -28 },
  { 1248, 23, 29, 22, 0, -28 },
  { 1332, 21, 29, 22, 2, -28 },
  { 1409, 21, 28, 22, 4, -28 },
  { 1483, 22, 29, 22, 1, -28 },
  { 1563, 21, 28, 22, 1, -28 },
  { 1637, 11, 22, 22, 6, -21 },
  { 1668, 14, 28, 22, 3, -21 },
  { 1717, 20, 19, 22, 2, -21 },
  { 1765, 22, 13, 22, 0, -18 },
  { 1801, 20, 19, 22, 1, -21 },
  { 1849, 17, 29, 22, 5, -28 },
  { 1911, 22, 34, 22, 1, -28 },
  { 2005, 22, 28, 22, -2, -28 },
  { 2082, 22, 28, 22, 0, -28 },
  { 2159, 22, 29, 22, 2, -28 },
  { 2239, 22, 28, 22, 0, -28 },
  { 2316, 23, 28, 22, 1, -28 },
  { 2397, 24, 28, 22, 1, -28 },
  { 2481, 22, 29, 22, 2, -28 },
  { 2561, 26, 28, 22, -1, -28 },
  { 2652, 24, 28, 22, 0, -28 },
  { 2736, 23, 29, 22, 0, -28 },
  { 2820, 25, 28, 22, 0, -28 },
  { 2908, 19, 28, 22, 0, -28 },
  { 2975, 25, 28, 22, -1, -28 },
  { 3063, 26, 28, 22, -1, -28 },
  { 3154, 22, 29, 22, 1, -28 },
  { 3234, 23, 28, 22, 0, -28 },
  { 3315, 21, 36, 22, 1, -28 },
  { 3410, 22, 28, 22, 0, -28 },
  { 3487, 23, 29, 22, 0, -28 },
  { 3571, 21, 28, 22, 4, -28 },
  { 3645, 23, 29, 22, 1, -28 },
  { 3729, 22, 28, 22, 4, -28 },
  { 3806, 26, 28, 22, 0, -28 },
  { 3897, 28, 28, 22, -2, -28 },
  { 3995, 21, 28, 22, 5, -28 },
  { 4069, 24, 28, 22, 0, -28 },
  { 4153, 22, 38, 22, 2, -31 },
  { 4258, 8, 38, 22, 8, -31 },
  { 4296, 22, 38, 22, -1, -31 },
  { 4401, 20, 16, 22, 2, -28 },
  { 4441, 21, 4, 22, -3, 3 },
  { 4452, 10, 8, 22, 9, -31 },
  { 4462, 21, 22, 22, 1, -22 },
  { 4520, 21, 32, 22, 0, -31 },
  { 4604, 20, 22, 22, 2, -22 },
  { 4659, 23, 31, 22, 1, -31 },
  { 4749, 20, 23, 22, 2, -22 },
  { 4807, 28, 39, 22, -3, -31 },
  { 4944, 24, 30, 22, -2, -22 },
  { 5034, 21, 31, 22, 0, -31 },
  { 5116, 16, 31, 22, 3, -31 },
  { 5178, 23, 39, 22, -2, -31 },
  { 5291, 23, 31, 22, 1, -31 },
  { 5381, 14, 31, 22, 5, -31 },
  { 5436, 23, 21, 22, -1, -21 },
  { 5497, 21, 22, 22, 0, -22 },
  { 5555, 20, 23, 22, 1, -22 },
  { 5613, 23, 29, 22, -2, -22 },
  { 5697, 20, 29, 22, 2, -22 },
  { 5770, 21, 21, 22, 1, -21 },
  { 5826, 20, 23, 22, 1, -22 },
  { 5884, 19, 27, 22, 3, -27 },
  { 5949, 20, 21, 22, 2, -21 },
  { 6002, 20, 21, 22, 3, -21 },
  { 6055, 23, 21, 22, 1, -21 },
  { 6116, 24, 21, 22, -1, -21 },
  { 6179, 27, 29, 22, -4, -21 },
  { 6277, 21, 21, 22, 1, -21 },
  { 6333, 21, 38, 22, 3, -31 },
  { 6433, 15, 38, 22, 4, -31 },
  { 6505, 22, 38, 22, -2, -31 },
  { 6610, 21, 8, 22, 1, -16 },
};

const GFXfont UbuntuSansMono_BoldItalic40pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic40pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic40pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _UBUNTUSANSMONO_BOLDITALIC40PT7B_H_
