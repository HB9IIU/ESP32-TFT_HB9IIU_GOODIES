#ifndef _UBUNTUSANSMONO_BOLDITALIC23PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x3C, 0x78, 0xF1, 0xC3, 0x8F, 0x1E, 0x38, 0x70, 0x00, 0x07,
  0x1F, 0x3C, 0x38, 0x73, 0xF9, 0xF9, 0xFC, 0xEE, 0x76, 0x33, 0x18, 0x03,
  0x9C, 0x0C, 0xE0, 0x73, 0x81, 0x8C, 0x3F, 0xFD, 0xFF, 0xE7, 0xFF, 0x87,
  0x38, 0x18, 0xC3, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x73, 0x81, 0x8C, 0x0E,
  0x70, 0x39, 0x80, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x1F, 0xF1, 0xFF, 0x0E,
  0x08, 0x70, 0x03, 0x80, 0x1E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x0E,
  0x00, 0x71, 0x03, 0x8F, 0xFC, 0xFF, 0xC0, 0xF8, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x0F, 0x07, 0x1F, 0x0E, 0x1B, 0x1C, 0x1B, 0x18, 0x33, 0x30,
  0x3B, 0x60, 0x1E, 0xC0, 0x0D, 0xC0, 0x03, 0xB0, 0x03, 0x78, 0x06, 0xDC,
  0x0C, 0xC8, 0x18, 0xD8, 0x39, 0x98, 0x70, 0xF8, 0xE0, 0xF0, 0x07, 0xE0,
  0x7F, 0x03, 0x98, 0x38, 0xC1, 0xCE, 0x0E, 0x60, 0x7E, 0x01, 0xE5, 0x3F,
  0x33, 0xBB, 0x98, 0xFD, 0xC3, 0xCE, 0x1C, 0x79, 0xF1, 0xFF, 0x8F, 0xCE,
  0x7B, 0x9C, 0xEE, 0x73, 0x00, 0x01, 0x80, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0C, 0x00, 0x02, 0x01, 0xC0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x18,
  0x00, 0x0E, 0x01, 0xC1, 0x39, 0x3A, 0xEF, 0xFE, 0x1E, 0x06, 0xC1, 0xDC,
  0x7B, 0xC2, 0x20, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x61, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x39, 0xF7, 0xCF, 0x19,
  0xEF, 0x30, 0xFF, 0xFF, 0xF8, 0x77, 0xFE, 0xE0, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x70, 0x77, 0x07, 0x76,
  0x7E, 0x67, 0xEE, 0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1, 0xCF, 0x78, 0x7F,
  0x83, 0xE0, 0x01, 0xC1, 0xF0, 0xF8, 0xFE, 0x3B, 0x88, 0xE0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xE0,
  0xFF, 0x87, 0xBE, 0x10, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3F, 0xF3, 0xFF, 0x9F, 0xFC,
  0x0F, 0xE1, 0xFF, 0x0C, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x07, 0xE0, 0xF8,
  0x0F, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE6, 0x3E, 0xFF, 0xCF, 0xF8,
  0x00, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x77, 0x07, 0x38, 0x71, 0x83,
  0x1C, 0x30, 0xE3, 0x87, 0x3F, 0xFD, 0xFF, 0xE0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0xF8, 0x3F, 0xC3, 0xFE, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x7C, 0x03, 0xF8, 0x27, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x31,
  0xF3, 0xFF, 0x1F, 0xF0, 0x01, 0xF0, 0x7F, 0x0F, 0xF1, 0xE0, 0x38, 0x07,
  0x00, 0x7F, 0x8F, 0xFC, 0xF1, 0xEE, 0x0E, 0xE0, 0xEE, 0x0E, 0xE1, 0xEF,
  0x3C, 0x7F, 0x83, 0xF0, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x1E, 0x03, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x00, 0x70, 0x0E, 0x00, 0x0F, 0xC1, 0xFE, 0x3C, 0xF3, 0x87, 0x38, 0x73,
  0x8E, 0x3D, 0xE1, 0xF8, 0x3F, 0x87, 0x3C, 0xE1, 0xCE, 0x0E, 0xE1, 0xCE,
  0x3C, 0xFF, 0x87, 0xF0, 0x07, 0xE0, 0xFF, 0x87, 0xBC, 0x70, 0xF3, 0x83,
  0x9C, 0x1C, 0xE0, 0xE7, 0x9F, 0x1F, 0xF0, 0x7B, 0x80, 0x3C, 0x01, 0xC0,
  0x3C, 0x1F, 0xC1, 0xFC, 0x1F, 0x80, 0x1C, 0x7C, 0xF9, 0xE0, 0x00, 0x00,
  0x00, 0x71, 0xF3, 0xE3, 0x80, 0x0E, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x7C, 0x7C, 0x3C, 0x18, 0x78, 0xF0, 0xC0, 0x00, 0x30, 0x1F,
  0x0F, 0xF3, 0xF8, 0x7C, 0x0F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3C,
  0x00, 0x80, 0x3F, 0xF9, 0xFF, 0xDF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF9,
  0xFF, 0x9F, 0xFC, 0x18, 0x03, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF0, 0x0F,
  0x07, 0xF3, 0xF8, 0xFE, 0x07, 0x00, 0x40, 0x00, 0x3F, 0x9F, 0xE6, 0x3C,
  0x0F, 0x03, 0x81, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x00, 0x00, 0x00, 0x70,
  0x3C, 0x0F, 0x03, 0xC0, 0x03, 0xF0, 0x7F, 0xC7, 0x8E, 0x30, 0x33, 0x81,
  0x98, 0xFD, 0xCF, 0xEC, 0xE7, 0x66, 0x3B, 0x31, 0x9B, 0x9D, 0xDC, 0xEE,
  0x77, 0x33, 0xF1, 0x8F, 0x8E, 0x00, 0x78, 0x01, 0xFE, 0x07, 0xF0, 0x00,
  0xE0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0x70, 0x77, 0x0E, 0x70, 0xE7, 0x1C,
  0x71, 0xC7, 0x3F, 0xF3, 0xFF, 0x38, 0x77, 0x07, 0x70, 0x7E, 0x07, 0x0F,
  0xE0, 0xFF, 0x87, 0xFE, 0x38, 0x71, 0xC3, 0x9E, 0x38, 0xFF, 0xC7, 0xF8,
  0x3F, 0xE1, 0xC7, 0x9C, 0x1C, 0xE0, 0xE7, 0x0F, 0x3F, 0xF3, 0xFF, 0x1F,
  0xF0, 0x07, 0xF0, 0x7F, 0xC7, 0xDC, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x3E, 0xE1,
  0xFF, 0x07, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0xFC, 0x38, 0xE1, 0xC7, 0x9C,
  0x3C, 0xE1, 0xE7, 0x0F, 0x38, 0x73, 0xC3, 0x9C, 0x3C, 0xE1, 0xC7, 0x1E,
  0x7F, 0xE3, 0xFE, 0x1F, 0xC0, 0x0F, 0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xFF, 0x87, 0xFE, 0x3F, 0xF8, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC1, 0x07, 0xF8, 0x3F,
  0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0x00, 0x07, 0xF0, 0x7F, 0xC7, 0xDC, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0xE7, 0x07, 0x38, 0x79, 0xC3, 0x8F, 0x1C, 0x7D, 0xE1,
  0xFF, 0x07, 0xF0, 0x1E, 0x1C, 0x70, 0x71, 0xC3, 0xC7, 0x0E, 0x3C, 0x38,
  0xE0, 0xE3, 0xFF, 0x8F, 0xFC, 0x3F, 0xF1, 0xC1, 0xC7, 0x0F, 0x1C, 0x38,
  0x70, 0xE3, 0x83, 0x8E, 0x1E, 0x38, 0x70, 0x0F, 0xFC, 0x7F, 0xF1, 0xFF,
  0x80, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xC0, 0x0E, 0x01, 0xFF, 0x8F, 0xFC, 0x3F, 0xF0, 0x07,
  0xF8, 0x3F, 0xC3, 0xFE, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC4, 0x1C, 0x3B, 0xE3, 0xFE, 0x0F,
  0xE0, 0x0E, 0x1E, 0x38, 0x70, 0x71, 0xE0, 0xE7, 0x81, 0xDE, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x01, 0xCE, 0x03, 0x8E, 0x07,
  0x1C, 0x1E, 0x3C, 0x38, 0x38, 0x70, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0E,
  0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xFF, 0xDF, 0xF7, 0xFE, 0x07, 0x0E, 0x1E, 0x3C, 0x3C, 0x78, 0x79,
  0xE1, 0xF3, 0xC3, 0xED, 0x86, 0xDF, 0x0D, 0xEE, 0x3B, 0xD8, 0x77, 0x30,
  0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x06, 0x18, 0x1C, 0x70, 0x38, 0x1C,
  0x1C, 0x78, 0x71, 0xE1, 0xC7, 0x8E, 0x3F, 0x38, 0xFC, 0xE3, 0xB3, 0x8E,
  0xCC, 0x73, 0xF1, 0xCF, 0xC7, 0x1F, 0x1C, 0x78, 0x61, 0xE3, 0x87, 0x8E,
  0x1E, 0x38, 0x30, 0x0F, 0xC1, 0xFE, 0x3E, 0xF3, 0x87, 0x70, 0x77, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1, 0xCF, 0x78,
  0x7F, 0x83, 0xE0, 0x0F, 0xE0, 0xFF, 0x87, 0xFE, 0x38, 0x71, 0xC3, 0x8E,
  0x1C, 0xE0, 0xE7, 0x1F, 0x3F, 0xF1, 0xFE, 0x1F, 0x80, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x00, 0x0F, 0xC1, 0xFE, 0x3E, 0xF3, 0x87, 0x70,
  0x77, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x1E, 0xE1,
  0xCF, 0x78, 0x7F, 0x83, 0xE0, 0x18, 0x01, 0xC0, 0x1F, 0x80, 0x70, 0x0F,
  0xE0, 0xFF, 0x87, 0xFE, 0x38, 0xF1, 0xC3, 0x9E, 0x3C, 0xE1, 0xC7, 0xFE,
  0x3F, 0xE3, 0xFC, 0x1C, 0xE0, 0xE3, 0x87, 0x1C, 0x38, 0xF3, 0x83, 0x9C,
  0x1C, 0x07, 0xF0, 0x7F, 0xC7, 0x8C, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7C,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x39, 0xF3,
  0xFF, 0x0F, 0xF0, 0x7F, 0xFB, 0xFF, 0xBF, 0xFC, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x39, 0xC3, 0xCE, 0x1C, 0x70, 0xE7,
  0x87, 0x38, 0x79, 0xC3, 0x8E, 0x1C, 0xF0, 0xE7, 0x0F, 0x38, 0x71, 0xC3,
  0x8E, 0x1C, 0x7B, 0xC3, 0xFE, 0x0F, 0xE0, 0x70, 0x7B, 0x83, 0x9C, 0x1C,
  0xE1, 0xC7, 0x0E, 0x38, 0xE1, 0xC7, 0x0E, 0x70, 0x73, 0x83, 0xB8, 0x1D,
  0xC0, 0xEC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x1C, 0x0E, 0x38,
  0x18, 0x60, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x0C, 0xEE, 0x3B, 0xDC,
  0x77, 0xB0, 0xFB, 0x61, 0xB7, 0xC3, 0xCF, 0x87, 0x9E, 0x1E, 0x3C, 0x3C,
  0x78, 0x70, 0xE0, 0x0E, 0x0F, 0x0F, 0x1E, 0x07, 0x1C, 0x07, 0x38, 0x03,
  0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0E, 0xE0, 0x1C, 0xF0, 0x38, 0x70, 0x78, 0x70, 0xF0, 0x70, 0xE0,
  0xFE, 0x0E, 0xE1, 0xCE, 0x3C, 0xE3, 0x87, 0x70, 0x77, 0x07, 0xE0, 0x7C,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x0F,
  0xFC, 0x7F, 0xE1, 0xFF, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF0, 0x03, 0xF8, 0x3F, 0x81, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0xF0, 0x7F, 0x80, 0xE7, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x03, 0xF8, 0x3F, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x07, 0xF0, 0x7F, 0x80, 0x03, 0x80, 0x7C, 0x0F, 0xC0, 0xFC, 0x1D,
  0xE3, 0x8E, 0x78, 0xEF, 0x0F, 0x60, 0x60, 0x7F, 0xF7, 0xFF, 0xFF, 0xF0,
  0x41, 0x8F, 0x8F, 0x08, 0x0F, 0xF3, 0xFE, 0x7C, 0xE7, 0x0E, 0xE1, 0xEE,
  0x1C, 0xE1, 0xCE, 0x1C, 0xE1, 0xCF, 0x7C, 0xFF, 0xC7, 0xDC, 0x06, 0x00,
  0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1F, 0xE3, 0xFE, 0x3C, 0xF3,
  0x87, 0x38, 0x73, 0x87, 0x70, 0x77, 0x0E, 0x71, 0xE7, 0x3C, 0xFF, 0xCF,
  0xF0, 0x0F, 0xF1, 0xFE, 0x3E, 0x27, 0x80, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x0F, 0xDC, 0x7F, 0xC3, 0xFC, 0x00, 0x18, 0x01, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x3F, 0xC7, 0xFC, 0x7C, 0xE3, 0x87, 0x38,
  0x79, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x87, 0x1E, 0xF8, 0xFF, 0xC3, 0xEE,
  0x00, 0x0F, 0xC7, 0xFD, 0xE3, 0xB8, 0x7E, 0x0F, 0xDF, 0xFF, 0xE7, 0xE0,
  0xE0, 0x1E, 0x11, 0xFF, 0x1F, 0xE0, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xFC,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x03, 0xFC, 0x3F, 0xF1, 0xF3, 0x87, 0x0E, 0x3C, 0x38, 0xE1,
  0xE3, 0x87, 0x0E, 0x1C, 0x3C, 0xF0, 0x7F, 0xC1, 0xFE, 0x00, 0x38, 0x01,
  0xE1, 0x8F, 0x0F, 0xF8, 0x3F, 0xC0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x1F, 0xE1, 0xFF, 0x3C, 0xF3, 0x87, 0x38, 0x73, 0x8E,
  0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x1E, 0x71, 0xCE, 0x1C, 0x06, 0x07, 0x83,
  0xC1, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0xFC, 0x0E, 0x07, 0x03, 0x83, 0x81,
  0xC0, 0xE0, 0x7B, 0x3F, 0x8F, 0xC0, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0xCF, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x78, 0x11, 0xC3, 0x87, 0x1C, 0x1C, 0xE0, 0xF7, 0x03,
  0xF8, 0x0F, 0xC0, 0x3F, 0x81, 0xEE, 0x07, 0x3C, 0x1C, 0x70, 0x71, 0xE3,
  0xC3, 0x80, 0xFE, 0xFE, 0xFC, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x38,
  0x70, 0x70, 0x70, 0x70, 0xF0, 0x7F, 0x7F, 0x7F, 0x3F, 0xF1, 0xFF, 0xCC,
  0xCE, 0x66, 0x77, 0x33, 0x3B, 0xB9, 0x9D, 0xCC, 0x0E, 0xE0, 0x67, 0x03,
  0x38, 0x39, 0x81, 0xC0, 0x1F, 0xE1, 0xFF, 0x3C, 0xF3, 0x87, 0x38, 0x73,
  0x8E, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x1E, 0x71, 0xCE, 0x1C, 0x1F, 0xC7,
  0xF9, 0xE7, 0xB8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x0E, 0xE1, 0xDE, 0xF3,
  0xFE, 0x3F, 0x00, 0x0F, 0xF0, 0x7F, 0x87, 0x1E, 0x38, 0x71, 0xC3, 0x8E,
  0x1C, 0xF0, 0xE7, 0x0E, 0x38, 0xF1, 0xDF, 0x1F, 0xF0, 0xFF, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x00, 0x0F, 0xF3, 0xFF, 0x3C, 0xE7, 0x0E, 0xF0,
  0xEE, 0x1E, 0xE1, 0xCE, 0x1C, 0xE1, 0xCF, 0x7C, 0x7F, 0x87, 0xF8, 0x03,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x1F, 0xF3, 0xFE, 0x3F, 0xE3, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x0F,
  0xF1, 0xFF, 0x1C, 0x21, 0xC0, 0x1E, 0x01, 0xF8, 0x0F, 0xC0, 0x1E, 0x01,
  0xE7, 0x3C, 0x7F, 0xCF, 0xF8, 0x02, 0x03, 0xC0, 0x70, 0x0E, 0x0F, 0xFF,
  0xFF, 0xBF, 0xF1, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xFF,
  0x1F, 0xE1, 0xFC, 0x38, 0xF7, 0x8E, 0x70, 0xE7, 0x0E, 0x71, 0xCF, 0x1C,
  0xE1, 0xCE, 0x1C, 0xE3, 0xCF, 0x7C, 0xFF, 0xC7, 0xDC, 0xE0, 0xFC, 0x3F,
  0x87, 0x71, 0xEE, 0x39, 0xCF, 0x3D, 0xC3, 0xF8, 0x7E, 0x0F, 0x81, 0xF0,
  0x3C, 0x00, 0x60, 0x3F, 0x01, 0xB9, 0x9D, 0xCC, 0xEE, 0xE6, 0x67, 0x33,
  0x6B, 0x9B, 0x78, 0xF3, 0xC7, 0x9E, 0x38, 0xE1, 0x87, 0x00, 0x1C, 0x3C,
  0x38, 0xE0, 0xE7, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xF0,
  0x1F, 0xE0, 0x73, 0x83, 0x8F, 0x3C, 0x1C, 0x0E, 0x0E, 0x1C, 0x3C, 0x38,
  0x70, 0x70, 0xE0, 0xF3, 0x81, 0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x78, 0x09, 0xE0, 0x3F, 0x80, 0x7C,
  0x00, 0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xFF, 0x1F, 0xF1, 0xFF, 0x80, 0x01, 0xF0, 0x7F,
  0x07, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0xF8, 0x0F, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70,
  0x38, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x80, 0x07, 0xC0, 0x7E, 0x01, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xF0,
  0x0F, 0x03, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0xE0, 0x7E, 0x0F, 0xC0, 0x1E, 0x39, 0xFB, 0x9F, 0xFD, 0xC7, 0xC0, 0x08,
  0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 16, 13, 3, -16 },
  { 15, 9, 7, 13, 4, -17 },
  { 23, 14, 16, 13, 0, -16 },
  { 51, 13, 21, 13, 0, -18 },
  { 86, 16, 16, 13, -1, -16 },
  { 118, 13, 16, 13, 0, -16 },
  { 144, 5, 7, 13, 6, -17 },
  { 149, 10, 22, 13, 3, -18 },
  { 177, 10, 22, 13, 0, -18 },
  { 205, 11, 10, 13, 2, -16 },
  { 219, 11, 12, 13, 1, -13 },
  { 236, 6, 8, 13, 2, -4 },
  { 242, 7, 3, 13, 3, -8 },
  { 245, 5, 4, 13, 3, -4 },
  { 248, 15, 22, 13, -1, -18 },
  { 290, 12, 16, 13, 1, -16 },
  { 314, 10, 16, 13, 1, -16 },
  { 334, 13, 16, 13, 0, -16 },
  { 360, 12, 16, 13, 0, -16 },
  { 384, 13, 16, 13, 0, -16 },
  { 410, 13, 16, 13, 0, -16 },
  { 436, 12, 16, 13, 1, -16 },
  { 460, 12, 16, 13, 2, -16 },
  { 484, 12, 16, 13, 1, -16 },
  { 508, 13, 16, 13, 0, -16 },
  { 534, 7, 12, 13, 3, -12 },
  { 545, 8, 16, 13, 2, -12 },
  { 561, 12, 11, 13, 1, -12 },
  { 578, 13, 8, 13, 0, -11 },
  { 591, 12, 11, 13, 0, -12 },
  { 608, 10, 16, 13, 3, -16 },
  { 628, 13, 19, 13, 0, -16 },
  { 659, 12, 16, 13, -1, -16 },
  { 683, 13, 16, 13, 0, -16 },
  { 709, 13, 16, 13, 1, -16 },
  { 735, 13, 16, 13, 0, -16 },
  { 761, 14, 16, 13, 0, -16 },
  { 789, 14, 16, 13, 0, -16 },
  { 817, 13, 16, 13, 1, -16 },
  { 843, 14, 16, 13, 0, -16 },
  { 871, 14, 16, 13, 0, -16 },
  { 899, 13, 16, 13, 0, -16 },
  { 925, 15, 16, 13, 0, -16 },
  { 955, 11, 16, 13, 0, -16 },
  { 977, 15, 16, 13, -1, -16 },
  { 1007, 14, 16, 13, 0, -16 },
  { 1035, 12, 16, 13, 1, -16 },
  { 1059, 13, 16, 13, 0, -16 },
  { 1085, 12, 20, 13, 1, -16 },
  { 1115, 13, 16, 13, 0, -16 },
  { 1141, 13, 16, 13, 0, -16 },
  { 1167, 13, 16, 13, 2, -16 },
  { 1193, 13, 16, 13, 1, -16 },
  { 1219, 13, 16, 13, 2, -16 },
  { 1245, 15, 16, 13, 0, -16 },
  { 1275, 16, 16, 13, -1, -16 },
  { 1307, 12, 16, 13, 3, -16 },
  { 1331, 14, 16, 13, 0, -16 },
  { 1359, 13, 22, 13, 1, -18 },
  { 1395, 5, 22, 13, 4, -18 },
  { 1409, 13, 22, 13, -1, -18 },
  { 1445, 12, 9, 13, 1, -16 },
  { 1459, 12, 3, 13, -2, 1 },
  { 1464, 6, 5, 13, 5, -18 },
  { 1468, 12, 12, 13, 1, -12 },
  { 1486, 12, 18, 13, 0, -18 },
  { 1513, 12, 12, 13, 1, -12 },
  { 1531, 13, 18, 13, 1, -18 },
  { 1561, 11, 12, 13, 1, -12 },
  { 1578, 16, 22, 13, -2, -18 },
  { 1622, 14, 16, 13, -1, -12 },
  { 1650, 12, 18, 13, 0, -18 },
  { 1677, 9, 18, 13, 2, -18 },
  { 1698, 13, 22, 13, -1, -18 },
  { 1734, 14, 18, 13, 0, -18 },
  { 1766, 8, 18, 13, 3, -18 },
  { 1784, 13, 12, 13, 0, -12 },
  { 1804, 12, 12, 13, 0, -12 },
  { 1822, 11, 12, 13, 1, -12 },
  { 1839, 13, 16, 13, -1, -12 },
  { 1865, 12, 16, 13, 1, -12 },
  { 1889, 12, 12, 13, 1, -12 },
  { 1907, 12, 12, 13, 0, -12 },
  { 1925, 11, 16, 13, 2, -16 },
  { 1947, 12, 12, 13, 1, -12 },
  { 1965, 11, 12, 13, 2, -12 },
  { 1982, 13, 12, 13, 1, -12 },
  { 2002, 14, 12, 13, -1, -12 },
  { 2023, 15, 16, 13, -2, -12 },
  { 2053, 13, 12, 13, 0, -12 },
  { 2073, 12, 22, 13, 2, -18 },
  { 2106, 9, 22, 13, 2, -18 },
  { 2131, 12, 22, 13, -1, -18 },
  { 2164, 13, 5, 13, 0, -9 },
};

const GFXfont UbuntuSansMono_BoldItalic23pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic23pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic23pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _UBUNTUSANSMONO_BOLDITALIC23PT7B_H_
