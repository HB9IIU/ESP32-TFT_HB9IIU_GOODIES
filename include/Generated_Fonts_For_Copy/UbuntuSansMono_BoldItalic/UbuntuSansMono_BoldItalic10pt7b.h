#ifndef _UBUNTUSANSMONO_BOLDITALIC10PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x66, 0x04, 0xC0, 0xFB, 0xAA, 0x14, 0xA7, 0xD6, 0xF9, 0x4A,
  0x00, 0x18, 0xF6, 0x98, 0x30, 0x69, 0xBC, 0x60, 0x65, 0xA7, 0x04, 0x39,
  0x69, 0x80, 0x3B, 0x5C, 0xDF, 0xCB, 0xA0, 0xEA, 0x19, 0x98, 0x8C, 0x42,
  0x18, 0x43, 0x00, 0x20, 0x84, 0x31, 0x08, 0xC4, 0x44, 0x00, 0x27, 0x8B,
  0xE0, 0x13, 0xFE, 0x42, 0x00, 0x76, 0xFE, 0x70, 0x06, 0x08, 0x30, 0x41,
  0x82, 0x0C, 0x10, 0x61, 0x80, 0x39, 0xB4, 0xDE, 0xCB, 0x67, 0x00, 0x1B,
  0x94, 0x23, 0x13, 0xE0, 0x39, 0x30, 0x86, 0x61, 0x0F, 0x80, 0x78, 0x42,
  0x60, 0x8F, 0xC0, 0x0C, 0x62, 0x92, 0xF8, 0x41, 0x00, 0x3C, 0x86, 0x1E,
  0x08, 0x6F, 0x00, 0x1C, 0x84, 0x1E, 0xC9, 0x27, 0x00, 0xF8, 0xCC, 0x44,
  0x62, 0x00, 0x39, 0xB6, 0x8C, 0x4B, 0x27, 0x00, 0x39, 0x24, 0xDE, 0x08,
  0x4E, 0x00, 0x6C, 0x2C, 0x6C, 0x2C, 0xA0, 0x1D, 0xCE, 0x0E, 0x08, 0x7D,
  0xE0, 0x3E, 0x61, 0xCF, 0xC8, 0x00, 0x70, 0xCC, 0xC0, 0x23, 0x00, 0x3D,
  0x15, 0xEB, 0xAA, 0xA9, 0x1C, 0x20, 0x19, 0x4A, 0x97, 0xE6, 0x20, 0x39,
  0xB4, 0x9E, 0x4B, 0x2F, 0x00, 0x7E, 0x61, 0x08, 0x43, 0xC0, 0x79, 0xA4,
  0xD2, 0x4B, 0x6F, 0x00, 0x3D, 0x86, 0x1E, 0x41, 0x0F, 0x80, 0x3C, 0x86,
  0x1E, 0x41, 0x0C, 0x00, 0x3D, 0x94, 0x12, 0xC9, 0x67, 0x80, 0x65, 0xB4,
  0xDE, 0xCB, 0x69, 0x80, 0x7C, 0x41, 0x0C, 0x20, 0x8F, 0x80, 0x3C, 0x20,
  0x82, 0x1A, 0x4F, 0x00, 0x6D, 0xA5, 0x18, 0x53, 0x69, 0x80, 0x23, 0x18,
  0x84, 0x63, 0xE0, 0x25, 0xB7, 0x5E, 0xEA, 0x29, 0x80, 0x65, 0x96, 0xD6,
  0xDA, 0x69, 0x80, 0x39, 0xB4, 0xF2, 0xCB, 0x67, 0x00, 0x39, 0xB4, 0xDE,
  0x73, 0x08, 0x00, 0x39, 0xB4, 0xF2, 0xCB, 0x67, 0x08, 0x30, 0x39, 0xB4,
  0x9E, 0x53, 0x49, 0x80, 0x3D, 0x86, 0x0C, 0x1A, 0x6F, 0x00, 0xF9, 0x08,
  0xC4, 0x23, 0x00, 0x65, 0xB4, 0x92, 0xCB, 0x67, 0x00, 0xCC, 0xE5, 0x2E,
  0x73, 0x00, 0x65, 0x14, 0x5E, 0xBB, 0x6D, 0x80, 0x64, 0xA3, 0x8C, 0x71,
  0x6D, 0x80, 0xCF, 0x65, 0x18, 0x41, 0x0C, 0x00, 0x7C, 0x21, 0x8C, 0x61,
  0x0F, 0x80, 0x39, 0x18, 0x84, 0x23, 0x10, 0x87, 0x00, 0xAB, 0xFD, 0x50,
  0x38, 0x46, 0x21, 0x08, 0xC4, 0x27, 0x00, 0x18, 0xE6, 0xB3, 0xFC, 0x5C,
  0x7A, 0x77, 0xB7, 0x80, 0x21, 0x18, 0xF4, 0xA7, 0x7E, 0x7D, 0x0C, 0x30,
  0x78, 0x04, 0x30, 0xDE, 0x4B, 0x6D, 0x9E, 0x7A, 0x7F, 0x87, 0x80, 0x06,
  0x14, 0x69, 0xE1, 0x02, 0x04, 0x18, 0xA1, 0xC0, 0x7D, 0x2C, 0x96, 0x72,
  0xCE, 0x00, 0x21, 0x18, 0xF4, 0xA7, 0x7A, 0x22, 0x0E, 0x64, 0x47, 0x08,
  0xC0, 0xF1, 0x08, 0x46, 0xA7, 0x00, 0x20, 0x82, 0x5A, 0x51, 0xC5, 0x36,
  0xE2, 0x66, 0x44, 0x47, 0x7D, 0xEE, 0xA2, 0x98, 0x7A, 0x53, 0xBD, 0x00,
  0x7A, 0x73, 0xB7, 0x00, 0x7A, 0x53, 0xBF, 0x42, 0x00, 0x7D, 0x2C, 0xB6,
  0x70, 0x41, 0x00, 0x7D, 0x84, 0x10, 0xC0, 0x7B, 0x0C, 0x3F, 0x00, 0x63,
  0x7C, 0x8C, 0x61, 0xC0, 0x6A, 0x57, 0xB7, 0x80, 0x9C, 0xA9, 0xCC, 0x00,
  0x47, 0xEB, 0xB6, 0xD0, 0x6C, 0xC3, 0x1C, 0xD8, 0x26, 0x48, 0xB1, 0xC1,
  0x06, 0x30, 0x00, 0x7C, 0x42, 0x10, 0xF8, 0x19, 0x08, 0xCC, 0x61, 0x18,
  0xC3, 0x00, 0x32, 0x22, 0x64, 0x44, 0xC8, 0x30, 0x84, 0x21, 0x9C, 0x84,
  0x66, 0x00, 0x6E, 0xE0,
};

const GFXglyph UbuntuSansMono_BoldItalic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 4, 7, 6, 1, -7 },
  { 5, 4, 4, 6, 2, -8 },
  { 7, 6, 7, 6, 0, -7 },
  { 13, 6, 9, 6, 0, -8 },
  { 20, 6, 7, 6, 0, -7 },
  { 26, 5, 7, 6, 0, -7 },
  { 31, 2, 4, 6, 3, -8 },
  { 32, 5, 10, 6, 1, -8 },
  { 39, 5, 10, 6, 0, -8 },
  { 46, 5, 4, 6, 1, -7 },
  { 49, 5, 5, 6, 0, -5 },
  { 53, 2, 4, 6, 1, -2 },
  { 54, 4, 2, 6, 1, -4 },
  { 55, 2, 2, 6, 1, -2 },
  { 56, 7, 10, 6, -1, -8 },
  { 65, 6, 7, 6, 0, -7 },
  { 71, 5, 7, 6, 0, -7 },
  { 76, 6, 7, 6, 0, -7 },
  { 82, 5, 7, 6, 0, -7 },
  { 87, 6, 7, 6, 0, -7 },
  { 93, 6, 7, 6, 0, -7 },
  { 99, 6, 7, 6, 0, -7 },
  { 105, 5, 7, 6, 1, -7 },
  { 110, 6, 7, 6, 0, -7 },
  { 116, 6, 7, 6, 0, -7 },
  { 122, 3, 5, 6, 1, -5 },
  { 124, 3, 7, 6, 1, -5 },
  { 127, 6, 5, 6, 0, -5 },
  { 131, 6, 4, 6, 0, -5 },
  { 134, 5, 5, 6, 0, -5 },
  { 138, 5, 7, 6, 1, -7 },
  { 143, 6, 9, 6, 0, -7 },
  { 150, 5, 7, 6, 0, -7 },
  { 155, 6, 7, 6, 0, -7 },
  { 161, 5, 7, 6, 1, -7 },
  { 166, 6, 7, 6, 0, -7 },
  { 172, 6, 7, 6, 0, -7 },
  { 178, 6, 7, 6, 0, -7 },
  { 184, 6, 7, 6, 0, -7 },
  { 190, 6, 7, 6, 0, -7 },
  { 196, 6, 7, 6, 0, -7 },
  { 202, 6, 7, 6, 0, -7 },
  { 208, 6, 7, 6, 0, -7 },
  { 214, 5, 7, 6, 0, -7 },
  { 219, 6, 7, 6, 0, -7 },
  { 225, 6, 7, 6, 0, -7 },
  { 231, 6, 7, 6, 0, -7 },
  { 237, 6, 7, 6, 0, -7 },
  { 243, 6, 9, 6, 0, -7 },
  { 250, 6, 7, 6, 0, -7 },
  { 256, 6, 7, 6, 0, -7 },
  { 262, 5, 7, 6, 1, -7 },
  { 267, 6, 7, 6, 0, -7 },
  { 273, 5, 7, 6, 1, -7 },
  { 278, 6, 7, 6, 0, -7 },
  { 284, 6, 7, 6, 0, -7 },
  { 290, 6, 7, 6, 1, -7 },
  { 296, 6, 7, 6, 0, -7 },
  { 302, 5, 10, 6, 1, -8 },
  { 309, 2, 10, 6, 2, -8 },
  { 312, 5, 10, 6, 0, -8 },
  { 319, 6, 4, 6, 0, -7 },
  { 322, 6, 1, 6, -1, 1 },
  { 323, 3, 2, 6, 2, -8 },
  { 324, 5, 5, 6, 0, -5 },
  { 328, 5, 8, 6, 0, -8 },
  { 333, 6, 5, 6, 0, -5 },
  { 337, 6, 8, 6, 0, -8 },
  { 343, 5, 5, 6, 0, -5 },
  { 347, 7, 10, 6, -1, -8 },
  { 356, 6, 7, 6, 0, -5 },
  { 362, 5, 8, 6, 0, -8 },
  { 367, 4, 8, 6, 1, -8 },
  { 371, 5, 10, 6, 0, -8 },
  { 378, 6, 8, 6, 0, -8 },
  { 384, 4, 8, 6, 1, -8 },
  { 388, 6, 5, 6, 0, -5 },
  { 392, 5, 5, 6, 0, -5 },
  { 396, 5, 5, 6, 0, -5 },
  { 400, 5, 7, 6, 0, -5 },
  { 405, 6, 7, 6, 0, -5 },
  { 411, 6, 5, 6, 0, -5 },
  { 415, 5, 5, 6, 0, -5 },
  { 419, 5, 7, 6, 1, -7 },
  { 424, 5, 5, 6, 0, -5 },
  { 428, 5, 5, 6, 1, -5 },
  { 432, 6, 5, 6, 0, -5 },
  { 436, 6, 5, 6, 0, -5 },
  { 440, 7, 7, 6, -1, -5 },
  { 447, 6, 5, 6, 0, -5 },
  { 451, 5, 10, 6, 1, -8 },
  { 458, 4, 10, 6, 1, -8 },
  { 463, 5, 10, 6, 0, -8 },
  { 470, 6, 2, 6, 0, -4 },
};

const GFXfont UbuntuSansMono_BoldItalic10pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic10pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic10pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _UBUNTUSANSMONO_BOLDITALIC10PT7B_H_
