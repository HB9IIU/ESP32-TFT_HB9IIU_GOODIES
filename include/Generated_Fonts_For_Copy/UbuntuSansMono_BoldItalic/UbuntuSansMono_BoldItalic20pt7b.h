#ifndef _UBUNTUSANSMONO_BOLDITALIC20PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x73, 0xCE, 0x38, 0xE3, 0x9C, 0x70, 0x00, 0x38, 0xF3, 0x80,
  0x73, 0xBB, 0x99, 0xCC, 0xE6, 0x66, 0x30, 0x07, 0x70, 0x66, 0x06, 0x60,
  0xCC, 0x7F, 0xF7, 0xFE, 0x19, 0x81, 0x98, 0xFF, 0xEF, 0xFC, 0xFF, 0xC6,
  0x60, 0xE6, 0x0C, 0xC0, 0x01, 0x80, 0x30, 0x0E, 0x07, 0xF1, 0xFE, 0x70,
  0x4E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xE0, 0x1C, 0xEF, 0x3F,
  0xE1, 0xF0, 0x18, 0x03, 0x00, 0x0E, 0x0C, 0x78, 0x61, 0x33, 0x0C, 0x98,
  0x36, 0xC0, 0xFE, 0x01, 0x98, 0x00, 0xD8, 0x06, 0xF0, 0x36, 0xC1, 0x9B,
  0x0C, 0x4C, 0x71, 0xE3, 0x87, 0x00, 0x07, 0x81, 0xF8, 0x63, 0x0C, 0x61,
  0x98, 0x36, 0x07, 0x81, 0xF3, 0x76, 0xDC, 0xFB, 0x8E, 0x71, 0xCF, 0xFC,
  0xFB, 0x80, 0x77, 0x76, 0x6C, 0x01, 0x01, 0xC1, 0xC1, 0xC1, 0xC1, 0xC0,
  0xE0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x70,
  0x1C, 0x0E, 0x02, 0x00, 0x04, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x08, 0x00, 0x1C, 0x0E, 0x13, 0x7F, 0xFF, 0xF8, 0xE0, 0xDC, 0xEE,
  0x22, 0x00, 0x06, 0x03, 0x80, 0xC0, 0x30, 0xFF, 0xFF, 0xE1, 0xC0, 0x60,
  0x18, 0x0E, 0x00, 0x18, 0xF3, 0xCF, 0x19, 0xEE, 0x00, 0x7E, 0xFF, 0xF0,
  0x6F, 0xFE, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x00, 0x0F,
  0x87, 0xF3, 0x9D, 0xC3, 0x60, 0xF9, 0x3E, 0xDF, 0xB7, 0xC1, 0xF0, 0x6C,
  0x3B, 0x9C, 0xFE, 0x1F, 0x00, 0x03, 0x87, 0x8F, 0xCF, 0xE3, 0x70, 0x30,
  0x38, 0x1C, 0x0E, 0x06, 0x07, 0x03, 0x9F, 0xF7, 0xF8, 0x0F, 0xC7, 0xFC,
  0x63, 0x88, 0x70, 0x0E, 0x03, 0x80, 0xF0, 0x38, 0x1E, 0x07, 0x81, 0xC0,
  0x38, 0x2F, 0xF9, 0xFF, 0x00, 0x0F, 0xC3, 0xFC, 0x43, 0x80, 0x70, 0x0C,
  0x07, 0x83, 0xC0, 0x7C, 0x01, 0xC0, 0x38, 0x07, 0x21, 0xCF, 0xF9, 0xFE,
  0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x83, 0xF0, 0xEC, 0x3B, 0x8E, 0x73, 0x8E,
  0x61, 0x9F, 0xFF, 0xFF, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0x0F, 0xF0, 0xFE,
  0x0C, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x3F, 0x00, 0xF8, 0x01, 0xC0, 0x1C,
  0x01, 0xC4, 0x38, 0xFF, 0x8F, 0xF0, 0x03, 0xE1, 0xF8, 0x7C, 0x1C, 0x07,
  0x00, 0xDC, 0x3F, 0xE7, 0x9C, 0xE1, 0x98, 0x33, 0x86, 0x71, 0xC7, 0xF0,
  0x7C, 0x00, 0x7F, 0xFF, 0xF0, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70,
  0x38, 0x0C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x00, 0x0F, 0x8F, 0xF3, 0x9C,
  0xC3, 0x71, 0xCE, 0xE1, 0xF1, 0xFC, 0xE3, 0xB0, 0xEC, 0x3B, 0x0E, 0xFF,
  0x1F, 0x80, 0x0F, 0x83, 0xF8, 0xE3, 0x98, 0x73, 0x0E, 0x61, 0xCE, 0x39,
  0xFF, 0x0E, 0xC0, 0x38, 0x0E, 0x07, 0x87, 0xE1, 0xF0, 0x00, 0x19, 0xDE,
  0x70, 0x00, 0x0C, 0xF7, 0xB8, 0x06, 0x1C, 0x78, 0x70, 0x00, 0x00, 0x0C,
  0x3C, 0x78, 0xF0, 0xC7, 0x9C, 0x00, 0x00, 0x40, 0x70, 0xFC, 0xFC, 0xF8,
  0x3C, 0x0F, 0xC0, 0x7C, 0x07, 0x80, 0x40, 0x3F, 0xEF, 0xFC, 0x00, 0x00,
  0x07, 0xFD, 0xFF, 0x80, 0x20, 0x07, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x07,
  0x87, 0xF3, 0xF0, 0xF0, 0x08, 0x00, 0xFE, 0x7F, 0x47, 0x07, 0x0F, 0x1E,
  0x38, 0x70, 0x60, 0x00, 0x00, 0xE0, 0xE0, 0xE0, 0x07, 0xE0, 0xFE, 0x18,
  0x73, 0x07, 0x33, 0xF6, 0x7E, 0x66, 0x66, 0xC6, 0x6C, 0xEE, 0xCC, 0xCC,
  0xCE, 0xFC, 0x67, 0xC6, 0x00, 0x70, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xC0,
  0x78, 0x0F, 0x03, 0xE0, 0x6E, 0x1D, 0xC3, 0x38, 0xE7, 0x18, 0xE7, 0xFC,
  0xFF, 0xB8, 0x76, 0x0F, 0xC1, 0xC0, 0x1F, 0xC3, 0xFC, 0x63, 0x9C, 0x33,
  0x8E, 0x73, 0x8F, 0xE1, 0xFE, 0x71, 0xCE, 0x19, 0xC7, 0x31, 0xEF, 0xF9,
  0xFE, 0x00, 0x07, 0xC3, 0xFC, 0xF1, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x87, 0xF0, 0x7E, 0x00, 0x1F, 0x83,
  0xF8, 0x67, 0x9C, 0x73, 0x8E, 0x71, 0xCC, 0x3B, 0x87, 0x70, 0xEE, 0x39,
  0x8F, 0x73, 0xCF, 0xF1, 0xFC, 0x00, 0x0F, 0xF1, 0xFF, 0x1C, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x3F, 0xC3, 0xF8, 0x30, 0x07, 0x00, 0x70, 0x07, 0x04,
  0x7F, 0x8F, 0xF8, 0x0F, 0xF1, 0xFF, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80,
  0x3F, 0xC3, 0xFC, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0x07, 0xC3, 0xFC, 0xF1, 0x3C, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x0E, 0xE1,
  0x9C, 0x73, 0x8E, 0x71, 0xC7, 0xF0, 0xFE, 0x00, 0x1C, 0x71, 0xC7, 0x18,
  0x73, 0x86, 0x38, 0xE3, 0x8E, 0x3F, 0xE7, 0xFE, 0x70, 0xC7, 0x1C, 0x61,
  0xCE, 0x1C, 0xE1, 0x8E, 0x38, 0x1F, 0xF1, 0xFF, 0x03, 0x00, 0x30, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0xFF,
  0x8F, 0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x84, 0x78, 0xFF, 0x07, 0xE0, 0x1C,
  0x78, 0xE3, 0x86, 0x38, 0x73, 0x83, 0xB8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0,
  0x77, 0x03, 0xB8, 0x18, 0xE1, 0xC7, 0x0E, 0x1C, 0x70, 0xE0, 0x1C, 0x0E,
  0x07, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0xFF, 0xFC, 0x0E, 0x38, 0x71, 0xC3, 0x9E, 0x3C, 0xF1, 0xEF, 0x0F, 0x58,
  0xEE, 0xC6, 0x66, 0x33, 0x71, 0x83, 0x1C, 0x18, 0xC0, 0xC6, 0x0E, 0x70,
  0x70, 0x1C, 0x31, 0xC7, 0x3C, 0x73, 0xC6, 0x36, 0x63, 0x66, 0x36, 0xE7,
  0x6C, 0x73, 0xC6, 0x3C, 0x63, 0xCE, 0x3C, 0xE3, 0x8C, 0x18, 0x0F, 0x8F,
  0xF3, 0x9D, 0xC7, 0x71, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xEC, 0x3B,
  0x9C, 0xFF, 0x1F, 0x00, 0x1F, 0xC1, 0xFE, 0x1C, 0xE1, 0x87, 0x38, 0x73,
  0x8E, 0x39, 0xE3, 0xFC, 0x7F, 0x87, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0x0F, 0x8F, 0xF3, 0x9D, 0xC7, 0x71, 0xF8, 0x7E, 0x1F, 0x87, 0xC1,
  0xF0, 0xEC, 0x3B, 0x9C, 0xFF, 0x1F, 0x03, 0x00, 0xE0, 0x1E, 0x01, 0x80,
  0x1F, 0x83, 0xF8, 0x63, 0x9C, 0x73, 0x8E, 0x71, 0xCC, 0xF3, 0xFC, 0x7F,
  0x0E, 0x61, 0x8E, 0x31, 0xCE, 0x19, 0xC3, 0x80, 0x0F, 0xE3, 0xFC, 0x71,
  0x1C, 0x03, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x38, 0x07, 0x21,
  0xCF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x30, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x00,
  0x38, 0xE6, 0x1D, 0xC3, 0xB8, 0x67, 0x1C, 0xC3, 0xB8, 0x77, 0x0C, 0xE3,
  0x9C, 0x73, 0x0E, 0x73, 0x8F, 0xF0, 0xFC, 0x00, 0xE0, 0xFC, 0x1B, 0x87,
  0x70, 0xCE, 0x39, 0xC7, 0x39, 0xC7, 0x38, 0xEE, 0x0D, 0x81, 0xF0, 0x3C,
  0x07, 0x80, 0xE0, 0x00, 0x18, 0x39, 0xC1, 0x8E, 0x0C, 0x60, 0x63, 0x07,
  0x3B, 0x31, 0xD9, 0x8D, 0xEC, 0x6B, 0xC3, 0xDE, 0x1C, 0xF1, 0xE7, 0x8E,
  0x38, 0x71, 0xC0, 0x0C, 0x1C, 0x38, 0xE0, 0xE7, 0x01, 0xD8, 0x07, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x80, 0x3F, 0x01, 0xDC, 0x0E, 0x30,
  0x70, 0xE3, 0xC3, 0x80, 0xE0, 0xEC, 0x39, 0x87, 0x39, 0xC7, 0x70, 0xEE,
  0x0F, 0x81, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x00,
  0x1F, 0xF1, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xFF, 0x8F, 0xF8, 0x07, 0xE0, 0xFC,
  0x3F, 0x87, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0xF8, 0x7E,
  0x00, 0xCE, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x77, 0x77, 0x77, 0x73, 0x07,
  0xE0, 0xFC, 0x1F, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x06, 0x00, 0xC1,
  0xF8, 0x7F, 0x00, 0x07, 0x03, 0xC0, 0xF8, 0x7E, 0x3B, 0x9C, 0x7E, 0x1D,
  0x06, 0x7F, 0xEF, 0xFF, 0xFF, 0x00, 0x67, 0xCE, 0x10, 0x0F, 0x0F, 0xF7,
  0xFD, 0xC6, 0xE3, 0xB0, 0xEC, 0x3B, 0x0C, 0xE7, 0x3F, 0xC7, 0xB8, 0x02,
  0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0xC3, 0xFC, 0xFF, 0x38, 0xCC, 0x37,
  0x0D, 0xC7, 0x71, 0xD8, 0xEF, 0xF3, 0xF8, 0x07, 0x87, 0xF7, 0xF9, 0xC0,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF1, 0x1F, 0xC3, 0xF0, 0x00, 0x20, 0x1C,
  0x03, 0x80, 0x70, 0x0C, 0x0F, 0x8F, 0xF3, 0xFE, 0x71, 0x9C, 0x73, 0x0E,
  0x61, 0xCC, 0x31, 0xCE, 0x3F, 0xC3, 0xDC, 0x0F, 0x0F, 0xE7, 0x9D, 0x87,
  0xE1, 0xFF, 0xEF, 0xE3, 0x80, 0xE0, 0x9F, 0xC3, 0xF0, 0x00, 0x10, 0x03,
  0xF0, 0x0F, 0xC0, 0x70, 0x01, 0xC0, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x03,
  0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0x80, 0x0E, 0x01, 0xF8, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0xFF, 0x1F,
  0xF1, 0xC6, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x3F, 0xC1, 0xFC, 0x01,
  0xC0, 0x18, 0x7F, 0x8F, 0xF0, 0x3C, 0x00, 0x02, 0x03, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0xE3, 0xFC, 0xFF, 0x39, 0xCC, 0x77, 0x1D, 0xC7, 0x71, 0x9C,
  0xE6, 0x3B, 0x8E, 0x0C, 0x3C, 0x70, 0x60, 0x1F, 0xBF, 0x7C, 0x38, 0x70,
  0xE1, 0x87, 0x0E, 0x4F, 0x9F, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x00,
  0x1F, 0xC3, 0xF8, 0xFE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x0F, 0xE3, 0xF8, 0x3E, 0x00, 0x02, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC7, 0x18, 0xE3, 0x9C, 0x3B, 0x83, 0xF0,
  0x3E, 0x07, 0x70, 0x77, 0x07, 0x38, 0x73, 0x8E, 0x1C, 0x7F, 0xF8, 0x70,
  0xE1, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x2F, 0xCF, 0x80, 0x0C,
  0xC7, 0xFC, 0xDD, 0xBB, 0x36, 0x6E, 0xCD, 0x9B, 0xB7, 0x06, 0xC0, 0xD8,
  0x3B, 0x06, 0x00, 0x0F, 0x8F, 0xF3, 0xFC, 0xE7, 0x31, 0xDC, 0x77, 0x1D,
  0xC6, 0x73, 0x98, 0xEE, 0x38, 0x0E, 0x1F, 0xDF, 0xEC, 0x3E, 0x1F, 0x0F,
  0x0F, 0x87, 0xE7, 0x7F, 0x9F, 0x00, 0x07, 0x81, 0xFE, 0x1F, 0xE1, 0xC6,
  0x18, 0x73, 0x86, 0x38, 0xE3, 0x8E, 0x33, 0xC7, 0xF8, 0x7F, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x8F, 0xF7, 0xFD, 0xC6, 0xE3, 0xB8,
  0xEE, 0x3B, 0x8E, 0xE7, 0x3F, 0xC7, 0xF0, 0x1C, 0x06, 0x03, 0x80, 0xE0,
  0x0F, 0x8F, 0xF3, 0xF8, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38,
  0x0E, 0x00, 0x07, 0x87, 0xF3, 0xDC, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0E,
  0x43, 0x9F, 0xEF, 0xF0, 0x04, 0x0E, 0x06, 0x1F, 0xFF, 0xFF, 0xFC, 0xC0,
  0xE0, 0x70, 0x38, 0x18, 0x0E, 0x27, 0xE1, 0xF0, 0x71, 0xDC, 0x77, 0x19,
  0x8E, 0xE3, 0xB8, 0xEE, 0x33, 0x8C, 0xE7, 0x3F, 0xC7, 0xB8, 0xC1, 0xF0,
  0xEC, 0x3B, 0x9C, 0xE7, 0x3B, 0x8E, 0xE3, 0xF0, 0x78, 0x1E, 0x07, 0x00,
  0xE0, 0x7C, 0x1F, 0x03, 0x66, 0x6C, 0xCD, 0xBB, 0x35, 0x67, 0xAC, 0xE7,
  0x1C, 0xE3, 0x18, 0x00, 0x1C, 0x31, 0xC7, 0x0C, 0xE0, 0xFC, 0x07, 0x80,
  0x70, 0x0F, 0x81, 0xF8, 0x1D, 0xC3, 0x9C, 0xF0, 0xE0, 0x0E, 0x18, 0x71,
  0xC3, 0x8E, 0x1C, 0xE0, 0xE7, 0x07, 0x30, 0x3B, 0x80, 0xD8, 0x07, 0xC0,
  0x3C, 0x01, 0xC0, 0x0E, 0x07, 0xE0, 0x3E, 0x03, 0xC0, 0x00, 0x1F, 0xE3,
  0xFC, 0xFF, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0F, 0xF3,
  0xFE, 0x00, 0x01, 0xE0, 0x7C, 0x1F, 0x83, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x60, 0x1C, 0x0F, 0x03, 0xC0, 0x1C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x30, 0x07, 0x00, 0xF8, 0x0F, 0x00, 0x06, 0x1C, 0x38, 0x70, 0xC3, 0x87,
  0x0E, 0x18, 0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x00,
  0x07, 0x01, 0xF0, 0x3F, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x80, 0x3C, 0x0F, 0x81, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x03,
  0x81, 0xF0, 0x78, 0x00, 0x3C, 0x6F, 0xDD, 0xFF, 0x63, 0xC0,
};

const GFXglyph UbuntuSansMono_BoldItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 14, 11, 3, -14 },
  { 12, 9, 6, 11, 3, -15 },
  { 19, 12, 14, 11, 0, -14 },
  { 40, 11, 18, 11, 0, -16 },
  { 65, 14, 14, 11, -1, -14 },
  { 90, 11, 14, 11, 0, -14 },
  { 110, 4, 6, 11, 5, -15 },
  { 113, 9, 20, 11, 2, -16 },
  { 136, 9, 20, 11, 0, -16 },
  { 159, 9, 9, 11, 2, -14 },
  { 170, 10, 10, 11, 1, -11 },
  { 183, 6, 7, 11, 1, -4 },
  { 189, 7, 3, 11, 2, -7 },
  { 192, 4, 4, 11, 3, -4 },
  { 194, 13, 20, 11, -1, -16 },
  { 227, 10, 14, 11, 1, -14 },
  { 245, 9, 14, 11, 1, -14 },
  { 261, 11, 14, 11, 0, -14 },
  { 281, 11, 14, 11, 0, -14 },
  { 301, 11, 14, 11, 0, -14 },
  { 321, 12, 14, 11, 0, -14 },
  { 342, 11, 14, 11, 1, -14 },
  { 362, 10, 14, 11, 2, -14 },
  { 380, 10, 14, 11, 1, -14 },
  { 398, 11, 14, 11, 0, -14 },
  { 418, 5, 11, 11, 3, -11 },
  { 425, 7, 14, 11, 1, -11 },
  { 438, 10, 10, 11, 1, -11 },
  { 451, 11, 6, 11, 0, -9 },
  { 460, 11, 10, 11, 0, -11 },
  { 474, 8, 14, 11, 3, -14 },
  { 488, 12, 17, 11, 0, -14 },
  { 514, 11, 14, 11, -1, -14 },
  { 534, 11, 14, 11, 0, -14 },
  { 554, 11, 14, 11, 1, -14 },
  { 574, 11, 14, 11, 0, -14 },
  { 594, 12, 14, 11, 0, -14 },
  { 615, 12, 14, 11, 0, -14 },
  { 636, 11, 14, 11, 1, -14 },
  { 656, 12, 14, 11, 0, -14 },
  { 677, 12, 14, 11, 0, -14 },
  { 698, 12, 14, 11, 0, -14 },
  { 719, 13, 14, 11, 0, -14 },
  { 742, 9, 14, 11, 0, -14 },
  { 758, 13, 14, 11, -1, -14 },
  { 781, 12, 14, 11, 0, -14 },
  { 802, 10, 14, 11, 1, -14 },
  { 820, 12, 14, 11, 0, -14 },
  { 841, 10, 18, 11, 1, -14 },
  { 864, 11, 14, 11, 0, -14 },
  { 884, 11, 14, 11, 0, -14 },
  { 904, 11, 14, 11, 2, -14 },
  { 924, 11, 14, 11, 1, -14 },
  { 944, 11, 14, 11, 2, -14 },
  { 964, 13, 14, 11, 0, -14 },
  { 987, 14, 14, 11, -1, -14 },
  { 1012, 11, 14, 11, 2, -14 },
  { 1032, 12, 14, 11, 0, -14 },
  { 1053, 11, 20, 11, 1, -16 },
  { 1081, 4, 20, 11, 4, -16 },
  { 1091, 11, 20, 11, -1, -16 },
  { 1119, 10, 8, 11, 1, -14 },
  { 1129, 11, 3, 11, -2, 1 },
  { 1134, 5, 4, 11, 4, -15 },
  { 1137, 10, 11, 11, 1, -11 },
  { 1151, 10, 16, 11, 0, -16 },
  { 1171, 10, 11, 11, 1, -11 },
  { 1185, 11, 16, 11, 1, -16 },
  { 1207, 10, 11, 11, 1, -11 },
  { 1221, 14, 20, 11, -2, -16 },
  { 1256, 12, 15, 11, -1, -11 },
  { 1279, 10, 16, 11, 0, -16 },
  { 1299, 7, 16, 11, 2, -16 },
  { 1313, 11, 20, 11, -1, -16 },
  { 1341, 12, 16, 11, 0, -16 },
  { 1365, 7, 15, 11, 2, -15 },
  { 1379, 11, 11, 11, 0, -11 },
  { 1395, 10, 11, 11, 0, -11 },
  { 1409, 9, 11, 11, 1, -11 },
  { 1422, 12, 15, 11, -1, -11 },
  { 1445, 10, 15, 11, 1, -11 },
  { 1464, 10, 11, 11, 1, -11 },
  { 1478, 10, 11, 11, 0, -11 },
  { 1492, 9, 14, 11, 2, -14 },
  { 1508, 10, 11, 11, 1, -11 },
  { 1522, 10, 11, 11, 2, -11 },
  { 1536, 11, 11, 11, 1, -11 },
  { 1552, 12, 11, 11, -1, -11 },
  { 1569, 13, 15, 11, -2, -11 },
  { 1594, 11, 11, 11, 0, -11 },
  { 1610, 11, 20, 11, 1, -16 },
  { 1638, 7, 20, 11, 2, -16 },
  { 1656, 11, 20, 11, -1, -16 },
  { 1684, 11, 4, 11, 0, -8 },
};

const GFXfont UbuntuSansMono_BoldItalic20pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic20pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic20pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _UBUNTUSANSMONO_BOLDITALIC20PT7B_H_
