#ifndef _UBUNTUSANSMONO_BOLDITALIC30PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic30pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x0F,
  0xC3, 0xF0, 0x78, 0x00, 0x7C, 0xF7, 0x8F, 0x78, 0xF7, 0x9F, 0x79, 0xEF,
  0x1E, 0xF1, 0xEE, 0x1C, 0xE1, 0xCE, 0x18, 0x00, 0xF3, 0xC0, 0x38, 0xE0,
  0x1E, 0x78, 0x07, 0x1C, 0x03, 0xC7, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFF, 0x83, 0xC7, 0x00, 0xE3, 0xC0, 0x38, 0xE0, 0x1E, 0x78,
  0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x38, 0xE0, 0x1E, 0x78, 0x07,
  0x1C, 0x03, 0xC7, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x3F, 0xC0, 0x7F, 0xF8, 0x7F, 0xF8, 0x3E, 0x1C, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x08, 0x0F, 0x0F,
  0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0x3F, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x70, 0xFC, 0x0E, 0x0E, 0xE1, 0xC1, 0xCE,
  0x1C, 0x1C, 0xE3, 0x81, 0xCC, 0x70, 0x19, 0xCE, 0x01, 0xFD, 0xC0, 0x1F,
  0xB8, 0x00, 0xF7, 0x80, 0x00, 0x70, 0x00, 0x0E, 0xF0, 0x01, 0xDF, 0x80,
  0x39, 0xF8, 0x07, 0x39, 0x80, 0xE3, 0x18, 0x0E, 0x33, 0x81, 0xC7, 0x38,
  0x38, 0x77, 0x07, 0x03, 0xF0, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x03, 0xFC,
  0x07, 0xFE, 0x07, 0x1E, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x1C, 0x0F, 0x38,
  0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC7, 0x1F, 0xC7, 0x3D, 0xEF, 0x79, 0xEE,
  0x70, 0xFE, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0xFC, 0x7F, 0xFC, 0x7F, 0xDE,
  0x3F, 0x9E, 0x7D, 0xF7, 0x9E, 0x79, 0xCF, 0x3C, 0xE3, 0x80, 0x00, 0x08,
  0x00, 0xE0, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0C,
  0x00, 0x10, 0x00, 0x00, 0x80, 0x07, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0x70, 0x01, 0x00, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x19, 0xC6, 0x77, 0x7B, 0xFF, 0xEF, 0xFF, 0xC1, 0xE0, 0x0F, 0xC0,
  0x77, 0x87, 0xDF, 0x0F, 0x3C, 0x18, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x0F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0x04, 0x1F, 0x3F, 0x3F, 0x3F, 0x1F, 0x0E, 0x1E, 0xFC, 0xF8, 0xE0, 0x7F,
  0xEF, 0xF9, 0xFF, 0x7F, 0xE0, 0x11, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0x1E, 0x1E, 0x0F, 0x3C, 0x0F, 0x3C,
  0x0F, 0x78, 0x0F, 0x79, 0xCF, 0x7B, 0xCE, 0x73, 0xDE, 0xF3, 0x9E, 0xF0,
  0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF8, 0xF8, 0x7F,
  0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x00, 0x38, 0x07, 0xC0, 0x7E, 0x0F, 0xF3,
  0xFF, 0x0F, 0xF8, 0x73, 0xC2, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xF3,
  0xE0, 0x40, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC0, 0x03, 0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x06, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x03, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xFC, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x60,
  0x7C, 0xFF, 0xF8, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0x78, 0x0F, 0x3C, 0x0F, 0x3C,
  0x07, 0x1E, 0x07, 0x0F, 0x07, 0x07, 0x87, 0x87, 0x87, 0x83, 0xC3, 0xFF,
  0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F,
  0xF0, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07,
  0xF8, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x30, 0x3E, 0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFC, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7B, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC, 0xF8,
  0x3C, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3C, 0x78, 0x3C, 0x7C,
  0x7C, 0x7F, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F,
  0xFE, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x03, 0xF8, 0x07, 0xFE, 0x0F, 0xFE, 0x1F, 0x1F, 0x1E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x1E, 0x1E, 0x1F, 0x3C, 0x0F, 0xF8, 0x0F, 0xF0, 0x3F,
  0xF8, 0x7C, 0x78, 0x78, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x7C, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0xE0, 0x03, 0xF0, 0x0F, 0xFC, 0x1F,
  0xFE, 0x3F, 0x3E, 0x3C, 0x1E, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78,
  0x0F, 0x7C, 0x1F, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xDE, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC,
  0x00, 0x06, 0x0F, 0x87, 0xE3, 0xF1, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x0F, 0x8F, 0xC7, 0xE3, 0xF0, 0xF0, 0x01, 0x80, 0xF8, 0x1F, 0x83,
  0xF0, 0x7C, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x0F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x0E, 0x03, 0xC3, 0xF0, 0x7C, 0x0E, 0x00,
  0x00, 0x02, 0x00, 0x0E, 0x00, 0x7F, 0x03, 0xFF, 0x0F, 0xFC, 0x7F, 0xE0,
  0x7F, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xF8, 0x00, 0x38, 0x00, 0x08, 0x1F, 0xFF, 0x9F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x7F,
  0xFE, 0x7F, 0xFF, 0x00, 0x10, 0x00, 0x78, 0x00, 0xFC, 0x03, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3E, 0x03, 0xFC, 0x3F, 0xF3, 0xFF,
  0x07, 0xF8, 0x0F, 0x80, 0x1C, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xE3, 0xFF,
  0x9F, 0xFC, 0x63, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x20, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x03, 0xFF,
  0x83, 0xFF, 0xC3, 0xE0, 0xE1, 0xC0, 0x79, 0xC0, 0x3D, 0xE1, 0xFC, 0xE1,
  0xFE, 0x71, 0xFF, 0x79, 0xE7, 0xB9, 0xE3, 0xDC, 0xF1, 0xCE, 0x70, 0xE7,
  0x38, 0xF3, 0x9C, 0x79, 0xCE, 0x38, 0xE7, 0x9C, 0x73, 0xFE, 0x38, 0xFF,
  0x1C, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0xC0, 0x7F, 0xE0, 0x1F,
  0xF0, 0x00, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xEE, 0x01, 0xEE, 0x01, 0xCE, 0x03, 0xCE, 0x03, 0x8E, 0x07, 0x8E,
  0x07, 0x0E, 0x0F, 0x0F, 0x0E, 0x0F, 0x1F, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF,
  0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x07, 0xFC,
  0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xF7, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x78,
  0x1C, 0x3C, 0x1E, 0x1E, 0xFE, 0x0F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0xC3,
  0xC1, 0xE1, 0xE0, 0x78, 0xF0, 0x3C, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x3F,
  0x1F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0x0F,
  0xFE, 0x1F, 0x8E, 0x3E, 0x02, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x30, 0x7F, 0xF0, 0x7F, 0xF0, 0x1F,
  0xE0, 0x07, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE0, 0xF0, 0xF0,
  0xF8, 0x78, 0x78, 0x3C, 0x3C, 0x1F, 0x1E, 0x0F, 0x1F, 0x07, 0x8F, 0x03,
  0xC7, 0x81, 0xE3, 0xC1, 0xF1, 0xE0, 0xF9, 0xE0, 0x78, 0xF0, 0x7C, 0x78,
  0x7C, 0x3C, 0xFC, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0x00, 0x0F, 0xFF,
  0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0xE1, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0x87, 0xFF, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF0, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xF8,
  0xE1, 0xF0, 0x10, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x07, 0x8F, 0x03, 0xCF, 0x83, 0xC7, 0x81, 0xE3, 0xE0, 0xF1,
  0xF0, 0x78, 0x78, 0x7C, 0x3E, 0x3C, 0x1F, 0xFE, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x07, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F, 0x07,
  0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1F, 0xFF, 0x0F, 0xFF, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x3C, 0x1E, 0x1F, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0x78, 0x78, 0x3E, 0x3E, 0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x7C,
  0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x20,
  0x78, 0x38, 0x7C, 0x3F, 0xFC, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0x83,
  0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x07, 0x87, 0x80, 0xF1, 0xF0, 0x3E, 0x7C,
  0x07, 0x9F, 0x00, 0xF7, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xDF, 0x00, 0x79, 0xE0, 0x1E, 0x3E, 0x03, 0xC3, 0xC0,
  0x78, 0x7C, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0x78, 0x1F, 0x0F, 0x03, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF8, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x7C, 0x1D, 0x8F, 0x83, 0xB3, 0xF0, 0x76, 0x6E, 0x1E, 0xDD, 0xC3, 0x9F,
  0x78, 0x73, 0xEE, 0x0E, 0x79, 0xC3, 0xCF, 0x38, 0x71, 0xCF, 0x0E, 0x01,
  0xE3, 0xC0, 0x38, 0x78, 0x07, 0x0F, 0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x07,
  0x8F, 0x01, 0xE0, 0x07, 0x01, 0xC3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3E, 0x0F,
  0x0F, 0x83, 0x87, 0xF1, 0xE1, 0xFC, 0x78, 0x7F, 0x1E, 0x1D, 0xC7, 0x0F,
  0x39, 0xC3, 0xCE, 0xF0, 0xF3, 0xBC, 0x38, 0xEE, 0x1E, 0x1F, 0x87, 0x87,
  0xE1, 0xE1, 0xF8, 0x70, 0x7C, 0x3C, 0x1F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0,
  0xE0, 0x3C, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE, 0x1F, 0xBE, 0x1E,
  0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0xF8,
  0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0,
  0x78, 0xF8, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x1F, 0xC0, 0x07, 0xFC, 0x03,
  0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x7C, 0x1E,
  0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x0F, 0xC7, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x0F, 0xFE,
  0x1F, 0xBE, 0x1E, 0x1F, 0x3C, 0x0F, 0x3C, 0x0F, 0x78, 0x0F, 0x78, 0x0F,
  0x78, 0x1F, 0xF8, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C,
  0xF0, 0x3C, 0xF0, 0x78, 0xF8, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x3F, 0xC0,
  0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x60,
  0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xC1, 0xE7, 0xE0, 0xF0, 0xF8, 0x78,
  0x7C, 0x78, 0x3E, 0x3C, 0x1E, 0x1E, 0x0F, 0x0F, 0x1F, 0x8F, 0xFF, 0x87,
  0xFF, 0x83, 0xFF, 0x01, 0xE7, 0x81, 0xF3, 0xE0, 0xF0, 0xF0, 0x78, 0x78,
  0x3C, 0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xE0, 0x01, 0xFF, 0x03,
  0xFF, 0xC1, 0xFF, 0xC1, 0xF0, 0xE0, 0xF0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x40, 0x3C, 0x38, 0x3E, 0x3F,
  0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFE, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x1F, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xE3, 0xE0, 0xF1, 0xE0,
  0x78, 0xF0, 0x3C, 0x78, 0x3C, 0x7C, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8F,
  0x07, 0x8F, 0x83, 0xC7, 0x81, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78,
  0x7C, 0x7C, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0,
  0x78, 0xF0, 0x78, 0x70, 0xF0, 0x70, 0xF0, 0x71, 0xE0, 0x71, 0xE0, 0x7B,
  0xC0, 0x7B, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x0F, 0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00,
  0xE1, 0xE0, 0x3C, 0x38, 0x07, 0x87, 0x00, 0xE1, 0xE0, 0x1C, 0x3C, 0xE3,
  0x87, 0x3C, 0xF0, 0xE7, 0x9C, 0x1D, 0xF3, 0x87, 0xB6, 0x70, 0xEE, 0xDE,
  0x1D, 0x9F, 0x83, 0xF3, 0xF0, 0x7C, 0x7E, 0x0F, 0x8F, 0x83, 0xE1, 0xF0,
  0x7C, 0x3E, 0x0F, 0x03, 0x80, 0x07, 0x80, 0xF0, 0x78, 0x1E, 0x03, 0xC3,
  0xE0, 0x3C, 0x3C, 0x03, 0xE7, 0x80, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xBC, 0x00, 0xF1, 0xE0, 0x1F, 0x1E, 0x03,
  0xE1, 0xE0, 0x3C, 0x1E, 0x07, 0xC1, 0xE0, 0xF8, 0x0F, 0x00, 0xF0, 0x1F,
  0xF0, 0x3E, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0x79, 0xE0,
  0x79, 0xE0, 0x7B, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80,
  0xFF, 0x80, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0xF1, 0xE7, 0x9E, 0x79,
  0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x3C, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C,
  0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xFC,
  0x0F, 0xBC, 0x1F, 0x3C, 0x1E, 0x3E, 0x3C, 0x1E, 0x7C, 0x1E, 0xF8, 0x1F,
  0x30, 0x0C, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x60, 0xE3,
  0xE3, 0xF1, 0xE0, 0x80, 0x03, 0xFC, 0x1F, 0xFC, 0x7F, 0xF9, 0xF9, 0xF7,
  0xC3, 0xEF, 0x07, 0xBE, 0x0F, 0x78, 0x1E, 0xF0, 0x7D, 0xE0, 0xF3, 0xC1,
  0xE7, 0x83, 0xCF, 0x9F, 0x9F, 0xFF, 0x1F, 0xFE, 0x1F, 0x9E, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xBE, 0x1E, 0x1E, 0x3E, 0x1F,
  0x3C, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x78, 0x3E, 0x78, 0x3C,
  0x78, 0xFC, 0x7F, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x07, 0xFE,
  0x1F, 0xFE, 0x3F, 0xCC, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x18, 0x7F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xFE, 0x0F, 0xFE, 0x0F,
  0xFF, 0x0F, 0xCF, 0x8F, 0x87, 0xC7, 0x83, 0xC7, 0xC1, 0xE3, 0xC0, 0xF1,
  0xE0, 0xF8, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E, 0x1F, 0x3F, 0x0F, 0xFF,
  0x83, 0xFF, 0xC0, 0xFC, 0xF0, 0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0xF9, 0xF8,
  0xF3, 0xC1, 0xEF, 0x03, 0xDE, 0x0F, 0xFB, 0xFE, 0xFF, 0xF9, 0xFF, 0xC3,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x8F, 0xFF, 0x0F, 0xFE, 0x0F, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7C, 0x40, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x01, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x8F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F,
  0x1E, 0x0F, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C, 0x0F,
  0x0F, 0x07, 0xC3, 0xE1, 0xE0, 0x7D, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x80,
  0x7B, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x10, 0x3E, 0x07, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0xE0, 0x03, 0x40, 0x00, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0xFC, 0x0F, 0xFE, 0x3F,
  0xFC, 0x7E, 0xF8, 0xF0, 0xF1, 0xE1, 0xE7, 0xC3, 0xCF, 0x07, 0x9E, 0x0F,
  0x3C, 0x3E, 0x78, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x87, 0xCF, 0x0F, 0x3C,
  0x1E, 0x00, 0x00, 0x80, 0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x18, 0x00,
  0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x7F, 0x8F, 0xF8, 0x07, 0x80, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1F, 0x11, 0xFF, 0x0F,
  0xF0, 0x7F, 0x00, 0x02, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0x01,
  0xFF, 0x81, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x20, 0xF0, 0x3F, 0xF8, 0x1F,
  0xF8, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x1F, 0x1E,
  0x1F, 0x0F, 0x1F, 0x07, 0x9F, 0x07, 0x9F, 0x03, 0xDF, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0xFF, 0x80, 0x7B, 0xE0, 0x3C, 0xF0, 0x1E, 0x7C, 0x1F, 0x1E,
  0x0F, 0x0F, 0x87, 0x83, 0xC3, 0xC1, 0xF0, 0xFF, 0xBF, 0xEF, 0xF0, 0x3C,
  0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE3, 0x7F, 0xDF, 0xF3, 0xFC,
  0x07, 0xCF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x79, 0xCF, 0x1E, 0x73, 0x87,
  0x3C, 0xE1, 0xCE, 0x38, 0xF3, 0x9E, 0x3C, 0xE7, 0x8E, 0x79, 0xC3, 0x80,
  0x70, 0xE0, 0x3C, 0x78, 0x0F, 0x1C, 0x03, 0x87, 0x00, 0xE3, 0xC0, 0x78,
  0x07, 0xF8, 0x1F, 0xFC, 0x7F, 0xF8, 0xFD, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF,
  0x87, 0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x7C, 0xF0, 0xF3, 0xC1, 0xE7, 0x83,
  0xCF, 0x0F, 0x9E, 0x1E, 0x78, 0x3C, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0xF1,
  0xF3, 0xE7, 0xC3, 0xEF, 0x07, 0xDE, 0x07, 0xF8, 0x0F, 0xF0, 0x3D, 0xE0,
  0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x8F, 0x9F, 0xFE, 0x1F, 0xF8, 0x1F, 0xE0,
  0x03, 0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC1, 0xE3, 0xE0, 0xF0, 0xF8, 0x78,
  0x3C, 0x78, 0x1E, 0x3C, 0x1F, 0x1E, 0x0F, 0x0F, 0x07, 0x8F, 0x87, 0xC7,
  0x87, 0xC3, 0xC7, 0xE1, 0xFF, 0xE1, 0xFF, 0xE0, 0xFF, 0xC0, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xFC, 0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0x1E, 0x3C, 0x1E, 0x7C, 0x3E, 0x78,
  0x3C, 0xF8, 0x3C, 0xF0, 0x3C, 0xF0, 0x7C, 0xF0, 0x78, 0xF0, 0x78, 0xF8,
  0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xFF, 0x0F, 0xFE, 0x1F,
  0xFE, 0x1F, 0xFC, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0x8C, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x3C, 0x30, 0x7C, 0x7F, 0xF8, 0xFF, 0xF8, 0x3F, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x07, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF,
  0x7F, 0xFE, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x30, 0x7F, 0xE0, 0x7F, 0xC0, 0x7F,
  0x80, 0x1E, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE1, 0xF3, 0xC3, 0xCF, 0x87,
  0x9E, 0x0F, 0x3C, 0x3E, 0x78, 0x79, 0xF0, 0xF3, 0xC1, 0xE7, 0x83, 0xCF,
  0x9F, 0x8F, 0xFF, 0x1F, 0xFE, 0x1F, 0x9E, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0,
  0xF3, 0xC1, 0xE7, 0x87, 0xCF, 0x0F, 0x1E, 0x3C, 0x3C, 0x78, 0x79, 0xE0,
  0xF3, 0xC1, 0xEF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x78, 0x07, 0xBC, 0x03, 0xDC, 0x01, 0xCE, 0x38, 0xE7, 0x1C, 0xF7,
  0x9E, 0x73, 0xCF, 0x39, 0xCF, 0x9C, 0xE6, 0xDC, 0x77, 0x6E, 0x3B, 0x37,
  0x1F, 0x9F, 0x0F, 0x8F, 0x87, 0xC7, 0x83, 0xC3, 0xC1, 0xC1, 0xC0, 0x1F,
  0x03, 0xC3, 0xC1, 0xE0, 0x78, 0xF8, 0x1E, 0x7C, 0x03, 0xDE, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x3F, 0xF0, 0x1F, 0x3C, 0x0F, 0x8F, 0x87, 0xC1, 0xE3, 0xE0, 0x78, 0x03,
  0xC0, 0xF0, 0x3C, 0x1F, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC3, 0xE0,
  0x3C, 0x3C, 0x03, 0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x1E, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF,
  0xC1, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xE1,
  0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0,
  0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0xFE, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x7F, 0x80, 0xFF, 0x00,
  0xFE, 0x00, 0xF8, 0x00, 0x0F, 0x02, 0x0F, 0xE3, 0xCF, 0xFF, 0xCF, 0xFF,
  0xC7, 0x1F, 0xE7, 0x83, 0xC0,
};

const GFXglyph UbuntuSansMono_BoldItalic30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 10, 21, 17, 4, -21 },
  { 28, 12, 10, 17, 5, -23 },
  { 43, 18, 21, 17, 0, -21 },
  { 91, 17, 26, 17, 0, -23 },
  { 147, 20, 21, 17, -1, -21 },
  { 200, 16, 21, 17, 0, -21 },
  { 242, 6, 10, 17, 8, -23 },
  { 250, 14, 30, 17, 3, -24 },
  { 303, 14, 30, 17, 0, -24 },
  { 356, 14, 13, 17, 3, -21 },
  { 379, 15, 15, 17, 1, -16 },
  { 408, 8, 11, 17, 2, -6 },
  { 419, 11, 4, 17, 3, -11 },
  { 425, 6, 6, 17, 4, -6 },
  { 430, 20, 29, 17, -2, -23 },
  { 503, 16, 21, 17, 1, -21 },
  { 545, 13, 21, 17, 1, -21 },
  { 580, 17, 21, 17, 0, -21 },
  { 625, 16, 21, 17, 0, -21 },
  { 667, 17, 21, 17, 0, -21 },
  { 712, 17, 21, 17, 0, -21 },
  { 757, 16, 21, 17, 1, -21 },
  { 799, 16, 21, 17, 3, -21 },
  { 841, 16, 21, 17, 1, -21 },
  { 883, 16, 21, 17, 1, -21 },
  { 925, 9, 16, 17, 4, -16 },
  { 943, 11, 21, 17, 2, -16 },
  { 972, 16, 15, 17, 1, -16 },
  { 1002, 17, 10, 17, 0, -14 },
  { 1024, 15, 15, 17, 1, -16 },
  { 1053, 13, 21, 17, 4, -21 },
  { 1088, 17, 26, 17, 1, -21 },
  { 1144, 16, 21, 17, -1, -21 },
  { 1186, 17, 21, 17, 0, -21 },
  { 1231, 16, 21, 17, 2, -21 },
  { 1273, 17, 21, 17, 0, -21 },
  { 1318, 17, 21, 17, 1, -21 },
  { 1363, 17, 21, 17, 1, -21 },
  { 1408, 17, 21, 17, 1, -21 },
  { 1453, 18, 21, 17, 0, -21 },
  { 1501, 18, 21, 17, 0, -21 },
  { 1549, 17, 21, 17, 0, -21 },
  { 1594, 19, 21, 17, 0, -21 },
  { 1644, 14, 21, 17, 0, -21 },
  { 1681, 19, 21, 17, -1, -21 },
  { 1731, 18, 21, 17, 0, -21 },
  { 1779, 16, 21, 17, 1, -21 },
  { 1821, 17, 21, 17, 0, -21 },
  { 1866, 16, 27, 17, 1, -21 },
  { 1920, 17, 21, 17, 0, -21 },
  { 1965, 17, 21, 17, 0, -21 },
  { 2010, 16, 21, 17, 3, -21 },
  { 2052, 17, 21, 17, 1, -21 },
  { 2097, 16, 21, 17, 3, -21 },
  { 2139, 19, 21, 17, 0, -21 },
  { 2189, 20, 21, 17, -1, -21 },
  { 2242, 16, 21, 17, 4, -21 },
  { 2284, 18, 21, 17, 0, -21 },
  { 2332, 16, 29, 17, 2, -23 },
  { 2390, 6, 29, 17, 6, -23 },
  { 2412, 17, 29, 17, -1, -23 },
  { 2474, 16, 12, 17, 1, -21 },
  { 2498, 16, 4, 17, -2, 2 },
  { 2506, 7, 6, 17, 7, -23 },
  { 2512, 15, 16, 17, 1, -16 },
  { 2542, 16, 23, 17, 0, -23 },
  { 2588, 16, 16, 17, 1, -16 },
  { 2620, 17, 23, 17, 1, -23 },
  { 2669, 15, 16, 17, 1, -16 },
  { 2699, 21, 29, 17, -2, -23 },
  { 2776, 18, 22, 17, -1, -16 },
  { 2826, 15, 23, 17, 0, -23 },
  { 2870, 12, 24, 17, 2, -24 },
  { 2906, 17, 30, 17, -1, -24 },
  { 2970, 17, 23, 17, 1, -23 },
  { 3019, 10, 23, 17, 4, -23 },
  { 3048, 18, 16, 17, -1, -16 },
  { 3084, 15, 16, 17, 0, -16 },
  { 3114, 15, 16, 17, 1, -16 },
  { 3144, 17, 22, 17, -1, -16 },
  { 3191, 16, 22, 17, 1, -16 },
  { 3235, 16, 16, 17, 1, -16 },
  { 3267, 16, 16, 17, 0, -16 },
  { 3299, 15, 20, 17, 2, -20 },
  { 3337, 15, 16, 17, 1, -16 },
  { 3367, 15, 16, 17, 2, -16 },
  { 3397, 17, 16, 17, 1, -16 },
  { 3431, 18, 16, 17, -1, -16 },
  { 3467, 20, 22, 17, -3, -16 },
  { 3522, 17, 16, 17, 0, -16 },
  { 3556, 16, 29, 17, 2, -23 },
  { 3614, 11, 29, 17, 3, -23 },
  { 3654, 16, 29, 17, -1, -23 },
  { 3712, 17, 6, 17, 0, -12 },
};

const GFXfont UbuntuSansMono_BoldItalic30pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic30pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic30pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _UBUNTUSANSMONO_BOLDITALIC30PT7B_H_
