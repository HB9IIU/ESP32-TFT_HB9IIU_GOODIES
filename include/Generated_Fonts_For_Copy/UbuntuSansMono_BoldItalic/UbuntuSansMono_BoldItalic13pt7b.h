#ifndef _UBUNTUSANSMONO_BOLDITALIC13PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x66, 0x64, 0x0C, 0xC0, 0x6F, 0x6D, 0xB4, 0x1B, 0x12, 0x7F,
  0x7E, 0x2C, 0xFE, 0xFE, 0x58, 0xD0, 0x0C, 0x38, 0xFB, 0x03, 0x07, 0x83,
  0x02, 0xFC, 0xF0, 0x80, 0x18, 0x94, 0x8A, 0x87, 0x80, 0xC0, 0xF8, 0x54,
  0x4A, 0xC6, 0x00, 0x1C, 0x68, 0x91, 0x43, 0x2B, 0xF3, 0x66, 0x76, 0xFA,
  0x0C, 0x63, 0x0C, 0x61, 0x84, 0x30, 0xC1, 0x06, 0x0C, 0x18, 0x60, 0xC3,
  0x0C, 0x30, 0xC6, 0x18, 0xC6, 0x30, 0x31, 0x5F, 0xCC, 0x6C, 0xA0, 0x08,
  0x31, 0xFF, 0xF1, 0x06, 0x00, 0x6C, 0xE0, 0x7F, 0xC0, 0xF0, 0x01, 0x81,
  0x80, 0x80, 0xC0, 0x40, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x1C, 0x00,
  0x1E, 0x6D, 0x8B, 0x55, 0xE8, 0xF1, 0x36, 0x78, 0x0D, 0xF3, 0xC2, 0x18,
  0x61, 0x84, 0xFC, 0x3E, 0x6C, 0x18, 0x31, 0xC6, 0x18, 0x60, 0xFC, 0x3E,
  0x4C, 0x18, 0x63, 0xC1, 0x81, 0x46, 0xF8, 0x06, 0x1C, 0x79, 0xB6, 0x5F,
  0xFF, 0x86, 0x08, 0x1F, 0x30, 0x30, 0x30, 0x7C, 0x0C, 0x04, 0x8C, 0xF8,
  0x1E, 0xF1, 0x87, 0x8F, 0xD1, 0xA3, 0x6C, 0xF8, 0x7F, 0xFC, 0x30, 0xC3,
  0x06, 0x18, 0x30, 0xC0, 0x1E, 0x6C, 0x89, 0xB3, 0x8D, 0xB1, 0xE6, 0x78,
  0x3C, 0xCD, 0x9B, 0x37, 0xE2, 0xC3, 0x1C, 0xF0, 0x6C, 0x0D, 0x80, 0x33,
  0x00, 0x66, 0x2C, 0x04, 0xFF, 0x30, 0x70, 0x60, 0x7E, 0xFC, 0x07, 0xF0,
  0x20, 0xF0, 0x78, 0x77, 0x9C, 0x00, 0xFC, 0xC6, 0x66, 0x60, 0x18, 0xC0,
  0x1E, 0x33, 0x63, 0x5E, 0x52, 0xD6, 0xF6, 0xDC, 0xC8, 0x64, 0x38, 0x06,
  0x1C, 0x28, 0xD1, 0x27, 0xCF, 0xB1, 0xC2, 0x3E, 0x6C, 0x8B, 0x77, 0xCC,
  0xD1, 0xE6, 0xF8, 0x3E, 0xE9, 0x06, 0x0C, 0x18, 0x30, 0x64, 0x78, 0x3C,
  0x5D, 0x9B, 0x36, 0x6C, 0xF3, 0x6E, 0xF8, 0x3F, 0x30, 0x30, 0x3C, 0x7C,
  0x60, 0x60, 0x40, 0xFC, 0x3F, 0x30, 0x30, 0x22, 0x7C, 0x60, 0x60, 0x40,
  0xC0, 0x3E, 0xEB, 0x06, 0x0C, 0xD1, 0xA2, 0x6C, 0xF8, 0x33, 0x23, 0x62,
  0x66, 0x7E, 0x46, 0xC4, 0xCC, 0xCC, 0x3F, 0x0C, 0x18, 0x18, 0x18, 0x18,
  0x10, 0x30, 0xFC, 0x1F, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0xDC, 0xF8,
  0x33, 0x26, 0x6C, 0x78, 0x78, 0x78, 0xCC, 0xCC, 0xCC, 0x30, 0xC2, 0x18,
  0x61, 0x84, 0x30, 0xFC, 0x33, 0x37, 0x76, 0x5A, 0x5A, 0x56, 0xC6, 0xC4,
  0x84, 0x33, 0x33, 0x72, 0x7A, 0x5E, 0x4E, 0xCC, 0xCC, 0xCC, 0x1E, 0x6D,
  0x8B, 0x34, 0x78, 0xF1, 0xB6, 0x78, 0x3E, 0x36, 0x23, 0x62, 0x7E, 0x78,
  0x40, 0xC0, 0xC0, 0x1E, 0x6D, 0x8B, 0x34, 0x78, 0xF1, 0xB6, 0x78, 0x60,
  0xF0, 0x3C, 0x6D, 0x9B, 0x37, 0xCF, 0x13, 0x66, 0xCC, 0x3E, 0x65, 0x81,
  0x83, 0xC1, 0x81, 0x66, 0xF8, 0x7F, 0x20, 0xC1, 0x83, 0x06, 0x18, 0x30,
  0x60, 0x33, 0x22, 0x66, 0x66, 0x66, 0x46, 0xCC, 0xEC, 0x78, 0xC7, 0x8F,
  0x16, 0x64, 0x8B, 0x14, 0x38, 0x60, 0x21, 0x63, 0x63, 0x5A, 0x5A, 0x6E,
  0xEC, 0xCC, 0xCC, 0x19, 0x8D, 0x82, 0x81, 0xC0, 0xC0, 0xF0, 0xD8, 0x6C,
  0xE2, 0x00, 0x8E, 0x3D, 0xBC, 0xE1, 0x84, 0x30, 0xC0, 0x3F, 0x06, 0x0C,
  0x0C, 0x18, 0x30, 0x60, 0xC0, 0xFC, 0x1E, 0x60, 0xC1, 0x82, 0x0C, 0x18,
  0x30, 0x41, 0x83, 0x07, 0x80, 0xC9, 0x26, 0xDB, 0x6D, 0x90, 0x3E, 0x08,
  0x30, 0x60, 0xC1, 0x06, 0x0C, 0x18, 0x20, 0xC7, 0x80, 0x18, 0xE6, 0xF3,
  0x8C, 0xFE, 0xDC, 0x80, 0x1E, 0xFD, 0x9E, 0x2C, 0xDD, 0x9F, 0x00, 0x30,
  0x60, 0xC1, 0xE7, 0xEC, 0xD9, 0xA2, 0xCD, 0xF0, 0x3D, 0xFC, 0x20, 0x83,
  0x2F, 0x80, 0x03, 0x03, 0x02, 0x1E, 0x7E, 0x66, 0xC4, 0xCC, 0xEC, 0x7C,
  0x39, 0xBC, 0xFE, 0xE3, 0x2F, 0x80, 0x07, 0x87, 0x43, 0x03, 0xE3, 0xF0,
  0x40, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x1E, 0x00, 0x0F, 0x3B, 0x33, 0x22,
  0x26, 0x3E, 0x16, 0x4C, 0xFC, 0x30, 0x60, 0xC1, 0xE7, 0xEC, 0xD9, 0x26,
  0xCD, 0x98, 0x39, 0x81, 0xEF, 0x18, 0x8C, 0x69, 0xC0, 0x03, 0x07, 0x00,
  0x1E, 0x3E, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x4C, 0xF8, 0x10, 0x30, 0x30,
  0x37, 0x2C, 0x78, 0x78, 0x78, 0x4C, 0xCC, 0xF6, 0x66, 0x6C, 0xCC, 0xDF,
  0x76, 0xF5, 0x6A, 0xBC, 0x78, 0xA3, 0x00, 0x3C, 0xFD, 0x9B, 0x24, 0xD9,
  0xB3, 0x00, 0x3C, 0xFD, 0x9A, 0x3C, 0x4D, 0x9E, 0x00, 0x1E, 0x3F, 0x33,
  0x33, 0x22, 0x6E, 0x7C, 0x60, 0xC0, 0x1E, 0x7D, 0x9A, 0x2C, 0xCD, 0x9F,
  0x06, 0x18, 0x3E, 0x7C, 0x83, 0x06, 0x0C, 0x30, 0x00, 0x3E, 0x69, 0x81,
  0xC0, 0xC9, 0xBE, 0x00, 0x30, 0xCF, 0xFF, 0x61, 0x86, 0x1A, 0x78, 0x4F,
  0x3C, 0xF2, 0x9B, 0x6F, 0x80, 0xC7, 0x9B, 0x26, 0xCD, 0x0E, 0x18, 0x00,
  0x63, 0x42, 0x5A, 0x5E, 0xEC, 0xEC, 0xCC, 0x66, 0x68, 0xF0, 0xC3, 0x8D,
  0xB3, 0x00, 0x33, 0x33, 0x33, 0x36, 0x16, 0x1C, 0x18, 0x18, 0xF0, 0x3E,
  0x7C, 0x30, 0xC3, 0x0C, 0x3F, 0x00, 0x1E, 0x30, 0x41, 0x83, 0x1C, 0x38,
  0x30, 0x60, 0xC1, 0x03, 0x80, 0x18, 0xC4, 0x63, 0x18, 0x8C, 0x63, 0x19,
  0x80, 0x1C, 0x0C, 0x18, 0x20, 0xC0, 0xC3, 0x84, 0x18, 0x30, 0x67, 0x80,
  0x73, 0xFC,
};

const GFXglyph UbuntuSansMono_BoldItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 9, 7, 2, -9 },
  { 6, 6, 4, 7, 2, -10 },
  { 9, 8, 9, 7, 0, -9 },
  { 18, 7, 11, 7, 0, -10 },
  { 28, 9, 9, 7, -1, -9 },
  { 39, 7, 9, 7, 0, -9 },
  { 47, 2, 4, 7, 4, -10 },
  { 48, 6, 12, 7, 1, -10 },
  { 57, 6, 12, 7, 0, -10 },
  { 66, 6, 6, 7, 1, -9 },
  { 71, 7, 6, 7, 0, -7 },
  { 77, 3, 4, 7, 1, -2 },
  { 79, 5, 2, 7, 1, -5 },
  { 81, 2, 2, 7, 2, -2 },
  { 82, 9, 12, 7, -1, -10 },
  { 96, 7, 9, 7, 0, -9 },
  { 104, 6, 9, 7, 0, -9 },
  { 111, 7, 9, 7, 0, -9 },
  { 119, 7, 9, 7, 0, -9 },
  { 127, 7, 9, 7, 0, -9 },
  { 135, 8, 9, 7, 0, -9 },
  { 144, 7, 9, 7, 1, -9 },
  { 152, 7, 9, 7, 1, -9 },
  { 160, 7, 9, 7, 0, -9 },
  { 168, 7, 9, 7, 0, -9 },
  { 176, 3, 6, 7, 2, -6 },
  { 179, 4, 8, 7, 1, -6 },
  { 183, 6, 6, 7, 1, -7 },
  { 188, 7, 4, 7, 0, -6 },
  { 192, 7, 6, 7, 0, -7 },
  { 198, 5, 9, 7, 2, -9 },
  { 204, 8, 11, 7, 0, -9 },
  { 215, 7, 9, 7, -1, -9 },
  { 223, 7, 9, 7, 0, -9 },
  { 231, 7, 9, 7, 1, -9 },
  { 239, 7, 9, 7, 0, -9 },
  { 247, 8, 9, 7, 0, -9 },
  { 256, 8, 9, 7, 0, -9 },
  { 265, 7, 9, 7, 1, -9 },
  { 273, 8, 9, 7, 0, -9 },
  { 282, 8, 9, 7, 0, -9 },
  { 291, 8, 9, 7, 0, -9 },
  { 300, 8, 9, 7, 0, -9 },
  { 309, 6, 9, 7, 0, -9 },
  { 316, 8, 9, 7, 0, -9 },
  { 325, 8, 9, 7, 0, -9 },
  { 334, 7, 9, 7, 0, -9 },
  { 342, 8, 9, 7, 0, -9 },
  { 351, 7, 11, 7, 0, -9 },
  { 361, 7, 9, 7, 0, -9 },
  { 369, 7, 9, 7, 0, -9 },
  { 377, 7, 9, 7, 1, -9 },
  { 385, 8, 9, 7, 0, -9 },
  { 394, 7, 9, 7, 1, -9 },
  { 402, 8, 9, 7, 0, -9 },
  { 411, 9, 9, 7, -1, -9 },
  { 422, 6, 9, 7, 2, -9 },
  { 429, 8, 9, 7, 0, -9 },
  { 438, 7, 12, 7, 1, -10 },
  { 449, 3, 12, 7, 2, -10 },
  { 454, 7, 12, 7, 0, -10 },
  { 465, 6, 5, 7, 1, -9 },
  { 469, 7, 1, 7, -1, 1 },
  { 470, 3, 3, 7, 3, -10 },
  { 472, 7, 7, 7, 0, -7 },
  { 479, 7, 10, 7, 0, -10 },
  { 488, 6, 7, 7, 1, -7 },
  { 494, 8, 10, 7, 0, -10 },
  { 504, 6, 7, 7, 1, -7 },
  { 510, 9, 12, 7, -1, -10 },
  { 524, 8, 9, 7, -1, -7 },
  { 533, 7, 10, 7, 0, -10 },
  { 542, 5, 10, 7, 1, -10 },
  { 549, 8, 12, 7, -1, -10 },
  { 561, 8, 10, 7, 0, -10 },
  { 571, 4, 10, 7, 2, -10 },
  { 576, 7, 7, 7, 0, -7 },
  { 583, 7, 7, 7, 0, -7 },
  { 590, 7, 7, 7, 0, -7 },
  { 597, 8, 9, 7, -1, -7 },
  { 606, 7, 9, 7, 0, -7 },
  { 614, 7, 7, 7, 0, -7 },
  { 621, 7, 7, 7, 0, -7 },
  { 628, 6, 9, 7, 1, -9 },
  { 635, 6, 7, 7, 1, -7 },
  { 641, 7, 7, 7, 1, -7 },
  { 648, 8, 7, 7, 0, -7 },
  { 655, 7, 7, 7, 0, -7 },
  { 662, 8, 9, 7, -1, -7 },
  { 671, 7, 7, 7, 0, -7 },
  { 678, 7, 12, 7, 1, -10 },
  { 689, 5, 12, 7, 1, -10 },
  { 697, 7, 12, 7, -1, -10 },
  { 708, 7, 2, 7, 0, -5 },
};

const GFXfont UbuntuSansMono_BoldItalic13pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic13pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic13pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _UBUNTUSANSMONO_BOLDITALIC13PT7B_H_
