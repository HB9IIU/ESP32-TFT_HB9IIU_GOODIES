#ifndef _UBUNTUSANSMONO_BOLDITALIC21PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic21pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x1C, 0x30, 0xE0, 0x03, 0x0F,
  0x1E, 0x38, 0x00, 0xF7, 0xE7, 0xE7, 0xE6, 0xCE, 0xCC, 0x8C, 0x03, 0x30,
  0x73, 0x06, 0x70, 0xE6, 0x3F, 0xF7, 0xFF, 0x1C, 0xC1, 0x9C, 0x39, 0x8F,
  0xFE, 0xFF, 0xE7, 0x30, 0x67, 0x0E, 0x60, 0xCE, 0x00, 0x01, 0xC0, 0x18,
  0x0F, 0xE1, 0xFF, 0x1C, 0x23, 0x80, 0x3C, 0x01, 0xE0, 0x1F, 0x80, 0x7C,
  0x01, 0xC0, 0x1C, 0x41, 0xC7, 0xFC, 0xFF, 0x83, 0xE0, 0x1C, 0x01, 0x80,
  0x0E, 0x0C, 0x7C, 0x31, 0xB1, 0x8C, 0xCC, 0x33, 0x60, 0xDB, 0x01, 0xD8,
  0x00, 0xE0, 0x03, 0x70, 0x1B, 0xC0, 0xD9, 0x06, 0x64, 0x31, 0xB1, 0xC7,
  0xCE, 0x1E, 0x00, 0x07, 0x81, 0xF8, 0x73, 0x0C, 0x61, 0x8C, 0x33, 0x07,
  0xC0, 0xF3, 0x3E, 0x6C, 0xFF, 0x8F, 0x71, 0xEE, 0x3D, 0xFF, 0x9F, 0x38,
  0x7E, 0xEE, 0xCC, 0xC0, 0x00, 0x80, 0x60, 0x3C, 0x3C, 0x0E, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0xF0, 0x10, 0x00, 0x02, 0x01, 0x80, 0xF0, 0x0E,
  0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0x80, 0x40, 0x00, 0x1C, 0x03,
  0x04, 0xCB, 0xBE, 0xFF, 0xC3, 0x03, 0xE1, 0xDE, 0x33, 0x04, 0x80, 0x06,
  0x03, 0x80, 0xE0, 0x30, 0xFF, 0xFF, 0xF1, 0xC0, 0x70, 0x18, 0x0E, 0x00,
  0x1C, 0xF3, 0xCF, 0x1C, 0xEF, 0x20, 0x7F, 0xFE, 0x7F, 0xFF, 0x00, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x07, 0x83, 0xF8,
  0xFF, 0x1C, 0x77, 0x0E, 0xC1, 0xFB, 0xBF, 0x76, 0xEC, 0xDC, 0x3B, 0x07,
  0x71, 0xCE, 0x79, 0xFE, 0x1F, 0x80, 0x01, 0x83, 0xC3, 0xEF, 0xE3, 0xF1,
  0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0x81, 0xC7, 0xFF, 0xFE, 0x07,
  0xC1, 0xFE, 0x1F, 0xE1, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0x70, 0x0F, 0xFC, 0xFF, 0xC0, 0x07, 0x83,
  0xFC, 0x77, 0x80, 0x70, 0x0E, 0x01, 0xC3, 0xF0, 0x7C, 0x0F, 0xC0, 0x38,
  0x07, 0x00, 0xE4, 0x3D, 0xFF, 0x3F, 0xC0, 0x00, 0x70, 0x0F, 0x01, 0xE0,
  0x3E, 0x07, 0xE0, 0xEE, 0x1C, 0xC3, 0x8C, 0x71, 0xC7, 0xFE, 0xFF, 0xEF,
  0xFE, 0x03, 0x80, 0x38, 0x03, 0x80, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xC0,
  0x1C, 0x01, 0x80, 0x1F, 0x03, 0xF8, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x43, 0xCF, 0xF8, 0xFF, 0x00, 0x00, 0xE0, 0xFC, 0x7F, 0x9E, 0x03, 0x80,
  0xE0, 0x1B, 0xE7, 0xFC, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xEE, 0x38, 0xFF,
  0x0F, 0x80, 0x7F, 0xEF, 0xFF, 0xFF, 0x81, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x00, 0x0F,
  0x83, 0xF8, 0xF7, 0x98, 0x73, 0x0E, 0x73, 0x8F, 0xE0, 0xF8, 0x77, 0x9C,
  0x73, 0x07, 0x60, 0xEE, 0x39, 0xFF, 0x1F, 0x80, 0x07, 0x81, 0xFC, 0x3F,
  0xE3, 0x87, 0x30, 0x73, 0x07, 0x38, 0x73, 0xFE, 0x1F, 0xE0, 0x4E, 0x01,
  0xC0, 0x3C, 0x0F, 0x87, 0xE0, 0xF8, 0x00, 0x18, 0xF3, 0xCE, 0x00, 0x00,
  0x1C, 0xF3, 0xCF, 0x00, 0x06, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00, 0x1C,
  0x3C, 0x3C, 0x3C, 0x1C, 0x38, 0xF0, 0x80, 0x00, 0x60, 0x7C, 0x3F, 0x3F,
  0x8F, 0x81, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0x80, 0x20, 0x3F, 0xF3, 0xFE,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x10, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1E, 0x07, 0xC7, 0xF7, 0xF0, 0xF0, 0x08, 0x00, 0x3E, 0x3F,
  0x9F, 0xE0, 0xF0, 0x70, 0x78, 0x78, 0x70, 0x70, 0x38, 0x00, 0x0C, 0x0F,
  0x07, 0x83, 0x80, 0x03, 0xC0, 0xFF, 0x1C, 0x73, 0x83, 0x30, 0x37, 0x3F,
  0x67, 0xF6, 0x67, 0x6E, 0x66, 0xC6, 0xEC, 0xEE, 0xEE, 0xEF, 0xC6, 0x7C,
  0x60, 0x07, 0x00, 0x3F, 0x81, 0xF8, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0,
  0x7E, 0x0C, 0xC3, 0x98, 0x63, 0x1C, 0x63, 0xFC, 0xFF, 0x9F, 0xF7, 0x0E,
  0xE1, 0xF8, 0x38, 0x0F, 0x81, 0xFE, 0x1F, 0xF1, 0xC7, 0x38, 0x73, 0x8E,
  0x3F, 0xC3, 0xF8, 0x3F, 0xE7, 0x0E, 0x70, 0xE7, 0x0E, 0x63, 0xCF, 0xFC,
  0xFF, 0x00, 0x03, 0xC0, 0xFF, 0x1F, 0xE3, 0x80, 0x78, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x71, 0x87, 0xF8, 0x3F,
  0x80, 0x0F, 0x01, 0xFC, 0x1F, 0xE1, 0x8E, 0x38, 0x63, 0x87, 0x38, 0x73,
  0x8E, 0x70, 0xE7, 0x0E, 0x71, 0xE7, 0x1C, 0xE7, 0x8F, 0xF0, 0xFE, 0x00,
  0x0F, 0xF0, 0xFF, 0x1F, 0xF1, 0xC0, 0x1C, 0x01, 0xC0, 0x3F, 0xC3, 0xFC,
  0x3F, 0xC3, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0xFC, 0xFF, 0xC0, 0x0F,
  0xF8, 0x7F, 0xC7, 0xFC, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0x87, 0xF8,
  0x3F, 0xC1, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0xFF, 0x1F, 0xE3, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x1C,
  0xE1, 0xCE, 0x1C, 0xE1, 0x8E, 0x38, 0xF3, 0x87, 0xF8, 0x3F, 0x80, 0x1C,
  0x38, 0xE1, 0xC7, 0x0C, 0x30, 0xE3, 0x87, 0x1C, 0x38, 0xFF, 0x87, 0xFC,
  0x7F, 0xE3, 0x87, 0x1C, 0x30, 0xC3, 0x8E, 0x1C, 0x70, 0xE3, 0x8F, 0x00,
  0x1F, 0xF8, 0xFF, 0x87, 0xFC, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7F, 0xE3, 0xFE,
  0x00, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x67, 0x8F, 0xF0, 0x7E, 0x00,
  0x1C, 0x38, 0xE3, 0xC7, 0x3C, 0x39, 0xC3, 0x9C, 0x1D, 0xC0, 0xFC, 0x07,
  0xC0, 0x77, 0x03, 0xB8, 0x1C, 0xE0, 0xE7, 0x0E, 0x1C, 0x70, 0xE3, 0x87,
  0x00, 0x0E, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xF8, 0x0E, 0x1C, 0x38, 0xF0,
  0xE3, 0x87, 0x9E, 0x1A, 0x78, 0x6B, 0x61, 0xAF, 0x8E, 0xEE, 0x33, 0xB0,
  0xCC, 0xC7, 0x07, 0x1C, 0x1C, 0x60, 0x61, 0x81, 0x8E, 0x0E, 0x00, 0x1C,
  0x38, 0xE1, 0xC7, 0x0C, 0x7C, 0x63, 0xE7, 0x1F, 0x38, 0xD9, 0x86, 0x6C,
  0x73, 0xE3, 0x9F, 0x18, 0xF0, 0xC7, 0x8E, 0x1C, 0x70, 0xE3, 0x07, 0x00,
  0x07, 0x83, 0xF8, 0xFF, 0x3C, 0x77, 0x0E, 0xE1, 0xF8, 0x3F, 0x07, 0xE1,
  0xDC, 0x3B, 0x87, 0x71, 0xCE, 0x79, 0xFE, 0x1F, 0x80, 0x0F, 0x81, 0xFE,
  0x1F, 0xF1, 0xC7, 0x18, 0x73, 0x87, 0x38, 0x73, 0xBE, 0x3F, 0xC7, 0xF0,
  0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x83, 0xF8, 0xFF,
  0x3C, 0x77, 0x0E, 0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xDC, 0x3B, 0x87, 0x71,
  0xCE, 0x79, 0xFE, 0x1F, 0x81, 0xC0, 0x3C, 0x03, 0xE0, 0x18, 0x00, 0x0F,
  0x81, 0xFE, 0x1F, 0xE1, 0xC7, 0x38, 0x73, 0x86, 0x38, 0xE3, 0xFC, 0x7F,
  0x87, 0xF0, 0x73, 0x87, 0x38, 0x61, 0xCE, 0x1C, 0xE1, 0xC0, 0x07, 0xC0,
  0xFF, 0x1F, 0xE1, 0x80, 0x38, 0x03, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x63, 0xCF, 0xF8, 0x7F, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x87, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0x38, 0x73, 0x86, 0x38, 0xE7, 0x0E,
  0x70, 0xE7, 0x0C, 0x71, 0xCE, 0x1C, 0xE1, 0xCE, 0x1C, 0xE3, 0x8E, 0x38,
  0xE7, 0x8F, 0xF0, 0x7E, 0x00, 0xE0, 0x7E, 0x0E, 0xE0, 0xEE, 0x1C, 0xE1,
  0xCE, 0x38, 0xE3, 0x8E, 0x30, 0x67, 0x06, 0x60, 0x6E, 0x06, 0xC0, 0x7C,
  0x07, 0x80, 0x78, 0x00, 0x18, 0x18, 0xC0, 0xCE, 0x0E, 0x70, 0x73, 0x03,
  0x18, 0x19, 0xDD, 0xCE, 0xEE, 0x6F, 0x63, 0x7B, 0x1E, 0xF8, 0xF7, 0x8F,
  0x1C, 0x70, 0xE3, 0x86, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0x81, 0xDC,
  0x07, 0x60, 0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0xEC,
  0x07, 0x38, 0x38, 0xE1, 0xE3, 0x8F, 0x0E, 0x00, 0xE0, 0x76, 0x0E, 0x71,
  0xC7, 0x1C, 0x73, 0x87, 0x70, 0x37, 0x03, 0xE0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0xFF, 0x87, 0xFC,
  0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x7F, 0xE3, 0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7E,
  0x0F, 0xE0, 0xE7, 0x39, 0xCE, 0x31, 0x8C, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x31, 0x8C, 0x70, 0x07, 0xF0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x7E, 0x0F, 0xE0, 0x03, 0x00, 0xF0,
  0x3E, 0x0F, 0xC3, 0xDC, 0x73, 0x9C, 0x77, 0x07, 0x40, 0x80, 0x7F, 0xEF,
  0xFF, 0xFF, 0x80, 0x47, 0x9E, 0x20, 0x1F, 0xCF, 0xF7, 0x9F, 0x87, 0xE1,
  0xB8, 0xEC, 0x3B, 0x8E, 0xE7, 0xBF, 0xE7, 0xF8, 0x0E, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x7F, 0x8F, 0xF1, 0xC7, 0x38, 0xE6, 0x1D, 0xC3, 0xB8,
  0x77, 0x1C, 0xC7, 0xBF, 0xE7, 0xF8, 0x0F, 0xE7, 0xF9, 0xE1, 0x38, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x8F, 0xF0, 0xFE, 0x00, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE1, 0xFC, 0x3F, 0xC7, 0x9C, 0xE1, 0xCE,
  0x18, 0xE3, 0x8C, 0x38, 0xE3, 0x8E, 0x78, 0xFF, 0x87, 0xF8, 0x1F, 0x8F,
  0xF7, 0x1D, 0x83, 0xE3, 0xFF, 0xEF, 0xE3, 0x80, 0xE0, 0x9F, 0xE3, 0xF8,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0x90, 0x0E, 0x00, 0x1C, 0x01, 0xFF, 0x83,
  0xFE, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x07, 0xF8, 0x7F, 0x87, 0x9C, 0x78, 0xE3, 0x87, 0x1C, 0x30,
  0xE3, 0x87, 0x1C, 0x3F, 0xE0, 0xFE, 0x00, 0x70, 0x03, 0x87, 0xF8, 0x7F,
  0xC1, 0xF8, 0x00, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0x8F,
  0xF9, 0xCF, 0x38, 0xE7, 0x1D, 0xC7, 0x38, 0xE7, 0x1C, 0xE3, 0x98, 0x67,
  0x1C, 0x04, 0x0E, 0x1E, 0x0C, 0x00, 0x00, 0xFC, 0xFC, 0x1C, 0x18, 0x38,
  0x38, 0x38, 0x38, 0x39, 0x3F, 0x3F, 0x00, 0x20, 0x07, 0x00, 0xF0, 0x0E,
  0x00, 0x00, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x7F, 0x0F, 0xE0,
  0x7C, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC7, 0x1C,
  0xE3, 0x9C, 0x3B, 0x83, 0xF0, 0x3F, 0x07, 0x70, 0x73, 0x87, 0x38, 0x71,
  0xCE, 0x1C, 0xFD, 0xF8, 0x61, 0xC3, 0x87, 0x0C, 0x38, 0x70, 0xE1, 0xC7,
  0x0E, 0x1C, 0x7F, 0xBF, 0x3F, 0xE3, 0xFE, 0x37, 0x77, 0x76, 0x76, 0x66,
  0x66, 0x6E, 0xEE, 0x0C, 0xE0, 0xCC, 0x0C, 0xC1, 0xC0, 0x1F, 0xC7, 0xFC,
  0xE7, 0x9C, 0x73, 0x8E, 0xE3, 0x9C, 0x73, 0x8E, 0x71, 0xCC, 0x33, 0x8E,
  0x00, 0x1F, 0x8F, 0xF7, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x8E, 0xE7,
  0xBF, 0xC7, 0xE0, 0x0F, 0xE1, 0xFE, 0x1C, 0x71, 0xC7, 0x18, 0x73, 0x87,
  0x38, 0x73, 0x8E, 0x3B, 0xE7, 0xFC, 0x7F, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xE0, 0x00, 0x1F, 0xE7, 0xF9, 0xE7, 0x38, 0xEE, 0x1D, 0xC3, 0x38, 0xE7,
  0x1C, 0xE7, 0x9F, 0xE1, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x1F,
  0xE7, 0xF8, 0xF3, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0xE1, 0x1C, 0x01, 0xE0, 0x3F, 0x01,
  0xF0, 0x0E, 0x63, 0xCF, 0xF3, 0xFC, 0x00, 0x1C, 0x07, 0x01, 0x83, 0xFF,
  0xFF, 0x8E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC4, 0x7F, 0x0F,
  0xC0, 0x71, 0xDC, 0x77, 0x1D, 0xC7, 0xE3, 0xB8, 0xEE, 0x3B, 0x8E, 0xE7,
  0xBF, 0xE7, 0xF8, 0xE1, 0xF8, 0x7E, 0x3B, 0x8E, 0xE7, 0x39, 0xCE, 0xE3,
  0xF0, 0x7C, 0x1E, 0x07, 0x00, 0xE0, 0x7E, 0x06, 0xE6, 0x6C, 0xEE, 0xCE,
  0xCD, 0xEC, 0xDF, 0x8F, 0x78, 0xE7, 0x8E, 0x70, 0xC7, 0x00, 0x1C, 0x38,
  0xE3, 0x83, 0xB8, 0x1F, 0x80, 0x78, 0x03, 0xC0, 0x3E, 0x03, 0xF8, 0x1D,
  0xC1, 0xC7, 0x3C, 0x38, 0x0E, 0x1C, 0x38, 0xE0, 0xE3, 0x83, 0x8E, 0x0E,
  0x70, 0x39, 0xC0, 0x6E, 0x01, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x00, 0x1F, 0xF1, 0xFE, 0x21, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x47, 0xF8, 0xFF, 0x80,
  0x03, 0xF0, 0x7E, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x1C, 0x07, 0x80, 0xF8, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x03, 0x90, 0x3E, 0x01, 0xE0, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C,
  0x1C, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70,
  0xE0, 0xE0, 0x07, 0xC1, 0xF8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0xC0, 0x1C, 0x0F, 0x81, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x0E, 0x03, 0xC1, 0xF0, 0x7C, 0x00, 0x3C, 0x77, 0xFE, 0x6F, 0xCC, 0x38,
};

const GFXglyph UbuntuSansMono_BoldItalic21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 15, 12, 3, -15 },
  { 15, 8, 7, 12, 4, -16 },
  { 22, 12, 15, 12, 0, -15 },
  { 45, 12, 18, 12, 0, -16 },
  { 72, 14, 15, 12, -1, -15 },
  { 99, 11, 15, 12, 0, -15 },
  { 120, 4, 7, 12, 6, -16 },
  { 124, 10, 21, 12, 2, -17 },
  { 151, 10, 21, 12, 0, -17 },
  { 178, 10, 10, 12, 2, -15 },
  { 191, 10, 10, 12, 1, -11 },
  { 204, 6, 8, 12, 1, -4 },
  { 210, 8, 2, 12, 2, -7 },
  { 212, 4, 4, 12, 3, -4 },
  { 214, 14, 20, 12, -1, -16 },
  { 249, 11, 15, 12, 1, -15 },
  { 270, 9, 15, 12, 1, -15 },
  { 287, 12, 15, 12, 0, -15 },
  { 310, 11, 15, 12, 0, -15 },
  { 331, 12, 15, 12, 0, -15 },
  { 354, 12, 15, 12, 0, -15 },
  { 377, 11, 15, 12, 1, -15 },
  { 398, 11, 15, 12, 2, -15 },
  { 419, 11, 15, 12, 1, -15 },
  { 440, 12, 15, 12, 0, -15 },
  { 463, 6, 11, 12, 3, -11 },
  { 472, 8, 15, 12, 1, -11 },
  { 487, 11, 10, 12, 1, -11 },
  { 501, 12, 7, 12, 0, -10 },
  { 512, 11, 10, 12, 0, -11 },
  { 526, 9, 15, 12, 3, -15 },
  { 543, 12, 18, 12, 0, -15 },
  { 570, 11, 15, 12, -1, -15 },
  { 591, 12, 15, 12, 0, -15 },
  { 614, 12, 15, 12, 1, -15 },
  { 637, 12, 15, 12, 0, -15 },
  { 660, 12, 15, 12, 0, -15 },
  { 683, 13, 15, 12, 0, -15 },
  { 708, 12, 15, 12, 1, -15 },
  { 731, 13, 15, 12, 0, -15 },
  { 756, 13, 15, 12, 0, -15 },
  { 781, 12, 15, 12, 0, -15 },
  { 804, 13, 15, 12, 0, -15 },
  { 829, 10, 15, 12, 0, -15 },
  { 848, 14, 15, 12, -1, -15 },
  { 875, 13, 15, 12, 0, -15 },
  { 900, 11, 15, 12, 1, -15 },
  { 921, 12, 15, 12, 0, -15 },
  { 944, 11, 19, 12, 1, -15 },
  { 971, 12, 15, 12, 0, -15 },
  { 994, 12, 15, 12, 0, -15 },
  { 1017, 11, 15, 12, 2, -15 },
  { 1038, 12, 15, 12, 1, -15 },
  { 1061, 12, 15, 12, 2, -15 },
  { 1084, 13, 15, 12, 0, -15 },
  { 1109, 14, 15, 12, -1, -15 },
  { 1136, 12, 15, 12, 2, -15 },
  { 1159, 13, 15, 12, 0, -15 },
  { 1184, 12, 20, 12, 1, -16 },
  { 1214, 5, 20, 12, 4, -16 },
  { 1227, 12, 20, 12, -1, -16 },
  { 1257, 11, 9, 12, 1, -15 },
  { 1270, 11, 3, 12, -2, 1 },
  { 1275, 5, 4, 12, 5, -16 },
  { 1278, 10, 11, 12, 1, -11 },
  { 1292, 11, 16, 12, 0, -16 },
  { 1314, 11, 11, 12, 1, -11 },
  { 1330, 12, 16, 12, 1, -16 },
  { 1354, 10, 11, 12, 1, -11 },
  { 1368, 15, 20, 12, -2, -16 },
  { 1406, 13, 15, 12, -1, -11 },
  { 1431, 11, 16, 12, 0, -16 },
  { 1453, 8, 17, 12, 2, -17 },
  { 1470, 12, 21, 12, -1, -17 },
  { 1502, 12, 16, 12, 0, -16 },
  { 1526, 7, 16, 12, 3, -16 },
  { 1540, 12, 11, 12, 0, -11 },
  { 1557, 11, 11, 12, 0, -11 },
  { 1573, 10, 11, 12, 1, -11 },
  { 1587, 12, 15, 12, -1, -11 },
  { 1610, 11, 15, 12, 1, -11 },
  { 1631, 11, 11, 12, 1, -11 },
  { 1647, 11, 11, 12, 0, -11 },
  { 1663, 10, 14, 12, 2, -14 },
  { 1681, 10, 11, 12, 1, -11 },
  { 1695, 10, 11, 12, 2, -11 },
  { 1709, 12, 11, 12, 1, -11 },
  { 1726, 13, 11, 12, -1, -11 },
  { 1744, 14, 15, 12, -2, -11 },
  { 1771, 12, 11, 12, 0, -11 },
  { 1788, 12, 20, 12, 1, -16 },
  { 1818, 8, 20, 12, 2, -16 },
  { 1838, 11, 20, 12, -1, -16 },
  { 1866, 12, 4, 12, 0, -8 },
};

const GFXfont UbuntuSansMono_BoldItalic21pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic21pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic21pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _UBUNTUSANSMONO_BOLDITALIC21PT7B_H_
