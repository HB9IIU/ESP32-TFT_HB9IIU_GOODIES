#ifndef _UBUNTUSANSMONO_BOLDITALIC25PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xC7, 0x8F, 0x1C, 0x38, 0xF1, 0xC0, 0x00,
  0x1E, 0x3C, 0x78, 0xE0, 0x79, 0xEF, 0x39, 0xCF, 0x39, 0xE7, 0x39, 0xC7,
  0x38, 0xC6, 0x18, 0x03, 0xCE, 0x07, 0x38, 0x0E, 0x70, 0x39, 0xC3, 0xFF,
  0xE7, 0xFF, 0x9F, 0xFF, 0x06, 0x38, 0x1C, 0xE0, 0x39, 0xC3, 0xFF, 0xE7,
  0xFF, 0xCF, 0xFF, 0x8E, 0x70, 0x1C, 0xE0, 0x71, 0x80, 0xE7, 0x00, 0x00,
  0xF0, 0x03, 0x80, 0x3F, 0x03, 0xFF, 0x0F, 0xF8, 0x78, 0x21, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x18, 0x3C, 0x7F, 0xE3, 0xFF, 0x01, 0xF0, 0x03, 0x80, 0x0E, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x07, 0xC1, 0xC7, 0xE1, 0xC3, 0x31, 0xC1, 0x99,
  0xC0, 0xCC, 0xC0, 0x6C, 0xC0, 0x3E, 0xC0, 0x0E, 0xE0, 0x00, 0xE0, 0x00,
  0xEF, 0x00, 0xEF, 0x80, 0x66, 0xE0, 0x66, 0x70, 0x73, 0x30, 0x71, 0x98,
  0x70, 0xFC, 0x70, 0x3C, 0x00, 0x01, 0xC0, 0x1F, 0xC0, 0xFF, 0x03, 0x8C,
  0x0C, 0x30, 0x71, 0xC1, 0xCE, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x73, 0xFB,
  0x9C, 0xEE, 0xF1, 0xF3, 0x87, 0xCE, 0x0E, 0x3C, 0xFC, 0x7F, 0xF0, 0xF9,
  0xE0, 0x7B, 0xBD, 0xEE, 0x73, 0x98, 0x00, 0x40, 0x38, 0x0F, 0x83, 0xE0,
  0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xC0, 0x10, 0x00, 0x01, 0x00, 0x70, 0x1E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x70, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0xF8, 0x3E,
  0x03, 0x00, 0x40, 0x00, 0x07, 0x00, 0x70, 0x66, 0x67, 0xEE, 0xFF, 0xF3,
  0xFC, 0x0F, 0x81, 0xFC, 0x39, 0xE1, 0x9C, 0x08, 0x80, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x00, 0x18, 0xF3, 0xCF, 0x3C, 0x73, 0xBC, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFE, 0x2F, 0xFF, 0xF0, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x7F,
  0x07, 0xFC, 0x3C, 0xF3, 0xC3, 0xBC, 0x1D, 0xC0, 0xEE, 0x67, 0xF7, 0x3F,
  0x3B, 0xF9, 0x9D, 0xC0, 0xEE, 0x0F, 0x70, 0x73, 0x87, 0x9F, 0xF8, 0x7F,
  0x81, 0xF8, 0x00, 0x01, 0xE0, 0x7C, 0x3F, 0x1F, 0xE3, 0xFC, 0x67, 0x80,
  0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x3F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x1F, 0xE1, 0xFF, 0x83, 0x9F, 0x08, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0x80, 0x01,
  0xC0, 0x3F, 0xC0, 0xFF, 0x83, 0x1F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x7C, 0x07, 0xE0, 0x1F, 0x80, 0x9F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC8,
  0x0F, 0x3D, 0xFC, 0xFF, 0xE3, 0xFE, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xB8, 0x1C, 0xE0, 0xE7, 0x87, 0x1C, 0x38, 0x71, 0xC1,
  0xC7, 0xFF, 0xFF, 0xFE, 0xFF, 0xF8, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x08, 0x1E, 0x1F, 0xF8, 0x7F, 0xF0, 0xFF, 0x80, 0x01, 0xFC, 0x1F,
  0xE0, 0xFE, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x7C, 0x1F, 0xF8, 0xFF,
  0xF3, 0xC3, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0xC3, 0xC7, 0xFE, 0x1F,
  0xF0, 0x3F, 0x80, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x7F,
  0x87, 0xFE, 0x38, 0xF3, 0x83, 0x9C, 0x1C, 0xF1, 0xE3, 0xDE, 0x1F, 0xE0,
  0xFE, 0x1E, 0xF9, 0xE1, 0xCE, 0x0F, 0x70, 0x7B, 0x83, 0x9E, 0x7C, 0xFF,
  0xC3, 0xFC, 0x00, 0x01, 0xC0, 0x3F, 0xC1, 0xFF, 0x87, 0x9E, 0x3C, 0x3C,
  0xE0, 0x73, 0x81, 0xCE, 0x0F, 0x3C, 0x3C, 0x7F, 0xF1, 0xFF, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x3E, 0x1F, 0xF0, 0x7F, 0x03, 0xF0, 0x00, 0x08,
  0xF3, 0xCF, 0x3C, 0x00, 0x00, 0x23, 0xCF, 0x3C, 0xF0, 0x02, 0x0F, 0x0F,
  0x0F, 0x0F, 0x00, 0x00, 0x00, 0x18, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x38,
  0xF0, 0xE0, 0x00, 0x18, 0x07, 0xC1, 0xFE, 0x3F, 0xC7, 0xF0, 0x7C, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x80, 0x3F, 0xFC,
  0xFF, 0xF3, 0xFF, 0x90, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xBF, 0xFC,
  0xFF, 0xF0, 0x18, 0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3C,
  0x07, 0xE1, 0xFE, 0x7F, 0x87, 0xF0, 0x1C, 0x00, 0x80, 0x00, 0x07, 0x0F,
  0xF9, 0xFF, 0x90, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0x80,
  0xE0, 0x1C, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0xF8, 0x0E, 0x00, 0x00,
  0xF0, 0x07, 0xF8, 0x3F, 0xF0, 0x70, 0xF1, 0xC0, 0xE7, 0x01, 0xCE, 0x7F,
  0x39, 0xFE, 0x73, 0x9C, 0xEE, 0x39, 0x9C, 0x63, 0x39, 0xC6, 0x73, 0x9C,
  0xE7, 0x19, 0xFE, 0x33, 0xF8, 0x71, 0xF0, 0xE0, 0x01, 0xE0, 0x01, 0xFF,
  0x01, 0xFC, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x7E, 0x07, 0xF0,
  0x3B, 0x83, 0xDC, 0x1C, 0xE1, 0xE7, 0x0E, 0x38, 0xF1, 0xC7, 0xFE, 0x7F,
  0xF3, 0xFF, 0xBC, 0x1D, 0xC0, 0xFE, 0x07, 0xE0, 0x38, 0x00, 0x80, 0x3F,
  0xE0, 0xFF, 0x87, 0x9F, 0x1E, 0x1C, 0x70, 0x71, 0xC3, 0xCF, 0x3E, 0x3F,
  0xF0, 0xFF, 0xC3, 0x8F, 0x8E, 0x0E, 0x78, 0x39, 0xC1, 0xE7, 0x07, 0x9F,
  0xFC, 0xFF, 0xE3, 0xFE, 0x00, 0x00, 0xE0, 0x1F, 0xF0, 0xFF, 0x87, 0xC6,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x82, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F,
  0x00, 0x01, 0x80, 0x3F, 0x80, 0xFF, 0x87, 0xBE, 0x1C, 0x3C, 0x70, 0xF1,
  0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x9E, 0x1E, 0x78, 0x79,
  0xC3, 0xC7, 0x1F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0x0F, 0xFE, 0x1F,
  0xF8, 0x3F, 0xF0, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xFC, 0x0F, 0xF8,
  0x3F, 0xF0, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F,
  0xFC, 0x3F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC7, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x1F, 0xF0, 0xFF, 0x87, 0xC6, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0x70, 0x03, 0xC1, 0xCF, 0x07, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0x8F,
  0x0E, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x00, 0x0E, 0x0E, 0x3C, 0x3C, 0x78,
  0x78, 0xE0, 0xE1, 0xC1, 0xC7, 0x87, 0x8F, 0xFF, 0x1F, 0xFC, 0x3F, 0xF8,
  0xF0, 0x71, 0xE1, 0xE3, 0x83, 0xC7, 0x07, 0x0E, 0x0E, 0x3C, 0x3C, 0x78,
  0x78, 0xE0, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF0, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE0, 0x07,
  0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x08,
  0x3C, 0x1F, 0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0x0E, 0x1F, 0x0E, 0x1C, 0x1E,
  0x3C, 0x1E, 0x78, 0x1C, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x3B, 0x80, 0x7B, 0xC0, 0x79, 0xE0, 0x71, 0xE0, 0x70, 0xE0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xE0, 0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1E,
  0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x00, 0x7F, 0xF7, 0xFE, 0xFF, 0xE0, 0x07, 0x0F, 0x07, 0x0F, 0x0F,
  0x1F, 0x0F, 0x1F, 0x0F, 0xBE, 0x1D, 0xB6, 0x1D, 0xFE, 0x19, 0xEE, 0x39,
  0xEE, 0x39, 0xCC, 0x39, 0x9C, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x70,
  0x38, 0x70, 0x38, 0xE0, 0x38, 0x0E, 0x0E, 0x3C, 0x1C, 0x7C, 0x38, 0xF8,
  0xE1, 0xF1, 0xC7, 0x63, 0x8E, 0xE7, 0x1D, 0xDC, 0x39, 0xB8, 0xF3, 0x71,
  0xC7, 0xE3, 0x8F, 0xC7, 0x0F, 0x0E, 0x1E, 0x38, 0x3C, 0x70, 0x78, 0xE0,
  0xE0, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x7C, 0xF3, 0xC7, 0xBC, 0x1D, 0xC0,
  0xEE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1D, 0xC0, 0xEE, 0x0F, 0x70, 0x73,
  0xC7, 0x9F, 0xF8, 0x7F, 0x81, 0xF8, 0x00, 0x00, 0xC0, 0x1F, 0xF0, 0x3F,
  0xF0, 0xF7, 0xE1, 0xE1, 0xC3, 0x83, 0xC7, 0x07, 0x0E, 0x0E, 0x3C, 0x7C,
  0x7F, 0xF0, 0xFF, 0xC1, 0xFE, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xFC, 0x7C, 0xF3,
  0xC7, 0xBC, 0x1D, 0xC0, 0xEE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1D, 0xC0,
  0xEE, 0x0F, 0x70, 0x73, 0xC7, 0x9F, 0xF8, 0x7F, 0x81, 0xF8, 0x07, 0x00,
  0x38, 0x01, 0xFC, 0x03, 0xC0, 0x06, 0x00, 0x01, 0x80, 0x3F, 0xC0, 0xFF,
  0x87, 0x9F, 0x1E, 0x3C, 0x70, 0xF1, 0xC3, 0xCF, 0x0E, 0x3C, 0xF8, 0xFF,
  0xC3, 0xFE, 0x1F, 0xF0, 0x79, 0xC1, 0xC7, 0x87, 0x0E, 0x3C, 0x3C, 0xF0,
  0xF3, 0x81, 0xC0, 0x00, 0xF0, 0x1F, 0xF0, 0xFF, 0xC7, 0xC6, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xC4, 0x0F, 0x1F, 0xFC, 0xFF, 0xE1, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFC, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x00, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0x8E, 0x0E, 0x38, 0x39,
  0xE1, 0xE7, 0x87, 0x9C, 0x1C, 0x70, 0x73, 0xC3, 0xCF, 0x0F, 0x38, 0x38,
  0xE1, 0xE3, 0x87, 0x8F, 0xFC, 0x3F, 0xF0, 0x7F, 0x00, 0xE0, 0x7F, 0x03,
  0xB8, 0x3D, 0xC1, 0xCE, 0x0E, 0x70, 0xF3, 0x87, 0x1C, 0x78, 0xE3, 0x87,
  0x3C, 0x39, 0xC1, 0xDE, 0x0E, 0xE0, 0x7E, 0x03, 0xF0, 0x0F, 0x00, 0x78,
  0x00, 0x1C, 0x07, 0x1C, 0x0E, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38,
  0x1C, 0x3B, 0x9C, 0x33, 0x9C, 0x77, 0x9C, 0x77, 0x98, 0x7F, 0xF8, 0x6C,
  0xF8, 0x7C, 0xF0, 0x78, 0xF0, 0xF8, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x0F,
  0x07, 0x83, 0x87, 0x81, 0xE7, 0x80, 0x73, 0x80, 0x3B, 0x80, 0x1F, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x01, 0xEE,
  0x01, 0xE7, 0x00, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0x70, 0xF0, 0x38, 0x00,
  0xE0, 0x7F, 0x87, 0xBC, 0x38, 0xE3, 0xC7, 0x1C, 0x39, 0xE1, 0xDE, 0x0F,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFC, 0x7F, 0xF0, 0xFF, 0xE0,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0xE7, 0x39, 0xCE, 0x73,
  0xDE, 0xF3, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0xDE, 0xF3, 0x9C, 0xE7, 0x38,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xC0, 0x1F, 0x01,
  0xF8, 0x1F, 0xC1, 0xEF, 0x1E, 0x79, 0xE1, 0xDF, 0x0F, 0x70, 0x79, 0x01,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x43, 0xCF, 0x8F, 0x08, 0x0F, 0xF8,
  0xFF, 0x8F, 0xBC, 0xF1, 0xEF, 0x0F, 0x78, 0x73, 0x83, 0x9C, 0x1C, 0xE1,
  0xE7, 0x0F, 0x3F, 0xF9, 0xFF, 0xC7, 0xEE, 0x00, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xC3, 0xFE, 0x3F, 0xF9, 0xE3,
  0xCE, 0x0E, 0x70, 0x73, 0x87, 0xBC, 0x3D, 0xC1, 0xCE, 0x1E, 0x7F, 0xE7,
  0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0xFF, 0x8F, 0xFC, 0xF8, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0xF0, 0xFF, 0xC3, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0xFF, 0x87, 0xFC, 0x3E, 0xF1, 0xE3, 0xCF, 0x0F, 0x3C, 0x38, 0xE0, 0xE3,
  0x83, 0x8E, 0x1E, 0x38, 0x78, 0xFF, 0xE3, 0xFF, 0x87, 0xEE, 0x00, 0x00,
  0x80, 0x7F, 0x07, 0xFC, 0x78, 0xF7, 0x87, 0xB8, 0x3B, 0xC7, 0xDF, 0xFC,
  0xFF, 0x87, 0x80, 0x3C, 0x00, 0xFF, 0x87, 0xFE, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x7F, 0xF0, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x5F, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x01, 0xE0, 0x00, 0x03, 0xFE, 0x0F, 0xFC, 0x3E, 0x70, 0xF0, 0xE1,
  0xC3, 0xC7, 0x87, 0x8F, 0x0E, 0x1C, 0x1C, 0x3C, 0x78, 0x7F, 0xF0, 0x7F,
  0xC0, 0x7F, 0x80, 0x0F, 0x00, 0x1E, 0x18, 0x78, 0x7F, 0xE0, 0xFF, 0x80,
  0x38, 0x00, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x7F, 0xC3, 0xFE, 0x1F, 0xF9, 0xE3, 0xCF, 0x1E, 0x70, 0xF3, 0x87, 0x3C,
  0x39, 0xE3, 0xCE, 0x1E, 0x70, 0xE3, 0x87, 0x3C, 0x78, 0x02, 0x01, 0xE0,
  0xF8, 0x3C, 0x02, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x3F, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0xF1, 0xFC, 0x7F, 0x00, 0x18,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x0F, 0xF8, 0x3F, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC1, 0x9F,
  0x0F, 0xF8, 0x3F, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x8F, 0x8F, 0x3C, 0x1C, 0xF0, 0x3B,
  0xC0, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0x78, 0x0E, 0x70, 0x3C, 0xF0,
  0x78, 0xE0, 0xE1, 0xE3, 0xC3, 0xC0, 0xFF, 0x7F, 0x3F, 0x83, 0xC1, 0xE0,
  0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0,
  0x7F, 0xBF, 0xCF, 0xE0, 0x1F, 0x78, 0xFF, 0xF3, 0xB9, 0xCE, 0xE7, 0x33,
  0x99, 0xCE, 0xE7, 0x33, 0x9D, 0xCE, 0x60, 0x3B, 0x81, 0xCE, 0x07, 0x38,
  0x1C, 0xC0, 0x70, 0x1F, 0xF0, 0xFF, 0x87, 0xFE, 0x78, 0xF3, 0xC7, 0x9C,
  0x3C, 0xE1, 0xCF, 0x0E, 0x78, 0xF3, 0x87, 0x9C, 0x38, 0xE1, 0xCF, 0x1E,
  0x00, 0x01, 0x00, 0xFE, 0x3F, 0xE3, 0xFF, 0x78, 0xF7, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0xFE, 0x0E, 0xF1, 0xEF, 0xFC, 0x7F, 0x87, 0xF0, 0x0F, 0xF0,
  0x3F, 0xE0, 0xE7, 0xC7, 0x87, 0x1E, 0x1C, 0x70, 0x71, 0xC3, 0xCF, 0x0F,
  0x3C, 0x78, 0xE3, 0xE3, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x0F, 0xF8, 0xFF, 0xCF, 0xFC, 0xF0,
  0xE7, 0x0F, 0x78, 0x7B, 0xC3, 0x9C, 0x1C, 0xE1, 0xE7, 0x8F, 0x3F, 0xF0,
  0xFF, 0x83, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00,
  0x1F, 0xF8, 0xFF, 0x8F, 0xFC, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x80,
  0x3F, 0xC3, 0xFE, 0x3C, 0x61, 0xC0, 0x0F, 0x00, 0x7E, 0x01, 0xFC, 0x03,
  0xE0, 0x07, 0x90, 0x3C, 0xFF, 0xCF, 0xFE, 0x3F, 0xC0, 0x0F, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x7F, 0xFF, 0xFE, 0xFF, 0xE3, 0xC0, 0x3C, 0x03, 0x80,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7F, 0xC3, 0xFC, 0x1F, 0xC0, 0x38,
  0x79, 0xC3, 0x9E, 0x1C, 0xF1, 0xE7, 0x0F, 0x38, 0x73, 0xC3, 0x9E, 0x3C,
  0xF1, 0xE7, 0x8F, 0x3F, 0xF9, 0xFF, 0xC7, 0xEE, 0x00, 0xF0, 0x7F, 0x87,
  0xBC, 0x39, 0xE3, 0xCF, 0x1C, 0x79, 0xE1, 0xCE, 0x0E, 0xF0, 0x77, 0x03,
  0xF8, 0x1F, 0x80, 0xF8, 0x03, 0x80, 0x00, 0x70, 0x1D, 0x80, 0x7E, 0x33,
  0xB9, 0xCE, 0xE7, 0x3B, 0xBC, 0xCE, 0xF7, 0x37, 0xDC, 0xDB, 0x63, 0xEF,
  0x8F, 0x3C, 0x38, 0xF0, 0xE3, 0x80, 0x1E, 0x1E, 0x1C, 0x38, 0x3C, 0xE0,
  0x3B, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x3D,
  0xE0, 0xF1, 0xC1, 0xC3, 0xCF, 0x07, 0x80, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0E, 0x0F, 0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x3C, 0x07, 0x38, 0x07,
  0x70, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x8F,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x70, 0x00, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0xFF, 0x1F, 0xF8, 0xFF, 0xE0, 0x00, 0x78, 0x0F, 0xC0, 0xFE, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x81,
  0xF8, 0x0F, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0x00, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F, 0x03, 0xC0,
  0xE0, 0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0x80, 0xE0,
  0x78, 0x1E, 0x07, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0x80, 0x3F, 0x01, 0xFC,
  0x01, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xF0, 0x07, 0x80, 0xFC, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x81, 0xF8, 0x1F, 0xC0, 0xF0, 0x00,
  0x1E, 0x18, 0xFC, 0x77, 0xFF, 0x9D, 0xFC, 0xE1, 0xE0,
};

const GFXglyph UbuntuSansMono_BoldItalic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 17, 14, 4, -17 },
  { 16, 11, 8, 14, 4, -19 },
  { 27, 15, 17, 14, 0, -17 },
  { 59, 14, 22, 14, 0, -19 },
  { 98, 17, 18, 14, -1, -18 },
  { 137, 14, 18, 14, 0, -18 },
  { 169, 5, 8, 14, 7, -19 },
  { 174, 11, 25, 14, 3, -20 },
  { 209, 11, 25, 14, 0, -20 },
  { 244, 12, 11, 14, 2, -17 },
  { 261, 12, 13, 14, 1, -14 },
  { 281, 6, 9, 14, 2, -5 },
  { 288, 8, 4, 14, 3, -9 },
  { 292, 4, 5, 14, 4, -5 },
  { 295, 16, 25, 14, -1, -20 },
  { 345, 13, 18, 14, 1, -18 },
  { 375, 11, 17, 14, 1, -17 },
  { 399, 14, 18, 14, 0, -18 },
  { 431, 14, 18, 14, 0, -18 },
  { 463, 14, 17, 14, 0, -17 },
  { 493, 15, 17, 14, 0, -17 },
  { 525, 14, 17, 14, 1, -17 },
  { 555, 14, 17, 14, 2, -17 },
  { 585, 13, 18, 14, 1, -18 },
  { 615, 14, 18, 14, 0, -18 },
  { 647, 6, 13, 14, 4, -13 },
  { 657, 8, 17, 14, 2, -13 },
  { 674, 13, 12, 14, 1, -13 },
  { 694, 14, 9, 14, 0, -12 },
  { 710, 13, 12, 14, 0, -13 },
  { 730, 11, 18, 14, 3, -18 },
  { 755, 15, 22, 14, 0, -18 },
  { 797, 13, 17, 14, -1, -17 },
  { 825, 14, 18, 14, 0, -18 },
  { 857, 14, 18, 14, 1, -18 },
  { 889, 14, 18, 14, 0, -18 },
  { 921, 15, 17, 14, 0, -17 },
  { 953, 14, 17, 14, 1, -17 },
  { 983, 14, 18, 14, 1, -18 },
  { 1015, 15, 17, 14, 0, -17 },
  { 1047, 15, 17, 14, 0, -17 },
  { 1079, 15, 17, 14, 0, -17 },
  { 1111, 16, 17, 14, 0, -17 },
  { 1145, 12, 17, 14, 0, -17 },
  { 1171, 16, 17, 14, -1, -17 },
  { 1205, 15, 17, 14, 0, -17 },
  { 1237, 13, 18, 14, 1, -18 },
  { 1267, 15, 18, 14, 0, -18 },
  { 1301, 13, 23, 14, 1, -18 },
  { 1339, 14, 18, 14, 0, -18 },
  { 1371, 14, 18, 14, 0, -18 },
  { 1403, 13, 17, 14, 3, -17 },
  { 1431, 14, 17, 14, 1, -17 },
  { 1461, 13, 17, 14, 3, -17 },
  { 1489, 16, 17, 14, 0, -17 },
  { 1523, 17, 17, 14, -1, -17 },
  { 1560, 13, 17, 14, 3, -17 },
  { 1588, 15, 17, 14, 0, -17 },
  { 1620, 14, 25, 14, 1, -20 },
  { 1664, 5, 25, 14, 5, -20 },
  { 1680, 14, 25, 14, -1, -20 },
  { 1724, 13, 10, 14, 1, -17 },
  { 1741, 13, 3, 14, -2, 2 },
  { 1746, 6, 5, 14, 6, -19 },
  { 1750, 13, 13, 14, 1, -13 },
  { 1772, 13, 19, 14, 0, -19 },
  { 1803, 13, 13, 14, 1, -13 },
  { 1825, 14, 19, 14, 1, -19 },
  { 1859, 13, 14, 14, 1, -14 },
  { 1882, 18, 24, 14, -2, -19 },
  { 1936, 15, 18, 14, -1, -13 },
  { 1970, 13, 19, 14, 0, -19 },
  { 2001, 10, 20, 14, 2, -20 },
  { 2026, 14, 25, 14, -1, -20 },
  { 2070, 15, 19, 14, 0, -19 },
  { 2106, 9, 19, 14, 3, -19 },
  { 2128, 14, 13, 14, 0, -13 },
  { 2151, 13, 13, 14, 0, -13 },
  { 2173, 12, 14, 14, 1, -14 },
  { 2194, 14, 18, 14, -1, -13 },
  { 2226, 13, 18, 14, 1, -13 },
  { 2256, 13, 13, 14, 1, -13 },
  { 2278, 13, 14, 14, 0, -14 },
  { 2301, 12, 17, 14, 2, -17 },
  { 2327, 13, 13, 14, 1, -13 },
  { 2349, 13, 13, 14, 2, -13 },
  { 2371, 14, 13, 14, 1, -13 },
  { 2394, 15, 13, 14, -1, -13 },
  { 2419, 16, 18, 14, -2, -13 },
  { 2455, 14, 13, 14, 0, -13 },
  { 2478, 13, 25, 14, 2, -20 },
  { 2519, 10, 25, 14, 2, -20 },
  { 2551, 13, 25, 14, -1, -20 },
  { 2592, 14, 5, 14, 0, -10 },
};

const GFXfont UbuntuSansMono_BoldItalic25pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic25pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic25pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _UBUNTUSANSMONO_BOLDITALIC25PT7B_H_
