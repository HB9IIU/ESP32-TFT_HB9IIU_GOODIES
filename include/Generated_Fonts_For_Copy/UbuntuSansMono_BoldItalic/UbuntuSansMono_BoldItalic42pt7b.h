#ifndef _UBUNTUSANSMONO_BOLDITALIC42PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0xFF, 0x07, 0xF8, 0x3F, 0x81, 0xFC, 0x07, 0xC0,
  0x08, 0x00, 0x3F, 0x1F, 0x9F, 0x8F, 0xDF, 0x87, 0xEF, 0xC7, 0xF7, 0xE3,
  0xF3, 0xF1, 0xF9, 0xF0, 0xFC, 0xF8, 0x7C, 0x7C, 0x3E, 0x3C, 0x1F, 0x3E,
  0x0F, 0x1E, 0x07, 0x8F, 0x03, 0x80, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xE1,
  0xE0, 0x01, 0xE1, 0xF0, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0x3E, 0x1F, 0x00, 0x1F,
  0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0x87, 0xC0, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x3E, 0x00,
  0x3E, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x0F, 0xF8, 0xF8, 0x1F, 0x80, 0x20, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0xC0, 0x0F, 0xC1, 0xE0, 0x7F, 0x87, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xC0, 0x7F,
  0x80, 0x7C, 0x07, 0xFC, 0x03, 0xC0, 0x3C, 0xF0, 0x3C, 0x03, 0xC7, 0x83,
  0xC0, 0x1E, 0x3C, 0x3C, 0x00, 0xE1, 0xC3, 0xC0, 0x07, 0x1E, 0x3E, 0x00,
  0x38, 0xF1, 0xE0, 0x01, 0xC7, 0x1E, 0x00, 0x0F, 0xF9, 0xE0, 0x00, 0x7F,
  0x9E, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0xF3, 0xF8, 0x00, 0x0F, 0x3F, 0xC0,
  0x00, 0xF3, 0xFF, 0x00, 0x0F, 0x9E, 0x78, 0x00, 0x79, 0xE3, 0xC0, 0x07,
  0x8F, 0x1E, 0x00, 0x78, 0x78, 0xF0, 0x07, 0x83, 0x87, 0x00, 0x78, 0x1C,
  0x78, 0x07, 0xC0, 0xF3, 0xC0, 0x7C, 0x07, 0xFC, 0x03, 0xC0, 0x3F, 0xC0,
  0x7C, 0x00, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7E,
  0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x07, 0xC3,
  0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0x84, 0x03, 0xFC, 0x1F, 0x0F, 0xFC, 0x3E, 0x3F, 0xFC, 0xF8,
  0xFC, 0xF9, 0xF3, 0xF1, 0xFF, 0xC7, 0xC1, 0xFF, 0x8F, 0x81, 0xFE, 0x3E,
  0x03, 0xFC, 0x7C, 0x03, 0xF0, 0xFC, 0x0F, 0xE1, 0xFC, 0x3F, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xDF, 0x83, 0xFE, 0x1F, 0x00, 0x3F,
  0x9F, 0x8F, 0xC7, 0xE7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1E, 0x0F,
  0x0F, 0x07, 0x80, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x20,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x07,
  0x0F, 0x0C, 0xF9, 0xE7, 0x9F, 0xBB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xF0, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0xFB, 0xE0, 0x3F, 0x7E, 0x0F,
  0xE7, 0xE0, 0xF8, 0xFC, 0x0F, 0x0E, 0x00, 0xC1, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0x81, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE,
  0x3F, 0xC7, 0xF8, 0x7F, 0x03, 0xC0, 0xF8, 0x3E, 0x7F, 0x8F, 0xE1, 0xF8,
  0x38, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF,
  0xE0, 0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF, 0x07,
  0xF0, 0xFC, 0x7F, 0x07, 0xE3, 0xF0, 0x1F, 0x3F, 0x00, 0xF9, 0xF8, 0x07,
  0xCF, 0x80, 0x3E, 0xFC, 0x01, 0xF7, 0xC7, 0x8F, 0xBE, 0x3C, 0x7F, 0xF3,
  0xE3, 0xFF, 0x9F, 0x3F, 0xF8, 0xF9, 0xFF, 0xC3, 0x8F, 0xBE, 0x00, 0x7D,
  0xF0, 0x07, 0xEF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x1F, 0x9F, 0x01,
  0xF8, 0xFC, 0x1F, 0xC7, 0xF1, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF,
  0xF0, 0x7F, 0xFC, 0x0F, 0xDF, 0x80, 0xE3, 0xF0, 0x10, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0x1F, 0xC0, 0xF0,
  0x1F, 0x80, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x38,
  0x1F, 0xC0, 0x40, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x40, 0x07, 0xF0, 0xF0, 0x3F, 0xC1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xF8, 0x03,
  0xF0, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xC1, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x01, 0xF0, 0x3E, 0x03, 0xF0, 0x7C, 0x03, 0xF2, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x20, 0x07, 0xF0, 0x7C, 0x1F, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF0, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xBF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0x81, 0xFC, 0xFC, 0x03, 0xF3, 0xE0, 0x0F,
  0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xCF,
  0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0x7F, 0x1F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFC, 0x1F, 0x81,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x3F,
  0x03, 0xF0, 0x3F, 0x0F, 0xC0, 0x7F, 0x3F, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0x3F, 0xC0, 0xFC, 0x1F,
  0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x3F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0xFC,
  0x7E, 0x01, 0xF8, 0xFC, 0x07, 0xF1, 0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0x87, 0xE1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x3F, 0x00,
  0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x1F, 0x3F, 0x00, 0x7C,
  0xFC, 0x03, 0xF1, 0xFC, 0x3F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFB, 0xE0, 0x1F, 0x9F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x81, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xC0, 0x7E, 0x0F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFE, 0x0F, 0xE0, 0xFC, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x07, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x10, 0x00, 0x00, 0x78,
  0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0x00,
  0xFC, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x81, 0xFE, 0x03, 0xF8,
  0x07, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x00,
  0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0x80, 0x7F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0x3C, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xFF,
  0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xC7, 0x07, 0xF1, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x01, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0x3E,
  0x0F, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x03, 0xDE,
  0x3E, 0x0F, 0xFE, 0x3C, 0x1F, 0xFE, 0x7C, 0x3F, 0xFE, 0x78, 0x7F, 0xFE,
  0x78, 0xFC, 0x7C, 0x78, 0xF8, 0x7C, 0xF8, 0xF8, 0x7C, 0xF9, 0xF0, 0x7C,
  0xF1, 0xF0, 0xF8, 0xF1, 0xF0, 0xF8, 0xF1, 0xF0, 0xF8, 0xF1, 0xF0, 0xF8,
  0xF1, 0xF1, 0xF0, 0xF1, 0xF9, 0xF0, 0xF0, 0xFF, 0xF0, 0xF0, 0xFF, 0xF0,
  0xF8, 0x7F, 0xE0, 0xF8, 0x3F, 0xE0, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0xF8, 0x01,
  0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0x7C,
  0x1F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xE0, 0x1F,
  0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7C, 0x00, 0xFD, 0xF8, 0x01, 0xFB,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0x1F, 0xE0, 0x7C, 0x0F, 0xC1,
  0xF8, 0x0F, 0x83, 0xF0, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0xFC, 0x3F,
  0x03, 0xF0, 0x7E, 0x7F, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0x83, 0xF8, 0x3E, 0x01, 0xF8, 0xFC, 0x03,
  0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F, 0x9F, 0x80, 0x7E,
  0x3F, 0x01, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0x8F, 0x83,
  0xFC, 0x02, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x80, 0xFF, 0xDF, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07,
  0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xF8,
  0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x00,
  0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8, 0x0F, 0xC3, 0xE0, 0x3F,
  0x8F, 0xC0, 0x7E, 0x1F, 0x81, 0xFC, 0x3F, 0x0F, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0xFF, 0x8F, 0x83, 0xF8, 0x02, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF8,
  0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xFE, 0x0F, 0xC0, 0xFF, 0x3F,
  0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x20, 0x07, 0xE0, 0x38, 0x0F,
  0xC0, 0x7F, 0x7F, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0x3E, 0x07, 0xE0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC7,
  0xF0, 0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F,
  0x8F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0xF8,
  0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF1, 0xFE,
  0x07, 0xFC, 0x77, 0x81, 0xEF, 0x3D, 0xE0, 0x7B, 0xCE, 0xF8, 0x3E, 0xF7,
  0xBC, 0x0F, 0xBF, 0xCF, 0x03, 0xC7, 0xF3, 0xC1, 0xF1, 0xF9, 0xF0, 0x7C,
  0x7E, 0x7C, 0x1F, 0x1F, 0x1F, 0x07, 0xC7, 0xC7, 0x83, 0xE1, 0xE3, 0xE0,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07,
  0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x3F,
  0xC0, 0x7C, 0x07, 0xF8, 0x1F, 0x00, 0xFF, 0x03, 0xE0, 0x1F, 0xF0, 0x7C,
  0x07, 0xDE, 0x0F, 0x80, 0xFB, 0xC3, 0xE0, 0x1F, 0x78, 0x7C, 0x03, 0xEF,
  0x8F, 0x80, 0xFC, 0xF1, 0xF0, 0x1F, 0x1E, 0x7E, 0x03, 0xE3, 0xCF, 0x80,
  0x7C, 0x7D, 0xF0, 0x1F, 0x87, 0xBE, 0x03, 0xE0, 0xFF, 0xC0, 0x7C, 0x1F,
  0xF0, 0x0F, 0x83, 0xFE, 0x03, 0xF0, 0x7F, 0xC0, 0x7C, 0x07, 0xF8, 0x0F,
  0x80, 0xFE, 0x01, 0xF0, 0x1F, 0xC0, 0x3E, 0x03, 0xF8, 0x0F, 0x80, 0x7F,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0xFF, 0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x3F, 0x1F, 0x80,
  0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07,
  0xCF, 0xC0, 0x0F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC,
  0xF8, 0x01, 0xF9, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F,
  0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0xFF,
  0x7F, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xE0, 0x7F, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC1, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0x3F, 0x83, 0xF8, 0x3F, 0x07, 0xE0, 0x3E, 0x1F, 0x80, 0x7E, 0x3F, 0x00,
  0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xCF, 0xC0, 0x0F,
  0x9F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xF8, 0x01, 0xF9,
  0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x3F,
  0x00, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0xFF, 0x7F, 0x81, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0x1F,
  0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x1F, 0x07, 0xC0, 0x7E,
  0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xF8, 0x1F, 0xC1,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0xFC, 0x07, 0xC0,
  0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x07,
  0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x03, 0xF0, 0x3C, 0x07, 0xE0, 0x04, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x30, 0x03,
  0xF0, 0x7E, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0x3F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0,
  0x7E, 0x0F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7C, 0x1F, 0x80,
  0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3F, 0x01,
  0xF8, 0x3F, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x7E, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0xFC, 0x03, 0xE0, 0xFC, 0x07,
  0xE0, 0xFC, 0x07, 0xE0, 0xFE, 0x0F, 0xC0, 0x7F, 0xBF, 0xC0, 0x7F, 0xFF,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xBF, 0x00, 0x7E,
  0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0xF8,
  0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x80, 0xF8, 0x7C, 0x03,
  0xF3, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0x3E, 0x00, 0xFD, 0xF0, 0x03, 0xF7,
  0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C,
  0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x7C, 0x7C, 0x0F, 0x8F,
  0x8F, 0x81, 0xF3, 0xF1, 0xE0, 0x3C, 0x7E, 0x7C, 0x0F, 0x9F, 0xCF, 0x81,
  0xF3, 0xF9, 0xF0, 0x3E, 0xFF, 0x3C, 0x07, 0x9C, 0xE7, 0x80, 0xF7, 0x9D,
  0xF0, 0x1E, 0xE3, 0xBC, 0x07, 0xFC, 0x77, 0x80, 0xF7, 0x0E, 0xF0, 0x1F,
  0xE1, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xC0, 0xFE,
  0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xC3, 0xE0, 0x01, 0xFC,
  0x1F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F,
  0x00, 0xFE, 0x00, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFF,
  0xF0, 0x07, 0xEF, 0xC0, 0x1F, 0xBF, 0x00, 0xFC, 0x7C, 0x07, 0xE1, 0xF0,
  0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x87, 0xF0, 0x7E, 0x1F, 0x80, 0xF8, 0xFC,
  0x03, 0xE3, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xF8, 0x7E,
  0x3F, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xFC,
  0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F,
  0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x1F, 0x0F, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x80, 0xFE, 0xFC, 0x0F, 0xE3, 0xE0, 0x7E, 0x1F, 0x87, 0xE0, 0xFC,
  0x7E, 0x07, 0xE7, 0xF0, 0x1F, 0xFF, 0x00, 0xFD, 0xF0, 0x07, 0xE7, 0x00,
  0x1C, 0x08, 0x00, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x10, 0x03, 0x00, 0xF0, 0x3F, 0x0F,
  0xF8, 0x7F, 0x87, 0xF8, 0x3E, 0x01, 0x80, 0x00, 0x06, 0x00, 0x01, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xC7, 0xE1,
  0xFC, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x3F, 0x1F, 0x00, 0xFC, 0xFC, 0x03, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E,
  0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF8, 0x3F, 0x87, 0xFB, 0xFE, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xEF, 0x81, 0xFF, 0x3F, 0x00, 0xC0,
  0x00, 0x00, 0x04, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x10, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFC, 0xFE, 0x0F, 0xC1, 0xFC,
  0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E,
  0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xE7, 0xE0, 0x3F, 0x1F, 0x81, 0xFC, 0x7E, 0x3F, 0xE1, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0xFC, 0x70, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x04, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xE3, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0,
  0x7C, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0xC1, 0xFC, 0x07, 0xFB, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xF7, 0xC0, 0x1F, 0xF3, 0xF0, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0xE1, 0xFC, 0xFC, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01,
  0xFB, 0xE0, 0x1F, 0xBF, 0x03, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xE0, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFE, 0x30, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xCF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xE0, 0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC,
  0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0xE3, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x1C, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x04,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x30, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xFC, 0xFF, 0x0F, 0xC1, 0xFC, 0x3F, 0x03, 0xF0,
  0xFC, 0x0F, 0xC3, 0xE0, 0x3E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F,
  0x0F, 0x80, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F,
  0x01, 0xF8, 0xFC, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC1, 0xFF,
  0xE1, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFE, 0x0F,
  0xFF, 0x01, 0xFF, 0x80, 0x10, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x02, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x20, 0x1F, 0x80, 0x38, 0x7F, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x08, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0xFE,
  0x0F, 0xC1, 0xFC, 0x0F, 0xC3, 0xF8, 0x0F, 0xC7, 0xF0, 0x0F, 0xCF, 0xE0,
  0x1F, 0x9F, 0xC0, 0x1F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x3F, 0x00,
  0x3E, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0,
  0x7F, 0xF8, 0xFF, 0xF3, 0xFF, 0xC7, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xFC, 0x0B, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0xC7, 0xFF, 0x87, 0xFE,
  0x01, 0x00, 0x03, 0xFC, 0x7E, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0x8F, 0x9F, 0x0F, 0x8F, 0x1F, 0x0F, 0x8F, 0x1F, 0x0F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x1F, 0x1F, 0x3E, 0x1F, 0x1E, 0x3E, 0x1E,
  0x3E, 0x3E, 0x1E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0x00, 0x06, 0x00, 0x07,
  0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xCF,
  0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xE1,
  0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C, 0x07, 0xC3, 0xF0,
  0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xF8, 0x0F, 0x87, 0xE0, 0x7E,
  0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE1, 0xF0, 0x1F, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xF3, 0xFC, 0x7E, 0x07, 0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xFB,
  0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x07, 0xE7, 0xF0, 0x7F, 0x1F,
  0xEF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E,
  0x0F, 0xC0, 0xFE, 0x0F, 0x81, 0xFC, 0x1F, 0x83, 0xFC, 0x1F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xF1, 0xF8, 0xFE, 0x0F, 0xCF, 0xE0, 0x7E, 0x7E, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7C, 0x03,
  0xF3, 0xE0, 0x3F, 0x1F, 0x01, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x3F,
  0xDF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x7F, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xE0, 0xFE, 0x00, 0x83, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x07, 0xF0, 0x70, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC3, 0x00,
  0x7E, 0x1F, 0x0F, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x08, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x08, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x04, 0x00, 0x1F, 0x81, 0xF8, 0xFC,
  0x0F, 0xCF, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8,
  0xF8, 0x0F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x01,
  0xF1, 0xF8, 0x1F, 0x8F, 0xC0, 0xFC, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F,
  0x81, 0xF0, 0xFC, 0x1F, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x1F, 0xE3, 0xE0, 0x08, 0x00, 0x00, 0xFC, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0xFD, 0xF8, 0x07, 0xE7, 0xC0, 0x7E, 0x3F, 0x03,
  0xF1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F,
  0x8F, 0xC0, 0xFC, 0x7E, 0x03, 0xE7, 0xE0, 0x1F, 0x3F, 0x00, 0xFB, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x3C, 0x3E, 0x7C, 0x3C,
  0x3E, 0x7C, 0x7C, 0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0xFC, 0x7C, 0x78, 0xFC,
  0x78, 0x79, 0xFC, 0x78, 0x79, 0xFC, 0xF8, 0x7B, 0xDE, 0xF0, 0x7B, 0xDE,
  0xF0, 0xFF, 0x9F, 0xE0, 0xF7, 0x9F, 0xE0, 0xFF, 0x1F, 0xE0, 0xFF, 0x1F,
  0xC0, 0xFE, 0x1F, 0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0xF8, 0x0F,
  0x00, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7E,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xC0, 0x03, 0xEF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0xFC,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC0, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E,
  0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x0F,
  0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x3F,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7E, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x20, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x20,
  0x3F, 0x80, 0xF1, 0xFF, 0x87, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xCF, 0x87, 0xFE, 0x3C, 0x0F, 0xF0, 0x10, 0x0F, 0x80,
};

const GFXglyph UbuntuSansMono_BoldItalic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 13, 30, 24, 6, -29 },
  { 50, 17, 13, 24, 7, -32 },
  { 78, 25, 29, 24, 0, -29 },
  { 169, 23, 38, 24, 0, -33 },
  { 279, 29, 31, 24, -2, -30 },
  { 392, 23, 30, 24, 0, -30 },
  { 479, 9, 14, 24, 11, -32 },
  { 495, 18, 41, 24, 5, -33 },
  { 588, 19, 41, 24, 0, -33 },
  { 686, 19, 18, 24, 4, -29 },
  { 729, 21, 21, 24, 1, -23 },
  { 785, 11, 15, 24, 3, -8 },
  { 806, 14, 6, 24, 5, -15 },
  { 817, 8, 9, 24, 6, -8 },
  { 826, 28, 41, 24, -2, -33 },
  { 970, 21, 31, 24, 2, -30 },
  { 1052, 19, 29, 24, 1, -29 },
  { 1121, 23, 30, 24, 0, -30 },
  { 1208, 23, 31, 24, 0, -30 },
  { 1298, 24, 29, 24, 0, -29 },
  { 1385, 24, 30, 24, 0, -29 },
  { 1475, 22, 30, 24, 2, -29 },
  { 1558, 22, 29, 24, 4, -29 },
  { 1638, 23, 31, 24, 1, -30 },
  { 1728, 22, 30, 24, 1, -30 },
  { 1811, 12, 23, 24, 6, -22 },
  { 1846, 15, 29, 24, 3, -22 },
  { 1901, 21, 20, 24, 2, -22 },
  { 1954, 23, 14, 24, 0, -19 },
  { 1995, 21, 20, 24, 1, -22 },
  { 2048, 18, 31, 24, 5, -30 },
  { 2118, 24, 36, 24, 1, -30 },
  { 2226, 23, 29, 24, -2, -29 },
  { 2310, 23, 29, 24, 0, -29 },
  { 2394, 23, 31, 24, 2, -30 },
  { 2484, 23, 29, 24, 0, -29 },
  { 2568, 24, 29, 24, 1, -29 },
  { 2655, 25, 29, 24, 1, -29 },
  { 2746, 23, 31, 24, 2, -30 },
  { 2836, 27, 29, 24, -1, -29 },
  { 2934, 25, 29, 24, 0, -29 },
  { 3025, 24, 30, 24, 0, -29 },
  { 3115, 27, 29, 24, 0, -29 },
  { 3213, 20, 29, 24, 0, -29 },
  { 3286, 26, 29, 24, -1, -29 },
  { 3381, 27, 29, 24, -1, -29 },
  { 3479, 23, 31, 24, 1, -30 },
  { 3569, 24, 29, 24, 0, -29 },
  { 3656, 23, 38, 24, 1, -30 },
  { 3766, 23, 29, 24, 0, -29 },
  { 3850, 24, 31, 24, 0, -30 },
  { 3943, 23, 29, 24, 4, -29 },
  { 4027, 24, 30, 24, 1, -29 },
  { 4117, 22, 29, 24, 5, -29 },
  { 4197, 27, 29, 24, 0, -29 },
  { 4295, 29, 29, 24, -2, -29 },
  { 4401, 22, 29, 24, 5, -29 },
  { 4481, 25, 29, 24, 0, -29 },
  { 4572, 23, 41, 24, 2, -33 },
  { 4690, 9, 41, 24, 8, -33 },
  { 4737, 23, 41, 24, -1, -33 },
  { 4855, 21, 17, 24, 2, -29 },
  { 4900, 22, 5, 24, -3, 3 },
  { 4914, 11, 9, 24, 9, -33 },
  { 4927, 22, 24, 24, 1, -23 },
  { 4993, 22, 34, 24, 0, -33 },
  { 5087, 21, 24, 24, 2, -23 },
  { 5150, 25, 34, 24, 1, -33 },
  { 5257, 21, 24, 24, 2, -23 },
  { 5320, 29, 41, 24, -3, -33 },
  { 5469, 25, 31, 24, -2, -23 },
  { 5566, 22, 33, 24, 0, -33 },
  { 5657, 17, 34, 24, 3, -33 },
  { 5730, 24, 41, 24, -2, -33 },
  { 5853, 24, 33, 24, 1, -33 },
  { 5952, 15, 33, 24, 5, -32 },
  { 6014, 24, 22, 24, -1, -22 },
  { 6080, 22, 23, 24, 0, -23 },
  { 6144, 21, 24, 24, 1, -23 },
  { 6207, 24, 31, 24, -2, -23 },
  { 6300, 21, 31, 24, 2, -23 },
  { 6382, 22, 23, 24, 1, -23 },
  { 6446, 21, 24, 24, 1, -23 },
  { 6509, 20, 30, 24, 3, -29 },
  { 6584, 21, 23, 24, 2, -22 },
  { 6645, 21, 22, 24, 3, -22 },
  { 6703, 24, 22, 24, 1, -22 },
  { 6769, 25, 22, 24, -1, -22 },
  { 6838, 28, 30, 24, -4, -22 },
  { 6943, 22, 22, 24, 1, -22 },
  { 7004, 22, 41, 24, 3, -33 },
  { 7117, 16, 41, 24, 4, -33 },
  { 7199, 23, 41, 24, -2, -33 },
  { 7317, 22, 9, 24, 1, -17 },
};

const GFXfont UbuntuSansMono_BoldItalic42pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic42pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic42pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _UBUNTUSANSMONO_BOLDITALIC42PT7B_H_
