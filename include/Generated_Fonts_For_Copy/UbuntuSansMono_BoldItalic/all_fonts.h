#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/UbuntuSansMono_BoldItalic
// Headers: 67

#include "UbuntuSansMono_BoldItalic6pt7b.h"
#include "UbuntuSansMono_BoldItalic7pt7b.h"
#include "UbuntuSansMono_BoldItalic8pt7b.h"
#include "UbuntuSansMono_BoldItalic9pt7b.h"
#include "UbuntuSansMono_BoldItalic10pt7b.h"
#include "UbuntuSansMono_BoldItalic11pt7b.h"
#include "UbuntuSansMono_BoldItalic12pt7b.h"
#include "UbuntuSansMono_BoldItalic13pt7b.h"
#include "UbuntuSansMono_BoldItalic14pt7b.h"
#include "UbuntuSansMono_BoldItalic15pt7b.h"
#include "UbuntuSansMono_BoldItalic16pt7b.h"
#include "UbuntuSansMono_BoldItalic17pt7b.h"
#include "UbuntuSansMono_BoldItalic18pt7b.h"
#include "UbuntuSansMono_BoldItalic19pt7b.h"
#include "UbuntuSansMono_BoldItalic20pt7b.h"
#include "UbuntuSansMono_BoldItalic21pt7b.h"
#include "UbuntuSansMono_BoldItalic22pt7b.h"
#include "UbuntuSansMono_BoldItalic23pt7b.h"
#include "UbuntuSansMono_BoldItalic24pt7b.h"
#include "UbuntuSansMono_BoldItalic25pt7b.h"
#include "UbuntuSansMono_BoldItalic26pt7b.h"
#include "UbuntuSansMono_BoldItalic27pt7b.h"
#include "UbuntuSansMono_BoldItalic28pt7b.h"
#include "UbuntuSansMono_BoldItalic29pt7b.h"
#include "UbuntuSansMono_BoldItalic30pt7b.h"
#include "UbuntuSansMono_BoldItalic31pt7b.h"
#include "UbuntuSansMono_BoldItalic32pt7b.h"
#include "UbuntuSansMono_BoldItalic33pt7b.h"
#include "UbuntuSansMono_BoldItalic34pt7b.h"
#include "UbuntuSansMono_BoldItalic35pt7b.h"
#include "UbuntuSansMono_BoldItalic36pt7b.h"
#include "UbuntuSansMono_BoldItalic37pt7b.h"
#include "UbuntuSansMono_BoldItalic38pt7b.h"
#include "UbuntuSansMono_BoldItalic39pt7b.h"
#include "UbuntuSansMono_BoldItalic40pt7b.h"
#include "UbuntuSansMono_BoldItalic41pt7b.h"
#include "UbuntuSansMono_BoldItalic42pt7b.h"
#include "UbuntuSansMono_BoldItalic43pt7b.h"
#include "UbuntuSansMono_BoldItalic44pt7b.h"
#include "UbuntuSansMono_BoldItalic45pt7b.h"
#include "UbuntuSansMono_BoldItalic46pt7b.h"
#include "UbuntuSansMono_BoldItalic47pt7b.h"
#include "UbuntuSansMono_BoldItalic48pt7b.h"
#include "UbuntuSansMono_BoldItalic49pt7b.h"
#include "UbuntuSansMono_BoldItalic50pt7b.h"
#include "UbuntuSansMono_BoldItalic51pt7b.h"
#include "UbuntuSansMono_BoldItalic52pt7b.h"
#include "UbuntuSansMono_BoldItalic53pt7b.h"
#include "UbuntuSansMono_BoldItalic54pt7b.h"
#include "UbuntuSansMono_BoldItalic55pt7b.h"
#include "UbuntuSansMono_BoldItalic56pt7b.h"
#include "UbuntuSansMono_BoldItalic57pt7b.h"
#include "UbuntuSansMono_BoldItalic58pt7b.h"
#include "UbuntuSansMono_BoldItalic59pt7b.h"
#include "UbuntuSansMono_BoldItalic60pt7b.h"
#include "UbuntuSansMono_BoldItalic61pt7b.h"
#include "UbuntuSansMono_BoldItalic62pt7b.h"
#include "UbuntuSansMono_BoldItalic63pt7b.h"
#include "UbuntuSansMono_BoldItalic64pt7b.h"
#include "UbuntuSansMono_BoldItalic65pt7b.h"
#include "UbuntuSansMono_BoldItalic66pt7b.h"
#include "UbuntuSansMono_BoldItalic67pt7b.h"
#include "UbuntuSansMono_BoldItalic68pt7b.h"
#include "UbuntuSansMono_BoldItalic69pt7b.h"
#include "UbuntuSansMono_BoldItalic70pt7b.h"
#include "UbuntuSansMono_BoldItalic71pt7b.h"
#include "UbuntuSansMono_BoldItalic72pt7b.h"
