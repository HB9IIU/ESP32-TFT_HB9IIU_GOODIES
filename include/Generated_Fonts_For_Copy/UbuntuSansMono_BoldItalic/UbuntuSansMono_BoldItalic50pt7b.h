#ifndef _UBUNTUSANSMONO_BOLDITALIC50PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01,
  0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x18,
  0x00, 0x3F, 0x87, 0xF7, 0xF8, 0xFF, 0x7F, 0x0F, 0xE7, 0xF0, 0xFE, 0x7F,
  0x0F, 0xE7, 0xF0, 0xFE, 0xFE, 0x1F, 0xCF, 0xE1, 0xFC, 0xFE, 0x1F, 0xCF,
  0xC1, 0xF8, 0xFC, 0x1F, 0x8F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x3F, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xC3,
  0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE0, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03, 0xFE, 0x01, 0xC0, 0x7F, 0x00,
  0x08, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x81, 0x80, 0x07, 0xF0, 0x7E, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x1F, 0xE0, 0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x07,
  0xFF, 0x00, 0xF8, 0x01, 0xE3, 0xC0, 0x3E, 0x00, 0xF8, 0xF0, 0x1F, 0x00,
  0x3C, 0x3C, 0x0F, 0x80, 0x1F, 0x0F, 0x07, 0xC0, 0x07, 0xC3, 0xC3, 0xE0,
  0x01, 0xE1, 0xF1, 0xF0, 0x00, 0x78, 0x78, 0x7C, 0x00, 0x1E, 0x3E, 0x3E,
  0x00, 0x07, 0xDF, 0x9F, 0x00, 0x01, 0xFF, 0xCF, 0x80, 0x00, 0x3F, 0xE7,
  0xC0, 0x00, 0x0F, 0xF3, 0xE0, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x08, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x0F, 0x9F, 0xF0, 0x00, 0x07, 0xC7, 0xFE, 0x00, 0x01, 0xF3, 0xFF, 0x80,
  0x00, 0xF9, 0xF1, 0xE0, 0x00, 0x7C, 0x78, 0x78, 0x00, 0x3E, 0x1E, 0x1E,
  0x00, 0x1F, 0x0F, 0x87, 0x80, 0x0F, 0x83, 0xE1, 0xE0, 0x03, 0xE0, 0xF0,
  0xF8, 0x01, 0xF0, 0x3C, 0x3C, 0x00, 0xF8, 0x0F, 0x1F, 0x00, 0x7C, 0x03,
  0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x1F, 0xF0, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8,
  0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xC2, 0x00, 0x3F, 0xE0, 0x7C, 0x1F, 0xFC, 0x1F, 0x87,
  0xFF, 0xC3, 0xF1, 0xFD, 0xFC, 0x7C, 0x7F, 0x1F, 0x9F, 0x8F, 0xC3, 0xFB,
  0xE3, 0xF0, 0x3F, 0xFC, 0x7E, 0x03, 0xFF, 0x0F, 0xC0, 0x7F, 0xE3, 0xF8,
  0x07, 0xF8, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x0F, 0xFC,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xBF, 0x03, 0xFF,
  0xE7, 0xF0, 0x3F, 0xF0, 0x7E, 0x00, 0x40, 0x00, 0x00, 0x3F, 0x9F, 0xDF,
  0xEF, 0xE7, 0xF3, 0xFB, 0xFD, 0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0x87,
  0xC3, 0xE1, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x06, 0x0F, 0x83, 0x1F, 0x1F,
  0x1E, 0x3F, 0x3C, 0xFE, 0x7F, 0xFB, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0,
  0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xE0, 0x3F, 0x9F, 0xE0, 0xFF, 0x1F, 0xC0,
  0x7C, 0x3F, 0x00, 0x78, 0x3C, 0x00, 0x60, 0x20, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F,
  0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFE, 0x07, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0xFC, 0x1F, 0xE3, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x78, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF3, 0xFF,
  0xF8, 0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x7F,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x81, 0xFF, 0x9F, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x0F, 0xE0,
  0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F,
  0x80, 0x1F, 0xCF, 0xC1, 0x87, 0xF7, 0xF1, 0xF1, 0xFD, 0xFC, 0xFC, 0x7F,
  0x7E, 0x3F, 0x1F, 0x9F, 0x8F, 0xC7, 0xEF, 0xE3, 0xF1, 0xFB, 0xF8, 0xF8,
  0xFE, 0xFE, 0x1C, 0x3F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xF3, 0xF0,
  0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x1F, 0xC3, 0xFE, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7F,
  0xFE, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xCF,
  0xE0, 0x1E, 0x3F, 0x80, 0x30, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xF8, 0x0F, 0xF0, 0x0E,
  0x00, 0xFF, 0x00, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xF8, 0x7F, 0xC0, 0x18, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x82,
  0x00, 0x0F, 0xF0, 0xF8, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07,
  0xF0, 0x3F, 0x00, 0x7F, 0x07, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x02,
  0x00, 0x0F, 0xF0, 0x3E, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xDF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x8F, 0xF8, 0x7F, 0x00, 0x7F,
  0x8F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xC7, 0xF0,
  0x01, 0xF8, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0xFF, 0x07, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x07,
  0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07,
  0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x3F,
  0x81, 0xFC, 0x07, 0xF8, 0x7F, 0x00, 0x7F, 0xBF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFB,
  0xFE, 0x01, 0xFC, 0x3F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC3,
  0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE3, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x03, 0xFC, 0x1F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x0F, 0xF9, 0xFF, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x00, 0xFE, 0x1F,
  0xC0, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x07,
  0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE,
  0x00, 0x7F, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFD, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xFE, 0x07, 0xF0, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x07, 0xF8, 0x1F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F,
  0xE0, 0x7F, 0x81, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x07, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x60, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x04, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x7E, 0x3F, 0xF1, 0xC0, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0x9F, 0xF0, 0x3F, 0xC0, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x1F, 0x80, 0x7F, 0xF1, 0xF0,
  0x1F, 0xFF, 0x3F, 0x07, 0xFF, 0xF3, 0xE0, 0xFF, 0xFE, 0x3E, 0x1F, 0xFF,
  0xE7, 0xE1, 0xFF, 0xFE, 0x7C, 0x3F, 0x87, 0xE7, 0xC3, 0xF0, 0x7E, 0x7C,
  0x7E, 0x0F, 0xC7, 0xC7, 0xE0, 0xFC, 0xFC, 0x7E, 0x0F, 0xCF, 0x87, 0xC0,
  0xFC, 0xF8, 0x7C, 0x1F, 0x8F, 0x87, 0xC1, 0xF8, 0xF8, 0x7C, 0x1F, 0x8F,
  0x87, 0xC1, 0xF8, 0xF8, 0x7E, 0x3F, 0x0F, 0x87, 0xF3, 0xF0, 0xF8, 0x7F,
  0xFF, 0x0F, 0x83, 0xFF, 0xF0, 0xFC, 0x3F, 0xFE, 0x0F, 0xC1, 0xFF, 0xE0,
  0x7C, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x07, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x3F,
  0x80, 0xFC, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xE0,
  0x07, 0xF1, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xFB,
  0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01,
  0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80,
  0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x0F, 0xE0,
  0x7F, 0x03, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x1F, 0xC0, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0xC3, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0x87, 0xFC, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0x00, 0xE0, 0x7F, 0x80, 0x04, 0x0F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x01, 0x00, 0xFF, 0xC3, 0xE0, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0xE0, 0x3F, 0x81, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00,
  0x7E, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0,
  0x0F, 0xE1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC,
  0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x7F, 0x83, 0xF8,
  0x07, 0xF8, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x1F, 0xF0, 0x7F, 0x07, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFE, 0x01, 0xC0, 0x7F, 0x80, 0x04, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00,
  0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x81, 0xFC, 0x07, 0xFC,
  0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x20, 0x03, 0xF8,
  0x03, 0xC0, 0x3F, 0xC0, 0x1F, 0x8F, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x01, 0xFC,
  0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0xF8,
  0x3F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xDF,
  0xE0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x81, 0xFE, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xF7, 0x87, 0xBE, 0x01,
  0xF7, 0x87, 0xBE, 0x01, 0xF7, 0x8F, 0x7C, 0x03, 0xF7, 0x8F, 0x7C, 0x03,
  0xF7, 0x9E, 0x7C, 0x03, 0xE7, 0xBE, 0x7C, 0x03, 0xE7, 0xBC, 0xFC, 0x07,
  0xE7, 0xFC, 0xFC, 0x07, 0xE7, 0xF8, 0xF8, 0x07, 0xC7, 0xF8, 0xF8, 0x0F,
  0xC3, 0xF1, 0xF8, 0x0F, 0xC3, 0xF1, 0xF8, 0x0F, 0xC3, 0xE1, 0xF8, 0x0F,
  0x83, 0xE1, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x7E, 0x01,
  0xFF, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0xFC, 0x01,
  0xFF, 0x80, 0xFC, 0x03, 0xFF, 0x81, 0xF8, 0x03, 0xFF, 0x81, 0xF8, 0x03,
  0xF7, 0xC1, 0xF8, 0x03, 0xF7, 0xC1, 0xF8, 0x07, 0xF7, 0xC3, 0xF8, 0x07,
  0xE7, 0xE3, 0xF0, 0x07, 0xE3, 0xE3, 0xF0, 0x07, 0xE3, 0xE3, 0xF0, 0x07,
  0xE3, 0xE7, 0xF0, 0x0F, 0xC3, 0xE7, 0xE0, 0x0F, 0xC1, 0xF7, 0xE0, 0x0F,
  0xC1, 0xF7, 0xE0, 0x0F, 0xC1, 0xF7, 0xE0, 0x1F, 0x81, 0xFF, 0xC0, 0x1F,
  0x80, 0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0xC0, 0x3F,
  0x80, 0xFF, 0x80, 0x3F, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0x80, 0x3F,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xFC, 0x3F, 0xC0,
  0x7F, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF3, 0xFC, 0x01, 0xFC, 0xFE,
  0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xF0, 0x01, 0xFD,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xEF, 0xE0, 0x03,
  0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xCF, 0xE0,
  0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F,
  0xE0, 0x1F, 0xE3, 0xF8, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x3F, 0xE3, 0xFE,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0x80,
  0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE,
  0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F,
  0x83, 0xFC, 0x3F, 0xC0, 0x7F, 0x1F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1,
  0xFC, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xDF, 0xC0, 0x07,
  0xF7, 0xF0, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xBF,
  0x80, 0x1F, 0xCF, 0xE0, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0xFE,
  0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F, 0xE3, 0xF8, 0x0F, 0xF0, 0xFF, 0x07,
  0xF8, 0x3F, 0xE3, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x01, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xF8,
  0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0xFE,
  0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xC7, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x1F,
  0x80, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0xFE, 0x00,
  0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0xFE, 0x03, 0xFC, 0x00, 0xC0, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x02, 0x00, 0x07, 0xF0, 0x38,
  0x00, 0xFF, 0x07, 0xE0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01,
  0xFC, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x83,
  0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x00,
  0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x01, 0xFC,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xF8, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x01,
  0xFD, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xE3, 0xF0, 0x03, 0xF8, 0x7E,
  0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0,
  0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x80,
  0x3F, 0x07, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0xCF,
  0xE0, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F,
  0xC7, 0xE1, 0xF0, 0x0F, 0x87, 0xE3, 0xF0, 0x1F, 0x8F, 0xE3, 0xF0, 0x1F,
  0x8F, 0xE3, 0xF0, 0x1F, 0x9F, 0xE3, 0xE0, 0x1F, 0x1F, 0xE3, 0xE0, 0x1F,
  0x3D, 0xE7, 0xE0, 0x3F, 0x3D, 0xE7, 0xC0, 0x3F, 0x79, 0xE7, 0xC0, 0x3E,
  0x79, 0xE7, 0xC0, 0x3E, 0xF1, 0xEF, 0xC0, 0x3E, 0xF1, 0xEF, 0x80, 0x3F,
  0xE1, 0xEF, 0x80, 0x7D, 0xE1, 0xEF, 0x80, 0x7F, 0xC1, 0xFF, 0x00, 0x7F,
  0xC1, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x07, 0xF8, 0x1F, 0x80, 0x03, 0xFC, 0x07, 0xE0, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFB, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xCF, 0xE0, 0x07,
  0xF0, 0xFC, 0x01, 0xFC, 0x1F, 0x80, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x87, 0xF0,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xEF, 0xE0, 0x00, 0xFD,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xFC, 0x1F,
  0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x1F,
  0xE1, 0xFC, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x1F, 0xE3, 0xFC, 0x03, 0xF8,
  0xFE, 0x00, 0xFE, 0x7F, 0x80, 0x3F, 0xBF, 0xC0, 0x07, 0xF3, 0xE0, 0x01,
  0xF0, 0x30, 0x00, 0x70, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x00, 0xC0, 0x0F, 0x80, 0x7E, 0x07,
  0xF8, 0x7F, 0xF0, 0xFF, 0xE1, 0xFE, 0x03, 0xE0, 0x07, 0x00, 0x10, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0x83, 0xF8, 0x7F, 0x80,
  0xFE, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xF1, 0xFC,
  0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xC7, 0xE0, 0x0F, 0xE1,
  0xF8, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x03, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xDF, 0x80,
  0xFF, 0xC7, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF9, 0xF0,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFF, 0x0F,
  0xE0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x1F, 0xC0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00,
  0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x07, 0xF0, 0xFE,
  0x03, 0xFC, 0x7F, 0x01, 0xFE, 0x1F, 0xC1, 0xFF, 0x87, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xC0, 0x20, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x08,
  0x1F, 0xFE, 0x7E, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xEF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0x83, 0xF8, 0x07, 0xF8,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xFC,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F,
  0x03, 0xFC, 0x01, 0xFF, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFD, 0xF8, 0x00, 0xFF, 0xC7,
  0xF0, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x7F, 0x80, 0xFE, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x1F, 0x9F, 0x80, 0x1F,
  0xDF, 0xC0, 0x1F, 0xEF, 0xC0, 0x1F, 0xE7, 0xE0, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE,
  0x01, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x60, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x08, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0x80, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01, 0xF8,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF,
  0x01, 0xFC, 0x01, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0xC0, 0x0F, 0xF0, 0x03, 0xFB, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0x87, 0xFC, 0x1F, 0xC0, 0xFF, 0x07,
  0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x80, 0xFE,
  0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F, 0x01,
  0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F, 0xE1,
  0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xCF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x20, 0x0F, 0xF0, 0x03, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x81, 0xFC, 0x07, 0xF8,
  0x0F, 0xE0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x3F,
  0x87, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE7, 0xF8, 0x00, 0xFE, 0x7F,
  0x80, 0x07, 0xF7, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xBF, 0x80, 0x03, 0xF9, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F,
  0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x03, 0xF8, 0x1F, 0xC0,
  0x1F, 0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x00, 0x7F, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F,
  0xFF, 0x8F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x9F, 0xF7, 0xCF, 0xFF, 0xE7, 0xFF, 0xF1,
  0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0xE0, 0x00, 0x0E, 0x01, 0x80,
  0x0F, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFB, 0xFD, 0xF8, 0x1F, 0x8F, 0x87, 0xE0, 0xF8, 0x7C,
  0x3E, 0x0F, 0xC3, 0xE1, 0xF0, 0x7E, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0xFC,
  0x1F, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0xC7, 0xE3, 0xF0, 0x7E,
  0x3F, 0x1F, 0x83, 0xE1, 0xF0, 0xFC, 0x1F, 0x0F, 0x87, 0xC1, 0xF8, 0x00,
  0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xF8,
  0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7C,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0x87, 0xFC, 0x1F, 0xC0, 0xFF,
  0x07, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0xFE, 0x01, 0xF8, 0x3F, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE1, 0xFC, 0x03, 0xF8, 0x7F,
  0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x0F,
  0xE1, 0xFC, 0x07, 0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x7F, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0x3F,
  0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x7F, 0x7F, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE,
  0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80,
  0x7F, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x03, 0xF0, 0x07, 0xF0,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x07, 0xE0,
  0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xFC,
  0x0F, 0xE0, 0xFF, 0x81, 0xFC, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFB, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x83, 0xF8, 0x7F, 0x80, 0xFC, 0x3F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0xFE,
  0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8,
  0xFE, 0x01, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x07,
  0xF0, 0xFF, 0x03, 0xF8, 0x3F, 0xE3, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x00,
  0x04, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0x80, 0x04, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xC0, 0x18, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x83,
  0x00, 0x1F, 0xC3, 0xE0, 0x3F, 0xE1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x01, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x10, 0x1F, 0xF3, 0xE0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x0F, 0xE0,
  0x3F, 0x87, 0xF0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x3F,
  0x80, 0xFE, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0x87,
  0xF0, 0x1F, 0xC3, 0xF8, 0x0F, 0xE1, 0xF8, 0x07, 0xF1, 0xFC, 0x03, 0xF8,
  0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0xFF,
  0x0F, 0xF9, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFD, 0xFC, 0x0F, 0xFC, 0x7E, 0x00, 0x60, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0, 0x1F, 0xCF,
  0xE0, 0x0F, 0xE7, 0xF0, 0x0F, 0xF3, 0xF8, 0x07, 0xF1, 0xFC, 0x07, 0xF8,
  0x7E, 0x03, 0xF8, 0x3F, 0x83, 0xFC, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFC,
  0x07, 0xF0, 0xFE, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x7F,
  0x00, 0x3F, 0x3F, 0x80, 0x1F, 0xBF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xC3,
  0xF0, 0xFC, 0x7E, 0x1F, 0x87, 0xC3, 0xF1, 0xFC, 0x3E, 0x1F, 0x8F, 0xE3,
  0xF0, 0xF8, 0xFF, 0x1F, 0x07, 0xC7, 0xF8, 0xF8, 0x3E, 0x7F, 0xC7, 0xC1,
  0xF3, 0xFE, 0x7C, 0x0F, 0xBE, 0xFB, 0xE0, 0x7D, 0xE7, 0xDE, 0x03, 0xFF,
  0x3F, 0xF0, 0x1E, 0xF0, 0xFF, 0x80, 0xFF, 0x87, 0xF8, 0x07, 0xF8, 0x3F,
  0xC0, 0x3F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0xCF, 0xF0, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC1, 0xFE, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8,
  0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xF0,
  0x02, 0x00, 0xFF, 0x00, 0xFC, 0x7F, 0xF8, 0x1F, 0x1F, 0xFF, 0xC7, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xE0, 0xFF,
  0xF0, 0xF8, 0x0F, 0xFC, 0x07, 0x00, 0x7F, 0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 16, 36, 28, 7, -35 },
  { 73, 20, 16, 28, 9, -38 },
  { 113, 30, 35, 28, 0, -35 },
  { 245, 27, 44, 28, 1, -39 },
  { 394, 34, 36, 28, -2, -35 },
  { 547, 27, 36, 28, 0, -35 },
  { 669, 9, 17, 28, 14, -38 },
  { 689, 23, 50, 28, 5, -40 },
  { 833, 23, 50, 28, 0, -40 },
  { 977, 23, 22, 28, 5, -35 },
  { 1041, 25, 25, 28, 2, -27 },
  { 1120, 14, 17, 28, 3, -9 },
  { 1150, 17, 7, 28, 6, -18 },
  { 1165, 10, 10, 28, 7, -9 },
  { 1178, 33, 48, 28, -3, -39 },
  { 1376, 26, 36, 28, 2, -35 },
  { 1493, 23, 35, 28, 1, -35 },
  { 1594, 28, 35, 28, 0, -35 },
  { 1717, 27, 36, 28, 0, -35 },
  { 1839, 28, 35, 28, 0, -35 },
  { 1962, 29, 36, 28, 0, -35 },
  { 2093, 27, 36, 28, 2, -35 },
  { 2215, 27, 35, 28, 4, -35 },
  { 2334, 27, 36, 28, 1, -35 },
  { 2456, 27, 35, 28, 1, -35 },
  { 2575, 14, 27, 28, 7, -26 },
  { 2623, 18, 34, 28, 3, -26 },
  { 2700, 26, 25, 28, 2, -27 },
  { 2782, 28, 17, 28, 0, -23 },
  { 2842, 25, 25, 28, 1, -27 },
  { 2921, 22, 36, 28, 6, -35 },
  { 3020, 28, 43, 28, 1, -35 },
  { 3171, 27, 35, 28, -2, -35 },
  { 3290, 28, 35, 28, 0, -35 },
  { 3413, 27, 36, 28, 3, -35 },
  { 3535, 28, 35, 28, 0, -35 },
  { 3658, 29, 35, 28, 1, -35 },
  { 3785, 30, 35, 28, 1, -35 },
  { 3917, 28, 36, 28, 2, -35 },
  { 4043, 32, 35, 28, -1, -35 },
  { 4183, 30, 35, 28, 0, -35 },
  { 4315, 29, 36, 28, 0, -35 },
  { 4446, 32, 35, 28, 0, -35 },
  { 4586, 23, 35, 28, 0, -35 },
  { 4687, 32, 35, 28, -2, -35 },
  { 4827, 32, 35, 28, -1, -35 },
  { 4967, 26, 36, 28, 2, -35 },
  { 5084, 29, 35, 28, 0, -35 },
  { 5211, 26, 45, 28, 2, -35 },
  { 5358, 28, 35, 28, 0, -35 },
  { 5481, 28, 36, 28, 0, -35 },
  { 5607, 27, 35, 28, 5, -35 },
  { 5726, 28, 36, 28, 2, -35 },
  { 5852, 27, 35, 28, 5, -35 },
  { 5971, 32, 35, 28, 0, -35 },
  { 6111, 34, 35, 28, -2, -35 },
  { 6260, 27, 35, 28, 6, -35 },
  { 6379, 31, 35, 28, -1, -35 },
  { 6515, 27, 48, 28, 3, -39 },
  { 6677, 12, 48, 28, 9, -39 },
  { 6749, 27, 48, 28, -1, -39 },
  { 6911, 26, 21, 28, 2, -35 },
  { 6980, 27, 6, 28, -4, 3 },
  { 7001, 13, 11, 28, 11, -39 },
  { 7019, 26, 28, 28, 1, -27 },
  { 7110, 26, 40, 28, 0, -39 },
  { 7240, 26, 28, 28, 2, -27 },
  { 7331, 30, 40, 28, 1, -39 },
  { 7481, 25, 28, 28, 2, -27 },
  { 7569, 35, 48, 28, -4, -39 },
  { 7779, 30, 36, 28, -2, -27 },
  { 7914, 26, 39, 28, 0, -39 },
  { 8041, 20, 40, 28, 4, -39 },
  { 8141, 28, 49, 28, -2, -39 },
  { 8313, 29, 39, 28, 1, -39 },
  { 8455, 17, 40, 28, 6, -39 },
  { 8540, 29, 27, 28, -1, -27 },
  { 8638, 26, 27, 28, 0, -27 },
  { 8726, 24, 28, 28, 2, -27 },
  { 8810, 28, 36, 28, -2, -27 },
  { 8936, 26, 36, 28, 2, -27 },
  { 9053, 26, 27, 28, 2, -27 },
  { 9141, 25, 28, 28, 1, -27 },
  { 9229, 24, 35, 28, 4, -34 },
  { 9334, 25, 27, 28, 2, -26 },
  { 9419, 25, 26, 28, 4, -26 },
  { 9501, 29, 26, 28, 1, -26 },
  { 9596, 31, 26, 28, -2, -26 },
  { 9697, 34, 35, 28, -5, -26 },
  { 9846, 27, 26, 28, 1, -26 },
  { 9934, 27, 48, 28, 3, -39 },
  { 10096, 18, 48, 28, 5, -39 },
  { 10204, 27, 48, 28, -2, -39 },
  { 10366, 27, 10, 28, 1, -20 },
};

const GFXfont UbuntuSansMono_BoldItalic50pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic50pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic50pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _UBUNTUSANSMONO_BOLDITALIC50PT7B_H_
