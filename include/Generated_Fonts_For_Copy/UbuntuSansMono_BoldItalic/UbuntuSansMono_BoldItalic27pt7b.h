#ifndef _UBUNTUSANSMONO_BOLDITALIC27PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic27pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x38, 0x00, 0x00, 0x30, 0xF8, 0xF8, 0xF8, 0xF0, 0x79, 0xEE, 0x3B, 0xCF,
  0x79, 0xEF, 0x3D, 0xC7, 0x38, 0xE6, 0x18, 0xC3, 0x00, 0x01, 0xC7, 0x01,
  0xCE, 0x03, 0xCE, 0x03, 0x8E, 0x03, 0x9C, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFE, 0x0E, 0x38, 0x0E, 0x70, 0x1C, 0x70, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF,
  0xFC, 0x39, 0xC0, 0x71, 0xC0, 0x73, 0x80, 0xE3, 0x80, 0xE7, 0x80, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0x87, 0x81,
  0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x40, 0x78, 0xF1, 0xF1, 0xFF, 0xC7, 0xFF,
  0x00, 0xF8, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x81, 0xC3, 0xF0,
  0x61, 0xDC, 0x30, 0x67, 0x1C, 0x19, 0xCE, 0x06, 0x67, 0x01, 0xBB, 0x80,
  0x7C, 0xC0, 0x1F, 0x60, 0x00, 0x38, 0x00, 0x1D, 0xE0, 0x0E, 0xF8, 0x07,
  0x77, 0x01, 0x99, 0xC0, 0xC6, 0x70, 0x71, 0x98, 0x38, 0x6E, 0x1C, 0x1F,
  0x0E, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x71, 0xC0, 0xE3,
  0x81, 0xC7, 0x03, 0x9C, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x1C, 0xFE, 0x73,
  0xDE, 0xE7, 0x1F, 0xDE, 0x3F, 0x3C, 0x3C, 0x78, 0x78, 0xFF, 0xF8, 0xFF,
  0x70, 0xFC, 0xF0, 0x3D, 0xE7, 0x9E, 0x79, 0xC7, 0x38, 0xE3, 0x80, 0x00,
  0x60, 0x0F, 0x03, 0xF0, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xE0, 0x1C,
  0x00, 0x80, 0x01, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x80, 0x70, 0x06, 0x00, 0x0F, 0x00, 0xF0, 0x0E, 0x0E, 0xE6, 0xF7,
  0xFF, 0xFF, 0x7F, 0xE1, 0xF0, 0x3F, 0x87, 0xBE, 0x39, 0xC1, 0x18, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x1C, 0x7C,
  0xF9, 0xF3, 0xE1, 0x8F, 0x7C, 0xF1, 0x00, 0x7F, 0xBF, 0xFF, 0xFF, 0xE0,
  0x77, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0x87, 0x8F, 0x3C, 0x3C, 0xE0, 0x77, 0x81,
  0xDC, 0x47, 0x73, 0xBF, 0xDE, 0xFF, 0x73, 0xBC, 0x0E, 0xE0, 0x7B, 0x81,
  0xEF, 0x0F, 0x3C, 0x7C, 0x7F, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x70,
  0x1F, 0x03, 0xE0, 0xFE, 0x3F, 0xE3, 0xDE, 0x19, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0xF8, 0x70, 0xF0, 0x81,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x7F, 0xF9, 0xFF,
  0xF3, 0xFF, 0xC0, 0x03, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x21, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x7C, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x20, 0x3C, 0xFF, 0xF1, 0xFF,
  0xC1, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x1F,
  0xC0, 0x7B, 0x81, 0xEF, 0x07, 0x9E, 0x1E, 0x38, 0x38, 0x70, 0xE1, 0xE3,
  0x83, 0xD7, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x80, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01,
  0xF8, 0x00, 0x78, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x40, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x00, 0x3E, 0x03, 0xFC, 0x1F, 0xF0, 0x7F,
  0x01, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x3D, 0xE0, 0x7F, 0xF0, 0xFF, 0xE3,
  0xC1, 0xE7, 0x83, 0xCF, 0x03, 0x9E, 0x0F, 0x3C, 0x1E, 0x3C, 0x78, 0x7F,
  0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0xFE, 0x7F, 0xFD, 0xFF, 0xF0, 0x03,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0xC7, 0x8F,
  0x3C, 0x1C, 0xF0, 0x73, 0xC3, 0xC7, 0x9E, 0x0F, 0xF0, 0x7F, 0x03, 0xFE,
  0x1E, 0x3C, 0xF0, 0x73, 0x81, 0xEE, 0x07, 0xBC, 0x3C, 0xFF, 0xF1, 0xFF,
  0x83, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x8F, 0x1F, 0x78, 0x3D,
  0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x78, 0x3C, 0xFF, 0xF3, 0xFF, 0x83, 0xDE,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0x80,
  0x00, 0x1E, 0x7C, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00, 0xE3, 0xE7, 0xCF,
  0x9E, 0x00, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x30, 0x78, 0xF8, 0x78, 0x20, 0x00,
  0x00, 0x0C, 0x01, 0xF0, 0x3F, 0xC3, 0xFE, 0x7F, 0xC1, 0xF8, 0x0F, 0x80,
  0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x00, 0x38, 0x00, 0x20, 0x3F,
  0xFE, 0x7F, 0xFC, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x9F, 0xFE,
  0x7F, 0xFC, 0xFF, 0xF8, 0x18, 0x00, 0x7C, 0x03, 0xFC, 0x03, 0xFC, 0x03,
  0xFC, 0x01, 0xF0, 0x07, 0xC0, 0xFF, 0x1F, 0xF3, 0xFE, 0x07, 0xC0, 0x1C,
  0x00, 0x80, 0x00, 0x3F, 0x8F, 0xF9, 0xFF, 0xB1, 0xF0, 0x1E, 0x03, 0xC0,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x18, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xF8, 0x3E, 0xF0,
  0xE0, 0x73, 0x80, 0xEF, 0x01, 0xDC, 0x7F, 0xB1, 0xFE, 0xE7, 0xFD, 0xCE,
  0x3B, 0x9C, 0xF6, 0x71, 0xCC, 0xE3, 0x99, 0xC7, 0x33, 0xCE, 0x63, 0xF8,
  0xE7, 0xF1, 0xC7, 0xC3, 0x80, 0x07, 0x80, 0x07, 0xFC, 0x07, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x7F, 0x01, 0xDC, 0x0F,
  0x70, 0x39, 0xC1, 0xE7, 0x07, 0x1C, 0x3C, 0x70, 0xE1, 0xC7, 0x87, 0x1F,
  0xFC, 0xFF, 0xF3, 0xFF, 0xDE, 0x07, 0x78, 0x1F, 0xC0, 0x7F, 0x03, 0xC0,
  0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x70, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7,
  0x87, 0x8E, 0x3E, 0x3F, 0xF8, 0x7F, 0xE0, 0xFF, 0xE1, 0xC1, 0xE7, 0x83,
  0xCF, 0x07, 0x9E, 0x0F, 0x38, 0x3C, 0x7F, 0xF9, 0xFF, 0xE3, 0xFF, 0x00,
  0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0x86, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x08, 0xFF, 0xE1, 0xFF, 0x83, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF0, 0xF3, 0xE1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x8E,
  0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x71, 0xC1, 0xE7, 0x83, 0xCF, 0x0F,
  0x9E, 0x1E, 0x38, 0xF8, 0xFF, 0xF1, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFF,
  0x07, 0xFF, 0x0F, 0xFF, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x3F, 0xF8, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF0,
  0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xF0, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x01, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0xF8, 0x63, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x73, 0xC1, 0xE7, 0x83,
  0xCF, 0x07, 0x9E, 0x0E, 0x3C, 0x3C, 0x3C, 0x78, 0x7F, 0xF0, 0xFF, 0xC0,
  0x7F, 0x80, 0x0F, 0x07, 0x87, 0x83, 0x83, 0x83, 0xC3, 0xC1, 0xE1, 0xE0,
  0xF0, 0xF0, 0x70, 0x70, 0x78, 0x78, 0x3C, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F,
  0xFF, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xC1, 0xC1, 0xE1, 0xE0, 0xF0,
  0xF0, 0x78, 0x78, 0x38, 0x3C, 0x3C, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F,
  0xFF, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x88, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0x03,
  0xFE, 0x07, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x61, 0xF0, 0x7F, 0xE0, 0xFF, 0xE0, 0x3F, 0x80, 0x0F,
  0x07, 0x87, 0x87, 0x83, 0xC7, 0x83, 0xC7, 0xC1, 0xE3, 0xC0, 0xF3, 0xC0,
  0x7B, 0xC0, 0x3B, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0x7C,
  0x07, 0x9E, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xE1, 0xE0, 0xF0, 0x78, 0x78,
  0x3C, 0x3C, 0x1E, 0x00, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xFB, 0xFF, 0xBF, 0xFC, 0x07,
  0x83, 0x83, 0xC3, 0xC1, 0xE1, 0xE1, 0xF1, 0xF0, 0xF8, 0xF8, 0x7C, 0xFC,
  0x36, 0x6C, 0x3B, 0x6E, 0x1D, 0xB7, 0x0E, 0xF3, 0x8E, 0x79, 0xC7, 0x39,
  0xC3, 0x80, 0xE1, 0xC0, 0x71, 0xE0, 0x78, 0xE0, 0x3C, 0x70, 0x1C, 0x78,
  0x0E, 0x3C, 0x0F, 0x00, 0x0E, 0x07, 0x87, 0x83, 0x83, 0xC1, 0xC3, 0xE1,
  0xE1, 0xF8, 0xF0, 0xFC, 0x70, 0x7E, 0x38, 0x7B, 0x1C, 0x39, 0xDE, 0x1C,
  0xEE, 0x0E, 0x77, 0x0F, 0x1B, 0x87, 0x8F, 0xC3, 0x87, 0xC1, 0xC3, 0xE1,
  0xE1, 0xF0, 0xF0, 0x78, 0x70, 0x38, 0x38, 0x1C, 0x00, 0x03, 0xF0, 0x3F,
  0xE1, 0xFF, 0xC7, 0x8F, 0x3C, 0x3C, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x70,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0x3C,
  0x7C, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFE, 0x0E, 0x3E, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x1E, 0x1C,
  0x1E, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0x80, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x3F,
  0xE1, 0xFF, 0xC7, 0x8F, 0x3C, 0x3C, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x70,
  0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F, 0x3C,
  0x7C, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x70, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0x71, 0xF1, 0xE1,
  0xE3, 0xC3, 0xC7, 0x87, 0x8E, 0x0F, 0x3C, 0x7C, 0x7F, 0xF0, 0xFF, 0xC1,
  0xFE, 0x07, 0x9E, 0x0F, 0x1C, 0x1E, 0x3C, 0x38, 0x38, 0xF0, 0x71, 0xE0,
  0xF3, 0xC1, 0xE0, 0x03, 0xFC, 0x0F, 0xFC, 0x3F, 0xF8, 0xF8, 0x21, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x30, 0x3C, 0x7F, 0xF1, 0xFF,
  0xE1, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x1E, 0x0E, 0x38, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xC7, 0x87,
  0x8E, 0x0F, 0x3C, 0x1E, 0x78, 0x38, 0xF0, 0xF1, 0xC1, 0xE7, 0x83, 0xCF,
  0x07, 0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0xF0, 0xFF, 0xE0, 0xFF, 0x80, 0xFE,
  0x00, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF7, 0x83, 0xCF, 0x07, 0x9E, 0x1E,
  0x3C, 0x3C, 0x78, 0x70, 0xF1, 0xE1, 0xE3, 0x83, 0xCF, 0x07, 0x9C, 0x0F,
  0x78, 0x1E, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0,
  0x00, 0x1E, 0x03, 0x8F, 0x01, 0xC7, 0x01, 0xE3, 0x80, 0xE1, 0xC0, 0x71,
  0xE0, 0x38, 0xE0, 0x3C, 0x73, 0x9C, 0x39, 0xCE, 0x1D, 0xE7, 0x1C, 0xF3,
  0x0E, 0xDB, 0x87, 0xED, 0xC3, 0xE6, 0xE1, 0xF3, 0xE0, 0xF1, 0xF0, 0xF8,
  0xF8, 0x78, 0x78, 0x3C, 0x1C, 0x00, 0x0F, 0x03, 0xC1, 0xE0, 0xE0, 0x78,
  0x78, 0x0E, 0x3C, 0x03, 0xDE, 0x00, 0xF7, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x03,
  0xDE, 0x01, 0xE3, 0x80, 0x78, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x83,
  0xC0, 0xF0, 0x3F, 0xE0, 0x7B, 0xC1, 0xE3, 0x83, 0xC7, 0x0F, 0x0F, 0x3C,
  0x1E, 0x78, 0x1D, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xF8, 0xFF,
  0xF0, 0xFF, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3F, 0xE0, 0xFF, 0x03, 0xFC,
  0x00, 0xF3, 0xCF, 0x3C, 0x71, 0xC7, 0x1C, 0x71, 0xE7, 0x9E, 0x79, 0xE7,
  0x8E, 0x38, 0xE3, 0x8E, 0x3C, 0xF3, 0xCF, 0x3C, 0xF0, 0x03, 0xFE, 0x07,
  0xFC, 0x0F, 0xF0, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x3F, 0xC0, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0xE0,
  0x07, 0x80, 0x3F, 0x01, 0xFC, 0x0F, 0x70, 0x7D, 0xE1, 0xE7, 0x8F, 0x0E,
  0x78, 0x3F, 0xC0, 0xF3, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x20, 0xE3, 0xE3, 0xF1, 0xC0, 0x80, 0x00, 0xC0, 0x1F, 0xF1, 0xFF, 0xCF,
  0xFE, 0x7C, 0x79, 0xE1, 0xEF, 0x07, 0xBC, 0x1C, 0xF0, 0xF3, 0x83, 0xCF,
  0x0F, 0x3C, 0x7C, 0xFF, 0xF1, 0xFF, 0xC3, 0xE7, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0xFE, 0x1F,
  0xF8, 0x7F, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0x83, 0xDE,
  0x0F, 0x78, 0x79, 0xE3, 0xE7, 0xFF, 0x3F, 0xF8, 0xFF, 0x80, 0x00, 0x40,
  0x1F, 0xF1, 0xFF, 0x8F, 0xFE, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x04, 0x7F, 0xE0, 0xFF, 0xC1, 0xFE,
  0x00, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x07, 0xFC, 0x1F, 0xFC, 0x3F, 0xF8, 0x7C, 0x78, 0x78,
  0x78, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0xF0, 0xE0, 0xF0, 0xF0, 0xF0, 0xF1,
  0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3E, 0x70, 0x00, 0x80, 0x1F, 0xC1, 0xFF,
  0x8F, 0xDF, 0x78, 0x3D, 0xE0, 0xF7, 0x07, 0xBF, 0xFC, 0xFF, 0xE3, 0xFE,
  0x0F, 0x00, 0x3C, 0x00, 0x7F, 0xE1, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3E, 0x20, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x13, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x30, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0x0E, 0x1E, 0x1E,
  0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x78, 0x00, 0x70, 0x61, 0xF0, 0xFF, 0xE0,
  0xFF, 0xC0, 0x7F, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE4, 0x07, 0xFE, 0x1F, 0xF8, 0x7F, 0xF1, 0xC3, 0xCF,
  0x0F, 0x3C, 0x3C, 0xF0, 0xE3, 0xC7, 0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7,
  0x87, 0x1C, 0x3C, 0xF0, 0xF0, 0x03, 0x80, 0xF8, 0x1E, 0x03, 0xC0, 0x20,
  0x00, 0x00, 0x03, 0xFC, 0x7F, 0x1F, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1C, 0x03, 0xC0, 0x7F, 0x8F, 0xF0, 0xFE, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x10, 0xF0, 0x7F, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x1F, 0x1E, 0x3C, 0x1E, 0x7C, 0x1E, 0xF0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x3D, 0xE0, 0x39, 0xE0, 0x78, 0xF0, 0x78,
  0xF0, 0x78, 0x78, 0xF0, 0x78, 0x7F, 0x9F, 0xCF, 0xF0, 0x3C, 0x0F, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x03, 0x81,
  0xE0, 0x78, 0x1E, 0x17, 0xF8, 0xFF, 0x3F, 0x80, 0x1F, 0xFC, 0x7F, 0xFC,
  0xE7, 0x79, 0xCE, 0x73, 0x9C, 0xE7, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x0E, 0x00, 0x00,
  0xC0, 0x7F, 0xE1, 0xFF, 0x87, 0xFF, 0x1C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF,
  0x0E, 0x3C, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x71, 0xC3, 0xCF,
  0x0F, 0x00, 0x01, 0x80, 0x7F, 0x07, 0xFC, 0x7F, 0xF7, 0x87, 0xBC, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x3D, 0xE3, 0xEF, 0xFE, 0x3F,
  0xE0, 0xFE, 0x00, 0x00, 0x60, 0x1F, 0xF0, 0x3F, 0xF0, 0x7F, 0xF0, 0xE1,
  0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F, 0x1C, 0x1E, 0x78, 0x3C, 0xF0, 0xF1,
  0xE3, 0xE3, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x80, 0x1F, 0xF1, 0xFF, 0xCF, 0xFF,
  0x7C, 0x39, 0xE1, 0xE7, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x0F,
  0x3C, 0x3C, 0xFF, 0xE1, 0xFF, 0x83, 0xFE, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x0F, 0xFC, 0x7F, 0xE1, 0xFF, 0x8F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x40, 0x1F, 0xF0, 0xFF, 0xC7, 0xFE,
  0x1E, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x07,
  0x88, 0x3C, 0x7F, 0xF3, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xC3, 0xC0, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xF0, 0x87, 0xFC, 0x3F, 0xE0,
  0xFF, 0x00, 0x3C, 0x3C, 0xF0, 0xE3, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xE1,
  0xC7, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x1E, 0x3F, 0xFC, 0x7F,
  0xF1, 0xFB, 0xC0, 0xF0, 0x7F, 0xC1, 0xEF, 0x07, 0xBC, 0x3C, 0xF0, 0xF1,
  0xC7, 0x87, 0x1E, 0x1C, 0xF0, 0x7B, 0x81, 0xFE, 0x07, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x00, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x77, 0x1C, 0xEE,
  0x79, 0xDC, 0xF3, 0x3B, 0xEE, 0x76, 0xDC, 0xFD, 0xB1, 0xF3, 0xE3, 0xE7,
  0xC7, 0x8F, 0x0F, 0x1E, 0x1C, 0x38, 0x00, 0x1E, 0x0F, 0x87, 0x8F, 0x01,
  0xC7, 0x80, 0xF7, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xF0, 0x07, 0xF8, 0x07, 0x9E, 0x07, 0x8F, 0x07, 0xC3, 0xC7, 0xC1,
  0xE0, 0x0F, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xC0, 0xE1, 0xE0, 0x70, 0xF0,
  0x38, 0xF0, 0x1E, 0x78, 0x0F, 0x78, 0x07, 0xBC, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x01, 0x1F, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x3F, 0xC0, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0x03, 0xC0, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x1F, 0xC0, 0xFE, 0x03,
  0xF0, 0x00, 0x0E, 0x08, 0x7F, 0x1C, 0xFF, 0xF3, 0xFF, 0xEF, 0x1F, 0x84,
  0x0C, 0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 8, 19, 15, 4, -19 },
  { 20, 11, 9, 15, 5, -21 },
  { 33, 16, 19, 15, 0, -19 },
  { 71, 15, 24, 15, 0, -21 },
  { 116, 18, 19, 15, -1, -19 },
  { 159, 15, 19, 15, 0, -19 },
  { 195, 6, 10, 15, 7, -21 },
  { 203, 12, 26, 15, 3, -21 },
  { 242, 12, 26, 15, 0, -21 },
  { 281, 12, 12, 15, 3, -19 },
  { 299, 13, 14, 15, 1, -15 },
  { 322, 7, 10, 15, 2, -5 },
  { 331, 9, 4, 15, 3, -10 },
  { 336, 5, 5, 15, 4, -5 },
  { 340, 17, 26, 15, -1, -21 },
  { 396, 14, 19, 15, 1, -19 },
  { 430, 12, 19, 15, 1, -19 },
  { 459, 15, 19, 15, 0, -19 },
  { 495, 15, 19, 15, 0, -19 },
  { 531, 15, 19, 15, 0, -19 },
  { 567, 16, 19, 15, 0, -19 },
  { 605, 15, 19, 15, 1, -19 },
  { 641, 15, 19, 15, 2, -19 },
  { 677, 14, 19, 15, 1, -19 },
  { 711, 14, 19, 15, 1, -19 },
  { 745, 7, 14, 15, 4, -14 },
  { 758, 9, 19, 15, 2, -14 },
  { 780, 14, 13, 15, 1, -14 },
  { 803, 15, 9, 15, 0, -12 },
  { 820, 14, 13, 15, 0, -14 },
  { 843, 11, 19, 15, 4, -19 },
  { 870, 15, 23, 15, 1, -19 },
  { 914, 14, 19, 15, -1, -19 },
  { 948, 15, 19, 15, 0, -19 },
  { 984, 14, 19, 15, 2, -19 },
  { 1018, 15, 19, 15, 0, -19 },
  { 1054, 16, 19, 15, 0, -19 },
  { 1092, 16, 19, 15, 1, -19 },
  { 1130, 15, 19, 15, 1, -19 },
  { 1166, 17, 19, 15, 0, -19 },
  { 1207, 16, 19, 15, 0, -19 },
  { 1245, 16, 19, 15, 0, -19 },
  { 1283, 17, 19, 15, 0, -19 },
  { 1324, 13, 19, 15, 0, -19 },
  { 1355, 17, 19, 15, -1, -19 },
  { 1396, 17, 19, 15, 0, -19 },
  { 1437, 14, 19, 15, 1, -19 },
  { 1471, 16, 19, 15, 0, -19 },
  { 1509, 14, 24, 15, 1, -19 },
  { 1551, 15, 19, 15, 0, -19 },
  { 1587, 15, 19, 15, 0, -19 },
  { 1623, 14, 19, 15, 3, -19 },
  { 1657, 15, 19, 15, 1, -19 },
  { 1693, 15, 19, 15, 3, -19 },
  { 1729, 17, 19, 15, 0, -19 },
  { 1770, 18, 19, 15, -1, -19 },
  { 1813, 15, 19, 15, 3, -19 },
  { 1849, 16, 19, 15, 0, -19 },
  { 1887, 14, 26, 15, 2, -21 },
  { 1933, 6, 26, 15, 5, -21 },
  { 1953, 15, 26, 15, -1, -21 },
  { 2002, 14, 11, 15, 1, -19 },
  { 2022, 14, 3, 15, -2, 2 },
  { 2028, 7, 6, 15, 6, -21 },
  { 2034, 14, 15, 15, 1, -15 },
  { 2061, 14, 21, 15, 0, -21 },
  { 2098, 14, 15, 15, 1, -15 },
  { 2125, 16, 21, 15, 1, -21 },
  { 2167, 14, 15, 15, 1, -15 },
  { 2194, 19, 26, 15, -2, -21 },
  { 2256, 16, 20, 15, -1, -15 },
  { 2296, 14, 21, 15, 0, -21 },
  { 2333, 11, 21, 15, 2, -21 },
  { 2362, 15, 26, 15, -1, -21 },
  { 2411, 16, 21, 15, 0, -21 },
  { 2453, 10, 21, 15, 3, -21 },
  { 2480, 15, 14, 15, 0, -14 },
  { 2507, 14, 15, 15, 0, -15 },
  { 2534, 13, 15, 15, 1, -15 },
  { 2559, 15, 20, 15, -1, -15 },
  { 2597, 14, 20, 15, 1, -15 },
  { 2632, 14, 14, 15, 1, -14 },
  { 2657, 14, 15, 15, 0, -15 },
  { 2684, 13, 18, 15, 2, -18 },
  { 2714, 14, 14, 15, 1, -14 },
  { 2739, 14, 14, 15, 2, -14 },
  { 2764, 15, 14, 15, 1, -14 },
  { 2791, 17, 14, 15, -1, -14 },
  { 2821, 17, 19, 15, -2, -14 },
  { 2862, 15, 14, 15, 0, -14 },
  { 2889, 14, 26, 15, 2, -21 },
  { 2935, 10, 26, 15, 3, -21 },
  { 2968, 14, 26, 15, -1, -21 },
  { 3014, 15, 6, 15, 0, -11 },
};

const GFXfont UbuntuSansMono_BoldItalic27pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic27pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic27pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _UBUNTUSANSMONO_BOLDITALIC27PT7B_H_
