#ifndef _UBUNTUSANSMONO_BOLDITALIC36PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic36pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x07, 0xE1, 0xFC, 0x3F, 0x87, 0xE0, 0x7C, 0x00,
  0x7E, 0x7E, 0xF8, 0xF9, 0xF1, 0xF3, 0xE3, 0xE7, 0xC7, 0xCF, 0x0F, 0x1E,
  0x3E, 0x7C, 0x78, 0xF0, 0xF1, 0xE1, 0xE3, 0x83, 0x80, 0x00, 0x3C, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x1E, 0x00, 0x78,
  0xF0, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0,
  0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x78,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x1E, 0x00,
  0xF1, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xC0, 0x40, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x20, 0x0F,
  0x83, 0xC3, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x00,
  0x40, 0x00, 0x03, 0xF0, 0x0F, 0x07, 0xF0, 0x1E, 0x07, 0xF8, 0x3C, 0x0E,
  0x38, 0x38, 0x0E, 0x38, 0x70, 0x1E, 0x78, 0xF0, 0x1C, 0x71, 0xE0, 0x1C,
  0x73, 0xC0, 0x1E, 0xF7, 0x80, 0x1F, 0xE7, 0x00, 0x0F, 0xCE, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xF0, 0x00,
  0xE7, 0xF0, 0x01, 0xCF, 0x78, 0x03, 0xCE, 0x38, 0x07, 0x9E, 0x70, 0x0F,
  0x1C, 0x70, 0x1E, 0x1C, 0x70, 0x1C, 0x1C, 0xF0, 0x38, 0x1F, 0xE0, 0x78,
  0x1F, 0xE0, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x08, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xE7, 0xC0, 0x7C, 0x3C, 0x07,
  0x83, 0xC0, 0x78, 0x78, 0x07, 0x87, 0x80, 0x78, 0xF0, 0x07, 0xBE, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x0F, 0x1F, 0xF1, 0xE3, 0xEF, 0x9E,
  0x3C, 0x7B, 0xE7, 0x87, 0xFC, 0x78, 0x3F, 0x8F, 0x81, 0xF8, 0xF8, 0x1F,
  0x0F, 0x83, 0xF0, 0xFC, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xF7, 0xC1, 0xFC,
  0x7C, 0x7E, 0xF9, 0xF3, 0xEF, 0x9F, 0x3E, 0x78, 0xF1, 0xE3, 0x87, 0x00,
  0x00, 0x02, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0xFE, 0x01, 0xFC,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x06, 0x00, 0x04, 0x00,
  0x00, 0x20, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x20, 0x00,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x04, 0x3C, 0x27, 0x9E, 0x73, 0xEE,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x01, 0xF8, 0x03, 0xFE, 0x03,
  0xEF, 0x83, 0xF3, 0xE0, 0xF1, 0xF0, 0x38, 0x60, 0x08, 0x20, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x03, 0x03, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC,
  0x0E, 0x07, 0x87, 0xCF, 0xE1, 0xF0, 0x70, 0x00, 0x7F, 0xF7, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xE0, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F,
  0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0xC0,
  0xF8, 0xF8, 0x1F, 0x3E, 0x01, 0xE7, 0xC0, 0x7C, 0xF0, 0x8F, 0xBE, 0x79,
  0xF7, 0xCF, 0x3E, 0xF1, 0xE7, 0xDE, 0x3C, 0xF3, 0xC6, 0x3E, 0xF8, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF0, 0xF8, 0x7E,
  0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFE, 0x07, 0xFE, 0x1F,
  0xFE, 0x1F, 0xFE, 0x0F, 0x7C, 0x0C, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0C, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x78, 0x3F, 0x02, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF,
  0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x00, 0x08, 0x00, 0x1F,
  0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x30, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x86, 0x01, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF,
  0x80, 0x03, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7B, 0xE0, 0x0F, 0x3E,
  0x01, 0xE3, 0xC0, 0x3C, 0x7C, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x1F, 0x07,
  0x83, 0xE0, 0x78, 0x3C, 0x0F, 0x87, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x06,
  0x01, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x81,
  0xFF, 0xE0, 0x7F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x9E, 0x01, 0xEF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xF8,
  0x3E, 0x3E, 0x03, 0xE7, 0x80, 0x7C, 0xF0, 0x0F, 0x9E, 0x01, 0xF3, 0xC0,
  0x3E, 0x7C, 0x0F, 0x8F, 0x83, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF,
  0xE0, 0x1F, 0xF0, 0x00, 0x20, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xE0, 0x0F,
  0xFF, 0x03, 0xFF, 0xF0, 0xFE, 0xFE, 0x1F, 0x07, 0xC3, 0xC0, 0x78, 0x78,
  0x0F, 0x1F, 0x03, 0xE1, 0xE0, 0x78, 0x3E, 0x1F, 0x03, 0xFF, 0xC0, 0x7F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFF, 0x81, 0xF1, 0xF8, 0x7C, 0x1F, 0x8F, 0x01,
  0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3F, 0x3F, 0x9F,
  0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x3E,
  0x0F, 0x8F, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0x80, 0x7C, 0xF8,
  0x0F, 0x9F, 0x01, 0xF3, 0xF0, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0x7F,
  0xFE, 0x01, 0x87, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x07, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xC0,
  0x00, 0x03, 0x03, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x18, 0x1F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x87,
  0xC0, 0x00, 0x60, 0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x07, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x07, 0x00, 0x78, 0x0F,
  0x83, 0xF8, 0x0F, 0x80, 0x70, 0x00, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x01,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0x87, 0xFF, 0x03, 0xFE, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0C, 0x00, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF8, 0x08, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0x1F, 0xE0, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0,
  0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x3F, 0xF1, 0xFF, 0xF3,
  0xFF, 0xE3, 0xFF, 0xE4, 0x0F, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x04, 0x00, 0x07, 0xFC,
  0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xC1, 0xF0, 0xF8, 0x0F, 0x1F, 0x00,
  0xF1, 0xE0, 0x0F, 0x3C, 0x1F, 0xF3, 0xC3, 0xFF, 0x78, 0x7F, 0xF7, 0x8F,
  0xFE, 0x71, 0xF1, 0xEF, 0x1E, 0x1E, 0xF3, 0xE3, 0xEF, 0x3C, 0x3C, 0xF3,
  0xC3, 0xCF, 0x3C, 0x3C, 0xE3, 0xC7, 0xCE, 0x3C, 0x78, 0xE3, 0xE7, 0x8F,
  0x3F, 0xF8, 0xF1, 0xFF, 0x8F, 0x0F, 0xF0, 0xF0, 0x18, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x20, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x03, 0xDE, 0x00, 0x7D, 0xE0, 0x07, 0x9E, 0x00, 0xF9, 0xE0,
  0x0F, 0x1E, 0x01, 0xF1, 0xE0, 0x1E, 0x1E, 0x03, 0xE1, 0xE0, 0x3C, 0x1E,
  0x07, 0xC1, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0,
  0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0xFF, 0xE0,
  0x7F, 0xFF, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xE0, 0xF8, 0x7E, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xFF,
  0x81, 0xFF, 0xFC, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0,
  0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x7C, 0x7C, 0x1F, 0xC7, 0xFF, 0xF8, 0x7F,
  0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xF8,
  0x07, 0xFF, 0x81, 0xFF, 0xF0, 0x7F, 0xFC, 0x1F, 0x81, 0x87, 0xE0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x0C, 0x1F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x02, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xC7,
  0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF1, 0xF0,
  0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x3E, 0x3E,
  0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x0F, 0xC7,
  0xC1, 0xF8, 0x7C, 0x7F, 0x07, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3F, 0x81, 0x87, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x3E, 0x03, 0xE7,
  0xC0, 0x7C, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F,
  0x83, 0xE1, 0xF8, 0x7C, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x06, 0x00, 0x00, 0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C,
  0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0x83, 0xE0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC1, 0xFF, 0xFF, 0x07,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xE0, 0x3E, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF,
  0xFE, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x40, 0x3E, 0x03, 0x03, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xE0, 0x7E, 0x0F,
  0x81, 0xF8, 0x1F, 0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0,
  0xFC, 0x03, 0xE3, 0xF0, 0x07, 0xCF, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xDF, 0x00,
  0x0F, 0xBF, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0x7C, 0x01,
  0xF0, 0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xC1, 0xF8, 0x0F, 0x81, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xFE, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x1F,
  0x87, 0xE0, 0x7F, 0x0F, 0xC0, 0xFE, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xB9,
  0xDE, 0x0F, 0x73, 0xB8, 0x1E, 0xEE, 0xF0, 0x3D, 0xDD, 0xE0, 0xF3, 0xF3,
  0xC1, 0xE7, 0xE7, 0x83, 0xCF, 0x9E, 0x07, 0x9F, 0x3C, 0x1E, 0x3C, 0x78,
  0x3C, 0x00, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF0,
  0x07, 0xC0, 0x07, 0xC0, 0x3C, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0x81, 0xF8,
  0x1E, 0x0F, 0xE0, 0x78, 0x3F, 0x83, 0xE0, 0xFF, 0x0F, 0x83, 0xFC, 0x3C,
  0x1F, 0x70, 0xF0, 0x7D, 0xC7, 0xC1, 0xE7, 0x9F, 0x07, 0x9E, 0x78, 0x1E,
  0x39, 0xE0, 0xF8, 0xEF, 0x83, 0xC3, 0xFE, 0x0F, 0x0F, 0xF0, 0x3C, 0x3F,
  0xC1, 0xF0, 0x7F, 0x07, 0x81, 0xFC, 0x1E, 0x07, 0xE0, 0x78, 0x1F, 0x83,
  0xE0, 0x7E, 0x0F, 0x80, 0xF8, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0x00,
  0x08, 0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F,
  0x8F, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7D, 0xF0,
  0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xC0,
  0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x81,
  0xF0, 0xF8, 0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE,
  0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x7C, 0x3F, 0x83, 0xE0, 0xFC, 0x3E, 0x03, 0xE1, 0xF0,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x0F, 0xE1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xC0, 0x3F, 0xC0,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x1F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x8F,
  0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7D, 0xF0, 0x0F,
  0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xF7, 0xC0, 0x3E,
  0xF8, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x81, 0xF0,
  0xF8, 0x7E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFE, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00,
  0x07, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF,
  0xE0, 0x7F, 0xFE, 0x07, 0xC3, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x81, 0xF0, 0xF0, 0x3E, 0x1F, 0x07, 0xE1, 0xF1, 0xFC, 0x1F,
  0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3E, 0x3E, 0x03,
  0xE3, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF8,
  0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x07, 0xC0, 0x00, 0x0C, 0x00, 0x0F,
  0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFC, 0x06, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x87, 0x01, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF,
  0x80, 0x01, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F,
  0xFF, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0x83, 0xE0, 0x7C,
  0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x83, 0xE0,
  0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x87,
  0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x0F,
  0x87, 0xC0, 0x7C, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0xC3, 0xF0, 0x7F,
  0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1C, 0x00,
  0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x7C, 0x03, 0xEF, 0x80,
  0xF9, 0xF0, 0x1F, 0x3E, 0x07, 0xC7, 0xC0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x3E, 0x3E,
  0x07, 0xCF, 0x80, 0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x3F, 0xE0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x78, 0x01,
  0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x1E, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x3C, 0x71, 0xE0, 0x79, 0xE3, 0xC1, 0xE7, 0xC7, 0x83,
  0xCF, 0xCF, 0x07, 0xBF, 0xBC, 0x0F, 0x77, 0x78, 0x1D, 0xEE, 0xF0, 0x7B,
  0x9D, 0xC0, 0xFF, 0x3F, 0x81, 0xFC, 0x7F, 0x03, 0xF8, 0xFE, 0x07, 0xE1,
  0xF8, 0x0F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F,
  0x00, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x01, 0xF0,
  0xFC, 0x01, 0xF0, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xEF, 0x80, 0x07, 0xEF, 0x80, 0x0F, 0xCF, 0x80, 0x0F, 0x87,
  0xC0, 0x1F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xFC, 0x03, 0xE0, 0xF8, 0x03, 0xFF, 0x00, 0xFD, 0xE0, 0x1F, 0x3C,
  0x07, 0xC7, 0xC1, 0xF8, 0xF8, 0x3E, 0x1F, 0x0F, 0x81, 0xE1, 0xF0, 0x3C,
  0x7C, 0x07, 0xDF, 0x00, 0xFB, 0xE0, 0x1F, 0xF8, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x81, 0xFF, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8,
  0xF8, 0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x3C, 0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E,
  0x1E, 0x1F, 0x1F, 0x1F, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x07, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFD, 0xF0,
  0x7E, 0x7C, 0x1F, 0x0F, 0x8F, 0x83, 0xE7, 0xE0, 0xFB, 0xF0, 0x1F, 0xF8,
  0x07, 0xCC, 0x01, 0xC0, 0x00, 0x40, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC, 0x20, 0x18, 0x1F, 0x1F, 0xC7, 0xF0,
  0xFC, 0x1C, 0x02, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE3, 0xF8, 0x7C, 0x7C, 0x0F, 0x9F, 0x03, 0xE3, 0xE0, 0x7C, 0xF8, 0x0F,
  0x9F, 0x01, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E,
  0x3F, 0x0F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0x3E,
  0x00, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF7,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x3F, 0x0F, 0x87, 0xC0,
  0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x03,
  0xE3, 0xE0, 0x7C, 0x78, 0x1F, 0x9F, 0x03, 0xE3, 0xE1, 0xFC, 0x7F, 0xFF,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x10, 0x00, 0x01, 0xFF,
  0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x80, 0x9F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x43, 0xFF, 0xF8, 0x7F, 0xFE,
  0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x1F, 0xFF,
  0x81, 0xFF, 0xFC, 0x1F, 0xC3, 0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0x7C,
  0x0F, 0x87, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x87, 0xE0, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0x9F, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xC1,
  0xFF, 0xF8, 0xFF, 0xFE, 0x3E, 0x07, 0xDF, 0x01, 0xF7, 0x80, 0xFB, 0xE0,
  0x7E, 0xF8, 0x7F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0x80, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x23, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0x81,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x30, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xE0, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x7E, 0x07, 0xC3, 0xE0,
  0x7C, 0x1F, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3C, 0x0F, 0x81,
  0xF0, 0x7C, 0x0F, 0xCF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0x80, 0x0E, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x04, 0x03, 0xF0, 0x3E,
  0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0x0F, 0xC7, 0xE1,
  0xF8, 0xF8, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x1F, 0x03,
  0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F,
  0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x87, 0xFE, 0x3F, 0xF8, 0xFF, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xE1, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x7F, 0xF8, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x10, 0x3F, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0xF8, 0x03,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x1F,
  0x0F, 0x81, 0xF1, 0xF0, 0x1F, 0x7E, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x03,
  0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x7C, 0xF8, 0x07, 0xC7, 0xC0,
  0x7C, 0x7C, 0x07, 0xC7, 0xE0, 0xFC, 0x3E, 0x0F, 0x83, 0xF0, 0xF8, 0x1F,
  0x0F, 0x81, 0xF8, 0x7F, 0xF3, 0xFF, 0x1F, 0xF8, 0xFF, 0xC8, 0x3E, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0xC1, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x3F,
  0xE0, 0x03, 0xF3, 0xE0, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFD, 0xF0,
  0xF3, 0xC7, 0x87, 0x9E, 0x3C, 0x78, 0xF3, 0xC3, 0xC7, 0x9E, 0x1E, 0x78,
  0xF0, 0xF3, 0xC7, 0x8F, 0x1E, 0x7C, 0x78, 0xF3, 0xC3, 0xC0, 0x1E, 0x1E,
  0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E,
  0x3E, 0x01, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xF8, 0x7E, 0x3F, 0x0F, 0xC7, 0xC1, 0xF0, 0xF8, 0x3E, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0x7C,
  0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x0F,
  0xCF, 0x81, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x07, 0xCF, 0xC3, 0xF1, 0xFF,
  0xF8, 0x7F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x08, 0x00, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x3C, 0x1F, 0x83,
  0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x7C, 0x07,
  0xC3, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x3F, 0x0F, 0x83, 0xF0, 0x7C,
  0x3F, 0x83, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE1, 0xF8, 0x7C, 0x7E, 0x0F, 0x8F, 0x81, 0xF3,
  0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0x8F,
  0x81, 0xF1, 0xF8, 0x3E, 0x1F, 0x0F, 0xC3, 0xFF, 0xF8, 0x7F, 0xFE, 0x07,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFE, 0x18, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x08, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x0C, 0x07, 0xE1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x20, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0x83, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x41, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8,
  0x00, 0x3E, 0x07, 0xCF, 0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x7C, 0x0F,
  0x9F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0x8F,
  0x83, 0xE3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x87, 0xE3, 0xFF,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xF9, 0xE0, 0xF8, 0x0F, 0xFE, 0x03,
  0xEF, 0x80, 0xFB, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x0F, 0xCF, 0x83, 0xE3,
  0xE1, 0xF0, 0x78, 0x7C, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xF7, 0xC0, 0x7D,
  0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0xFB, 0xE0, 0x07, 0x9E, 0x00, 0x3C, 0xF0,
  0x01, 0xE7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x3E, 0x78,
  0x71, 0xF3, 0xC7, 0x9F, 0x9E, 0x3C, 0xFC, 0xE1, 0xEE, 0xEF, 0x0F, 0xF7,
  0x78, 0x7F, 0x3B, 0x83, 0xF8, 0xFC, 0x1F, 0x87, 0xC0, 0xF8, 0x3E, 0x07,
  0xC1, 0xE0, 0x3C, 0x0F, 0x00, 0x0F, 0x80, 0xFC, 0x1F, 0x07, 0xE0, 0x7C,
  0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xF9, 0xF8, 0x07, 0xC3,
  0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x1F, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xE0,
  0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0x7C, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF1,
  0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF3, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF7,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x6F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0,
  0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF,
  0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFE, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x08, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0xE1, 0xFF, 0x1F, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x7D, 0xFF, 0xCF, 0x87, 0xF8, 0x30, 0x1F, 0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 11, 25, 20, 5, -25 },
  { 36, 15, 11, 20, 6, -27 },
  { 57, 21, 25, 20, 0, -25 },
  { 123, 20, 32, 20, 0, -28 },
  { 203, 24, 27, 20, -1, -26 },
  { 284, 20, 26, 20, 0, -26 },
  { 349, 7, 12, 20, 10, -27 },
  { 360, 16, 36, 20, 4, -29 },
  { 432, 16, 36, 20, 0, -29 },
  { 504, 17, 16, 20, 3, -25 },
  { 538, 18, 18, 20, 1, -20 },
  { 579, 10, 13, 20, 2, -7 },
  { 596, 12, 5, 20, 4, -13 },
  { 604, 7, 7, 20, 5, -7 },
  { 611, 24, 35, 20, -2, -28 },
  { 716, 19, 27, 20, 1, -26 },
  { 781, 16, 25, 20, 1, -25 },
  { 831, 20, 26, 20, 0, -26 },
  { 896, 20, 27, 20, 0, -26 },
  { 964, 20, 25, 20, 0, -25 },
  { 1027, 21, 26, 20, 0, -25 },
  { 1096, 19, 26, 20, 2, -25 },
  { 1158, 19, 25, 20, 3, -25 },
  { 1218, 19, 27, 20, 1, -26 },
  { 1283, 19, 26, 20, 1, -26 },
  { 1345, 10, 19, 20, 5, -19 },
  { 1369, 13, 25, 20, 2, -19 },
  { 1410, 18, 17, 20, 2, -19 },
  { 1449, 20, 12, 20, 0, -17 },
  { 1479, 18, 17, 20, 1, -19 },
  { 1518, 15, 26, 20, 5, -26 },
  { 1567, 20, 31, 20, 1, -26 },
  { 1645, 20, 25, 20, -2, -25 },
  { 1708, 20, 25, 20, 0, -25 },
  { 1771, 19, 27, 20, 2, -26 },
  { 1836, 20, 25, 20, 0, -25 },
  { 1899, 20, 25, 20, 1, -25 },
  { 1962, 21, 25, 20, 1, -25 },
  { 2028, 19, 27, 20, 2, -26 },
  { 2093, 22, 25, 20, 0, -25 },
  { 2162, 22, 25, 20, 0, -25 },
  { 2231, 21, 26, 20, 0, -25 },
  { 2300, 23, 25, 20, 0, -25 },
  { 2372, 17, 25, 20, 0, -25 },
  { 2426, 23, 25, 20, -1, -25 },
  { 2498, 22, 25, 20, 0, -25 },
  { 2567, 19, 27, 20, 1, -26 },
  { 2632, 21, 25, 20, 0, -25 },
  { 2698, 19, 33, 20, 1, -26 },
  { 2777, 20, 25, 20, 0, -25 },
  { 2840, 20, 27, 20, 0, -26 },
  { 2908, 19, 25, 20, 4, -25 },
  { 2968, 21, 26, 20, 1, -25 },
  { 3037, 19, 25, 20, 4, -25 },
  { 3097, 23, 25, 20, 0, -25 },
  { 3169, 24, 25, 20, -1, -25 },
  { 3244, 19, 25, 20, 4, -25 },
  { 3304, 22, 25, 20, 0, -25 },
  { 3373, 20, 35, 20, 2, -28 },
  { 3461, 8, 35, 20, 7, -28 },
  { 3496, 20, 35, 20, -1, -28 },
  { 3584, 18, 15, 20, 2, -25 },
  { 3618, 19, 5, 20, -3, 2 },
  { 3630, 9, 8, 20, 8, -28 },
  { 3639, 19, 19, 20, 1, -19 },
  { 3685, 19, 29, 20, 0, -28 },
  { 3754, 18, 19, 20, 2, -19 },
  { 3797, 21, 28, 20, 1, -28 },
  { 3871, 18, 19, 20, 2, -19 },
  { 3914, 25, 35, 20, -3, -28 },
  { 4024, 21, 26, 20, -1, -19 },
  { 4093, 19, 28, 20, 0, -28 },
  { 4160, 14, 28, 20, 3, -28 },
  { 4209, 21, 35, 20, -2, -28 },
  { 4301, 20, 28, 20, 1, -28 },
  { 4371, 13, 28, 20, 4, -28 },
  { 4417, 21, 19, 20, -1, -19 },
  { 4467, 19, 19, 20, 0, -19 },
  { 4513, 18, 20, 20, 1, -19 },
  { 4558, 21, 26, 20, -2, -19 },
  { 4627, 19, 26, 20, 1, -19 },
  { 4689, 19, 19, 20, 1, -19 },
  { 4735, 19, 20, 20, 0, -19 },
  { 4783, 17, 25, 20, 3, -25 },
  { 4837, 18, 19, 20, 2, -19 },
  { 4880, 18, 19, 20, 3, -19 },
  { 4923, 21, 19, 20, 1, -19 },
  { 4973, 22, 19, 20, -1, -19 },
  { 5026, 24, 26, 20, -3, -19 },
  { 5104, 20, 19, 20, 0, -19 },
  { 5152, 20, 35, 20, 2, -28 },
  { 5240, 13, 35, 20, 4, -28 },
  { 5297, 19, 35, 20, -1, -28 },
  { 5381, 20, 7, 20, 0, -14 },
};

const GFXfont UbuntuSansMono_BoldItalic36pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic36pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic36pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _UBUNTUSANSMONO_BOLDITALIC36PT7B_H_
