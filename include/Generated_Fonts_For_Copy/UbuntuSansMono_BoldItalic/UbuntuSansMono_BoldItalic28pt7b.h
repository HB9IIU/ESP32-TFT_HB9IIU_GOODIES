#ifndef _UBUNTUSANSMONO_BOLDITALIC28PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x87, 0x83, 0xC3, 0xE1, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E,
  0x0F, 0x07, 0x00, 0x00, 0x01, 0xC1, 0xF0, 0xF8, 0x7C, 0x3C, 0x00, 0x79,
  0xEF, 0x3F, 0xC7, 0xF9, 0xEF, 0x3D, 0xC7, 0xB8, 0xE7, 0x1C, 0xC3, 0x00,
  0x01, 0xE7, 0x80, 0xE3, 0x80, 0xF3, 0x80, 0x71, 0xC3, 0xFF, 0xF9, 0xFF,
  0xF8, 0xFF, 0xFC, 0x9E, 0x70, 0x0E, 0x38, 0x07, 0x3C, 0x07, 0x1C, 0x1F,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xE0, 0xE7, 0x80, 0xE3, 0x80, 0x71, 0xC0,
  0x79, 0xC0, 0x38, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x01,
  0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x0F, 0x8E, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x40, 0x3C, 0x7D, 0xF8, 0x7F, 0xF8, 0xFF, 0xE0, 0x0F,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x21, 0xF8, 0x38,
  0x3F, 0x06, 0x0E, 0x61, 0xC1, 0x8C, 0x70, 0x33, 0x9C, 0x06, 0x77, 0x00,
  0xFD, 0xC0, 0x1F, 0x30, 0x01, 0xCE, 0x00, 0x03, 0x80, 0x00, 0xEF, 0x00,
  0x3B, 0xF0, 0x0E, 0x66, 0x01, 0x9C, 0xC0, 0x73, 0x18, 0x1C, 0x67, 0x07,
  0x0C, 0xC1, 0xC1, 0xF8, 0x70, 0x1E, 0x00, 0x00, 0xF0, 0x07, 0xF0, 0x1F,
  0xF0, 0x78, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x8E, 0x07, 0x38, 0x0F, 0xE0,
  0x0F, 0x80, 0x7E, 0x39, 0xFE, 0x77, 0x9D, 0xCE, 0x3F, 0xBC, 0x3E, 0x78,
  0x3C, 0xF0, 0xF9, 0xFF, 0xF1, 0xFF, 0xF1, 0xF9, 0xE0, 0x7F, 0xFD, 0xEF,
  0x73, 0x9C, 0xC0, 0x00, 0x30, 0x07, 0x80, 0x7E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0x00, 0x01,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xFC, 0x03, 0x80, 0x18, 0x00, 0x0F, 0x00, 0x78, 0x11, 0xCD,
  0xEC, 0xEF, 0xFF, 0x7F, 0xFC, 0x3C, 0x03, 0xF0, 0x3D, 0xC3, 0xCF, 0x0E,
  0x70, 0x21, 0x00, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x81,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x1E, 0x7C, 0xF9, 0xF3, 0xE1, 0xC7, 0x7C, 0xF1,
  0x80, 0x7F, 0xDF, 0xEF, 0xFB, 0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xF9, 0xE3, 0xE1,
  0xC7, 0x83, 0xCE, 0x07, 0xBC, 0x0F, 0x7B, 0x9C, 0xE7, 0x3B, 0xCE, 0x77,
  0x99, 0xEF, 0x03, 0xDE, 0x07, 0x3C, 0x1E, 0x78, 0x38, 0xF0, 0xF0, 0xFF,
  0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0xF0, 0x1F, 0x07, 0xF3, 0xFE, 0x3F,
  0xE1, 0xDE, 0x11, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8,
  0x0F, 0xF8, 0x7F, 0xF8, 0x7F, 0xF0, 0xC1, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0,
  0x01, 0xF0, 0x1F, 0xF8, 0x3F, 0xF8, 0x39, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x40, 0x79, 0xFF, 0xF3, 0xFF, 0xC3,
  0xFE, 0x00, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFE,
  0x03, 0xDC, 0x07, 0x9C, 0x0F, 0x3C, 0x1E, 0x3C, 0x3C, 0x3C, 0x38, 0x38,
  0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x40, 0x78,
  0x7F, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0x00, 0x02, 0x01, 0xFC, 0x0F, 0xF8,
  0x3F, 0xF0, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x7F, 0xE0, 0xFF,
  0xF3, 0xFF, 0xE7, 0x83, 0xCF, 0x03, 0xDE, 0x07, 0xBC, 0x0E, 0x78, 0x3C,
  0x78, 0x78, 0xFF, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0,
  0xF9, 0xF1, 0xC1, 0xE3, 0x83, 0xCF, 0x07, 0x0F, 0x1E, 0x1F, 0x78, 0x1F,
  0xE0, 0x7F, 0x81, 0xEF, 0x87, 0x8F, 0x9E, 0x0F, 0x3C, 0x1E, 0x70, 0x3C,
  0xF0, 0xF9, 0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xE0,
  0x7F, 0xE1, 0xFB, 0xE3, 0xC3, 0xCF, 0x03, 0x9E, 0x07, 0xBC, 0x0F, 0x78,
  0x1E, 0xF8, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x63, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x07, 0xE1, 0xFF, 0x83, 0xFC, 0x07, 0xC0, 0x00, 0x1E, 0x3F,
  0x3F, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF8, 0xF8, 0xF8, 0xF8,
  0x07, 0x83, 0xF0, 0xFC, 0x3E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x80, 0xE0, 0x70, 0xF8, 0x3C, 0x0C, 0x00,
  0x00, 0x04, 0x00, 0x38, 0x03, 0xF0, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x1F,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0x80, 0x07,
  0x00, 0x02, 0x00, 0x3F, 0xFF, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0x08, 0x00, 0x3C,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0x80, 0x7E,
  0x07, 0xFC, 0x7F, 0xE3, 0xFE, 0x03, 0xE0, 0x07, 0x00, 0x10, 0x00, 0x00,
  0x0F, 0x8F, 0xF9, 0xFF, 0xBD, 0xF4, 0x1E, 0x03, 0xC0, 0x78, 0x3E, 0x0F,
  0x83, 0xE0, 0xF0, 0x1C, 0x07, 0x80, 0x00, 0x00, 0x03, 0x80, 0xF8, 0x1F,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0xF8, 0x3F, 0xF8, 0xF0, 0x73,
  0xC0, 0xE7, 0x01, 0xDC, 0x3F, 0xB8, 0xFF, 0x73, 0xFF, 0xCF, 0x3F, 0x9C,
  0x77, 0x38, 0xEE, 0xF1, 0xDD, 0xE7, 0xB3, 0xCE, 0x67, 0x9C, 0xE7, 0xF9,
  0xCF, 0xF3, 0x87, 0xC7, 0x00, 0x07, 0x00, 0x0F, 0xFC, 0x0F, 0xF8, 0x07,
  0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1D, 0xC0, 0x7B,
  0x80, 0xE7, 0x03, 0xCE, 0x07, 0x1C, 0x1E, 0x3C, 0x38, 0x78, 0xFF, 0xF1,
  0xFF, 0xE7, 0xFF, 0xCE, 0x07, 0xBC, 0x0F, 0x78, 0x1F, 0xE0, 0x3F, 0xC0,
  0x78, 0x01, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0E, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0E, 0x1E, 0x1E, 0x1F, 0xFC, 0x3F, 0xF8, 0x3F, 0xF8, 0x3C,
  0xFC, 0x3C, 0x1C, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0x78, 0x7C, 0x7F,
  0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x01, 0xF8, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF,
  0xE3, 0xE0, 0x47, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8,
  0x21, 0xFF, 0xC1, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0x80, 0x1F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x07, 0x1C, 0x1E,
  0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0x81, 0xEF, 0x07, 0x9E, 0x0F, 0x3C,
  0x3C, 0x71, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00, 0x07, 0xFF, 0x83,
  0xFF, 0x83, 0xFF, 0xC1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xFC, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xF8, 0x3F, 0xFC, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8, 0x3F, 0xF8,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE,
  0x1F, 0x02, 0x3E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x3C, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF8, 0x78,
  0x78, 0x70, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x0F, 0x07, 0x87, 0x83,
  0xC3, 0x81, 0xE3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x7F,
  0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0x07, 0x8F, 0x07, 0x87, 0x83, 0xC3,
  0xC1, 0xE1, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x3C, 0x1E,
  0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC0, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x7F,
  0xF8, 0x7F, 0xFC, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x40, 0x78,
  0x60, 0xF0, 0x7F, 0xF0, 0xFF, 0xE0, 0x3F, 0xC0, 0x0F, 0x07, 0xC3, 0xC3,
  0xC0, 0xF1, 0xF0, 0x78, 0xF8, 0x1E, 0x7C, 0x07, 0x9E, 0x01, 0xEF, 0x00,
  0x77, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xE7, 0x80, 0x79,
  0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x81, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F,
  0x0F, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x7F, 0xFB, 0xFF, 0xFF, 0xFC, 0x07, 0x83,
  0xC1, 0xE1, 0xF0, 0x78, 0x78, 0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xE7, 0xE1,
  0xDD, 0xB8, 0x77, 0xEE, 0x1D, 0xF7, 0x07, 0x7D, 0xC3, 0xDE, 0x70, 0xE3,
  0x9C, 0x38, 0x0F, 0x1E, 0x03, 0x87, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x1E,
  0x3C, 0x07, 0x8F, 0x01, 0xC0, 0x0F, 0x03, 0x87, 0x83, 0xC3, 0xC1, 0xC3,
  0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x78, 0x77, 0x3C, 0x7B, 0x9C, 0x3D, 0xCE,
  0x1C, 0xEF, 0x0E, 0x37, 0x8F, 0x1F, 0x87, 0x8F, 0xC3, 0x87, 0xE1, 0xC1,
  0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x70, 0x3C, 0x38, 0x1E, 0x00, 0x01, 0xE0,
  0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE3, 0xE1, 0xE7, 0x83, 0xDE, 0x07, 0xBC,
  0x0F, 0x78, 0x1F, 0xE0, 0x3B, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07,
  0x3C, 0x1E, 0x78, 0x7C, 0xF1, 0xF0, 0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x00,
  0x01, 0xF0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0x0F, 0x0F, 0x1E, 0x0F,
  0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1C, 0x3E, 0x3F, 0xFE, 0x3F, 0xFC,
  0x3F, 0xF0, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF, 0xE3,
  0xE1, 0xE7, 0x83, 0xDE, 0x07, 0xBC, 0x0F, 0x78, 0x1E, 0xE0, 0x3B, 0xC0,
  0xF7, 0x81, 0xEF, 0x03, 0xDE, 0x07, 0x3C, 0x1E, 0x78, 0x7C, 0xF1, 0xF0,
  0xFF, 0xC1, 0xFF, 0x01, 0xFC, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x03, 0xC0, 0x01, 0xC0, 0x0F, 0xFC, 0x0F, 0xFE, 0x0F, 0xFE, 0x0E,
  0x1E, 0x1E, 0x0F, 0x1E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1E, 0x3C, 0xFC, 0x3F,
  0xFC, 0x3F, 0xF0, 0x3F, 0xE0, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0x70, 0x78,
  0x78, 0xF0, 0x78, 0xF0, 0x38, 0xF0, 0x3C, 0x00, 0xF8, 0x07, 0xFF, 0x0F,
  0xFE, 0x0F, 0x9E, 0x1E, 0x02, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x60, 0x78, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1E,
  0x0F, 0x1E, 0x0E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x3C, 0x1E, 0x78,
  0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x78, 0xF0, 0x78, 0xF0,
  0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF0, 0xF0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F,
  0x80, 0xF0, 0x1F, 0xE0, 0x7B, 0xC0, 0xF7, 0x81, 0xCF, 0x07, 0x9E, 0x0E,
  0x3C, 0x3C, 0x78, 0x78, 0xF1, 0xE1, 0xE3, 0xC3, 0xCF, 0x07, 0x9E, 0x07,
  0x78, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x00, 0x1E, 0x03, 0xC7, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x1E, 0x1C, 0x07,
  0x8F, 0x01, 0xC3, 0x8C, 0x70, 0xE7, 0x1C, 0x39, 0xCE, 0x0E, 0xFB, 0x87,
  0x3E, 0xE1, 0xDB, 0xB8, 0x76, 0xFC, 0x1F, 0x3F, 0x06, 0xC7, 0xC1, 0xE1,
  0xE0, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x00, 0x07, 0x83, 0xE0, 0xF0,
  0x78, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x3D, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7B, 0x80, 0x1E, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x3C, 0x3C,
  0x0F, 0x03, 0x83, 0xE0, 0x78, 0x00, 0xF0, 0x1E, 0xE0, 0x79, 0xC1, 0xE3,
  0xC3, 0xC7, 0x8F, 0x0F, 0x3C, 0x0E, 0x78, 0x1D, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0x83, 0xFF,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFE, 0x00, 0x03,
  0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xFF, 0x81, 0xFF, 0x03,
  0xFE, 0x00, 0xF3, 0xC7, 0x1C, 0x71, 0xC7, 0x9E, 0x79, 0xE7, 0x9E, 0x78,
  0xE3, 0x8E, 0x38, 0xF3, 0xCF, 0x3C, 0xF3, 0xCF, 0x1C, 0x71, 0xC0, 0x01,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7F,
  0xC0, 0x7F, 0x80, 0xFF, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0xC0, 0xF7, 0x83, 0xEF, 0x0F, 0x8F, 0x3E, 0x1E, 0xF8, 0x3C, 0xE0, 0x3C,
  0x40, 0x40, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xF0, 0x20, 0xE1, 0xE7, 0xE1,
  0xE0, 0x80, 0x03, 0xF8, 0x3F, 0xF1, 0xFF, 0xCF, 0x8F, 0x78, 0x39, 0xE1,
  0xEF, 0x07, 0xBC, 0x1E, 0xF0, 0x73, 0xC3, 0xCF, 0x0F, 0x3C, 0x7C, 0xFF,
  0xF1, 0xFF, 0xC3, 0xF7, 0x80, 0x01, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x78, 0x1F, 0xF8, 0x3F, 0xF8,
  0x78, 0xF1, 0xE0, 0xE3, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x1C, 0x1E, 0x78,
  0x3C, 0xF0, 0xF9, 0xE3, 0xE3, 0xFF, 0x8F, 0xFE, 0x1F, 0xF8, 0x00, 0x03,
  0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0xE2, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x04, 0x7F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x00, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x03, 0xFC, 0x0F, 0xFC, 0x1F, 0xFC, 0x3E, 0x3C,
  0x78, 0x38, 0x78, 0x78, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF1, 0xF0, 0xFF, 0xF0, 0x7F, 0xF0, 0x3F, 0x78, 0x03, 0xF0,
  0x3F, 0xE1, 0xFF, 0xCF, 0x0F, 0x78, 0x1D, 0xE0, 0xF7, 0x07, 0xFF, 0xFE,
  0xFF, 0xE3, 0xFC, 0x0F, 0x00, 0x3E, 0x04, 0x7F, 0xF0, 0xFF, 0xC1, 0xFF,
  0x00, 0x00, 0x03, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0xFF,
  0xF0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x04, 0x7C, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x81, 0xFF,
  0xC1, 0xF1, 0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0xF0, 0x78, 0x78, 0x3C, 0x3C,
  0x1E, 0x1E, 0x0E, 0x0F, 0x8F, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7D, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x40, 0xF0, 0x3F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0,
  0x00, 0x00, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xFC, 0x1F, 0xFC, 0x7F, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C, 0x3C,
  0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x38, 0x39, 0xE1, 0xE7, 0x87, 0x9E, 0x1E,
  0x70, 0x73, 0xC3, 0xC0, 0x03, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x38, 0x00,
  0x00, 0x03, 0xFC, 0x7F, 0x8F, 0xF2, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x8F, 0xF1, 0xFE, 0x1F, 0xC0, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x43, 0xE0, 0xFF,
  0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x1F, 0x0F, 0x1F,
  0x07, 0x1F, 0x07, 0x9F, 0x03, 0xDF, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0x78, 0x1E, 0x3C, 0x0F, 0x0F, 0x07,
  0x87, 0x87, 0xC3, 0xE0, 0x7F, 0x9F, 0xE7, 0xFB, 0xFC, 0x0F, 0x03, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x78, 0x1E, 0x07, 0x85, 0xFF, 0x3F, 0xC7, 0xF0, 0x07, 0xCE, 0x0F, 0xFF,
  0x1F, 0xFF, 0x1C, 0xE7, 0x1C, 0xE7, 0x1C, 0xE7, 0x1C, 0xE7, 0x39, 0xCF,
  0x39, 0xCE, 0x38, 0x0E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C,
  0xF0, 0x1C, 0x07, 0xF0, 0x7F, 0xF1, 0xFF, 0xC7, 0x8F, 0x1E, 0x3C, 0xF0,
  0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3C, 0xE0, 0xE7, 0x87, 0x9E, 0x1E, 0x78,
  0x79, 0xC1, 0xCF, 0x0F, 0x00, 0x07, 0xE0, 0x3F, 0xC1, 0xFF, 0x8F, 0x9E,
  0x78, 0x3D, 0xE0, 0xFF, 0x03, 0xFC, 0x0E, 0xF0, 0x7B, 0xC1, 0xEF, 0x0F,
  0xBC, 0x3C, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xFC,
  0x0F, 0xFE, 0x0F, 0x1E, 0x0E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F,
  0x1C, 0x1E, 0x3C, 0x1E, 0x3C, 0x3E, 0x3C, 0x7C, 0x3F, 0xF8, 0x7F, 0xF0,
  0x7F, 0xC0, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF1, 0xF1, 0xE7, 0xC3, 0xCF, 0x07, 0x3C,
  0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC3, 0xC7, 0x87, 0x87, 0xFF,
  0x0F, 0xFE, 0x0F, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x03, 0xFE, 0x3F, 0xF8, 0x7F, 0xF0, 0xFF, 0xC3, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x3F,
  0xF0, 0xF8, 0x41, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8,
  0x01, 0xF0, 0x01, 0xE1, 0x03, 0xC7, 0xFF, 0x1F, 0xFE, 0x1F, 0xF8, 0x00,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x07, 0xFF, 0xBF, 0xFF, 0xFF, 0xE3,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x84, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x3C, 0x3C, 0xF0, 0xF3, 0xC3,
  0xCE, 0x0F, 0x78, 0x79, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0xF0, 0xF3, 0xC3,
  0xCF, 0x0F, 0x3C, 0x7C, 0xFF, 0xF1, 0xFF, 0xC3, 0xF7, 0x80, 0xF0, 0x3F,
  0xC0, 0xFF, 0x07, 0xBC, 0x1E, 0xF0, 0xF1, 0xC3, 0xC7, 0x9E, 0x1E, 0x78,
  0x7B, 0xC1, 0xEF, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x0E, 0x73, 0x8E, 0xF3, 0x9E, 0xE3,
  0x9C, 0xE7, 0x9C, 0xE7, 0x9C, 0xEF, 0xB8, 0xFD, 0xB8, 0xFD, 0xB0, 0xF9,
  0xF0, 0xF1, 0xF0, 0xF1, 0xE0, 0xE1, 0xE0, 0x1E, 0x07, 0x87, 0x87, 0x83,
  0xC7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0,
  0x03, 0xF0, 0x03, 0xF8, 0x03, 0xDE, 0x03, 0xCF, 0x03, 0xE3, 0xC3, 0xE1,
  0xE3, 0xE0, 0xF8, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E, 0x0F, 0x01, 0xE1,
  0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xC0, 0x1E, 0x78, 0x03, 0xCE,
  0x00, 0x7B, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x81, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xFF, 0x8F, 0xFF, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xFC,
  0x07, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0x03,
  0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0x07,
  0xF0, 0x1F, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x07, 0xC0,
  0x3F, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0x06, 0x7F, 0x1D, 0xFF, 0xFB, 0xFF, 0xEF, 0x1F, 0x84, 0x04, 0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 9, 19, 16, 4, -19 },
  { 23, 11, 9, 16, 5, -21 },
  { 36, 17, 19, 16, 0, -19 },
  { 77, 16, 25, 16, 0, -22 },
  { 127, 19, 20, 16, -1, -20 },
  { 175, 15, 20, 16, 0, -20 },
  { 213, 5, 9, 16, 8, -21 },
  { 219, 13, 27, 16, 3, -22 },
  { 263, 13, 27, 16, 0, -22 },
  { 307, 13, 12, 16, 3, -19 },
  { 327, 14, 14, 16, 1, -15 },
  { 352, 7, 10, 16, 2, -5 },
  { 361, 10, 4, 16, 3, -10 },
  { 366, 5, 5, 16, 4, -5 },
  { 370, 19, 27, 16, -2, -22 },
  { 435, 15, 20, 16, 1, -20 },
  { 473, 12, 19, 16, 1, -19 },
  { 502, 15, 20, 16, 0, -20 },
  { 540, 15, 20, 16, 0, -20 },
  { 578, 16, 19, 16, 0, -19 },
  { 616, 16, 19, 16, 0, -19 },
  { 654, 15, 20, 16, 1, -20 },
  { 692, 14, 19, 16, 3, -19 },
  { 726, 15, 20, 16, 1, -20 },
  { 764, 15, 20, 16, 1, -20 },
  { 802, 8, 14, 16, 4, -14 },
  { 816, 10, 19, 16, 2, -14 },
  { 840, 15, 14, 16, 1, -15 },
  { 867, 16, 9, 16, 0, -13 },
  { 885, 15, 14, 16, 0, -15 },
  { 912, 11, 20, 16, 4, -20 },
  { 940, 15, 24, 16, 1, -20 },
  { 985, 15, 19, 16, -1, -19 },
  { 1021, 16, 20, 16, 0, -20 },
  { 1061, 15, 20, 16, 2, -20 },
  { 1099, 15, 20, 16, 0, -20 },
  { 1137, 17, 19, 16, 0, -19 },
  { 1178, 16, 19, 16, 1, -19 },
  { 1216, 16, 20, 16, 1, -20 },
  { 1256, 17, 19, 16, 0, -19 },
  { 1297, 17, 19, 16, 0, -19 },
  { 1338, 16, 19, 16, 0, -19 },
  { 1376, 18, 19, 16, 0, -19 },
  { 1419, 13, 19, 16, 0, -19 },
  { 1450, 18, 19, 16, -1, -19 },
  { 1493, 17, 19, 16, 0, -19 },
  { 1534, 15, 20, 16, 1, -20 },
  { 1572, 16, 20, 16, 0, -20 },
  { 1612, 15, 25, 16, 1, -20 },
  { 1659, 16, 20, 16, 0, -20 },
  { 1699, 16, 20, 16, 0, -20 },
  { 1739, 15, 19, 16, 3, -19 },
  { 1775, 16, 19, 16, 1, -19 },
  { 1813, 15, 19, 16, 3, -19 },
  { 1849, 18, 19, 16, 0, -19 },
  { 1892, 19, 19, 16, -1, -19 },
  { 1938, 15, 19, 16, 3, -19 },
  { 1974, 17, 19, 16, 0, -19 },
  { 2015, 15, 27, 16, 2, -22 },
  { 2066, 6, 27, 16, 5, -22 },
  { 2087, 16, 27, 16, -1, -22 },
  { 2141, 15, 11, 16, 1, -19 },
  { 2162, 15, 3, 16, -2, 2 },
  { 2168, 7, 6, 16, 6, -22 },
  { 2174, 14, 15, 16, 1, -15 },
  { 2201, 15, 22, 16, 0, -22 },
  { 2243, 14, 15, 16, 1, -15 },
  { 2270, 16, 22, 16, 1, -22 },
  { 2314, 14, 15, 16, 1, -15 },
  { 2341, 19, 27, 16, -2, -22 },
  { 2406, 17, 20, 16, -1, -15 },
  { 2449, 14, 22, 16, 0, -22 },
  { 2488, 11, 22, 16, 2, -22 },
  { 2519, 16, 27, 16, -1, -22 },
  { 2573, 17, 22, 16, 0, -22 },
  { 2620, 10, 22, 16, 3, -22 },
  { 2648, 16, 15, 16, -1, -15 },
  { 2678, 14, 15, 16, 0, -15 },
  { 2705, 14, 15, 16, 1, -15 },
  { 2732, 16, 20, 16, -1, -15 },
  { 2772, 15, 20, 16, 1, -15 },
  { 2810, 15, 15, 16, 1, -15 },
  { 2839, 15, 15, 16, 0, -15 },
  { 2868, 13, 19, 16, 2, -19 },
  { 2899, 14, 15, 16, 1, -15 },
  { 2926, 14, 15, 16, 2, -15 },
  { 2953, 16, 15, 16, 1, -15 },
  { 2983, 17, 15, 16, -1, -15 },
  { 3015, 19, 20, 16, -3, -15 },
  { 3063, 15, 15, 16, 0, -15 },
  { 3092, 15, 27, 16, 2, -22 },
  { 3143, 10, 27, 16, 3, -22 },
  { 3177, 15, 27, 16, -1, -22 },
  { 3228, 15, 6, 16, 0, -11 },
};

const GFXfont UbuntuSansMono_BoldItalic28pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic28pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic28pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _UBUNTUSANSMONO_BOLDITALIC28PT7B_H_
