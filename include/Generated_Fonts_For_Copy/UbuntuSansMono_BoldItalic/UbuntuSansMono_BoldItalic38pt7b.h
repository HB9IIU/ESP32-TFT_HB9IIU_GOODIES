#ifndef _UBUNTUSANSMONO_BOLDITALIC38PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x3E, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0x7E, 0x07, 0xC0, 0x10, 0x00, 0x7E, 0x7E, 0xF8, 0xFD, 0xF1, 0xFF,
  0xE3, 0xEF, 0xC7, 0xDF, 0x1F, 0xBE, 0x3E, 0x78, 0x7C, 0xF0, 0xF9, 0xE1,
  0xE3, 0x83, 0xC7, 0x07, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0xF8, 0x01,
  0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x07, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x0F, 0x0F,
  0x00, 0x1E, 0x3E, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xE3, 0xC0,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x80, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0xF8, 0xF0, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xE0, 0x20, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x06, 0x01, 0xF8, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xFC, 0x03, 0xC1, 0xFE, 0x03, 0xC0, 0xEF, 0x03, 0xC0,
  0xF3, 0x83, 0xC0, 0x71, 0xC1, 0xC0, 0x38, 0xE1, 0xE0, 0x3C, 0x71, 0xE0,
  0x1E, 0x79, 0xE0, 0x0F, 0x39, 0xE0, 0x07, 0xFD, 0xE0, 0x01, 0xFC, 0xE0,
  0x00, 0x7C, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF1, 0x80, 0x00, 0xF3,
  0xF0, 0x00, 0xF3, 0xF8, 0x00, 0x73, 0xFE, 0x00, 0x79, 0xCF, 0x00, 0x79,
  0xE7, 0x80, 0x78, 0xE3, 0xC0, 0x78, 0x71, 0xC0, 0x78, 0x38, 0xE0, 0x78,
  0x1C, 0xF0, 0x38, 0x0F, 0xF0, 0x3C, 0x07, 0xF8, 0x3C, 0x01, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xC0, 0x3E, 0x3E, 0x01, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x78,
  0x07, 0xC3, 0xC0, 0x3E, 0x3C, 0x00, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x3C, 0x3F, 0xE3, 0xC3, 0xFF, 0x1E, 0x3E, 0x7D, 0xF3,
  0xE3, 0xFF, 0x1E, 0x0F, 0xF9, 0xF0, 0x3F, 0x8F, 0x81, 0xF8, 0x7C, 0x07,
  0xC3, 0xF0, 0x7F, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0x9F, 0x07,
  0xF8, 0xF8, 0x3F, 0x3E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0x78,
  0xF0, 0xF0, 0xF0, 0x00, 0x03, 0x00, 0x03, 0x80, 0x07, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x30,
  0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0x00,
  0x0F, 0x00, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x0C,
  0x78, 0x27, 0x9C, 0xF7, 0xEE, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFE,
  0x03, 0xF0, 0x03, 0xDE, 0x03, 0xEF, 0x83, 0xF7, 0xE3, 0xF1, 0xF0, 0x78,
  0xF0, 0x18, 0x20, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x87, 0xE1, 0xFC, 0xFF, 0x3F, 0xC7, 0xF1, 0xF8, 0x1E, 0x0F,
  0x0F, 0xCF, 0xE3, 0xF0, 0xF0, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF,
  0xEF, 0xFF, 0x00, 0x3E, 0x7E, 0x7F, 0xFF, 0xFF, 0x7E, 0x7C, 0x10, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xF7, 0xF0, 0xFC, 0x1F, 0x1F, 0x81,
  0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xC7,
  0x9F, 0x7C, 0xF9, 0xF7, 0xCF, 0x9F, 0x7C, 0xF1, 0xF7, 0xCF, 0x3E, 0x78,
  0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xC7,
  0xC1, 0xF8, 0x7C, 0x3F, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF8, 0x3F, 0xFC, 0x1F, 0x7C, 0x0E, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x81, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x81, 0xC0, 0xFC, 0x08, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0,
  0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x3E,
  0x7F, 0x00, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE1, 0x80, 0x7F,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x3E, 0x7C,
  0x01, 0xF1, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x01, 0xE0, 0xF8, 0x0F,
  0x03, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xF2, 0x7F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F,
  0xFE, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC1,
  0xC0, 0x7F, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF,
  0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0xFF, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x30, 0x07, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0x1F, 0x8F, 0x80, 0xFC, 0xF8, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0x8F, 0x80, 0xF8,
  0xFC, 0x1F, 0x87, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0x18, 0x00, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xE3,
  0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0xC7, 0xE0, 0x7E, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xFF, 0x01, 0xF3, 0xF8, 0x3E, 0x1F, 0x87, 0xC0, 0xFC, 0xF8, 0x07, 0xCF,
  0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xFC, 0xFC, 0x0F, 0x8F, 0xFF, 0xF8,
  0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x7E,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x1F, 0xEF, 0xE1, 0xF0,
  0x3F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E,
  0x01, 0xF3, 0xE0, 0x1F, 0x3F, 0x03, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xF0,
  0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xC1, 0xFC, 0x3F, 0x8F, 0xF1,
  0xFE, 0x1F, 0x83, 0xE0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x1F, 0x83, 0xF8, 0xFF, 0x1F, 0xE1, 0xF8, 0x3E, 0x01, 0x00, 0x01,
  0xF0, 0x1F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xF8, 0x0F, 0x80, 0x10,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x7E, 0x03,
  0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0x78, 0x07, 0x80, 0xFC,
  0x1F, 0xC0, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7C, 0x00,
  0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFE, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0xC0, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0xF0,
  0x00, 0x18, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF,
  0x3E, 0xFF, 0x20, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x7C, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x10, 0x00,
  0x00, 0x1F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7C,
  0x0F, 0x87, 0xC0, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x0F, 0xF9,
  0xE1, 0xFF, 0xDE, 0x1F, 0xFE, 0xF1, 0xFF, 0xE7, 0x8F, 0x8F, 0x38, 0xF8,
  0xFB, 0xC7, 0x87, 0xDE, 0x3C, 0x3C, 0xF3, 0xE1, 0xE7, 0x9F, 0x0F, 0x3C,
  0xF8, 0xF9, 0xE7, 0xC7, 0xCF, 0x3E, 0x3C, 0x78, 0xFF, 0xE3, 0xC7, 0xFF,
  0x1E, 0x1F, 0xF8, 0xF0, 0x7F, 0x87, 0xC0, 0x40, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xF0, 0x10, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xF7, 0xC0, 0x0F, 0x9E,
  0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x1E,
  0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0xF8, 0x1E, 0x07, 0xFF, 0xF8,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xF0, 0x0F, 0x9F, 0x00,
  0xFC, 0xF8, 0x07, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xFF, 0xE0, 0x0F, 0xC0,
  0x00, 0x3C, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x0F, 0xC0, 0xF8,
  0x7C, 0x0F, 0xC3, 0xE0, 0xFC, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x03, 0xE1, 0xFC, 0x3F, 0x03, 0xF1, 0xF0, 0x0F, 0x8F,
  0x80, 0x7C, 0x7C, 0x03, 0xE7, 0xE0, 0x3F, 0x3E, 0x03, 0xF1, 0xF0, 0x7F,
  0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xF0, 0x10, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x1C, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x03, 0xE1, 0xF8, 0x1F, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x3F, 0x01, 0xF1, 0xF0, 0x1F, 0x8F,
  0x80, 0xFC, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3E, 0x03, 0xF1, 0xF0, 0x1F,
  0x8F, 0x80, 0xF8, 0xFC, 0x0F, 0xC7, 0xC0, 0xFC, 0x3E, 0x0F, 0xE1, 0xF1,
  0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x07, 0xE0, 0x10, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x03,
  0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E,
  0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x81, 0xF8, 0x7E, 0x0F, 0x83, 0xF8, 0x7C,
  0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03,
  0x80, 0x00, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xE0, 0x3F, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x7E, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x1F, 0x80, 0xF8, 0x1F,
  0x01, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x3E,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x03, 0xE0, 0x7C,
  0x07, 0xE0, 0x7C, 0x07, 0xC0, 0xFC, 0x07, 0xC0, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x08, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x20, 0x1F, 0x81, 0xE0, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xE0, 0x7F, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0xFC, 0x07,
  0xC1, 0xF8, 0x07, 0xC3, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F,
  0x8F, 0xC0, 0x0F, 0x9F, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x7E,
  0x1F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0xFC,
  0x07, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFD,
  0xFF, 0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xE0, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x07, 0xF0,
  0xFE, 0x07, 0xF0, 0xFE, 0x07, 0xF1, 0xDE, 0x07, 0xF9, 0xDE, 0x0F, 0x7B,
  0xBC, 0x0F, 0x3F, 0xBC, 0x0F, 0x3F, 0x3C, 0x1F, 0x3F, 0x3C, 0x1E, 0x3E,
  0x7C, 0x1E, 0x3E, 0x78, 0x1E, 0x3C, 0x78, 0x3E, 0x3C, 0x78, 0x3C, 0x00,
  0xF8, 0x3C, 0x00, 0xF8, 0x7C, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x7C, 0x01,
  0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xE0, 0xF8, 0x03,
  0xE0, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x03, 0xF0,
  0x1E, 0x03, 0xF8, 0x1E, 0x07, 0xF8, 0x3E, 0x07, 0xF8, 0x3E, 0x07, 0xFC,
  0x3C, 0x07, 0xBC, 0x3C, 0x0F, 0xBC, 0x7C, 0x0F, 0x9C, 0x7C, 0x0F, 0x9E,
  0x78, 0x0F, 0x1E, 0x78, 0x1F, 0x1E, 0xF8, 0x1F, 0x1E, 0xF8, 0x1F, 0x0E,
  0xF8, 0x1E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x3E, 0x07,
  0xF0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x7C, 0x07, 0xE0, 0x7C, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFC, 0x3F, 0x1F, 0x81,
  0xF1, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xE0,
  0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E, 0xFC,
  0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7C, 0xFC, 0x0F, 0xCF,
  0xC1, 0xF8, 0x7E, 0x3F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x30, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0x07, 0xF0, 0x7C, 0x0F,
  0xC1, 0xF0, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F, 0xC3,
  0xE0, 0x3E, 0x1F, 0x83, 0xF8, 0x7C, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0xFC, 0x3F, 0x1F,
  0x81, 0xF1, 0xF0, 0x1F, 0x3F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7,
  0xE0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xF7, 0xC0, 0x3E,
  0xFC, 0x03, 0xEF, 0xC0, 0x3E, 0xFC, 0x07, 0xEF, 0xC0, 0x7C, 0xFC, 0x0F,
  0xCF, 0xC1, 0xF8, 0x7E, 0x3F, 0x87, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF,
  0xC0, 0x0F, 0xF0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xE0,
  0xFC, 0x1F, 0x03, 0xE1, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3,
  0xE0, 0x7E, 0x1F, 0x07, 0xE1, 0xF0, 0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C,
  0x3E, 0x07, 0xE1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF8,
  0xFC, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFB, 0xF0, 0x1F, 0x00,
  0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x80, 0x1F, 0x07, 0x80, 0xFC, 0x1F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x70,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x3E, 0x03, 0xF0,
  0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x7E, 0x07, 0xE1, 0xF0,
  0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3E,
  0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE1, 0xF8, 0x1F, 0x87, 0xC0, 0x7C, 0x1F,
  0x01, 0xF0, 0x7C, 0x07, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3F, 0x03,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x10, 0x00, 0x00, 0xFC, 0x01, 0xFF,
  0xE0, 0x1F, 0xBF, 0x00, 0xF9, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0x7C, 0x03,
  0xE3, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xC0, 0xF8, 0x3E,
  0x07, 0xC1, 0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x3E, 0x01, 0xE1, 0xF0,
  0x0F, 0x1F, 0x00, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1F,
  0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x3E,
  0x0F, 0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1E, 0x3C, 0x7C,
  0x1E, 0x3C, 0x78, 0x3E, 0x7C, 0x78, 0x3E, 0x7C, 0x78, 0x3C, 0xFC, 0xF8,
  0x3C, 0xFC, 0xF0, 0x3D, 0xDC, 0xF0, 0x3D, 0xDE, 0xF0, 0x7B, 0x9F, 0xE0,
  0x7F, 0x8F, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x3F,
  0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x7C, 0x01,
  0xF8, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xFB, 0xE0, 0x1F, 0x9F, 0x01, 0xF8, 0xF8, 0x0F, 0x87,
  0xC0, 0xFC, 0x3E, 0x07, 0xC0, 0xF8, 0x7C, 0x07, 0xC7, 0xE0, 0x3E, 0x3E,
  0x01, 0xF3, 0xE0, 0x0F, 0xBF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0x7C, 0x3E, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF8, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFF, 0x01, 0xF3, 0xE0, 0x7E, 0x7C, 0x1F, 0x8F, 0xC7, 0xE0, 0xF9, 0xF8,
  0x1F, 0x7E, 0x03, 0xFF, 0xC0, 0x3E, 0xF0, 0x07, 0x84, 0x00, 0xC0, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x20, 0x3C, 0x3F, 0x1F, 0xC7, 0xF8, 0xF8, 0x1C, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xC3, 0xE3, 0xF0, 0x7E, 0x7E,
  0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0xFC, 0xF8, 0x0F, 0x8F,
  0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xFC, 0x1F, 0x8F, 0xC3, 0xF8,
  0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFE, 0x7C, 0x00, 0x08,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xC7, 0xE1,
  0xF8, 0x3F, 0x1F, 0x03, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x3F,
  0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x7E, 0x7E, 0x0F,
  0xC7, 0xC1, 0xFC, 0x7F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF,
  0x80, 0x01, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFC, 0x08, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF8, 0x30, 0x7F, 0xFE, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x04, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0xFF, 0x00, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFC, 0x3E, 0x0F, 0xC1, 0xF8,
  0x7E, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0xF8,
  0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x7F, 0x9F, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF,
  0xE1, 0xFF, 0xFC, 0x7E, 0x0F, 0xDF, 0x80, 0xFB, 0xE0, 0x3F, 0xF8, 0x07,
  0xDF, 0x03, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0x80,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x02, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7E,
  0x08, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0x07,
  0xC0, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0x80, 0xF8,
  0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x01,
  0xF0, 0x3E, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x01, 0x8F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x04, 0x01,
  0xF8, 0x0F, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0x87, 0xF0, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8,
  0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x07, 0xE3, 0xF0, 0x7C, 0x3E,
  0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC7, 0xE0, 0xFC, 0x7C, 0x0F, 0x87,
  0xC0, 0xF8, 0x7C, 0x0F, 0x8F, 0xC1, 0xF8, 0x00, 0x70, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x87, 0xFE, 0x1F, 0xFC, 0x00, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x84, 0x3F, 0xF8, 0x7F, 0xF0,
  0x7F, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x08, 0x0F, 0x80, 0x7C, 0xFE, 0x01, 0xFF,
  0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x10,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x1F, 0xC3, 0xE0, 0xFC, 0x0F, 0x87, 0xE0, 0x3E, 0x3F,
  0x01, 0xF9, 0xF8, 0x07, 0xCF, 0xC0, 0x1F, 0x7E, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFB, 0xF0, 0x07, 0xE7,
  0xC0, 0x1F, 0x9F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xFC, 0x07, 0xC1, 0xF0,
  0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x83, 0xE0, 0x3F, 0x00, 0xFF, 0xE7, 0xFF,
  0x3F, 0xF9, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7E, 0x13, 0xFF, 0xDF, 0xFE, 0x7F, 0xF1, 0xFF, 0x00, 0x03, 0xF9, 0xF0,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0x1E, 0x7C, 0x3C,
  0x78, 0xF0, 0xF3, 0xE7, 0xC7, 0xCF, 0x1E, 0x1E, 0x3C, 0x78, 0x78, 0xF1,
  0xE1, 0xE3, 0xCF, 0x8F, 0x9E, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x1F, 0x1F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x0F, 0x87, 0xF0, 0xF8, 0x3F, 0x1F, 0x83, 0xF1, 0xF8, 0x3E,
  0x1F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x07, 0xE3, 0xF0, 0x7C, 0x3E, 0x07,
  0xC3, 0xE0, 0x7C, 0x3E, 0x0F, 0xC7, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0,
  0xF8, 0x7C, 0x1F, 0x8F, 0xC1, 0xF8, 0x00, 0x18, 0x00, 0x3F, 0xE0, 0x1F,
  0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0x0F, 0xCF, 0xC1, 0xF9, 0xF0,
  0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0xFE, 0x03, 0xFF, 0x80,
  0x7D, 0xF0, 0x0F, 0xBF, 0x03, 0xF7, 0xE0, 0xFC, 0xFE, 0x3F, 0x8F, 0xFF,
  0xE1, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xE0,
  0xFC, 0x0F, 0x81, 0xF0, 0x7E, 0x07, 0xC1, 0xF0, 0x1F, 0x07, 0xC0, 0x7C,
  0x1F, 0x01, 0xF0, 0xFC, 0x0F, 0xC3, 0xE0, 0x3E, 0x0F, 0x81, 0xF8, 0x3E,
  0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xC3, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0x1F, 0xC3, 0xE3, 0xF0, 0x3E, 0x3E, 0x03, 0xE7, 0xE0, 0x7E, 0x7C, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xCF, 0xC0, 0xFC, 0xFC, 0x0F, 0x8F, 0xC0,
  0xF8, 0x7C, 0x0F, 0x87, 0xE1, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x01, 0xFF,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0C, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFC, 0x04, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x38, 0x1F, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x28, 0x00, 0x00, 0x70, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xFF, 0xFD, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xE0, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC1, 0x83, 0xFF, 0xE0, 0xFF,
  0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x1F, 0x07, 0xE7, 0xE0, 0xF8, 0xF8,
  0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xFC, 0xFC, 0x1F, 0x1F, 0x03, 0xE3, 0xE0,
  0x7C, 0x7C, 0x1F, 0x9F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0xC7, 0xE3, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFC, 0x1F, 0xCF, 0x80, 0xF8, 0x07, 0xFF, 0x00, 0xFB, 0xE0,
  0x1F, 0x7C, 0x07, 0xEF, 0xC0, 0xF9, 0xF8, 0x3F, 0x3F, 0x07, 0xC3, 0xE1,
  0xF8, 0x7C, 0x3E, 0x0F, 0x8F, 0xC1, 0xF1, 0xF0, 0x3E, 0x7C, 0x07, 0xDF,
  0x80, 0xFB, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0x07, 0x9F, 0x00, 0x1E, 0x78, 0x78, 0xF9, 0xE1, 0xE3, 0xC7, 0x8F,
  0x8F, 0x1E, 0x3E, 0x7C, 0x79, 0xF9, 0xE1, 0xE7, 0xE7, 0x87, 0x3F, 0x9C,
  0x3C, 0xEE, 0xF0, 0xF7, 0xBB, 0xC3, 0xDC, 0xEE, 0x0F, 0xF3, 0xF8, 0x3F,
  0x8F, 0xE0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0x83, 0xE0, 0x3C, 0x0F,
  0x80, 0x0F, 0xC0, 0x7E, 0x0F, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x0F,
  0x80, 0x3F, 0x3E, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xE0, 0x1F,
  0x87, 0xC0, 0x7E, 0x0F, 0x81, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x00, 0x03,
  0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xC0,
  0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF8,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x3E,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x01, 0x0F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x08, 0x7F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x0F,
  0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0xC1, 0xFE, 0x0F, 0x3F, 0xF9, 0xE7,
  0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0x0F, 0xF8, 0xF0, 0x7F, 0x02, 0x01, 0xC0,
};

const GFXglyph UbuntuSansMono_BoldItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 12, 27, 21, 5, -26 },
  { 42, 15, 12, 21, 7, -29 },
  { 65, 23, 26, 21, 0, -26 },
  { 140, 21, 33, 21, 0, -29 },
  { 227, 25, 28, 21, -1, -27 },
  { 315, 21, 27, 21, 0, -27 },
  { 386, 8, 13, 21, 10, -29 },
  { 399, 17, 37, 21, 4, -30 },
  { 478, 17, 37, 21, 0, -30 },
  { 557, 17, 16, 21, 4, -26 },
  { 591, 19, 19, 21, 1, -21 },
  { 637, 10, 13, 21, 3, -7 },
  { 654, 13, 5, 21, 4, -13 },
  { 663, 8, 8, 21, 5, -7 },
  { 671, 25, 37, 21, -2, -30 },
  { 787, 20, 28, 21, 1, -27 },
  { 857, 17, 26, 21, 1, -26 },
  { 913, 21, 27, 21, 0, -27 },
  { 984, 21, 28, 21, 0, -27 },
  { 1058, 22, 26, 21, 0, -26 },
  { 1130, 22, 27, 21, 0, -26 },
  { 1205, 20, 28, 21, 2, -27 },
  { 1275, 21, 26, 21, 3, -26 },
  { 1344, 20, 28, 21, 1, -27 },
  { 1414, 20, 27, 21, 1, -27 },
  { 1482, 11, 21, 21, 5, -20 },
  { 1511, 13, 26, 21, 3, -20 },
  { 1554, 19, 18, 21, 2, -20 },
  { 1597, 21, 12, 21, 0, -17 },
  { 1629, 19, 18, 21, 1, -20 },
  { 1672, 16, 28, 21, 5, -27 },
  { 1728, 21, 33, 21, 1, -27 },
  { 1815, 21, 26, 21, -2, -26 },
  { 1884, 21, 27, 21, 0, -27 },
  { 1955, 21, 28, 21, 2, -27 },
  { 2029, 21, 27, 21, 0, -27 },
  { 2100, 22, 26, 21, 1, -26 },
  { 2172, 22, 26, 21, 1, -26 },
  { 2244, 21, 28, 21, 2, -27 },
  { 2318, 24, 26, 21, -1, -26 },
  { 2396, 23, 26, 21, 0, -26 },
  { 2471, 22, 27, 21, 0, -26 },
  { 2546, 24, 26, 21, 0, -26 },
  { 2624, 18, 26, 21, 0, -26 },
  { 2683, 24, 26, 21, -1, -26 },
  { 2761, 24, 26, 21, -1, -26 },
  { 2839, 20, 28, 21, 1, -27 },
  { 2909, 22, 27, 21, 0, -27 },
  { 2984, 20, 34, 21, 1, -27 },
  { 3069, 21, 27, 21, 0, -27 },
  { 3140, 22, 28, 21, 0, -27 },
  { 3217, 20, 26, 21, 4, -26 },
  { 3282, 22, 27, 21, 1, -26 },
  { 3357, 21, 26, 21, 4, -26 },
  { 3426, 24, 26, 21, 0, -26 },
  { 3504, 26, 26, 21, -2, -26 },
  { 3589, 21, 26, 21, 4, -26 },
  { 3658, 23, 26, 21, 0, -26 },
  { 3733, 21, 37, 21, 2, -30 },
  { 3831, 9, 37, 21, 7, -30 },
  { 3873, 21, 37, 21, -1, -30 },
  { 3971, 19, 15, 21, 2, -26 },
  { 4007, 20, 5, 21, -3, 2 },
  { 4020, 9, 7, 21, 9, -29 },
  { 4028, 20, 20, 21, 1, -20 },
  { 4078, 20, 31, 21, 0, -30 },
  { 4156, 19, 20, 21, 2, -20 },
  { 4204, 22, 30, 21, 1, -30 },
  { 4287, 19, 22, 21, 2, -21 },
  { 4340, 27, 36, 21, -3, -29 },
  { 4462, 23, 27, 21, -2, -20 },
  { 4540, 20, 30, 21, 0, -30 },
  { 4615, 15, 30, 21, 3, -30 },
  { 4672, 22, 37, 21, -2, -30 },
  { 4774, 22, 30, 21, 1, -30 },
  { 4857, 13, 29, 21, 5, -29 },
  { 4905, 22, 20, 21, -1, -20 },
  { 4960, 20, 20, 21, 0, -20 },
  { 5010, 19, 22, 21, 1, -21 },
  { 5063, 22, 27, 21, -2, -20 },
  { 5138, 20, 27, 21, 1, -20 },
  { 5206, 20, 20, 21, 1, -20 },
  { 5256, 20, 22, 21, 0, -21 },
  { 5311, 18, 26, 21, 3, -26 },
  { 5370, 19, 20, 21, 2, -20 },
  { 5418, 19, 20, 21, 3, -20 },
  { 5466, 22, 20, 21, 1, -20 },
  { 5521, 23, 20, 21, -1, -20 },
  { 5579, 25, 27, 21, -3, -20 },
  { 5664, 21, 20, 21, 0, -20 },
  { 5717, 20, 37, 21, 3, -30 },
  { 5810, 14, 37, 21, 4, -30 },
  { 5875, 20, 37, 21, -1, -30 },
  { 5968, 20, 8, 21, 1, -15 },
};

const GFXfont UbuntuSansMono_BoldItalic38pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic38pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic38pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _UBUNTUSANSMONO_BOLDITALIC38PT7B_H_
