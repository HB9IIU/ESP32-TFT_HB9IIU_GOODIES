#ifndef _UBUNTUSANSMONO_BOLDITALIC12PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic12pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB4, 0x36, 0xDE, 0xF5, 0x20, 0x1E, 0x29, 0xF9, 0x66, 0x9F,
  0x94, 0x58, 0x0C, 0x7D, 0x93, 0x03, 0x83, 0x83, 0x6E, 0x78, 0x40, 0x21,
  0x72, 0x54, 0x78, 0x78, 0x3C, 0x2A, 0x54, 0x9C, 0x08, 0x78, 0x91, 0x43,
  0x2A, 0xB7, 0x6E, 0x7C, 0x7B, 0x40, 0x04, 0x33, 0x8C, 0x61, 0x0C, 0x30,
  0xC1, 0x06, 0x08, 0x11, 0x86, 0x10, 0x84, 0x23, 0x19, 0x99, 0x80, 0x33,
  0xA3, 0xDE, 0x50, 0x18, 0x61, 0x3F, 0x30, 0xC0, 0x6D, 0xE0, 0xF0, 0xF0,
  0x03, 0x02, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0xC0, 0x08,
  0x79, 0x9B, 0x35, 0x6A, 0xB3, 0x26, 0x78, 0x1D, 0xE5, 0x86, 0x18, 0x43,
  0x3F, 0x08, 0xF8, 0x98, 0x20, 0xC7, 0x18, 0x60, 0xFC, 0x08, 0x78, 0x18,
  0x23, 0x81, 0x83, 0x46, 0xF8, 0x0E, 0x38, 0xD3, 0x64, 0xDF, 0x82, 0x0C,
  0x3E, 0x40, 0x83, 0xC0, 0xC1, 0xA3, 0x7C, 0x1E, 0x61, 0x83, 0xE4, 0x58,
  0x93, 0x3C, 0xFC, 0x31, 0x8C, 0x21, 0x84, 0x30, 0x08, 0x7C, 0x9B, 0x23,
  0x8D, 0xB3, 0x66, 0x78, 0x08, 0x79, 0x9A, 0x36, 0x67, 0x83, 0x1C, 0xF0,
  0x6C, 0x0D, 0x80, 0x33, 0x00, 0x66, 0x6C, 0x1D, 0xEC, 0x3C, 0x38, 0x7E,
  0xF8, 0x07, 0xE0, 0x60, 0xF0, 0xDE, 0xE0, 0x27, 0x86, 0x66, 0x60, 0x18,
  0xC0, 0x08, 0x7D, 0x8A, 0x75, 0x7E, 0xAD, 0x7E, 0xC8, 0xC8, 0xE0, 0x0E,
  0x1C, 0x78, 0xB3, 0x67, 0xD9, 0xE3, 0x3C, 0x4D, 0x93, 0xC4, 0xC8, 0xB3,
  0x7C, 0x08, 0xF6, 0x30, 0xC2, 0x08, 0x32, 0xF8, 0x3C, 0xC9, 0x9B, 0x34,
  0x49, 0xB6, 0x78, 0x3E, 0x40, 0x83, 0xE6, 0x08, 0x10, 0x7E, 0x3E, 0x40,
  0x83, 0xE6, 0x0C, 0x10, 0x60, 0x09, 0xF6, 0x30, 0x82, 0x29, 0xB6, 0xF0,
  0x32, 0xCD, 0x9B, 0xE4, 0x59, 0xB3, 0x64, 0x3E, 0x30, 0x60, 0xC1, 0x06,
  0x0D, 0x7C, 0x3E, 0x0C, 0x10, 0x60, 0xC1, 0xA6, 0x7C, 0x37, 0x6C, 0x78,
  0x70, 0x58, 0x58, 0xCC, 0xCC, 0x30, 0x86, 0x18, 0x61, 0x0C, 0x7E, 0x26,
  0xED, 0x6A, 0xF5, 0x58, 0xA1, 0x46, 0x22, 0xED, 0xDA, 0xA5, 0xD9, 0xB3,
  0x44, 0x08, 0x79, 0x9B, 0x34, 0x78, 0xB3, 0x26, 0x78, 0x3E, 0x4D, 0x9B,
  0x77, 0xC8, 0x30, 0x60, 0x08, 0x79, 0x9B, 0x34, 0x78, 0xB3, 0x26, 0x78,
  0x40, 0xE0, 0x3C, 0xCD, 0x9B, 0x67, 0x8B, 0x32, 0x66, 0x08, 0x7D, 0x83,
  0x03, 0x83, 0x83, 0x46, 0xF8, 0xFE, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30,
  0x26, 0xCD, 0x9B, 0x24, 0xD9, 0xB3, 0x3C, 0xC7, 0x9B, 0x26, 0xCD, 0x8E,
  0x18, 0x30, 0x63, 0x62, 0x42, 0x56, 0x6C, 0xEC, 0xCC, 0xC8, 0x27, 0x34,
  0x1C, 0x18, 0x38, 0x68, 0x4C, 0xCC, 0xC6, 0x99, 0x63, 0x86, 0x0C, 0x18,
  0x30, 0x3E, 0x08, 0x30, 0xC3, 0x0C, 0x31, 0x7C, 0x3C, 0xC2, 0x08, 0x61,
  0x84, 0x10, 0xC3, 0x0F, 0x00, 0xD9, 0x24, 0x93, 0x6D, 0x80, 0x3C, 0x30,
  0xC2, 0x18, 0x61, 0x84, 0x30, 0xCF, 0x00, 0x39, 0xE4, 0xB3, 0x08, 0xFC,
  0xCC, 0x3E, 0xC9, 0x36, 0x6C, 0xCF, 0x80, 0x30, 0x82, 0x1F, 0x65, 0x14,
  0xF7, 0xF8, 0x7F, 0x08, 0x20, 0xCB, 0xE0, 0x06, 0x0C, 0x19, 0xE6, 0x49,
  0xB3, 0x66, 0x7C, 0x3C, 0xCD, 0x37, 0x84, 0x4F, 0x80, 0x07, 0x0C, 0x08,
  0x3F, 0x18, 0x18, 0x18, 0x10, 0x10, 0x30, 0xE0, 0x3E, 0xC9, 0x32, 0x67,
  0xC5, 0x26, 0x78, 0x30, 0xC2, 0x1F, 0x6D, 0xB4, 0xF3, 0xC8, 0x31, 0x81,
  0xE2, 0x31, 0x8D, 0x78, 0x06, 0x0C, 0x01, 0xF0, 0x40, 0x83, 0x06, 0x08,
  0xB3, 0xE0, 0x30, 0x60, 0x81, 0x36, 0x8E, 0x16, 0x2C, 0xCC, 0x75, 0x8C,
  0x46, 0x31, 0x8D, 0x78, 0x7E, 0xAD, 0x56, 0xA8, 0x51, 0x80, 0x7D, 0xB6,
  0xD3, 0xCF, 0x20, 0x3D, 0x94, 0x73, 0xCD, 0xE0, 0x3E, 0x64, 0xC9, 0x36,
  0xEF, 0x98, 0x60, 0x3E, 0xC9, 0x36, 0x64, 0xCF, 0x06, 0x0C, 0x3E, 0x41,
  0x83, 0x04, 0x18, 0x00, 0x3D, 0x83, 0x87, 0x8F, 0xE0, 0x30, 0x9F, 0x98,
  0x61, 0x04, 0x9E, 0xCF, 0x69, 0xA6, 0x9B, 0xE0, 0xCF, 0x6D, 0xBC, 0x61,
  0x80, 0x42, 0xAD, 0x57, 0xAE, 0xD9, 0x00, 0x66, 0x78, 0xE1, 0xC7, 0x99,
  0x80, 0x33, 0x36, 0x36, 0x34, 0x1C, 0x18, 0x30, 0xE0, 0x7E, 0x18, 0x61,
  0x86, 0x5F, 0x00, 0x1C, 0xC3, 0x08, 0x63, 0x06, 0x10, 0x41, 0x07, 0x00,
  0x18, 0x8C, 0x62, 0x11, 0x8C, 0x42, 0x30, 0x38, 0x20, 0x86, 0x18, 0x31,
  0x0C, 0x30, 0x8E, 0x00, 0x67, 0xF9, 0x20,
};

const GFXglyph UbuntuSansMono_BoldItalic12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 8, 7, 2, -8 },
  { 4, 5, 4, 7, 2, -9 },
  { 7, 7, 8, 7, 0, -8 },
  { 14, 7, 10, 7, 0, -9 },
  { 23, 8, 9, 7, 0, -9 },
  { 32, 7, 9, 7, 0, -9 },
  { 40, 3, 4, 7, 3, -9 },
  { 42, 6, 12, 7, 1, -10 },
  { 51, 5, 12, 7, 0, -10 },
  { 59, 6, 5, 7, 1, -8 },
  { 63, 6, 6, 7, 0, -7 },
  { 68, 3, 4, 7, 1, -2 },
  { 70, 4, 1, 7, 1, -4 },
  { 71, 2, 2, 7, 2, -2 },
  { 72, 8, 11, 7, -1, -9 },
  { 83, 7, 9, 7, 0, -9 },
  { 91, 6, 8, 7, 0, -8 },
  { 97, 7, 9, 7, 0, -9 },
  { 105, 7, 9, 7, 0, -9 },
  { 113, 7, 8, 7, 0, -8 },
  { 120, 7, 8, 7, 0, -8 },
  { 127, 7, 8, 7, 0, -8 },
  { 134, 6, 8, 7, 1, -8 },
  { 140, 7, 9, 7, 0, -9 },
  { 148, 7, 9, 7, 0, -9 },
  { 156, 3, 6, 7, 2, -6 },
  { 159, 4, 8, 7, 1, -6 },
  { 163, 6, 5, 7, 1, -6 },
  { 167, 7, 4, 7, 0, -6 },
  { 171, 6, 5, 7, 0, -6 },
  { 175, 5, 9, 7, 2, -9 },
  { 181, 7, 11, 7, 0, -9 },
  { 191, 7, 8, 7, -1, -8 },
  { 198, 7, 8, 7, 0, -8 },
  { 205, 6, 9, 7, 1, -9 },
  { 212, 7, 8, 7, 0, -8 },
  { 219, 7, 8, 7, 0, -8 },
  { 226, 7, 8, 7, 0, -8 },
  { 233, 6, 9, 7, 1, -9 },
  { 240, 7, 8, 7, 0, -8 },
  { 247, 7, 8, 7, 0, -8 },
  { 254, 7, 8, 7, 0, -8 },
  { 261, 8, 8, 7, 0, -8 },
  { 269, 6, 8, 7, 0, -8 },
  { 275, 7, 8, 7, 0, -8 },
  { 282, 7, 8, 7, 0, -8 },
  { 289, 7, 9, 7, 0, -9 },
  { 297, 7, 8, 7, 0, -8 },
  { 304, 7, 11, 7, 0, -9 },
  { 314, 7, 8, 7, 0, -8 },
  { 321, 7, 9, 7, 0, -9 },
  { 329, 7, 8, 7, 1, -8 },
  { 336, 7, 8, 7, 0, -8 },
  { 343, 7, 8, 7, 1, -8 },
  { 350, 8, 8, 7, 0, -8 },
  { 358, 8, 8, 7, 0, -8 },
  { 366, 7, 8, 7, 1, -8 },
  { 373, 7, 8, 7, 0, -8 },
  { 380, 6, 11, 7, 1, -9 },
  { 389, 3, 11, 7, 2, -9 },
  { 394, 6, 11, 7, 0, -9 },
  { 403, 6, 5, 7, 1, -8 },
  { 407, 6, 1, 7, -1, 1 },
  { 408, 3, 2, 7, 3, -9 },
  { 409, 7, 6, 7, 0, -6 },
  { 415, 6, 9, 7, 0, -9 },
  { 422, 6, 6, 7, 1, -6 },
  { 427, 7, 9, 7, 0, -9 },
  { 435, 7, 6, 7, 0, -6 },
  { 441, 8, 11, 7, -1, -9 },
  { 452, 7, 8, 7, 0, -6 },
  { 459, 6, 9, 7, 0, -9 },
  { 466, 5, 9, 7, 1, -9 },
  { 472, 7, 11, 7, -1, -9 },
  { 482, 7, 9, 7, 0, -9 },
  { 490, 5, 9, 7, 1, -9 },
  { 496, 7, 6, 7, 0, -6 },
  { 502, 6, 6, 7, 0, -6 },
  { 507, 6, 6, 7, 0, -6 },
  { 512, 7, 8, 7, -1, -6 },
  { 519, 7, 8, 7, 0, -6 },
  { 526, 7, 6, 7, 0, -6 },
  { 532, 6, 6, 7, 0, -6 },
  { 537, 6, 8, 7, 1, -8 },
  { 543, 6, 6, 7, 1, -6 },
  { 548, 6, 6, 7, 1, -6 },
  { 553, 7, 6, 7, 0, -6 },
  { 559, 7, 6, 7, 0, -6 },
  { 565, 8, 8, 7, -1, -6 },
  { 573, 7, 6, 7, 0, -6 },
  { 579, 6, 11, 7, 1, -9 },
  { 588, 5, 11, 7, 1, -9 },
  { 595, 6, 11, 7, 0, -9 },
  { 604, 7, 3, 7, 0, -5 },
};

const GFXfont UbuntuSansMono_BoldItalic12pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic12pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic12pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _UBUNTUSANSMONO_BOLDITALIC12PT7B_H_
