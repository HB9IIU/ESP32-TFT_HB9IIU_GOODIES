#ifndef _UBUNTUSANSMONO_BOLDITALIC70PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0xFF,
  0xC1, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF, 0x07,
  0xFF, 0x1F, 0xF8, 0x3F, 0xF1, 0xFF, 0x81, 0xFF, 0x8F, 0xFC, 0x0F, 0xFC,
  0x7F, 0xE0, 0x7F, 0xC3, 0xFF, 0x03, 0xFE, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF,
  0x81, 0xFF, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x7F, 0xC1, 0xFE, 0x03,
  0xFC, 0x0F, 0xE0, 0x1F, 0xE0, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x07, 0xF0,
  0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFC, 0x00,
  0x78, 0x01, 0xFF, 0xC0, 0x00, 0x60, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x01, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0x00, 0x00,
  0xFF, 0xE0, 0x3F, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF7, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xBF, 0xC0, 0x07, 0xF0, 0x00, 0x7F,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0xFE,
  0x0F, 0xC0, 0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFC,
  0x1F, 0x81, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x83, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x87, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x7F, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF1, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE1, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x87, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x8F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x7F, 0xFF, 0x80, 0x00, 0x03,
  0xF8, 0x7F, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0xFE, 0x1F, 0x80, 0x00, 0x0F,
  0xF0, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0xFC, 0x1F, 0x80, 0x00, 0x1F,
  0xC1, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0x00, 0x7F,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFE,
  0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x7F, 0x81, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x1F, 0xE1,
  0xFF, 0x00, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFE, 0x03, 0xE0, 0x07, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F,
  0xFF, 0x01, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0x07, 0xFF, 0xFF, 0x87, 0xF8, 0x7F, 0xC7, 0xFE, 0x3F, 0x87, 0xFC, 0x1F,
  0xF3, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0xE3, 0xFC, 0x03, 0xFF, 0xFE, 0x3F,
  0xE0, 0x0F, 0xFF, 0xE1, 0xFF, 0x00, 0x7F, 0xFF, 0x0F, 0xF0, 0x01, 0xFF,
  0xF0, 0x7F, 0x80, 0x07, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xF8, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xF0,
  0x3F, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFB, 0xFE, 0x07,
  0xFF, 0xFF, 0x8F, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xC0, 0x3F, 0xFE, 0x03,
  0xFE, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x8F,
  0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x1F, 0xFC, 0x7F, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x38, 0x0F, 0xF0, 0x18, 0x3E,
  0x0F, 0xE0, 0x7C, 0x3F, 0x87, 0xE1, 0xFC, 0x7F, 0xC7, 0xE7, 0xFC, 0x7F,
  0xF7, 0xEF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0xC0, 0x07,
  0xFE, 0x7F, 0xE0, 0x0F, 0xFC, 0x7F, 0xF0, 0x1F, 0xFC, 0x3F, 0xF8, 0x0F,
  0xF8, 0x3F, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x20, 0x04, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xF9, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF,
  0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC1,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x07,
  0xF0, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x07,
  0xC0, 0x7F, 0xC3, 0xFF, 0x9F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x1F, 0xFC, 0x3F, 0xC0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xF9, 0xFF, 0xE0, 0x1F, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x3F, 0xE0,
  0xF8, 0x1F, 0xF3, 0xFE, 0x1F, 0xC1, 0xFF, 0x7F, 0xC1, 0xFC, 0x1F, 0xF7,
  0xFC, 0x3F, 0xE3, 0xFE, 0x7F, 0xC3, 0xFC, 0x3F, 0xE7, 0xFC, 0x3F, 0xC3,
  0xFE, 0x7F, 0x83, 0xFC, 0x3F, 0xEF, 0xF8, 0x3F, 0x83, 0xFE, 0xFF, 0x83,
  0xF8, 0x7F, 0xCF, 0xF8, 0x1E, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x7F, 0xCF,
  0xF8, 0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xF8, 0x00, 0x0F,
  0xF8, 0xFF, 0x80, 0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F, 0xFC, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xDF, 0xF0, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFE, 0x3F, 0xF0, 0x00, 0xF8,
  0x3F, 0xF0, 0x00, 0xC0, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0xFE, 0x00, 0x0F,
  0x00, 0x1F, 0xFC, 0x00, 0x18, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x43, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x10, 0x00, 0x00, 0xFF, 0xC0, 0x38, 0x00,
  0x07, 0xFF, 0x80, 0x7E, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xCF, 0xF8, 0x00, 0x00, 0xFF,
  0x9F, 0xF0, 0x00, 0x01, 0xFF, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x20, 0x00, 0x03, 0xFF, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xC0,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0xC0, 0x00, 0x07, 0xFC, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0xFF, 0xC0,
  0x00, 0xFF, 0x83, 0xFE, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0xFF, 0xC3, 0xFE, 0x00,
  0x03, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0xFF, 0xC0, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F,
  0xFC, 0x00, 0x3F, 0xFD, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xF3,
  0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x0F,
  0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x07, 0xFE,
  0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xF9, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x01, 0xFF,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x00, 0x7F, 0xC3, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0,
  0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF3, 0xFF, 0x00,
  0x00, 0x78, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFC,
  0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F, 0xF9, 0xFF, 0xFC, 0x3E, 0x00,
  0xFF, 0xF0, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFE, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3C, 0xFF, 0x07, 0xF0, 0x03, 0xFF,
  0xFF, 0x0F, 0xF0, 0x0F, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0xFF, 0xFE, 0x1F,
  0xE0, 0x3F, 0xFF, 0xFE, 0x1F, 0xE0, 0x7F, 0xFF, 0xFE, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xFC, 0x3F, 0x81, 0xFF, 0x83, 0xFC,
  0x3F, 0x81, 0xFF, 0x03, 0xFC, 0x3F, 0x83, 0xFE, 0x07, 0xFC, 0x3F, 0x83,
  0xFC, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0x07,
  0xF8, 0x7F, 0x07, 0xF8, 0x0F, 0xF8, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x7F,
  0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x0F, 0xF0,
  0x1F, 0xF0, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0,
  0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC0, 0xFF, 0x07, 0xFE, 0x3F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF,
  0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x7F,
  0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0xDF,
  0xE0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x3F, 0xE7, 0xF8, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xFC, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0xFF, 0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x03, 0xFE,
  0x7F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0xF0, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xF8, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0x81,
  0xFF, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00,
  0x1F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xE0, 0x03, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0x80, 0x1F, 0xFE, 0x00, 0x0E,
  0x00, 0xFF, 0xF0, 0x00, 0x08, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x10, 0x01, 0xFF,
  0xE0, 0x01, 0xC0, 0x07, 0xFF, 0xF9, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x03, 0xFF,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x1F,
  0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0xFF, 0x80, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x07,
  0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFF, 0x80, 0x7F, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0xC0, 0x01, 0xC0, 0x0F, 0xFE, 0x00,
  0x00, 0x80, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x03, 0xFF, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFE,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x30, 0x00, 0x1F, 0xF8, 0x00, 0x1C, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0x83, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x8F,
  0xFE, 0x00, 0x00, 0x1F, 0xF9, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF7, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xDF,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC7, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0,
  0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F,
  0xFE, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x07, 0xEF, 0xC0, 0x07, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x7F, 0x7E, 0x0F,
  0xDF, 0xC0, 0x07, 0xF7, 0xE0, 0xFD, 0xFC, 0x00, 0x7F, 0x7E, 0x1F, 0x9F,
  0xC0, 0x0F, 0xF3, 0xE1, 0xFB, 0xFC, 0x00, 0xFE, 0x3E, 0x3F, 0x3F, 0x80,
  0x0F, 0xE3, 0xE7, 0xF3, 0xF8, 0x01, 0xFE, 0x3E, 0x7E, 0x3F, 0x80, 0x1F,
  0xE3, 0xFF, 0xE7, 0xF8, 0x01, 0xFE, 0x3F, 0xFC, 0x7F, 0x80, 0x1F, 0xC3,
  0xFF, 0xC7, 0xF0, 0x03, 0xFC, 0x3F, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xFF,
  0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xF0, 0xFF, 0x00, 0x7F, 0x83, 0xFE, 0x0F,
  0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xF0,
  0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F,
  0xF0, 0x00, 0xFF, 0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xF3, 0xF8, 0x1F, 0xF0,
  0x01, 0xFF, 0x3F, 0x81, 0xFF, 0x00, 0x1F, 0xF3, 0xF8, 0x1F, 0xE0, 0x01,
  0xFE, 0x1F, 0xC1, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x3F, 0xE0, 0x03, 0xFE,
  0x1F, 0xC3, 0xFE, 0x00, 0x3F, 0xE1, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F,
  0xE3, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xE7,
  0xFC, 0x00, 0x7F, 0xC0, 0xFE, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xE7, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xFF, 0xF8, 0x00,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x3F,
  0xF0, 0x01, 0xFF, 0x83, 0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF1,
  0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00,
  0x7F, 0xE7, 0xFC, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xFB, 0xFF,
  0x00, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x7F,
  0xE7, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF9, 0xFF, 0x00,
  0x01, 0xFF, 0x8F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x07, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0xC3, 0xFF,
  0x00, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFF, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF0, 0x7F, 0xFF, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x0F,
  0xF8, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0x7F, 0xF0,
  0x0F, 0xFE, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x01, 0xFF, 0x83,
  0xFF, 0x80, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x01,
  0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFE,
  0x00, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF,
  0x9F, 0xF8, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFC, 0x00,
  0x03, 0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0x9F,
  0xF8, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x03,
  0xFF, 0x3F, 0xE0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x8F, 0xF8,
  0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xE7, 0xFE, 0x00, 0x07, 0xFE,
  0x3F, 0xF0, 0x00, 0x3F, 0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xFC, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF,
  0xE0, 0x1F, 0xFF, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x00,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFE, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x7F, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x0F,
  0xFC, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x30, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x10, 0x00, 0x00, 0xFF, 0xC0, 0x1C, 0x00,
  0x01, 0xFF, 0x80, 0x3F, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x03,
  0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xFE, 0x00,
  0x0F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F,
  0xF0, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x03,
  0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFF, 0x00, 0x01, 0xFF, 0x9F, 0xF8,
  0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x00, 0xFF, 0xC7, 0xFC, 0x00, 0x07, 0xFC,
  0x3F, 0xE0, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x7F, 0xC0, 0x01, 0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xF8, 0x1F,
  0xF0, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F,
  0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xFC, 0x07,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07,
  0xF8, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x01, 0xFF, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x7F, 0xC0, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x03, 0xFE,
  0x3F, 0xE0, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x00, 0xFF, 0x9F, 0xE0, 0x00,
  0x07, 0xFD, 0xFF, 0x00, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xF0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x03,
  0xFC, 0x3F, 0xE0, 0xFF, 0x00, 0x1F, 0xC1, 0xFF, 0x07, 0xF8, 0x01, 0xFE,
  0x1F, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0xC3, 0xFC, 0x00, 0x7F, 0x8F,
  0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0xF0, 0xFF, 0x00, 0x1F, 0xC7, 0xEF,
  0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0x7E, 0x3F, 0x80, 0x0F, 0xF3, 0xF3, 0xF3,
  0xFC, 0x00, 0x7F, 0x1F, 0x9F, 0x9F, 0xC0, 0x03, 0xF9, 0xF8, 0xFC, 0xFE,
  0x00, 0x1F, 0xDF, 0xC7, 0xE7, 0xF0, 0x00, 0xFE, 0xFC, 0x3F, 0x7F, 0x80,
  0x0F, 0xEF, 0xE1, 0xFB, 0xF8, 0x00, 0x7F, 0x7E, 0x0F, 0xDF, 0xC0, 0x03,
  0xFF, 0xF0, 0x7E, 0xFE, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x81, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC7, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xCF, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xEF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x03, 0xFF, 0x1F, 0xF0, 0x00,
  0x1F, 0xFC, 0x7F, 0xC0, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x03, 0xFF, 0x07,
  0xFC, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x7F,
  0xE0, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0x1F,
  0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x00, 0xFF, 0x8F, 0xFC,
  0x00, 0x03, 0xFE, 0x7F, 0xE0, 0x00, 0x0F, 0xF9, 0xFF, 0x00, 0x00, 0x3F,
  0xEF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFE, 0x07, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03,
  0xFF, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xBF, 0xF0, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0x07, 0xFF, 0x3F, 0xF0, 0x00, 0xFF, 0xE1, 0xFF, 0x80, 0x1F, 0xFC,
  0x1F, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x07,
  0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFC, 0x1F, 0xFC, 0x00, 0x7F,
  0xE3, 0xFF, 0x80, 0x07, 0xFE, 0x7F, 0xF0, 0x00, 0x7F, 0xEF, 0xFE, 0x00,
  0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x3F, 0xF3, 0xFC, 0x00, 0x03, 0xFE, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x30, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x08, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x07,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x0F, 0xFF, 0x00, 0x7F, 0xC1, 0xFF,
  0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xC3, 0xFF, 0x80, 0x0F, 0xFC,
  0x3F, 0xF0, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0xE0, 0x01,
  0xFF, 0x87, 0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xC0, 0x01, 0xFF, 0x0F, 0xFC,
  0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07,
  0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFE, 0x07, 0xFE, 0x01, 0xFF, 0xE0,
  0x7F, 0xF8, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF1, 0xFF, 0x00, 0x3F, 0xFC, 0x1F, 0xE0,
  0x00, 0x7E, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x40, 0x00, 0x07, 0xFC,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFC,
  0x07, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0xE0, 0x01, 0xFF, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xE0,
  0x01, 0xFF, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x0F,
  0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x3F,
  0xE1, 0xFF, 0x80, 0x07, 0xFE, 0x1F, 0xF8, 0x00, 0x7F, 0xE1, 0xFF, 0x80,
  0x0F, 0xFC, 0x1F, 0xF0, 0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x1F, 0xF8, 0x3F,
  0xF0, 0x03, 0xFF, 0x83, 0xFF, 0x00, 0xFF, 0xF0, 0x3F, 0xF0, 0x7F, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x10, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFF,
  0xC0, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE3, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x0F, 0xF0, 0x00, 0x01, 0xF8,
  0x02, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xE1, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x00, 0xFF, 0x8F, 0xFC, 0x00, 0x1F, 0xF3, 0xFF, 0x00, 0x03, 0xFE,
  0x7F, 0xC0, 0x00, 0xFF, 0xCF, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F,
  0xFE, 0x7F, 0xC0, 0x03, 0xFF, 0x8F, 0xF8, 0x07, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x10, 0x1F, 0xFF, 0x00, 0x3E, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x0C, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x08, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x83, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x8F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE7, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x07, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE1, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03,
  0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8,
  0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x81,
  0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0,
  0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x08, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x20, 0x00, 0xFF, 0xE0, 0x00, 0x70, 0x03, 0xFF, 0x80,
  0x01, 0xFC, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x0F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x01,
  0xFF, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x00, 0x7F,
  0xE1, 0xFF, 0xC0, 0x00, 0x3F, 0xE1, 0xFF, 0xC0, 0x00, 0x3F, 0xF1, 0xFF,
  0xC0, 0x00, 0x1F, 0xFB, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x00, 0x00,
  0x3F, 0xF3, 0xFF, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x07,
  0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x18, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x3F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFE, 0x1F, 0xE1, 0xFF, 0x01, 0xFC, 0x1F, 0xE0, 0xFE, 0x03,
  0xFC, 0x1F, 0xE0, 0xFE, 0x03, 0xFC, 0x1F, 0xC1, 0xFE, 0x03, 0xFC, 0x1F,
  0xC1, 0xFE, 0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x3F, 0xC1, 0xFE,
  0x07, 0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x3F, 0x83, 0xFC, 0x07, 0xF0,
  0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x0F, 0xF0, 0x7F, 0x83,
  0xF8, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0xFF, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0xF8, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x07,
  0xFE, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x07, 0xFC, 0x0F, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x0F, 0xF8, 0x1F, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x1F,
  0xF8, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xF0,
  0x03, 0xFF, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x03, 0xFF, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00, 0x7F,
  0xE0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x3F, 0xF8, 0x03, 0xFF, 0x0F, 0xFE,
  0x00, 0x7F, 0xF1, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0xCF,
  0xFC, 0x00, 0x1F, 0xF9, 0xFF, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x00, 0x7F,
  0xEF, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x00, 0x01, 0xFF, 0x3F, 0xE0, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x0F, 0xFD, 0xFF, 0x80, 0x01, 0xFF, 0xBF, 0xF0,
  0x00, 0x3F, 0xF7, 0xFE, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x01, 0xFF, 0x9F,
  0xF8, 0x00, 0x3F, 0xE3, 0xFF, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x03, 0xFF,
  0x8F, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xE0, 0x3F, 0xF8, 0x1F, 0xFF, 0x3F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xF8, 0x3F, 0xFE, 0x00, 0x3F,
  0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x7F, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x01,
  0xFF, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x07,
  0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0xFC, 0x3F, 0xF8,
  0x00, 0xFF, 0xC3, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x87,
  0xFE, 0x00, 0x1F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF, 0x87, 0xFC, 0x00, 0x1F,
  0xF0, 0xFF, 0xC0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0,
  0x03, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x07, 0xFE, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xC0,
  0x0F, 0xFC, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xF9, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFB, 0xFF, 0x00, 0x00, 0x78, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x10, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x3F, 0x80, 0x1F, 0xF8, 0x00, 0x30, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x18, 0x00, 0x07, 0xFE,
  0x01, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83, 0xFE,
  0x00, 0x3F, 0xE0, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xF8, 0x01, 0xFF, 0x83,
  0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xF8, 0x00,
  0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x0F, 0xFC,
  0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xE0, 0x03, 0xFE, 0x0F,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03, 0xFF,
  0x07, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x80, 0x1F, 0xF8, 0x3F, 0xF0, 0x03,
  0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x0F, 0xFC, 0x1F, 0xF8,
  0x01, 0xFF, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF, 0xF3, 0xFF, 0x00, 0x7F,
  0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x04, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x07, 0xFE, 0x7F, 0xC0, 0x00, 0xFF, 0xE7, 0xFC, 0x00,
  0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xF8, 0x7F,
  0xE0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xE0, 0x03, 0xFF,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x07, 0xFE, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x3F, 0xF0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xE0, 0x03, 0xFF, 0x07,
  0xFC, 0x00, 0x3F, 0xF0, 0xFF, 0xC0, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x1F,
  0xF1, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xF0, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x01, 0xFF, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x3F,
  0xC0, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0xFE,
  0x07, 0xF8, 0x3F, 0x81, 0xFE, 0x07, 0xF8, 0x7F, 0x81, 0xFE, 0x07, 0xF0,
  0x7F, 0x83, 0xFF, 0x0F, 0xF0, 0x7F, 0x83, 0xFF, 0x0F, 0xF0, 0x7F, 0x87,
  0xFF, 0x0F, 0xE0, 0x7F, 0x07, 0xFF, 0x0F, 0xE0, 0x7F, 0x0F, 0xFF, 0x1F,
  0xE0, 0x7F, 0x0F, 0xFF, 0x1F, 0xC0, 0x7F, 0x1F, 0xFF, 0x1F, 0xC0, 0x7F,
  0x1F, 0xBF, 0x3F, 0xC0, 0x7F, 0x3F, 0xBF, 0x3F, 0x80, 0x7F, 0x3F, 0x3F,
  0x3F, 0x80, 0x7E, 0x7F, 0x3F, 0x7F, 0x00, 0xFE, 0xFE, 0x3F, 0x7F, 0x00,
  0xFE, 0xFE, 0x3F, 0x7F, 0x00, 0xFF, 0xFC, 0x3F, 0xFE, 0x00, 0xFF, 0xF8,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x81, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0x00,
  0x03, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFD, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x8F, 0xFC, 0x00, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x83, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF1, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xCF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x60,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0xFE, 0x01,
  0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0x1F, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xF8, 0x3F, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x38, 0x00, 0x3F, 0xE0,
  0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 39, 0, -1 },
  { 1, 22, 50, 39, 10, -49 },
  { 139, 29, 22, 39, 12, -53 },
  { 219, 42, 49, 39, 0, -49 },
  { 477, 38, 62, 39, 1, -54 },
  { 772, 48, 51, 39, -3, -50 },
  { 1078, 37, 51, 39, 1, -50 },
  { 1314, 14, 23, 39, 19, -53 },
  { 1355, 31, 69, 39, 8, -56 },
  { 1623, 32, 69, 39, 0, -56 },
  { 1899, 32, 31, 39, 7, -49 },
  { 2023, 35, 35, 39, 2, -38 },
  { 2177, 19, 25, 39, 5, -13 },
  { 2237, 24, 10, 39, 8, -25 },
  { 2267, 14, 14, 39, 10, -13 },
  { 2292, 47, 68, 39, -4, -55 },
  { 2692, 36, 51, 39, 3, -50 },
  { 2922, 32, 49, 39, 2, -49 },
  { 3118, 39, 50, 39, 0, -50 },
  { 3362, 39, 51, 39, -1, -50 },
  { 3611, 40, 49, 39, 0, -49 },
  { 3856, 41, 50, 39, 0, -49 },
  { 4113, 38, 50, 39, 3, -49 },
  { 4351, 38, 49, 39, 6, -49 },
  { 4584, 37, 51, 39, 2, -50 },
  { 4820, 38, 50, 39, 1, -50 },
  { 5058, 19, 38, 39, 10, -37 },
  { 5149, 24, 49, 39, 5, -37 },
  { 5296, 36, 34, 39, 3, -37 },
  { 5449, 38, 23, 39, 1, -32 },
  { 5559, 36, 34, 39, 1, -37 },
  { 5712, 30, 51, 39, 9, -50 },
  { 5904, 40, 61, 39, 1, -50 },
  { 6209, 37, 49, 39, -3, -49 },
  { 6436, 39, 50, 39, 0, -49 },
  { 6680, 38, 51, 39, 4, -50 },
  { 6923, 39, 50, 39, 0, -49 },
  { 7167, 41, 49, 39, 1, -49 },
  { 7419, 41, 49, 39, 2, -49 },
  { 7671, 39, 51, 39, 3, -50 },
  { 7920, 44, 49, 39, -1, -49 },
  { 8190, 42, 49, 39, 0, -49 },
  { 8448, 41, 50, 39, 0, -49 },
  { 8705, 44, 49, 39, 0, -49 },
  { 8975, 32, 49, 39, 1, -49 },
  { 9171, 44, 49, 39, -2, -49 },
  { 9441, 44, 49, 39, -1, -49 },
  { 9711, 37, 51, 39, 2, -50 },
  { 9947, 41, 49, 39, 0, -49 },
  { 10199, 37, 63, 39, 2, -50 },
  { 10491, 39, 49, 39, 0, -49 },
  { 10730, 40, 51, 39, 0, -50 },
  { 10985, 37, 49, 39, 7, -49 },
  { 11212, 40, 50, 39, 2, -49 },
  { 11462, 37, 49, 39, 8, -49 },
  { 11689, 45, 49, 39, 0, -49 },
  { 11965, 48, 49, 39, -3, -49 },
  { 12259, 38, 49, 39, 8, -49 },
  { 12492, 43, 49, 39, -1, -49 },
  { 12756, 38, 68, 39, 4, -55 },
  { 13079, 16, 68, 39, 13, -55 },
  { 13215, 38, 68, 39, -2, -55 },
  { 13538, 36, 29, 39, 3, -49 },
  { 13669, 38, 8, 39, -6, 5 },
  { 13707, 17, 14, 39, 16, -54 },
  { 13737, 36, 39, 39, 2, -38 },
  { 13913, 36, 55, 39, 0, -54 },
  { 14161, 36, 39, 39, 3, -38 },
  { 14337, 41, 55, 39, 2, -54 },
  { 14619, 35, 39, 39, 3, -38 },
  { 14790, 49, 67, 39, -6, -54 },
  { 15201, 42, 51, 39, -3, -38 },
  { 15469, 36, 54, 39, 0, -54 },
  { 15712, 27, 56, 39, 6, -55 },
  { 15901, 39, 68, 39, -3, -55 },
  { 16233, 41, 54, 39, 1, -54 },
  { 16510, 25, 55, 39, 8, -54 },
  { 16682, 40, 37, 39, -1, -37 },
  { 16867, 36, 38, 39, 0, -38 },
  { 17038, 35, 39, 39, 2, -38 },
  { 17209, 40, 51, 39, -3, -38 },
  { 17464, 36, 51, 39, 3, -38 },
  { 17694, 37, 38, 39, 2, -38 },
  { 17870, 36, 39, 39, 1, -38 },
  { 18046, 33, 49, 39, 6, -48 },
  { 18249, 35, 38, 39, 3, -37 },
  { 18416, 36, 37, 39, 5, -37 },
  { 18583, 40, 37, 39, 2, -37 },
  { 18768, 42, 37, 39, -2, -37 },
  { 18963, 46, 50, 39, -6, -37 },
  { 19251, 38, 37, 39, 1, -37 },
  { 19427, 37, 68, 39, 5, -55 },
  { 19742, 26, 68, 39, 7, -55 },
  { 19963, 38, 68, 39, -3, -55 },
  { 20286, 38, 14, 39, 1, -28 },
};

const GFXfont UbuntuSansMono_BoldItalic70pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic70pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic70pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _UBUNTUSANSMONO_BOLDITALIC70PT7B_H_
