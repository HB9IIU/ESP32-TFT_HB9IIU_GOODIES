#ifndef _UBUNTUSANSMONO_BOLDITALIC37PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x07, 0xC0, 0x3E, 0x3E, 0x7C, 0x7D, 0xF9, 0xFB, 0xE3, 0xF7,
  0xC7, 0xCF, 0x8F, 0x9E, 0x1F, 0x3C, 0x3C, 0x78, 0x78, 0xE0, 0xE3, 0xC1,
  0xC7, 0x03, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80,
  0x1E, 0x3E, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x1E, 0x07, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0xF1, 0xE0,
  0x07, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xC0, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x3C, 0x3C,
  0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3E, 0x00, 0xF8, 0xF0, 0x03,
  0xC7, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xE0, 0xE0, 0x7E, 0x01, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x06, 0x01, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x07, 0x81, 0xF8, 0x07,
  0x81, 0xFE, 0x07, 0x81, 0xE7, 0x07, 0x80, 0xE3, 0x83, 0x80, 0x71, 0xC3,
  0x80, 0x78, 0xE3, 0xC0, 0x38, 0xE3, 0xC0, 0x1C, 0x73, 0xC0, 0x0F, 0xFB,
  0xC0, 0x03, 0xF9, 0xC0, 0x01, 0xF9, 0xC0, 0x00, 0x31, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE7, 0xC0, 0x01, 0xE7, 0xF0, 0x00, 0xE7, 0xF8, 0x00,
  0xE7, 0x9C, 0x00, 0xF3, 0x8E, 0x00, 0xF1, 0xC7, 0x00, 0xF0, 0xE3, 0x80,
  0xF0, 0xF3, 0xC0, 0x70, 0x79, 0xC0, 0x70, 0x3F, 0xE0, 0x78, 0x0F, 0xE0,
  0x78, 0x07, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xF8,
  0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0x83,
  0xC0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0x7C, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0xE0, 0xFF, 0x0F, 0x1F, 0xF8, 0xF3, 0xEF, 0x9E, 0x7C,
  0x7D, 0xE7, 0x83, 0xFC, 0x78, 0x3F, 0xCF, 0x81, 0xF8, 0xF8, 0x0F, 0x8F,
  0x83, 0xF8, 0x7E, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xF7, 0xC1, 0xFC, 0x3E,
  0x3E, 0xFD, 0xFB, 0xE7, 0xCF, 0xBE, 0x7C, 0xF9, 0xE3, 0xC7, 0x00, 0x00,
  0x06, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xC0, 0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x04, 0x00, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x06, 0x3C, 0x67, 0xDE, 0xFB, 0xF6, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x81, 0xE0, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xE7,
  0xC3, 0xF3, 0xF0, 0xF8, 0xF0, 0x18, 0x60, 0x04, 0x20, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x81, 0xF8, 0x3F, 0x0F, 0xF1, 0xFC,
  0x3F, 0x83, 0xF0, 0x1E, 0x07, 0x83, 0xF3, 0xFC, 0x3E, 0x07, 0x00, 0x7F,
  0xFB, 0xFF, 0x9F, 0xFC, 0xFF, 0xEF, 0xFF, 0x00, 0x3C, 0x7E, 0x7E, 0xFF,
  0xFE, 0xFE, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F,
  0x01, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3C, 0x71, 0xE7,
  0xCF, 0x9E, 0x7C, 0xF3, 0xE7, 0xCF, 0x3E, 0x78, 0xF3, 0xE7, 0x80, 0x3E,
  0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0xF8, 0x78, 0x1F,
  0x87, 0xC3, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF,
  0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xF0, 0x7F, 0xF8, 0x7F, 0xF8, 0x1F, 0x7C, 0x0E, 0x3E, 0x04,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x81, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x80,
  0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xC3,
  0xF0, 0x30, 0x1F, 0x02, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xFC, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x03, 0x83, 0xF0, 0x20, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC6, 0x01, 0xF8,
  0x7F, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0x80, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0x7C, 0x00, 0xF3,
  0xE0, 0x0F, 0x1F, 0x00, 0xF0, 0xF8, 0x0F, 0x07, 0x80, 0xF0, 0x7C, 0x0F,
  0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF0, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x81,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x30, 0x0F, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x03, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7D, 0xFC,
  0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF8, 0x0F, 0x8F, 0x80,
  0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0xF8,
  0x0F, 0x8F, 0xC1, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC3, 0xF0, 0xF8,
  0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F,
  0xCF, 0xC0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03,
  0xE1, 0xF8, 0x7C, 0x0F, 0x87, 0x80, 0xFC, 0xF8, 0x07, 0xCF, 0x80, 0x7C,
  0xF8, 0x0F, 0x8F, 0xC1, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xFE,
  0x01, 0xFF, 0x80, 0x03, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x87, 0xE1, 0xF0, 0x3E, 0x3E, 0x03, 0xE3,
  0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x3E,
  0x3F, 0xDF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x07,
  0x81, 0xF8, 0x3F, 0x0F, 0xF1, 0xFC, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F, 0x83, 0xF0, 0xFF, 0x1F, 0xC3,
  0xF8, 0x3E, 0x00, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFC,
  0x03, 0xF0, 0x03, 0xC0, 0x1E, 0x01, 0xF8, 0x3F, 0xC0, 0x7C, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x1F,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0x80,
  0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0xC0, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0xC0, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x80, 0x08, 0x00, 0x03, 0x80, 0x00, 0x7E, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xFF,
  0xE0, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x0F,
  0xF8, 0xFF, 0xF8, 0xFF, 0xF9, 0xFF, 0xF3, 0x87, 0xE4, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0xE7, 0xE0, 0xF8,
  0x0F, 0x07, 0x80, 0x7C, 0x78, 0x03, 0xE7, 0xC0, 0x1F, 0x3C, 0x1F, 0xF3,
  0xC3, 0xFF, 0x9E, 0x3F, 0xFC, 0xF1, 0xFF, 0xE7, 0x1F, 0x1F, 0x78, 0xF0,
  0xF3, 0xC7, 0x87, 0x9E, 0x7C, 0x7C, 0xF3, 0xC3, 0xE7, 0x9E, 0x1E, 0x3C,
  0xF0, 0xF1, 0xE7, 0xCF, 0x8F, 0x3F, 0x7C, 0x78, 0xFF, 0xC3, 0xC7, 0xFE,
  0x1E, 0x1F, 0xF0, 0xF0, 0x18, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFE,
  0x04, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFE, 0x00, 0x3D, 0xE0, 0x07, 0xDE, 0x00, 0x79, 0xF0, 0x0F,
  0x9F, 0x00, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xE1, 0xF0, 0x3E, 0x1F, 0x03,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x1F, 0x01, 0xF3, 0xE0, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x7C, 0x3F, 0x03, 0xE0, 0xFC, 0x1F, 0x03, 0xE1,
  0xF0, 0x1F, 0x0F, 0x81, 0xF0, 0x7C, 0x1F, 0x83, 0xE7, 0xF8, 0x3F, 0xFF,
  0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xC0, 0xFC, 0x3E,
  0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x7E,
  0x3E, 0x0F, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xE1, 0xE1, 0xFC, 0x02, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x60, 0x7F, 0xFE, 0x03,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x7C,
  0x3F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1F, 0x1F,
  0x81, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3F, 0x03, 0xF3,
  0xE0, 0x3F, 0x3E, 0x03, 0xE3, 0xE0, 0x7E, 0x7E, 0x07, 0xC7, 0xC0, 0xFC,
  0x7C, 0x1F, 0x87, 0xC7, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80,
  0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F, 0xE1,
  0xE1, 0xF8, 0x02, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xFC, 0x1F, 0x0F, 0xC1, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x0F,
  0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF8,
  0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x3F, 0x03,
  0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x0F, 0xC1,
  0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x3E,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x3F, 0x00, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x20, 0x1F, 0x80, 0xE0, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x1F, 0x03, 0xF0, 0x3E,
  0x0F, 0xC0, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x03, 0xF1, 0xF8, 0x07, 0xC7,
  0xE0, 0x0F, 0x9F, 0x80, 0x1F, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x3E, 0x00,
  0x3E, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xFC, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xE0, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x83,
  0xF0, 0x3F, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x7F, 0x03, 0xF8, 0xEE,
  0x07, 0x73, 0xFC, 0x1E, 0xE7, 0x78, 0x3D, 0xDE, 0xF0, 0x7B, 0xB9, 0xE1,
  0xF7, 0xF7, 0x83, 0xCF, 0xCF, 0x07, 0x8F, 0x9E, 0x0F, 0x1E, 0x3C, 0x3E,
  0x38, 0xF8, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x1F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x03,
  0xE1, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x78, 0x1F, 0x80,
  0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07, 0xC1, 0xFE, 0x0F, 0x03, 0xFC, 0x1E,
  0x07, 0xF8, 0x7C, 0x0F, 0x70, 0xF8, 0x3E, 0xF1, 0xF0, 0x7D, 0xE3, 0xC0,
  0xFB, 0xC7, 0x81, 0xE3, 0x9F, 0x07, 0xC7, 0xBE, 0x0F, 0x8F, 0x78, 0x1F,
  0x1E, 0xF0, 0x3C, 0x1F, 0xE0, 0x78, 0x3F, 0xC1, 0xF0, 0x7F, 0x03, 0xE0,
  0xFE, 0x07, 0x81, 0xFC, 0x0F, 0x01, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xE7, 0xE0, 0xF8, 0x3F, 0x1F, 0x01,
  0xF3, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1F, 0x7E, 0x01, 0xF7, 0xC0,
  0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xEF, 0xC0, 0x3E, 0xF8,
  0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF, 0x80, 0xF8, 0xFC, 0x1F, 0x87,
  0xC3, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x00,
  0x01, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xE1, 0xF8, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xF1, 0xF0,
  0x7F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFC, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xFE, 0x0F, 0xE7,
  0xE0, 0xF8, 0x3F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0,
  0x1F, 0x7E, 0x01, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xEF, 0xC0, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x0F, 0xCF,
  0x80, 0xF8, 0xFC, 0x1F, 0x87, 0xC3, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0,
  0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x00, 0x01,
  0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7C, 0x7F,
  0x03, 0xE0, 0xF8, 0x3F, 0x07, 0xE1, 0xF0, 0x3F, 0x0F, 0x81, 0xF0, 0x7C,
  0x0F, 0x83, 0xE0, 0xFC, 0x3E, 0x0F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xF1, 0xF0, 0x0F, 0x87,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x1F,
  0x81, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x00, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7E, 0x0F, 0x07, 0xE0, 0x10,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x84, 0x00, 0x7C, 0x38, 0x0F, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xF8,
  0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x0F, 0x80,
  0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x80, 0xF8, 0x7C, 0x0F, 0xC7, 0xE0, 0x7C, 0x3E, 0x03, 0xE1, 0xF0,
  0x3F, 0x0F, 0x81, 0xF0, 0x7E, 0x1F, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x40, 0x00, 0xF8, 0x01, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x78, 0x07, 0x8F, 0x80,
  0x78, 0xF0, 0x07, 0x9F, 0x00, 0x79, 0xE0, 0x07, 0xBE, 0x00, 0x7B, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x80,
  0x3E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x1F, 0x00,
  0x7C, 0x1E, 0x00, 0x78, 0x1E, 0x3C, 0x78, 0x1E, 0x3C, 0x78, 0x3E, 0x7C,
  0xF8, 0x3C, 0x7C, 0xF0, 0x3C, 0xFC, 0xF0, 0x3C, 0xFC, 0xF0, 0x3D, 0xDC,
  0xF0, 0x3B, 0xDD, 0xE0, 0x7B, 0x9D, 0xE0, 0x7F, 0x9D, 0xE0, 0x7F, 0x1D,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x0F, 0x80, 0xFC, 0x0F,
  0x80, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0x1F, 0x81, 0xF0,
  0x0F, 0x80, 0xFC, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x07,
  0xC7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xF7, 0xC0, 0x01, 0xF9, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x3E, 0x7C, 0x07,
  0xE7, 0xC0, 0x7C, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x1F, 0x03, 0xC3,
  0xF0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF,
  0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0xF8, 0x78, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1F, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x3C,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0xC0, 0x7E, 0x7C, 0x1F, 0x8F, 0x87, 0xE1, 0xF0, 0xF8, 0x3F,
  0x3E, 0x03, 0xEF, 0xC0, 0x7C, 0xF0, 0x0F, 0xCC, 0x00, 0xC0, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x20,
  0x18, 0x1F, 0x0F, 0xCF, 0xF0, 0xFC, 0x1E, 0x06, 0x00, 0x7F, 0x00, 0x3F,
  0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xFE, 0x7C, 0x7E, 0x0F, 0x8F, 0x81,
  0xF3, 0xE0, 0x3E, 0x7C, 0x0F, 0xDF, 0x81, 0xF3, 0xE0, 0x3E, 0x7C, 0x07,
  0xCF, 0x81, 0xF9, 0xF0, 0x3E, 0x3E, 0x07, 0xC7, 0xE1, 0xF8, 0x7F, 0xFF,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xE7, 0xC0, 0x00, 0x30, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFB, 0xC0, 0x3F, 0xFE, 0x07, 0xFF,
  0xE0, 0xFF, 0xFE, 0x1F, 0xDF, 0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03,
  0xE3, 0xE0, 0x7C, 0xFC, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F,
  0xDF, 0x81, 0xF3, 0xE0, 0x7E, 0x7C, 0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8,
  0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF,
  0xF0, 0x7F, 0xFC, 0x7F, 0xFE, 0x3F, 0xF7, 0x8F, 0xC0, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x18, 0xFF, 0xFE, 0x1F, 0xFF,
  0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x01,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0x9F, 0x03, 0xF0, 0x7C, 0x0F, 0x81,
  0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3F, 0x0F, 0xC0, 0xF8, 0x3E, 0x03, 0xE0,
  0xF8, 0x0F, 0x83, 0xE0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC,
  0x3F, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xCF,
  0x80, 0x00, 0xFE, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0x8F,
  0xDF, 0x81, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x1F, 0xBF, 0xFF, 0xEF,
  0xFF, 0xF3, 0xFF, 0xF0, 0xFF, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x08, 0xFF, 0xFE, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x40, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x87, 0xC0, 0xFC, 0x1F,
  0x81, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xF0,
  0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xFB, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x01,
  0x9F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x04, 0x01, 0xF0, 0x0F, 0x9F,
  0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xE0,
  0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83,
  0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xF1, 0xF0, 0x7E, 0x3E, 0x0F, 0x8F, 0x81, 0xF0, 0x00, 0xF0,
  0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x47, 0xFE, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x84, 0x7F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x81, 0xF8, 0x0F, 0xBF,
  0x80, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x43, 0xE0, 0xFC, 0x1F, 0x0F, 0xC0, 0xF8, 0xFC, 0x0F, 0xCF,
  0xC0, 0x7C, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xEF, 0x80, 0x3F, 0x7E, 0x01, 0xF1, 0xF0,
  0x0F, 0x8F, 0xC0, 0x7C, 0x3E, 0x03, 0xE1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0,
  0x3F, 0x0F, 0x81, 0xF8, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xF8, 0xFF, 0xCF,
  0xFE, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x09, 0xFF, 0xCF,
  0xFE, 0x3F, 0xF0, 0xFF, 0x80, 0x00, 0xE0, 0x60, 0x3F, 0xDF, 0x81, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0xF3, 0xE7, 0x87, 0x8F, 0x3C, 0x3C, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0xF8, 0xF1, 0xE7, 0x87, 0x9E, 0x3C, 0x7C, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x78,
  0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0xF1, 0xF0, 0x07, 0x80, 0x00, 0xFF,
  0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x0F,
  0xC7, 0xE0, 0xF8, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F,
  0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x1F, 0x8F, 0x83, 0xE3, 0xE0, 0x7C,
  0x7C, 0x0F, 0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x7C, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0xDF, 0xCF, 0xC1, 0xF3,
  0xE0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xEF, 0xC1, 0xFB, 0xF0, 0xFC, 0x7F, 0xFE,
  0x1F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3E, 0x3F, 0x81,
  0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC3, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x1F, 0x87, 0xC1, 0xF8, 0x7C,
  0x1F, 0xC3, 0xE1, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7F, 0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0xE7, 0xE3, 0xF8, 0x7E,
  0x3E, 0x07, 0xC7, 0xE0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0xFC, 0x7C, 0x0F,
  0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x8F, 0xC0, 0xF8, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xF8, 0x04, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC,
  0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0x7E, 0x1C, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE1, 0x80, 0xFC, 0x3F, 0xFF, 0x8F,
  0xFF, 0xE3, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x08, 0x00, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x41, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF8,
  0x0F, 0xFC, 0x00, 0x3F, 0x07, 0xCF, 0x81, 0xF3, 0xE0, 0xFC, 0xF8, 0x3E,
  0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0xC1, 0xF9, 0xF0, 0x7C, 0xF8, 0x1F, 0x3E,
  0x07, 0xCF, 0x83, 0xF3, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0x87,
  0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0xF9, 0xF0, 0xF8, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0xFB, 0xE0, 0x7E, 0xF8, 0x1F, 0x3E, 0x07, 0xCF,
  0x83, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xCF, 0x81, 0xF7,
  0xE0, 0x7D, 0xF0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7B, 0xE0, 0x07, 0xDF, 0x00,
  0x3C, 0xF0, 0xE1, 0xE7, 0x8F, 0x0F, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F,
  0x3F, 0x3C, 0x71, 0xF9, 0xC7, 0x9D, 0xDE, 0x3C, 0xEE, 0xF1, 0xEE, 0x77,
  0x0F, 0xF3, 0xF8, 0x7F, 0x1F, 0xC3, 0xF8, 0xFC, 0x1F, 0x87, 0xE0, 0xFC,
  0x3E, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x00, 0x0F, 0xC0, 0xFC, 0x1F, 0x07,
  0xE0, 0x7E, 0x1F, 0x00, 0xF8, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0x7E, 0x00, 0xF8, 0xF8,
  0x07, 0xE3, 0xF0, 0x3F, 0x07, 0xC1, 0xF8, 0x1F, 0x0F, 0xC0, 0x7E, 0x00,
  0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x7E,
  0x03, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF3, 0xE0, 0x01, 0xF3, 0xE0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x67, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xF8, 0x7F, 0xFF,
  0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xF0,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xFF,
  0xE0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x00, 0x83,
  0xF8, 0x3C, 0xFF, 0xC7, 0xBF, 0xFF, 0xEF, 0xFF, 0xFD, 0xE3, 0xFF, 0x3C,
  0x1F, 0xC1, 0x00, 0xE0,
};

const GFXglyph UbuntuSansMono_BoldItalic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 12, 26, 21, 5, -26 },
  { 40, 15, 12, 21, 6, -28 },
  { 63, 22, 26, 21, 0, -26 },
  { 135, 21, 33, 21, 0, -29 },
  { 222, 25, 27, 21, -1, -26 },
  { 307, 20, 26, 21, 0, -26 },
  { 372, 7, 12, 21, 10, -28 },
  { 383, 17, 36, 21, 4, -29 },
  { 460, 17, 36, 21, 0, -29 },
  { 537, 17, 17, 21, 4, -26 },
  { 574, 19, 18, 21, 1, -20 },
  { 617, 11, 13, 21, 2, -7 },
  { 635, 13, 5, 21, 4, -13 },
  { 644, 8, 7, 21, 5, -7 },
  { 651, 25, 36, 21, -2, -29 },
  { 764, 20, 27, 21, 1, -26 },
  { 832, 17, 26, 21, 1, -26 },
  { 888, 20, 26, 21, 0, -26 },
  { 953, 20, 27, 21, 0, -26 },
  { 1021, 21, 26, 21, 0, -26 },
  { 1090, 21, 27, 21, 0, -26 },
  { 1161, 20, 27, 21, 2, -26 },
  { 1229, 20, 26, 21, 3, -26 },
  { 1294, 20, 27, 21, 1, -26 },
  { 1362, 20, 26, 21, 1, -26 },
  { 1427, 11, 20, 21, 5, -20 },
  { 1455, 14, 26, 21, 2, -20 },
  { 1501, 19, 18, 21, 2, -20 },
  { 1544, 21, 12, 21, 0, -17 },
  { 1576, 19, 18, 21, 1, -20 },
  { 1619, 15, 26, 21, 5, -26 },
  { 1668, 21, 32, 21, 1, -26 },
  { 1752, 20, 26, 21, -2, -26 },
  { 1817, 21, 26, 21, 0, -26 },
  { 1886, 20, 27, 21, 2, -26 },
  { 1954, 20, 26, 21, 0, -26 },
  { 2019, 21, 26, 21, 1, -26 },
  { 2088, 22, 26, 21, 1, -26 },
  { 2160, 20, 27, 21, 2, -26 },
  { 2228, 23, 26, 21, 0, -26 },
  { 2303, 22, 26, 21, 0, -26 },
  { 2375, 22, 27, 21, 0, -26 },
  { 2450, 23, 26, 21, 0, -26 },
  { 2525, 17, 26, 21, 0, -26 },
  { 2581, 23, 26, 21, -1, -26 },
  { 2656, 23, 26, 21, 0, -26 },
  { 2731, 20, 27, 21, 1, -26 },
  { 2799, 21, 26, 21, 0, -26 },
  { 2868, 20, 33, 21, 1, -26 },
  { 2951, 21, 26, 21, 0, -26 },
  { 3020, 21, 27, 21, 0, -26 },
  { 3091, 19, 26, 21, 4, -26 },
  { 3153, 21, 27, 21, 1, -26 },
  { 3224, 20, 26, 21, 4, -26 },
  { 3289, 24, 26, 21, 0, -26 },
  { 3367, 25, 26, 21, -1, -26 },
  { 3449, 20, 26, 21, 4, -26 },
  { 3514, 22, 26, 21, 0, -26 },
  { 3586, 20, 36, 21, 2, -29 },
  { 3676, 8, 36, 21, 7, -29 },
  { 3712, 20, 36, 21, -1, -29 },
  { 3802, 19, 15, 21, 2, -26 },
  { 3838, 20, 5, 21, -3, 2 },
  { 3851, 9, 8, 21, 8, -29 },
  { 3860, 19, 20, 21, 1, -20 },
  { 3908, 19, 30, 21, 0, -29 },
  { 3980, 18, 20, 21, 2, -20 },
  { 4025, 22, 29, 21, 1, -29 },
  { 4105, 18, 20, 21, 2, -20 },
  { 4150, 26, 36, 21, -3, -29 },
  { 4267, 23, 27, 21, -2, -20 },
  { 4345, 19, 29, 21, 0, -29 },
  { 4414, 14, 29, 21, 3, -29 },
  { 4465, 21, 36, 21, -2, -29 },
  { 4560, 21, 29, 21, 1, -29 },
  { 4637, 13, 29, 21, 4, -29 },
  { 4685, 21, 20, 21, -1, -20 },
  { 4738, 19, 20, 21, 0, -20 },
  { 4786, 18, 21, 21, 1, -20 },
  { 4834, 21, 27, 21, -2, -20 },
  { 4905, 20, 27, 21, 1, -20 },
  { 4973, 20, 20, 21, 1, -20 },
  { 5023, 19, 21, 21, 0, -20 },
  { 5073, 17, 25, 21, 3, -25 },
  { 5127, 18, 19, 21, 2, -19 },
  { 5170, 18, 19, 21, 3, -19 },
  { 5213, 21, 19, 21, 1, -19 },
  { 5263, 22, 19, 21, -1, -19 },
  { 5316, 24, 26, 21, -3, -19 },
  { 5394, 20, 19, 21, 0, -19 },
  { 5442, 19, 36, 21, 3, -29 },
  { 5528, 13, 36, 21, 4, -29 },
  { 5587, 19, 36, 21, -1, -29 },
  { 5673, 19, 8, 21, 1, -15 },
};

const GFXfont UbuntuSansMono_BoldItalic37pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic37pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic37pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _UBUNTUSANSMONO_BOLDITALIC37PT7B_H_
