#ifndef _UBUNTUSANSMONO_BOLDITALIC32PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3E,
  0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x20, 0x3E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3C, 0x00, 0x78, 0xFF, 0xCF, 0xBE, 0x7D, 0xF3, 0xEF,
  0x1E, 0x78, 0xF3, 0x87, 0x9C, 0x38, 0xE1, 0xC6, 0x0C, 0x00, 0x00, 0xF1,
  0xE0, 0x1E, 0x38, 0x03, 0x8F, 0x00, 0xF1, 0xC0, 0x1C, 0x78, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0xC0, 0xE3, 0xC0, 0x3C, 0x78,
  0x07, 0x8E, 0x00, 0xE3, 0xC0, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x07, 0x1E, 0x01, 0xE3, 0x80, 0x38, 0xF0, 0x0F, 0x1E, 0x01,
  0xE7, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xF8, 0x3E, 0x04, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x30, 0x3E, 0x1F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x04, 0x1F, 0x80, 0xE0,
  0xFE, 0x07, 0x03, 0xB8, 0x38, 0x1C, 0x61, 0xC0, 0x71, 0x8F, 0x01, 0xCE,
  0x38, 0x07, 0x39, 0xC0, 0x1D, 0xCE, 0x00, 0x7F, 0x70, 0x00, 0xFB, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x73, 0x00, 0x03, 0xBF, 0x00, 0x1D, 0xFC, 0x00,
  0xE7, 0x70, 0x07, 0x18, 0xC0, 0x3C, 0xE3, 0x00, 0xE3, 0x9C, 0x07, 0x0E,
  0x70, 0x38, 0x3B, 0x81, 0xC0, 0xFE, 0x0E, 0x01, 0xF0, 0x00, 0x01, 0x00,
  0x00, 0x38, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0x78, 0xF0, 0x38,
  0x78, 0x3C, 0x3C, 0x1E, 0x3C, 0x0F, 0x3C, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xFC, 0x71, 0xFE, 0x39, 0xFF, 0x3D, 0xE3, 0xDE, 0xF1, 0xFE, 0xF0, 0x7E,
  0x78, 0x1F, 0x3C, 0x0F, 0x1F, 0x1F, 0xC7, 0xFF, 0xE3, 0xFF, 0x78, 0xFE,
  0x3C, 0x7D, 0xEF, 0xBE, 0xFB, 0xCF, 0x38, 0xE3, 0x80, 0x00, 0x18, 0x01,
  0xE0, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0x70, 0x00, 0x80, 0x00, 0x00, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x0E, 0x00,
  0x08, 0x00, 0x00, 0x07, 0xC0, 0x0F, 0x00, 0x0E, 0x03, 0x9C, 0x67, 0xBB,
  0xDF, 0xFF, 0xBF, 0xFF, 0x81, 0xC0, 0x0F, 0xE0, 0x3D, 0xE0, 0xFB, 0xE1,
  0xE7, 0xC1, 0xC7, 0x01, 0x04, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x1C, 0x1E, 0x7E,
  0x7E, 0x3C, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0x7F, 0xE0, 0x7B, 0xFF, 0xFF,
  0xFB, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x70, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xF8, 0xF0, 0xF0,
  0x7C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x07, 0xBC, 0x63, 0xDE, 0x79, 0xEF,
  0x3D, 0xE7, 0x9C, 0xF7, 0xCC, 0x7B, 0xC0, 0x3D, 0xE0, 0x3C, 0xF0, 0x1E,
  0x78, 0x1F, 0x3E, 0x1F, 0x0F, 0x9F, 0x07, 0xFF, 0x81, 0xFF, 0x80, 0x7F,
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x1F, 0xF8, 0x7F, 0xE1,
  0xEF, 0x86, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x07, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x07, 0x8F, 0xC1, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xFF,
  0xF8, 0x7F, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE0, 0x00, 0x78, 0x01, 0xFF,
  0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x60, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x90, 0x0F,
  0x8E, 0x0F, 0xCF, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0x80, 0x00, 0x07, 0xC0,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x1E,
  0xF8, 0x0F, 0x3C, 0x07, 0x8F, 0x03, 0xC3, 0xC1, 0xE1, 0xF0, 0xF0, 0x78,
  0x38, 0x1E, 0x1F, 0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x80,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x01,
  0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x0B, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x08, 0x07, 0xC1, 0xC3, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF,
  0x80, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF8, 0x1F,
  0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3D, 0xF8,
  0x1F, 0xFF, 0x07, 0xFF, 0xE1, 0xF8, 0xF8, 0xF8, 0x1F, 0x3E, 0x07, 0xCF,
  0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1E, 0x1E, 0x07, 0x87, 0xC7, 0xE0, 0xFF,
  0xF0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xCF, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xFF, 0xC1,
  0xFF, 0xF0, 0xF0, 0xF8, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1F, 0x0F,
  0x07, 0xCF, 0x03, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x81, 0xF3, 0xE1, 0xE0,
  0xF9, 0xF0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x9F, 0x0F, 0x8F,
  0xFF, 0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0xF0, 0x03, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xE3, 0xE1, 0xF1, 0xE0, 0x7C, 0xF0, 0x3E, 0xF8, 0x0F, 0x7C,
  0x07, 0xBE, 0x07, 0xCF, 0x03, 0xE7, 0xFF, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0C, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7E, 0x07, 0xFE,
  0x0F, 0xFE, 0x07, 0xFC, 0x03, 0xF0, 0x00, 0x0E, 0x1F, 0x3F, 0x3F, 0x3F,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8,
  0x01, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x00,
  0xE0, 0x3C, 0x3F, 0x0F, 0xC1, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x03, 0xC0,
  0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xE1, 0xFF, 0x81, 0xFE, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03,
  0xE0, 0x00, 0x60, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F,
  0xFF, 0xCF, 0xFF, 0xE0, 0x10, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0xFE, 0x07, 0xFE,
  0x3F, 0xF8, 0xFF, 0xC0, 0xFF, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x03, 0x80,
  0xFF, 0xC3, 0xFF, 0x8F, 0xFE, 0x30, 0xFC, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0x3E,
  0x1F, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xE0, 0xFF, 0x78, 0xFF, 0x9C,
  0x7F, 0xE7, 0x1F, 0xFB, 0xCF, 0x1E, 0xE3, 0x87, 0x39, 0xE3, 0xCE, 0x78,
  0xF3, 0x9E, 0x3C, 0xE7, 0x8F, 0x39, 0xE7, 0x8E, 0x7F, 0xE3, 0x8F, 0xF8,
  0xE1, 0xFE, 0x3C, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x10, 0x0F,
  0xFC, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1D, 0xE0, 0x0F, 0x78, 0x07, 0x9E,
  0x01, 0xE7, 0x80, 0xF9, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07, 0x87, 0xC3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0x81, 0xF3, 0xC0,
  0x7C, 0xF0, 0x1F, 0x7C, 0x07, 0xFE, 0x01, 0xF0, 0x07, 0xFE, 0x01, 0xFF,
  0xE0, 0x7F, 0xF8, 0x3E, 0x3F, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x7C,
  0x7C, 0x1E, 0x1F, 0x3F, 0x87, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xFC, 0x3E,
  0x1F, 0x0F, 0x03, 0xE3, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x0F, 0x1E, 0x07,
  0xC7, 0xEF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x00, 0x38,
  0x00, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xE1, 0xF8, 0x70, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x02, 0x1F, 0xCF, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0, 0x07,
  0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x3E, 0x7E, 0x0F, 0x0F, 0x83, 0xC1,
  0xE1, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0xC7, 0x81, 0xE3, 0xE0, 0x78,
  0xF8, 0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xE3, 0xC0, 0xF1, 0xF0, 0x7C, 0x78,
  0x3E, 0x1E, 0x1F, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0,
  0x00, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3F,
  0xE0, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xC3, 0x87, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x3C, 0x78,
  0x1F, 0x1E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0x78, 0xF8, 0x3E, 0x1E, 0x0F,
  0x87, 0xC3, 0xC1, 0xF8, 0xF0, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0x80,
  0x07, 0x81, 0xF0, 0x78, 0x1E, 0x0F, 0x81, 0xE0, 0xF0, 0x3E, 0x0F, 0x03,
  0xE0, 0xF0, 0x3C, 0x1F, 0x03, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0xC1, 0xFF,
  0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xF8, 0x3C, 0x0F, 0x83, 0xC0, 0xF0, 0x7C,
  0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x1E, 0x0F,
  0x83, 0xE0, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x84, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x04, 0x0F, 0x81, 0xE7, 0xF0, 0x7F, 0xFC, 0x07,
  0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x87,
  0xC0, 0xF8, 0xF8, 0x0F, 0x0F, 0x80, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF7,
  0xC0, 0x1E, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3D,
  0xF0, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07,
  0x83, 0xE0, 0x78, 0x3E, 0x0F, 0x81, 0xE0, 0xF8, 0x1F, 0x0F, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xFF, 0xFB,
  0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x80, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x3F, 0x07, 0xE3, 0xF0, 0xFE, 0x7E, 0x0E, 0xE7, 0xE0,
  0xEE, 0xEE, 0x0E, 0xEE, 0xE1, 0xEF, 0xDE, 0x1E, 0xFD, 0xE1, 0xCF, 0x9C,
  0x3C, 0xF1, 0xC3, 0xCF, 0x3C, 0x3C, 0x03, 0xC3, 0x80, 0x3C, 0x78, 0x07,
  0x87, 0x80, 0x78, 0x78, 0x07, 0x87, 0x00, 0x78, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0xF0, 0xF8, 0x1E, 0x0F, 0x81, 0xE0, 0xFC, 0x1E, 0x0F,
  0xC1, 0xE0, 0xFC, 0x3C, 0x1F, 0xE3, 0xC1, 0xEE, 0x3C, 0x1E, 0xE3, 0xC1,
  0xCE, 0x78, 0x3C, 0xF7, 0x83, 0xC7, 0x78, 0x3C, 0x77, 0x83, 0xC7, 0xF0,
  0x78, 0x7F, 0x07, 0x87, 0xF0, 0x78, 0x3F, 0x07, 0x83, 0xE0, 0xF0, 0x3E,
  0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x0F, 0x01, 0xC0, 0x00, 0x78, 0x01, 0xFF,
  0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF8, 0xF8, 0xF8, 0x7C, 0xF8, 0x1E, 0x78,
  0x0F, 0x7C, 0x07, 0xBE, 0x07, 0xDE, 0x03, 0xEF, 0x01, 0xFF, 0x80, 0xF7,
  0xC0, 0x7B, 0xE0, 0x7D, 0xE0, 0x3E, 0xF0, 0x1E, 0x7C, 0x1F, 0x3E, 0x1F,
  0x0F, 0x9F, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0x00, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x07, 0xCF, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0xC3,
  0xC0, 0xF8, 0xF8, 0x1E, 0x1F, 0x03, 0xC3, 0xC0, 0xF8, 0x78, 0xFE, 0x0F,
  0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xE1, 0xF8,
  0xF8, 0xF8, 0x7C, 0xF8, 0x1E, 0x78, 0x0F, 0x7C, 0x07, 0xBE, 0x07, 0xDE,
  0x03, 0xEF, 0x01, 0xFF, 0x80, 0xF7, 0xC0, 0x7B, 0xE0, 0x7D, 0xE0, 0x3E,
  0xF0, 0x1E, 0x7C, 0x1F, 0x3E, 0x1F, 0x0F, 0x9F, 0x87, 0xFF, 0x81, 0xFF,
  0x80, 0x7F, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00,
  0x7E, 0x00, 0x0E, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x3E,
  0x3F, 0x0F, 0x07, 0xC3, 0xC1, 0xF0, 0xF0, 0x7C, 0x7C, 0x1E, 0x1E, 0x07,
  0x87, 0x87, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0F, 0xFE, 0x03,
  0xC7, 0x81, 0xF1, 0xF0, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE3, 0xE0,
  0x78, 0xF8, 0x1E, 0x3C, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0x7F,
  0xFC, 0x1F, 0xFE, 0x0F, 0x81, 0x83, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC4, 0x01,
  0xE1, 0xE1, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xC7,
  0xC0, 0xF1, 0xF0, 0x7C, 0x78, 0x1F, 0x1E, 0x07, 0x8F, 0x81, 0xE3, 0xE0,
  0xF8, 0xF0, 0x3E, 0x3C, 0x0F, 0x1F, 0x03, 0xC7, 0xC1, 0xF1, 0xE0, 0x7C,
  0x78, 0x1E, 0x3E, 0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF0, 0x3C, 0x3E,
  0x1F, 0x0F, 0xDF, 0x81, 0xFF, 0xE0, 0x7F, 0xF0, 0x0F, 0xF8, 0x00, 0x78,
  0x07, 0xFE, 0x03, 0xEF, 0x80, 0xF9, 0xE0, 0x3C, 0x78, 0x1F, 0x1E, 0x07,
  0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x78, 0x7C, 0x1E, 0x1E, 0x07, 0x87, 0x81,
  0xE3, 0xC0, 0x78, 0xF0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xEF, 0x00, 0x7B,
  0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x0E, 0x1E,
  0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01, 0xE1, 0xC0, 0x1C, 0x3C, 0xF3, 0xC3,
  0xCF, 0x3C, 0x3D, 0xF3, 0xC3, 0x9F, 0x38, 0x3B, 0xB3, 0x87, 0xBB, 0x78,
  0x7F, 0x37, 0x07, 0x63, 0x70, 0x7E, 0x37, 0x07, 0xC3, 0xF0, 0x7C, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0x07, 0xC0, 0xFC, 0x0F,
  0x03, 0xC0, 0x3C, 0x1F, 0x00, 0xF8, 0xF8, 0x01, 0xE3, 0xC0, 0x07, 0xDE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x7D,
  0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x03, 0xE0, 0xF0,
  0x0F, 0x83, 0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0xF8,
  0x0F, 0xBC, 0x0F, 0x9F, 0x07, 0xCF, 0x87, 0xC3, 0xC3, 0xC1, 0xE3, 0xE0,
  0xF3, 0xE0, 0x79, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x04, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFC,
  0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xF1, 0xE3, 0xC7, 0xCF, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x9F, 0x3E, 0x3C, 0x78, 0xF1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x3E, 0x7C, 0xF8, 0xF1, 0xE3, 0xC7, 0x80, 0x00,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x78, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x3E, 0xF0, 0x3E, 0x78,
  0x3E, 0x3E, 0x3E, 0x0F, 0x3E, 0x07, 0xBE, 0x03, 0xE7, 0x01, 0xE1, 0x00,
  0x40, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x30,
  0x78, 0xFE, 0x3F, 0x0E, 0x02, 0x01, 0xFE, 0x07, 0xFF, 0x1F, 0xFF, 0x3F,
  0xFF, 0x3E, 0x1F, 0x7C, 0x1E, 0x78, 0x1E, 0xF8, 0x3E, 0xF8, 0x3E, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x3C, 0xF8, 0x7C, 0xFD, 0xFC, 0x7F, 0xFC, 0x7F,
  0xFC, 0x3F, 0xBE, 0x00, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x7C, 0x07, 0xFF,
  0x07, 0xFF, 0xC3, 0xFF, 0xE1, 0xE0, 0xF8, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C,
  0x1F, 0x3C, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0xCF, 0x83, 0xE7, 0x83, 0xE3,
  0xC7, 0xF1, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x83,
  0xFF, 0x83, 0xFF, 0xC3, 0xFF, 0xC3, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x03, 0xFD, 0xE1, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x7F, 0xFC,
  0x0F, 0xFF, 0x83, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x07, 0x87, 0xC1, 0xF0,
  0xF8, 0x3E, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x87, 0xC1,
  0xFB, 0xF8, 0x1F, 0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xBE, 0x00, 0x01, 0xFC,
  0x07, 0xFE, 0x0F, 0xFF, 0x1F, 0x1F, 0x3E, 0x0F, 0x7C, 0x0F, 0x78, 0x1F,
  0x78, 0x7E, 0xFF, 0xFE, 0xFF, 0xF8, 0xFF, 0xC0, 0xF8, 0x00, 0x78, 0x00,
  0x7E, 0x1C, 0x7F, 0xFC, 0x3F, 0xFC, 0x0F, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x40, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xF3, 0xE0,
  0xF8, 0x7C, 0x3E, 0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x3E, 0x0F, 0x87,
  0xC1, 0xF0, 0xF8, 0x3C, 0x1F, 0x07, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x1E, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC1, 0x01, 0xF0, 0x3F,
  0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1F, 0x0F, 0x1E,
  0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3E, 0x1F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C,
  0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x7C, 0x03,
  0xC0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xCF, 0xF8, 0xFF, 0x8F, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x01, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x7F,
  0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x83, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x07, 0xC7,
  0xC3, 0xE1, 0xF1, 0xF0, 0x78, 0xF8, 0x1E, 0x7C, 0x0F, 0xBE, 0x03, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x07, 0xDF, 0x01, 0xE3, 0xC0,
  0x78, 0xF8, 0x3E, 0x1E, 0x0F, 0x87, 0xC3, 0xC1, 0xF0, 0xF0, 0x3E, 0x00,
  0x7F, 0xDF, 0xFB, 0xFE, 0x7F, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F,
  0x81, 0xE0, 0x3C, 0x07, 0x80, 0xFD, 0xDF, 0xF9, 0xFF, 0x3F, 0xC0, 0x03,
  0xE7, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0x3C, 0xF1, 0xE7, 0x9E, 0x3C,
  0xF3, 0x87, 0x9C, 0x70, 0xE3, 0x9E, 0x3C, 0xF3, 0xC7, 0x9E, 0x70, 0xF3,
  0x8E, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xC3, 0x80,
  0x78, 0xF0, 0x0F, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF,
  0x1F, 0x0F, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x0F, 0x3E, 0x1F, 0x3C, 0x1F,
  0x3C, 0x1E, 0x3C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C,
  0xF8, 0x7C, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3F, 0xFE, 0x3E, 0x1F,
  0x7C, 0x1F, 0x78, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x1E, 0xF0, 0x1E,
  0xF8, 0x3E, 0xF8, 0x7C, 0xFC, 0xFC, 0x7F, 0xF8, 0x7F, 0xF0, 0x3F, 0xC0,
  0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0x7E, 0x0F, 0x07, 0xC3,
  0xC1, 0xF0, 0xF0, 0x7C, 0x7C, 0x1F, 0x1E, 0x07, 0xC7, 0x81, 0xE1, 0xE0,
  0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x0F, 0xFF, 0x83, 0xFF, 0xE1, 0xFF, 0xE0,
  0x7F, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xFF,
  0xE3, 0xE1, 0xF3, 0xE0, 0xF9, 0xF0, 0x78, 0xF0, 0x3C, 0xF8, 0x1E, 0x7C,
  0x1F, 0x3E, 0x0F, 0x1F, 0x07, 0x8F, 0x83, 0xC3, 0xE7, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0x87, 0xFF, 0x83, 0xFF, 0xC3,
  0xFF, 0xE1, 0xF0, 0x10, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xC1, 0xF1, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC2, 0x03, 0xE1, 0xC3, 0xF1,
  0xFF, 0xF1, 0xFF, 0xF0, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFC,
  0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xC3, 0xFF, 0x83, 0xFF, 0x03, 0xFE,
  0x00, 0x1E, 0x0F, 0x1E, 0x0F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x3C,
  0x1E, 0x7C, 0x1E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0xF8, 0x3C, 0xF8,
  0x7C, 0xF8, 0x7C, 0xFD, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x3F, 0xBC, 0xF8,
  0x0F, 0xBC, 0x0F, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xE1,
  0xE1, 0xF0, 0xF0, 0xF0, 0x7C, 0xF8, 0x3E, 0x78, 0x0F, 0x78, 0x07, 0xFC,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0E, 0x71, 0xE7, 0x9C,
  0x79, 0xEF, 0x3E, 0x73, 0xCF, 0x9C, 0xF7, 0xEF, 0x39, 0xFB, 0x8E, 0xEE,
  0xE3, 0xBB, 0xF0, 0xFC, 0xFC, 0x3F, 0x3F, 0x0F, 0x8F, 0x83, 0xC1, 0xE0,
  0xF0, 0x70, 0x00, 0x0F, 0x03, 0xE1, 0xF0, 0x78, 0x1E, 0x1F, 0x03, 0xE7,
  0xC0, 0x3C, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFB, 0xE0, 0x3E, 0x7C,
  0x0F, 0x87, 0xC3, 0xE0, 0xF8, 0xF8, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x1E,
  0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0xF0,
  0x0F, 0x8F, 0x80, 0x7C, 0x78, 0x01, 0xE7, 0xC0, 0x0F, 0x3C, 0x00, 0x7B,
  0xE0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC3,
  0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xFF, 0x87, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xE0,
  0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x07,
  0x02, 0x07, 0xF0, 0xF3, 0xFF, 0x79, 0xFF, 0xFE, 0x7B, 0xFF, 0x3C, 0x3F,
  0x81, 0x03, 0x80,
};

const GFXglyph UbuntuSansMono_BoldItalic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 10, 22, 18, 5, -22 },
  { 29, 13, 10, 18, 6, -24 },
  { 46, 19, 22, 18, 0, -22 },
  { 99, 18, 28, 18, 0, -25 },
  { 162, 22, 24, 18, -1, -23 },
  { 228, 17, 23, 18, 0, -23 },
  { 277, 6, 10, 18, 9, -24 },
  { 285, 14, 31, 18, 4, -25 },
  { 340, 15, 31, 18, 0, -25 },
  { 399, 15, 14, 18, 3, -22 },
  { 426, 16, 16, 18, 1, -17 },
  { 458, 9, 11, 18, 2, -6 },
  { 471, 11, 4, 18, 4, -11 },
  { 477, 6, 6, 18, 5, -6 },
  { 482, 21, 31, 18, -2, -25 },
  { 564, 17, 23, 18, 1, -23 },
  { 613, 14, 22, 18, 1, -22 },
  { 652, 18, 23, 18, 0, -23 },
  { 704, 17, 23, 18, 0, -23 },
  { 753, 18, 22, 18, 0, -22 },
  { 803, 19, 22, 18, 0, -22 },
  { 856, 18, 22, 18, 1, -22 },
  { 906, 17, 22, 18, 3, -22 },
  { 953, 17, 23, 18, 1, -23 },
  { 1002, 17, 23, 18, 1, -23 },
  { 1051, 8, 17, 18, 5, -17 },
  { 1068, 11, 22, 18, 2, -17 },
  { 1099, 17, 15, 18, 1, -17 },
  { 1131, 18, 11, 18, 0, -15 },
  { 1156, 16, 15, 18, 1, -17 },
  { 1186, 14, 23, 18, 4, -23 },
  { 1227, 18, 28, 18, 1, -23 },
  { 1290, 18, 22, 18, -2, -22 },
  { 1340, 18, 22, 18, 0, -22 },
  { 1390, 17, 23, 18, 2, -23 },
  { 1439, 18, 22, 18, 0, -22 },
  { 1489, 18, 22, 18, 1, -22 },
  { 1539, 19, 22, 18, 1, -22 },
  { 1592, 18, 23, 18, 1, -23 },
  { 1644, 20, 22, 18, 0, -22 },
  { 1699, 19, 22, 18, 0, -22 },
  { 1752, 19, 22, 18, 0, -22 },
  { 1805, 20, 22, 18, 0, -22 },
  { 1860, 15, 22, 18, 0, -22 },
  { 1902, 20, 22, 18, -1, -22 },
  { 1957, 20, 22, 18, 0, -22 },
  { 2012, 17, 23, 18, 1, -23 },
  { 2061, 19, 22, 18, 0, -22 },
  { 2114, 17, 29, 18, 1, -23 },
  { 2176, 18, 22, 18, 0, -22 },
  { 2226, 18, 23, 18, 0, -23 },
  { 2278, 17, 22, 18, 3, -22 },
  { 2325, 18, 22, 18, 1, -22 },
  { 2375, 18, 22, 18, 3, -22 },
  { 2425, 20, 22, 18, 0, -22 },
  { 2480, 22, 22, 18, -1, -22 },
  { 2541, 17, 22, 18, 4, -22 },
  { 2588, 19, 22, 18, 0, -22 },
  { 2641, 17, 31, 18, 2, -25 },
  { 2707, 7, 31, 18, 6, -25 },
  { 2735, 18, 31, 18, -1, -25 },
  { 2805, 17, 13, 18, 1, -22 },
  { 2833, 17, 4, 18, -3, 2 },
  { 2842, 8, 7, 18, 7, -25 },
  { 2849, 16, 17, 18, 1, -17 },
  { 2883, 17, 25, 18, 0, -25 },
  { 2937, 17, 17, 18, 1, -17 },
  { 2974, 19, 25, 18, 1, -25 },
  { 3034, 16, 17, 18, 1, -17 },
  { 3068, 23, 31, 18, -3, -25 },
  { 3158, 19, 23, 18, -1, -17 },
  { 3213, 16, 25, 18, 0, -25 },
  { 3263, 12, 25, 18, 3, -25 },
  { 3301, 19, 31, 18, -2, -25 },
  { 3375, 18, 25, 18, 1, -25 },
  { 3432, 11, 25, 18, 4, -25 },
  { 3467, 19, 17, 18, -1, -17 },
  { 3508, 16, 17, 18, 0, -17 },
  { 3542, 16, 17, 18, 1, -17 },
  { 3576, 18, 23, 18, -1, -17 },
  { 3628, 17, 23, 18, 1, -17 },
  { 3677, 17, 17, 18, 1, -17 },
  { 3714, 17, 17, 18, 0, -17 },
  { 3751, 15, 22, 18, 3, -22 },
  { 3793, 16, 17, 18, 1, -17 },
  { 3827, 17, 17, 18, 2, -17 },
  { 3864, 18, 17, 18, 1, -17 },
  { 3903, 19, 17, 18, -1, -17 },
  { 3944, 21, 23, 18, -3, -17 },
  { 4005, 18, 17, 18, 0, -17 },
  { 4044, 17, 31, 18, 2, -25 },
  { 4110, 12, 31, 18, 3, -25 },
  { 4157, 17, 31, 18, -1, -25 },
  { 4223, 18, 7, 18, 0, -13 },
};

const GFXfont UbuntuSansMono_BoldItalic32pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic32pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic32pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _UBUNTUSANSMONO_BOLDITALIC32PT7B_H_
