#ifndef _UBUNTUSANSMONO_BOLDITALIC58PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0xE1,
  0xFF, 0x3F, 0xC1, 0xFE, 0x3F, 0xC1, 0xFE, 0x3F, 0xC3, 0xFE, 0x7F, 0xC3,
  0xFE, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83, 0xFC, 0x7F, 0x83,
  0xF8, 0x7F, 0x07, 0xF8, 0x7F, 0x07, 0xF8, 0xFE, 0x07, 0xF0, 0xFE, 0x07,
  0xF0, 0xFE, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xF8, 0x07,
  0xC0, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F, 0x80, 0x7F, 0xC0, 0x07,
  0x00, 0xFF, 0x00, 0x02, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x80, 0x00,
  0xFF, 0x03, 0x80, 0x03, 0xFE, 0x07, 0xE0, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x01, 0xFF,
  0xC0, 0x03, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xFF, 0x80, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x3E, 0x01, 0xF0, 0x01, 0xF8,
  0x7C, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x1F, 0x80, 0x07, 0xC1, 0xF0, 0x7E,
  0x00, 0x0F, 0x87, 0xC1, 0xF8, 0x00, 0x1F, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x7C, 0x3F, 0x00, 0x00, 0xF9, 0xF8, 0xFC,
  0x00, 0x01, 0xFF, 0xF3, 0xF0, 0x00, 0x03, 0xFF, 0xCF, 0xC0, 0x00, 0x03,
  0xFF, 0x3F, 0x00, 0x00, 0x07, 0xFC, 0x7C, 0x00, 0x00, 0x03, 0xE1, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0xFF, 0x80, 0x00, 0x03, 0xE3,
  0xFF, 0x80, 0x00, 0x0F, 0xCF, 0xFF, 0x00, 0x00, 0x3F, 0x3F, 0xFE, 0x00,
  0x00, 0xFC, 0x7C, 0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x7C, 0x00, 0x0F, 0xC3,
  0xE0, 0xF0, 0x00, 0x1F, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x0F, 0x87, 0xC0,
  0x01, 0xF8, 0x1E, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x1F, 0x00, 0x1F, 0x80,
  0xF8, 0x7E, 0x00, 0x7E, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x03, 0xF3, 0xF0,
  0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0x00,
  0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFE, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x20, 0x00, 0xFF, 0xE0,
  0x7F, 0x01, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0xF0, 0x7E, 0x0F, 0xFF, 0xF0,
  0xFE, 0x1F, 0xE7, 0xF8, 0xFC, 0x1F, 0xC3, 0xFD, 0xFC, 0x3F, 0x83, 0xFD,
  0xF8, 0x7F, 0x01, 0xFF, 0xF8, 0x7F, 0x00, 0xFF, 0xF0, 0x7F, 0x00, 0xFF,
  0xF0, 0x7F, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0xE0, 0x7F, 0xEF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0xE7,
  0xF0, 0x1F, 0xFF, 0xC7, 0xF8, 0x07, 0xFF, 0x03, 0xF8, 0x00, 0x70, 0x00,
  0x00, 0x3F, 0xE7, 0xFC, 0xFF, 0x1F, 0xE7, 0xFC, 0xFF, 0x9F, 0xE3, 0xFC,
  0x7F, 0x8F, 0xE3, 0xFC, 0x7F, 0x8F, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x0C, 0x0F, 0xC0, 0x47,
  0xC3, 0xF0, 0xF1, 0xF8, 0xFC, 0x7E, 0x7F, 0x9E, 0x7F, 0xBF, 0xF7, 0xBF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01,
  0xFD, 0xFE, 0x00, 0xFF, 0x3F, 0xC0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE1, 0xFF,
  0x07, 0xF8, 0x7F, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x03, 0xC0, 0x00, 0x80,
  0x40, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x78, 0x01, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x0F,
  0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF8, 0x3F, 0xF0, 0xFF,
  0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0xFF, 0xFC, 0x0F, 0x81, 0xFC, 0x3F, 0xE7, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xE7, 0xFC, 0x3F, 0x81, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xE0,
  0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x01,
  0xFC, 0x7F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x7F,
  0x3F, 0xC3, 0xC1, 0xFC, 0xFE, 0x1F, 0x87, 0xF3, 0xF8, 0xFE, 0x1F, 0xDF,
  0xE3, 0xF8, 0xFF, 0x7F, 0x8F, 0xE3, 0xFD, 0xFC, 0x3F, 0x8F, 0xE7, 0xF0,
  0xFC, 0x3F, 0x9F, 0xC3, 0xE1, 0xFE, 0xFF, 0x02, 0x07, 0xFB, 0xFC, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFF, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0,
  0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x03, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x1F, 0xE7, 0xF8, 0x03, 0xE1, 0xFE, 0x00, 0xE0, 0xFF, 0x80,
  0x20, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x78, 0x01, 0xFF,
  0x00, 0x70, 0x00, 0xFF, 0x00, 0x40, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF7, 0xFF, 0x80,
  0x1C, 0x01, 0xFF, 0x00, 0x20, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x40, 0x00, 0x7F, 0xE0, 0xF0, 0x01, 0xFF, 0x83,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x30, 0x00, 0x3F, 0xE0, 0x0F, 0x80, 0x3F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F,
  0x80, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x7F,
  0x80, 0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x01,
  0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFE,
  0x01, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0xC0, 0x1F,
  0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80,
  0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x7F, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0xBF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x03, 0xFE, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFC,
  0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x7F, 0x1F,
  0xE0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF8, 0x7F,
  0xE0, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xF3, 0xF8, 0x00, 0x3E,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x78, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x07, 0xFF,
  0x07, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0,
  0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF, 0xE0, 0x7F, 0xC0,
  0x3F, 0x80, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1E, 0x01, 0xFF, 0x10, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xDF, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x7B, 0xF8, 0x7E, 0x03,
  0xFF, 0xFC, 0x7E, 0x03, 0xFF, 0xFC, 0x3F, 0x03, 0xFF, 0xFE, 0x3F, 0x83,
  0xFF, 0xFF, 0x1F, 0x83, 0xFF, 0xFF, 0x8F, 0xC1, 0xFF, 0xFF, 0x87, 0xE1,
  0xFE, 0x1F, 0xC7, 0xE0, 0xFE, 0x0F, 0xE3, 0xF0, 0xFE, 0x07, 0xF1, 0xF8,
  0x7F, 0x03, 0xF8, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x3F, 0x81, 0xFC, 0x7E,
  0x1F, 0xC0, 0xFE, 0x3F, 0x0F, 0xE0, 0x7F, 0x1F, 0x87, 0xF0, 0x7F, 0x0F,
  0xC3, 0xF8, 0x3F, 0x87, 0xE1, 0xFC, 0x1F, 0xC3, 0xF0, 0xFE, 0x0F, 0xE1,
  0xF8, 0x7F, 0x87, 0xE0, 0xFC, 0x1F, 0xF7, 0xF0, 0x7E, 0x0F, 0xFF, 0xF8,
  0x3F, 0x07, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xFC, 0x07, 0xE0, 0x7F, 0xFE,
  0x03, 0xF0, 0x1F, 0xFF, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0xFE, 0x1F,
  0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFE, 0x7F,
  0x80, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x01,
  0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03,
  0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0xF8, 0x0F,
  0xF0, 0x07, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x3F,
  0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x1F, 0xF8, 0x7F, 0xC1, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x28, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x78, 0x03, 0xFF, 0x00, 0x08, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xE0, 0x03, 0x00, 0x7F, 0xF8, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x0F, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x01,
  0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03,
  0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFE, 0x0F,
  0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x0F, 0xF0, 0x01, 0xFE, 0x1F,
  0xE0, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x1F,
  0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xF0, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F,
  0x81, 0xFF, 0xE0, 0x7F, 0x9F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0x40, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x78, 0x07,
  0xFE, 0x00, 0x08, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0x80, 0x7F, 0x80, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0x80, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x60, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0xFF, 0x80, 0x0F,
  0xE0, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x1F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F, 0x80,
  0xFF, 0x80, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x01,
  0xFE, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x7F, 0x87, 0xFC,
  0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x01, 0xFE,
  0x7F, 0xC0, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0xC0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0xC0,
  0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x7F, 0xC0, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0xE0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0xF0,
  0x07, 0xEF, 0x03, 0xFF, 0x80, 0x3F, 0x78, 0x3E, 0xF8, 0x01, 0xFB, 0xC1,
  0xFF, 0xC0, 0x0F, 0xDF, 0x1F, 0x7E, 0x00, 0xFC, 0xF8, 0xFB, 0xF0, 0x07,
  0xE7, 0xCF, 0x9F, 0x80, 0x3F, 0x3E, 0xFD, 0xF8, 0x03, 0xF9, 0xF7, 0xCF,
  0xC0, 0x1F, 0xCF, 0xFE, 0x7E, 0x00, 0xFC, 0x7F, 0xE3, 0xF0, 0x07, 0xE3,
  0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xF1, 0xFC, 0x03, 0xF8, 0xFF, 0x0F, 0xC0,
  0x1F, 0x87, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0xFC,
  0x3F, 0x80, 0x7F, 0x07, 0xC1, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xFC, 0x01, 0xFC,
  0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xFC,
  0x07, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0x80, 0x1F, 0xDF, 0x03, 0xFC, 0x00,
  0xFE, 0xFC, 0x1F, 0xC0, 0x0F, 0xE7, 0xE0, 0xFE, 0x00, 0x7F, 0x3F, 0x07,
  0xF0, 0x03, 0xF8, 0xF8, 0x3F, 0x80, 0x1F, 0xC7, 0xE3, 0xF8, 0x01, 0xFC,
  0x3F, 0x1F, 0xC0, 0x0F, 0xE1, 0xF8, 0xFE, 0x00, 0x7F, 0x07, 0xC7, 0xF0,
  0x03, 0xF8, 0x3F, 0x7F, 0x00, 0x3F, 0xC1, 0xFB, 0xF8, 0x01, 0xFC, 0x0F,
  0xDF, 0xC0, 0x0F, 0xE0, 0x7E, 0xFE, 0x00, 0x7F, 0x01, 0xFF, 0xE0, 0x07,
  0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0xF8, 0x01, 0xFC, 0x03, 0xFF,
  0xC0, 0x0F, 0xE0, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xE0, 0x07, 0xF0,
  0x03, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x83, 0xFE, 0x07,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F,
  0x80, 0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80,
  0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0xBF, 0xC0, 0x01, 0xFE, 0x7F, 0x80, 0x03,
  0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0, 0x03, 0xFC,
  0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x80, 0x7F, 0xC1,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xF8,
  0x01, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F,
  0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x80, 0x0F, 0xF1, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F,
  0xC7, 0xF8, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xFC,
  0x7F, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFE, 0x7F,
  0x80, 0x03, 0xFC, 0xFF, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFF, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xE0, 0xFF, 0x80,
  0x7F, 0xC1, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x0F, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x03, 0xFF,
  0x01, 0xFE, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF,
  0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF,
  0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE,
  0x07, 0xF8, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xFC, 0x07, 0xF8, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0x80,
  0x3F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0,
  0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x0F, 0xE0,
  0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x78, 0x01, 0xFE, 0x00,
  0x04, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x10, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x1F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0,
  0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x01, 0xFE, 0x07,
  0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xE0,
  0x7F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8,
  0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xE0, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFE, 0xFF, 0x80, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFC, 0xFF,
  0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x1F, 0xE0, 0xFF,
  0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x7F,
  0x8F, 0xE0, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0xFE, 0x01, 0xFC, 0x3F, 0x87,
  0xF0, 0x0F, 0xE1, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xE1, 0xF8, 0x03, 0xF0,
  0xFF, 0x1F, 0xC0, 0x3F, 0x8F, 0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0xC7, 0xE0,
  0x0F, 0xC7, 0xFE, 0x3F, 0x00, 0x7E, 0x7F, 0xF1, 0xF8, 0x03, 0xF3, 0xEF,
  0x9F, 0xC0, 0x1F, 0xBF, 0x7C, 0xFC, 0x01, 0xF9, 0xF3, 0xE7, 0xE0, 0x0F,
  0xDF, 0x1F, 0x3F, 0x00, 0x7E, 0xF8, 0x7B, 0xF0, 0x03, 0xFF, 0x83, 0xDF,
  0x80, 0x1F, 0x7C, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xFE,
  0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x03, 0xFC,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0x3F, 0x80, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F, 0x8F, 0xF0,
  0x01, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0,
  0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x03,
  0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x7F,
  0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x1F, 0xCF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F,
  0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFD, 0xFE, 0x00, 0x7F,
  0xCF, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xC1, 0xFE, 0x07, 0xFC, 0x0F,
  0xF0, 0x3F, 0xE0, 0x7F, 0xC3, 0xFE, 0x01, 0xFE, 0x3F, 0xE0, 0x0F, 0xF3,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xF7, 0xF0,
  0x00, 0x7F, 0x8F, 0x00, 0x01, 0xE0, 0x10, 0x00, 0x0C, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFE, 0x00, 0x08, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0xE0, 0x7F, 0xC3, 0xFF,
  0x87, 0xFF, 0x8F, 0xFF, 0x0F, 0xFC, 0x0F, 0xE0, 0x0F, 0x00, 0x0C, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0xFF, 0x80, 0x3F,
  0xC3, 0xFC, 0x00, 0xFF, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1,
  0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0xC0,
  0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07,
  0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFE, 0xFF, 0x00, 0xFF, 0xE1, 0xFC, 0x00, 0x38, 0x04, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0x80,
  0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x0F, 0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x1F,
  0xE0, 0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x8F, 0xF0,
  0x07, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0xFF, 0x01, 0xFF, 0x87, 0xF8, 0x1F,
  0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xC0, 0x08, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x20, 0xFF, 0xF0, 0x3F, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x3F, 0xF8, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xC0, 0x00,
  0x38, 0x04, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0xFF, 0x83, 0xFE, 0x01, 0xFE, 0x1F, 0xF0,
  0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01,
  0xFE, 0x7F, 0x80, 0x0F, 0xF9, 0xFE, 0x00, 0xFF, 0xC7, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x07, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x08, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x38, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x0F, 0xF8, 0x03, 0xFF, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07,
  0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x03, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x08,
  0x00, 0x1F, 0xF0, 0x03, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xF0, 0x1F,
  0xF0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC,
  0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC,
  0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F,
  0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0xC1,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x80, 0x7F, 0x80, 0x00, 0x01, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x87, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x18, 0x03, 0xFE, 0x00, 0x1F,
  0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x03,
  0xFC, 0x03, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0xC1, 0xFF, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0x00,
  0x07, 0xF9, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x07, 0xF8, 0xFF, 0x80, 0x07, 0xF8, 0x3F,
  0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87, 0xFF,
  0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x01, 0x3F, 0xF0, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x78, 0x00, 0x7F, 0xF9, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F,
  0xC3, 0xF8, 0xFE, 0x07, 0xE1, 0xF8, 0x7F, 0x07, 0xF0, 0xFC, 0x3F, 0x83,
  0xF8, 0x7E, 0x1F, 0xC1, 0xF8, 0x7F, 0x0F, 0xC0, 0xFC, 0x3F, 0x87, 0xE0,
  0xFE, 0x1F, 0x87, 0xF0, 0x7F, 0x0F, 0xC3, 0xF8, 0x3F, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0xC3, 0xF0, 0xFE, 0x0F, 0xE1, 0xF8, 0x7F,
  0x07, 0xE0, 0xFC, 0x3F, 0x83, 0xF0, 0x80, 0x1F, 0x83, 0xF8, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0xFE, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0x01, 0xFF,
  0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1,
  0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0xFF,
  0x00, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF8,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0x81, 0xFF, 0x1F, 0xF0, 0x0F, 0xF3, 0xFE,
  0x00, 0xFF, 0x3F, 0xC0, 0x0F, 0xF7, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F,
  0xF7, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xEF, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x3F, 0xEF, 0xF0, 0x03, 0xFC, 0xFF, 0x00, 0x7F, 0xCF,
  0xF8, 0x0F, 0xF8, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0x8F, 0xFE,
  0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03,
  0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x3F, 0xC0, 0x7F, 0x80, 0x3F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF0, 0x3F, 0xF8, 0x07, 0xF8,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xDE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0x01, 0xFE, 0x1F, 0xF8, 0x07, 0xF8, 0x7F,
  0xC0, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x7F, 0xC0,
  0x0F, 0xF1, 0xFE, 0x00, 0x7F, 0x87, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x07,
  0xF8, 0xFF, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0xFF, 0x0F, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFE, 0x0F,
  0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0xE1, 0xFF, 0x81, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x10, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x7C, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC,
  0x1F, 0x80, 0x7F, 0x80, 0x0C, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x06,
  0x00, 0x0F, 0xF8, 0x3E, 0x00, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x04, 0x03,
  0xFF, 0x0F, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F,
  0x80, 0x7F, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x1F,
  0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8,
  0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x81, 0xFE, 0x01,
  0xFE, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0xE0, 0x7F, 0xE3, 0xFF,
  0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFE, 0xFF, 0x00, 0xFF, 0xE1, 0xF8, 0x00,
  0x3C, 0x04, 0x00, 0xFF, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0xFF, 0x9F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x0F, 0xF1, 0xFE, 0x00,
  0x7F, 0xC7, 0xF8, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F,
  0xC1, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xE0,
  0x7F, 0x80, 0xFF, 0x00, 0xFF, 0x07, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x0F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x03, 0xFC,
  0x7F, 0x80, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xDF, 0xF0, 0x00, 0x7F, 0x7F,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03,
  0xF1, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x0F, 0xC1, 0xFC, 0x7F, 0x07, 0xE0,
  0xFE, 0x3F, 0x07, 0xF0, 0x7E, 0x1F, 0x83, 0xF8, 0x3F, 0x0F, 0xC3, 0xFC,
  0x3F, 0x07, 0xE1, 0xFE, 0x1F, 0x83, 0xF1, 0xFF, 0x0F, 0xC3, 0xF8, 0xFF,
  0x8F, 0xC1, 0xF8, 0xFF, 0xC7, 0xE0, 0xFC, 0x7F, 0xE3, 0xF0, 0x7E, 0x7E,
  0xF3, 0xF0, 0x3F, 0x3E, 0x79, 0xF8, 0x1F, 0xBF, 0x3E, 0xFC, 0x0F, 0xDF,
  0x1F, 0x7C, 0x07, 0xFF, 0x8F, 0xFE, 0x03, 0xEF, 0x87, 0xFE, 0x01, 0xFF,
  0xC3, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x3F,
  0xE0, 0x7F, 0xC0, 0x1F, 0xE0, 0x3F, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xE7, 0xF8, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x03, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x3F, 0xC7,
  0xF8, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x02, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x60, 0x07, 0xFE, 0x00, 0xF8, 0x3F, 0xFE,
  0x03, 0xF8, 0xFF, 0xFF, 0x0F, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xDF, 0xFF, 0xF8, 0xFE, 0x07, 0xFF,
  0xE1, 0xF8, 0x07, 0xFF, 0x81, 0xF0, 0x03, 0xFE, 0x00, 0x20, 0x01, 0xE0,
  0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 18, 41, 32, 8, -40 },
  { 94, 24, 18, 32, 10, -44 },
  { 148, 34, 40, 32, 0, -40 },
  { 318, 31, 51, 32, 1, -45 },
  { 516, 39, 42, 32, -2, -41 },
  { 721, 32, 42, 32, 0, -41 },
  { 889, 11, 19, 32, 16, -44 },
  { 916, 26, 57, 32, 6, -46 },
  { 1102, 26, 57, 32, 0, -46 },
  { 1288, 26, 25, 32, 6, -40 },
  { 1370, 29, 30, 32, 2, -32 },
  { 1479, 16, 21, 32, 4, -11 },
  { 1521, 19, 8, 32, 7, -21 },
  { 1540, 12, 12, 32, 8, -11 },
  { 1558, 38, 56, 32, -3, -45 },
  { 1824, 30, 42, 32, 2, -41 },
  { 1982, 26, 40, 32, 2, -40 },
  { 2112, 32, 41, 32, 0, -41 },
  { 2276, 31, 42, 32, 0, -41 },
  { 2439, 33, 40, 32, 0, -40 },
  { 2604, 34, 41, 32, 0, -40 },
  { 2779, 32, 41, 32, 2, -40 },
  { 2943, 31, 40, 32, 5, -40 },
  { 3098, 31, 42, 32, 2, -41 },
  { 3261, 31, 41, 32, 1, -41 },
  { 3420, 16, 32, 32, 8, -31 },
  { 3484, 20, 41, 32, 4, -31 },
  { 3587, 29, 28, 32, 3, -31 },
  { 3689, 32, 20, 32, 0, -27 },
  { 3769, 30, 28, 32, 1, -31 },
  { 3874, 24, 42, 32, 8, -41 },
  { 4000, 33, 50, 32, 1, -41 },
  { 4207, 32, 40, 32, -3, -40 },
  { 4367, 32, 42, 32, 0, -41 },
  { 4535, 32, 42, 32, 3, -41 },
  { 4703, 32, 42, 32, 0, -41 },
  { 4871, 33, 40, 32, 1, -40 },
  { 5036, 35, 40, 32, 1, -40 },
  { 5211, 32, 42, 32, 3, -41 },
  { 5379, 37, 40, 32, -1, -40 },
  { 5564, 35, 40, 32, 0, -40 },
  { 5739, 34, 41, 32, 0, -40 },
  { 5914, 37, 40, 32, 0, -40 },
  { 6099, 27, 40, 32, 0, -40 },
  { 6234, 37, 40, 32, -2, -40 },
  { 6419, 37, 40, 32, -1, -40 },
  { 6604, 31, 42, 32, 2, -41 },
  { 6767, 34, 41, 32, 0, -41 },
  { 6942, 31, 52, 32, 2, -41 },
  { 7144, 32, 41, 32, 0, -41 },
  { 7308, 33, 42, 32, 0, -41 },
  { 7482, 31, 40, 32, 6, -40 },
  { 7637, 33, 41, 32, 2, -40 },
  { 7807, 32, 40, 32, 6, -40 },
  { 7967, 37, 40, 32, 0, -40 },
  { 8152, 39, 40, 32, -2, -40 },
  { 8347, 31, 40, 32, 7, -40 },
  { 8502, 36, 40, 32, -1, -40 },
  { 8682, 32, 56, 32, 3, -45 },
  { 8906, 13, 56, 32, 11, -45 },
  { 8997, 31, 56, 32, -1, -45 },
  { 9214, 29, 23, 32, 3, -40 },
  { 9298, 31, 7, 32, -5, 4 },
  { 9326, 14, 12, 32, 13, -45 },
  { 9347, 30, 32, 32, 2, -31 },
  { 9467, 30, 46, 32, 0, -45 },
  { 9640, 29, 32, 32, 3, -31 },
  { 9756, 34, 46, 32, 2, -45 },
  { 9952, 30, 32, 32, 2, -31 },
  { 10072, 41, 56, 32, -5, -45 },
  { 10359, 34, 42, 32, -2, -31 },
  { 10538, 30, 45, 32, 0, -45 },
  { 10707, 22, 47, 32, 5, -46 },
  { 10837, 33, 57, 32, -3, -46 },
  { 11073, 33, 45, 32, 1, -45 },
  { 11259, 20, 46, 32, 7, -45 },
  { 11374, 33, 31, 32, -1, -31 },
  { 11502, 30, 31, 32, 0, -31 },
  { 11619, 28, 32, 32, 2, -31 },
  { 11731, 33, 42, 32, -3, -31 },
  { 11905, 30, 42, 32, 2, -31 },
  { 12063, 30, 31, 32, 2, -31 },
  { 12180, 29, 32, 32, 1, -31 },
  { 12296, 27, 41, 32, 5, -40 },
  { 12435, 30, 32, 32, 2, -31 },
  { 12555, 30, 31, 32, 4, -31 },
  { 12672, 33, 31, 32, 2, -31 },
  { 12800, 35, 31, 32, -2, -31 },
  { 12936, 38, 42, 32, -5, -31 },
  { 13136, 31, 31, 32, 1, -31 },
  { 13257, 31, 56, 32, 4, -45 },
  { 13474, 21, 56, 32, 6, -45 },
  { 13621, 31, 56, 32, -2, -45 },
  { 13838, 31, 12, 32, 1, -23 },
};

const GFXfont UbuntuSansMono_BoldItalic58pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic58pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic58pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _UBUNTUSANSMONO_BOLDITALIC58PT7B_H_
