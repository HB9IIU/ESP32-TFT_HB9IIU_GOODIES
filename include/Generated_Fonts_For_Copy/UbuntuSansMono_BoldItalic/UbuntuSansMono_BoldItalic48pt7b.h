#ifndef _UBUNTUSANSMONO_BOLDITALIC48PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x80,
  0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x01, 0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7E, 0x00, 0x20, 0x00, 0x3F, 0x87, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F,
  0xE7, 0xF0, 0xFE, 0x7F, 0x0F, 0xE7, 0xF0, 0xFC, 0x7E, 0x0F, 0xC7, 0xE1,
  0xFC, 0x7E, 0x1F, 0x87, 0xC1, 0xF8, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0xF8,
  0x1F, 0x0F, 0x81, 0xE0, 0xF0, 0x1E, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x87,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0x87, 0xE0, 0x01, 0xF8, 0x7C, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x01, 0xF0,
  0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0x80, 0xF0, 0x1F, 0xC0, 0x08, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x08, 0x00, 0x7F, 0x07, 0xC0, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x80, 0x3F, 0x80, 0x0F, 0x80, 0x3F, 0xE0, 0x07, 0x80, 0x3F, 0xF0, 0x07,
  0xC0, 0x3E, 0x7C, 0x07, 0xC0, 0x1E, 0x3E, 0x07, 0xC0, 0x0F, 0x1F, 0x07,
  0xC0, 0x0F, 0x8F, 0x07, 0xC0, 0x07, 0x87, 0x83, 0xC0, 0x03, 0xC3, 0xC3,
  0xE0, 0x01, 0xE3, 0xE3, 0xE0, 0x00, 0xF1, 0xE3, 0xE0, 0x00, 0x7D, 0xF3,
  0xE0, 0x00, 0x3F, 0xF3, 0xE0, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x03, 0xF1,
  0xE0, 0x00, 0x00, 0x61, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x01, 0xF3, 0xFC, 0x00, 0x01, 0xF3, 0xFE, 0x00, 0x00,
  0xF1, 0xFF, 0x80, 0x00, 0xF9, 0xF7, 0xC0, 0x00, 0xF8, 0xF1, 0xE0, 0x00,
  0xF8, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x78, 0x00, 0xF8, 0x3C, 0x3C, 0x00,
  0x78, 0x1E, 0x3E, 0x00, 0x7C, 0x1F, 0x1E, 0x00, 0x7C, 0x0F, 0x9F, 0x00,
  0x7C, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x7C, 0x00, 0xFF, 0x80,
  0x7C, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xC0, 0xFC, 0x01,
  0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xC3, 0xF0,
  0x01, 0xF1, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x87, 0x00, 0xFF, 0x81, 0xF0, 0x7F, 0xF0, 0xFC, 0x3F,
  0xFE, 0x3E, 0x1F, 0x9F, 0x8F, 0x8F, 0xC3, 0xF7, 0xE7, 0xE0, 0xFF, 0xF1,
  0xF8, 0x1F, 0xF8, 0x7C, 0x03, 0xFE, 0x3F, 0x00, 0xFF, 0x0F, 0xC0, 0x1F,
  0xC3, 0xF0, 0x0F, 0xF0, 0xFE, 0x07, 0xFC, 0x1F, 0xEF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFE, 0x3F, 0x03, 0xFE, 0x0F, 0xC0,
  0x3F, 0x9F, 0xCF, 0xEF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F,
  0x1F, 0x8F, 0x87, 0xC3, 0xC1, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x01, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x60, 0xF8, 0x11, 0xE3, 0xE3, 0xC7, 0xE7, 0x9F, 0xBF, 0xDD, 0xFE,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x03,
  0xFE, 0x00, 0x1F, 0x7C, 0x00, 0xFD, 0xF8, 0x07, 0xF3, 0xF0, 0x3F, 0x8F,
  0xE0, 0xFE, 0x3F, 0x80, 0xF8, 0x78, 0x01, 0xC1, 0xC0, 0x02, 0x02, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x3F,
  0x81, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF8,
  0x0F, 0x80, 0x7C, 0x0F, 0xC1, 0xFC, 0x7F, 0xC3, 0xFC, 0x1F, 0xC0, 0xF0,
  0x00, 0x3F, 0xFF, 0x9F, 0xFF, 0x9F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF7,
  0xFF, 0xF0, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0xC0, 0x7F, 0x1F,
  0xC0, 0x3F, 0x8F, 0xC0, 0x0F, 0xCF, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF3,
  0xF0, 0x01, 0xFB, 0xF8, 0x60, 0xFD, 0xF8, 0x78, 0xFE, 0xFC, 0x7E, 0x7E,
  0x7E, 0x3E, 0x3F, 0x7F, 0x3F, 0x1F, 0xBF, 0x1F, 0x8F, 0xDF, 0x87, 0x8F,
  0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xF9, 0xF8, 0x01,
  0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x1F, 0xC0,
  0xFE, 0x0F, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00,
  0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0x9F, 0xC0, 0x7C, 0x7E, 0x00, 0x81, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0x7C, 0x07, 0xF0, 0x0E, 0x00, 0x7F, 0x00, 0x80,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0x3F, 0xF0, 0x0E, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x02, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x80, 0x07, 0xF8, 0x78, 0x03, 0xFC,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xDF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x1F,
  0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x3F,
  0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF8,
  0x1F, 0x80, 0x7E, 0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x20, 0x01, 0xFE, 0x03, 0x80,
  0x3F, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x03, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xF8, 0x1F,
  0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x8F,
  0xE0, 0x0F, 0xC1, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x90, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x1F,
  0xF0, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x80,
  0xFE, 0x1F, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x9F, 0xE0, 0x1F, 0x83,
  0xFC, 0x0F, 0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0xFE,
  0x00, 0x7E, 0x3F, 0x80, 0x1F, 0x8F, 0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8,
  0xFF, 0x01, 0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x7E,
  0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC7, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xFC,
  0x7F, 0x00, 0x7E, 0x1F, 0xFB, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x01, 0xE0, 0x3F, 0x83, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC,
  0x3F, 0xE1, 0xFE, 0x07, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x03, 0xF8, 0x1F, 0xE1, 0xFF, 0x0F, 0xF8,
  0x7F, 0xC3, 0xFE, 0x1F, 0xE0, 0x7E, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFE, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x07, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xFC,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xF0, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x70, 0x1F, 0xE2, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x07, 0xF8, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0xC0,
  0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x7E, 0x03, 0xFF, 0x8F, 0x81, 0xFF, 0xF3,
  0xE0, 0x7F, 0xFE, 0x7C, 0x1F, 0xFF, 0x8F, 0x87, 0xFF, 0xF3, 0xE1, 0xFE,
  0x7E, 0x7C, 0x3F, 0x0F, 0xCF, 0x8F, 0xC1, 0xF1, 0xF1, 0xF8, 0x7E, 0x7C,
  0x3E, 0x0F, 0xCF, 0x8F, 0xC1, 0xF9, 0xF1, 0xF8, 0x3E, 0x3E, 0x3F, 0x07,
  0xC7, 0xC7, 0xE1, 0xF8, 0xF8, 0xFC, 0x3F, 0x1F, 0x1F, 0x87, 0xC3, 0xE3,
  0xF8, 0xF8, 0x7C, 0x3F, 0xFF, 0x0F, 0x87, 0xFF, 0xE1, 0xF0, 0x7F, 0xF8,
  0x3F, 0x07, 0xFF, 0x07, 0xE0, 0x7F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x9E, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07,
  0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87,
  0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x00, 0x1F,
  0xDF, 0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7E,
  0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xFC,
  0x0F, 0xC0, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xE0, 0xFF, 0x81, 0xFC, 0x03,
  0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x3F,
  0x80, 0x3F, 0x87, 0xE0, 0x07, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x7F,
  0x87, 0xF0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0x70, 0x3F, 0xC0, 0x04, 0x1F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x80, 0x7F, 0xC1, 0xE0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0x87, 0xF8, 0x0F, 0xE0, 0xFF, 0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0,
  0x7F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF8, 0x03,
  0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0,
  0x07, 0xF1, 0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x87,
  0xE0, 0x0F, 0xE3, 0xF8, 0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0xFF,
  0x0F, 0xC0, 0x3F, 0x87, 0xF0, 0x1F, 0xE1, 0xFC, 0x1F, 0xF0, 0x7F, 0x3F,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0xE0, 0x3F, 0xC0,
  0x04, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x01, 0x0F, 0xC0, 0x0F, 0xC3, 0xF8,
  0x01, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x83, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x07, 0xF8, 0x3F, 0x80,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F,
  0x01, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80,
  0x7E, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0,
  0x1F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x01, 0x00, 0x3F, 0xC0, 0x38, 0x03, 0xF8, 0x03,
  0xE0, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00,
  0x7E, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC7,
  0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xF9, 0xFE, 0x00, 0x07, 0xEF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07,
  0xF7, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8,
  0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x0F,
  0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0xFE,
  0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x03,
  0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x80, 0x3F,
  0xC1, 0xFF, 0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xEE,
  0x1E, 0xF0, 0x07, 0xDE, 0x7B, 0xE0, 0x1F, 0x3C, 0xF7, 0xC0, 0x3E, 0x7B,
  0xCF, 0x80, 0x7C, 0xF7, 0x9F, 0x01, 0xF9, 0xFE, 0x7E, 0x03, 0xE3, 0xFC,
  0xF8, 0x07, 0xC7, 0xF1, 0xF0, 0x0F, 0x8F, 0xE3, 0xE0, 0x3F, 0x1F, 0x8F,
  0xC0, 0x7E, 0x3F, 0x1F, 0x80, 0xF8, 0x7C, 0x3E, 0x03, 0xF0, 0x00, 0x7C,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x03,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x80, 0x3F, 0x01, 0xFE,
  0x01, 0xF8, 0x07, 0xFC, 0x07, 0xE0, 0x1F, 0xF0, 0x1F, 0x80, 0xFF, 0xC0,
  0x7E, 0x03, 0xFF, 0x83, 0xF0, 0x0F, 0xFE, 0x0F, 0xC0, 0x3F, 0xF8, 0x3F,
  0x00, 0xF9, 0xE0, 0xFC, 0x07, 0xE7, 0xC3, 0xE0, 0x1F, 0x9F, 0x1F, 0x80,
  0x7E, 0x7C, 0x7E, 0x01, 0xF0, 0xF1, 0xF8, 0x0F, 0xC3, 0xE7, 0xC0, 0x3F,
  0x0F, 0xBF, 0x00, 0xFC, 0x3E, 0xFC, 0x03, 0xE0, 0xFB, 0xF0, 0x1F, 0x81,
  0xEF, 0x80, 0x7E, 0x07, 0xFE, 0x01, 0xF8, 0x1F, 0xF8, 0x07, 0xE0, 0x7F,
  0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x0F, 0xF0,
  0x0F, 0xC0, 0x3F, 0xC0, 0x7E, 0x00, 0xFF, 0x01, 0xF8, 0x03, 0xF8, 0x07,
  0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFE, 0x1F, 0xC0, 0x7F,
  0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0, 0x07,
  0xF3, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x1F, 0xDF, 0xC0,
  0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xF9, 0xF8,
  0x01, 0xFC, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0xFF, 0x0F, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xF8,
  0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7F,
  0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F,
  0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0xFF,
  0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xE0, 0x1F, 0xCF, 0xE0, 0x0F, 0xE7, 0xF0,
  0x07, 0xF3, 0xF0, 0x03, 0xFB, 0xF8, 0x01, 0xFD, 0xFC, 0x00, 0xFE, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x1F, 0xDF,
  0xC0, 0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xF9,
  0xF8, 0x01, 0xFC, 0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x80, 0xFE,
  0x1F, 0xC0, 0xFF, 0x0F, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0xFE, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xF0, 0x0F, 0xE0, 0x7E, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xE1, 0xFC, 0x01, 0xFC, 0x1F, 0x80,
  0x3F, 0x83, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x87,
  0xF0, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0xE0, 0x1F, 0x80,
  0x04, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x18, 0x00, 0x7F, 0x03, 0xC0, 0x3F, 0xC0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC,
  0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x1F, 0x80,
  0x3F, 0x83, 0xF0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x83,
  0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x07,
  0xF0, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0x7F,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7E,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x1F, 0xC0,
  0x7F, 0x87, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00,
  0xFC, 0xFE, 0x00, 0x7F, 0x3F, 0x80, 0x1F, 0xCF, 0xE0, 0x0F, 0xE3, 0xF8,
  0x03, 0xF8, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x0F, 0xE0, 0x1F, 0x83,
  0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x7E,
  0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0,
  0x1F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x1F,
  0x80, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x7C, 0x3E, 0x1F, 0x80, 0xF8,
  0x7C, 0x3E, 0x03, 0xF1, 0xF8, 0x7C, 0x07, 0xE3, 0xF1, 0xF8, 0x0F, 0x8F,
  0xE3, 0xE0, 0x1F, 0x1F, 0xC7, 0xC0, 0x3E, 0x7F, 0x8F, 0x80, 0xFC, 0xFF,
  0x3F, 0x01, 0xF3, 0xDE, 0x7C, 0x03, 0xEF, 0xBC, 0xF8, 0x07, 0xDE, 0x79,
  0xF0, 0x0F, 0xFC, 0xFF, 0xC0, 0x1E, 0xF0, 0xFF, 0x80, 0x7F, 0xE1, 0xFF,
  0x00, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0,
  0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x3F,
  0x80, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01,
  0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x01,
  0xFE, 0x07, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x3F, 0x9F, 0xC0,
  0x1F, 0xCF, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x0F, 0xE0, 0xFC,
  0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0x0F, 0xC3, 0xF0, 0x07,
  0xE3, 0xF8, 0x03, 0xF3, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x40, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFC, 0x1F,
  0x83, 0xF8, 0x7F, 0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x0F,
  0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFB,
  0xF8, 0x03, 0xFD, 0xFC, 0x03, 0xFC, 0x7E, 0x01, 0xFC, 0x3F, 0x81, 0xFC,
  0x1F, 0xC1, 0xFC, 0x07, 0xE1, 0xFE, 0x03, 0xF9, 0xFE, 0x01, 0xFD, 0xFE,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x8E, 0x00, 0x1F, 0x02, 0x00, 0x04, 0x00,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x10, 0x03, 0x80, 0x7E,
  0x07, 0xF0, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x7E, 0x01, 0xC0, 0x08, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0xC0, 0xFE,
  0x3F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x1F, 0x8F, 0xE0, 0x1F,
  0xC7, 0xF0, 0x0F, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xFC, 0x03,
  0xF8, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x7F, 0x0F, 0xE0,
  0x7F, 0x07, 0xF8, 0x7F, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFE, 0xFC, 0x07, 0xFC, 0x7F, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x3C, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x03, 0xF8, 0x3F, 0xC3, 0xF8, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x7F, 0x00, 0xFE,
  0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xC0, 0x1F, 0xCF, 0xE0, 0x0F,
  0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xF8, 0x07, 0xF1, 0xFC, 0x07,
  0xF8, 0xFE, 0x0F, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xE0, 0x10, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xFC, 0x0F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x16, 0x80, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x1D, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0,
  0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFE, 0x01, 0xFC, 0x0F, 0xE0,
  0x1F, 0xC0, 0xFE, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xF8,
  0x07, 0xF8, 0x7F, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xEF, 0xC0, 0x0F, 0xF8, 0xFE, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xF9, 0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x80,
  0x3F, 0x3F, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0xFE, 0x7E, 0x03,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x30, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xF1, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x83, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0x80, 0xFE, 0x01,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0,
  0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x3F, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x03, 0x00, 0x3F, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFE,
  0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xF0, 0x1F,
  0xC3, 0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7E, 0x03,
  0xF8, 0x7F, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0xC0, 0x7E, 0x0F, 0xC0,
  0x7F, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0xE1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80,
  0x06, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x01, 0x00, 0x7F, 0x00, 0x30, 0x1F, 0xE0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x01,
  0xFE, 0x07, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x07,
  0xE0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x07, 0xF7, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x00,
  0x1F, 0xCF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC1,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x03,
  0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0x7F, 0xFE,
  0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x87, 0x7F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x0F, 0xFE,
  0x00, 0xC0, 0x00, 0x0C, 0x02, 0x00, 0x3F, 0xE3, 0xF8, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xCF, 0xEF, 0xC1, 0xF1,
  0xF8, 0xF8, 0x3E, 0x3F, 0x1F, 0x0F, 0xC7, 0xC3, 0xE1, 0xF0, 0xF8, 0xFC,
  0x3E, 0x1F, 0x1F, 0x87, 0xC7, 0xE3, 0xE1, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE3, 0xF0, 0xF8, 0xFC, 0x7C, 0x3F, 0x00, 0x0F, 0x87,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x01,
  0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0x3E, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xC1, 0xFE, 0x0F, 0xC0, 0x7F, 0x07, 0xE0, 0x3F, 0x87, 0xF0,
  0x1F, 0xC3, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0xFE,
  0x03, 0xF8, 0x7F, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0xFE, 0x1F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x3F, 0x87, 0xF0, 0x1F, 0x83, 0xF0, 0x1F, 0xC3,
  0xF8, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7E, 0x03, 0xF8,
  0x7F, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x0F, 0xE0,
  0xFF, 0x1F, 0xC0, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x80, 0x7F, 0x3F, 0x00,
  0x3F, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0x7E, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0xFE, 0x7E, 0x01,
  0xFC, 0x7F, 0x03, 0xFC, 0x7F, 0x87, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7E, 0x03,
  0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xFC,
  0x07, 0xF8, 0x3F, 0x01, 0xFE, 0x07, 0xE0, 0x7F, 0xC1, 0xFC, 0x7F, 0xF0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFE, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xC1, 0xFC, 0x7F, 0x80,
  0xFC, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0x7F, 0x1F, 0xC0, 0x3F, 0x8F, 0xC0,
  0x1F, 0x8F, 0xE0, 0x1F, 0xC7, 0xF0, 0x0F, 0xE3, 0xF8, 0x07, 0xF1, 0xF8,
  0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x3F, 0x80, 0xFE, 0x1F,
  0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFD, 0xF8,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xF0, 0x04, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x20, 0x03, 0xF8,
  0x78, 0x07, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x06, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x01, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFF, 0x0F, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7F, 0x1F, 0xC0, 0x7E, 0x1F,
  0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFE, 0x3F, 0x80, 0xFC, 0x3F,
  0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xFC, 0x7F, 0x01, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x03, 0xF8, 0xFE, 0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFE,
  0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF8, 0x1F,
  0xF1, 0xF8, 0x01, 0x80, 0x00, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFE, 0xFE,
  0x00, 0xFE, 0xFE, 0x01, 0xFC, 0xFE, 0x01, 0xFC, 0xFE, 0x03, 0xF8, 0xFE,
  0x03, 0xF8, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7E, 0x3F, 0x80, 0x7F,
  0x3F, 0x80, 0x7F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7E, 0x3E, 0x00,
  0x07, 0xE3, 0xE0, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC7, 0xE1, 0xF0, 0xF8,
  0x7E, 0x3F, 0x0F, 0x87, 0xC3, 0xF8, 0xF8, 0x7C, 0x7F, 0x9F, 0x07, 0xC7,
  0xF9, 0xF0, 0x7C, 0xFF, 0x9F, 0x07, 0xCF, 0x79, 0xE0, 0x7D, 0xF7, 0xBE,
  0x07, 0x9E, 0x7B, 0xE0, 0x7B, 0xE7, 0xBC, 0x07, 0xBC, 0x7F, 0xC0, 0x7F,
  0xC7, 0xFC, 0x07, 0xF8, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x07, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x03,
  0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF9,
  0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xF8,
  0x00, 0xFE, 0x0F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x06, 0x03, 0xFE, 0x03, 0xF1, 0xFF, 0xE0, 0xF8, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xC7, 0xFF, 0xE3,
  0xE0, 0x7F, 0xF0, 0x78, 0x0F, 0xF8, 0x02, 0x00, 0x70, 0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 15, 34, 27, 7, -33 },
  { 65, 20, 15, 27, 8, -36 },
  { 103, 28, 33, 27, 0, -33 },
  { 219, 26, 42, 27, 1, -37 },
  { 356, 33, 35, 27, -2, -34 },
  { 501, 26, 34, 27, 0, -34 },
  { 612, 9, 16, 27, 13, -36 },
  { 630, 22, 47, 27, 5, -38 },
  { 760, 22, 47, 27, 0, -38 },
  { 890, 22, 21, 27, 5, -33 },
  { 948, 23, 24, 27, 2, -26 },
  { 1017, 13, 17, 27, 3, -9 },
  { 1045, 17, 6, 27, 5, -17 },
  { 1058, 9, 10, 27, 7, -9 },
  { 1070, 32, 47, 27, -3, -38 },
  { 1258, 25, 35, 27, 2, -34 },
  { 1368, 22, 33, 27, 1, -33 },
  { 1459, 27, 34, 27, 0, -34 },
  { 1574, 26, 35, 27, 0, -34 },
  { 1688, 27, 33, 27, 0, -33 },
  { 1800, 28, 34, 27, 0, -33 },
  { 1919, 26, 35, 27, 2, -34 },
  { 2033, 26, 33, 27, 4, -33 },
  { 2141, 26, 35, 27, 1, -34 },
  { 2255, 26, 34, 27, 1, -34 },
  { 2366, 13, 26, 27, 7, -25 },
  { 2409, 17, 33, 27, 3, -25 },
  { 2480, 25, 23, 27, 2, -25 },
  { 2552, 27, 16, 27, 0, -22 },
  { 2606, 24, 23, 27, 1, -25 },
  { 2675, 21, 35, 27, 6, -34 },
  { 2767, 27, 41, 27, 1, -34 },
  { 2906, 26, 33, 27, -2, -33 },
  { 3014, 27, 34, 27, 0, -34 },
  { 3129, 26, 35, 27, 3, -34 },
  { 3243, 26, 34, 27, 0, -34 },
  { 3354, 28, 33, 27, 1, -33 },
  { 3470, 28, 33, 27, 1, -33 },
  { 3586, 27, 35, 27, 2, -34 },
  { 3705, 30, 33, 27, -1, -33 },
  { 3829, 29, 33, 27, 0, -33 },
  { 3949, 28, 34, 27, 0, -33 },
  { 4068, 30, 33, 27, 0, -33 },
  { 4192, 22, 33, 27, 0, -33 },
  { 4283, 31, 33, 27, -2, -33 },
  { 4411, 30, 33, 27, -1, -33 },
  { 4535, 25, 35, 27, 2, -34 },
  { 4645, 28, 34, 27, 0, -34 },
  { 4764, 25, 43, 27, 2, -34 },
  { 4899, 27, 34, 27, 0, -34 },
  { 5014, 27, 35, 27, 0, -34 },
  { 5133, 25, 33, 27, 5, -33 },
  { 5237, 27, 34, 27, 2, -33 },
  { 5352, 26, 33, 27, 5, -33 },
  { 5460, 31, 33, 27, 0, -33 },
  { 5588, 33, 33, 27, -2, -33 },
  { 5725, 25, 33, 27, 6, -33 },
  { 5829, 30, 33, 27, -1, -33 },
  { 5953, 26, 47, 27, 3, -38 },
  { 6106, 11, 47, 27, 9, -38 },
  { 6171, 26, 47, 27, -1, -38 },
  { 6324, 25, 19, 27, 2, -33 },
  { 6384, 26, 6, 27, -4, 3 },
  { 6404, 12, 10, 27, 11, -37 },
  { 6419, 25, 27, 27, 1, -26 },
  { 6504, 25, 38, 27, 0, -37 },
  { 6623, 25, 27, 27, 2, -26 },
  { 6708, 28, 38, 27, 1, -37 },
  { 6841, 24, 27, 27, 2, -26 },
  { 6922, 34, 46, 27, -4, -37 },
  { 7118, 29, 35, 27, -2, -26 },
  { 7245, 25, 37, 27, 0, -37 },
  { 7361, 19, 39, 27, 4, -38 },
  { 7454, 27, 47, 27, -2, -38 },
  { 7613, 27, 37, 27, 1, -37 },
  { 7738, 16, 38, 27, 6, -37 },
  { 7814, 27, 26, 27, -1, -26 },
  { 7902, 25, 26, 27, 0, -26 },
  { 7984, 24, 27, 27, 1, -26 },
  { 8065, 27, 35, 27, -2, -26 },
  { 8184, 25, 35, 27, 2, -26 },
  { 8294, 25, 26, 27, 2, -26 },
  { 8376, 24, 27, 27, 1, -26 },
  { 8457, 23, 34, 27, 4, -33 },
  { 8555, 24, 26, 27, 2, -25 },
  { 8633, 24, 25, 27, 4, -25 },
  { 8708, 28, 25, 27, 1, -25 },
  { 8796, 29, 25, 27, -1, -25 },
  { 8887, 32, 34, 27, -4, -25 },
  { 9023, 26, 25, 27, 1, -25 },
  { 9105, 26, 47, 27, 3, -38 },
  { 9258, 18, 47, 27, 5, -38 },
  { 9364, 26, 47, 27, -2, -38 },
  { 9517, 26, 10, 27, 1, -19 },
};

const GFXfont UbuntuSansMono_BoldItalic48pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic48pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic48pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _UBUNTUSANSMONO_BOLDITALIC48PT7B_H_
