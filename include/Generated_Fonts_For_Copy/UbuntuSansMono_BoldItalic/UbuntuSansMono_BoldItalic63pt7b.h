#ifndef _UBUNTUSANSMONO_BOLDITALIC63PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0,
  0x03, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xCF, 0xF8, 0x3F,
  0xE3, 0xFE, 0x0F, 0xF8, 0xFF, 0x83, 0xFE, 0x7F, 0xE1, 0xFF, 0x9F, 0xF0,
  0x7F, 0xC7, 0xFC, 0x1F, 0xF1, 0xFF, 0x07, 0xFC, 0x7F, 0x81, 0xFE, 0x1F,
  0xE0, 0x7F, 0x87, 0xF8, 0x1F, 0xE3, 0xFC, 0x0F, 0xF0, 0xFF, 0x03, 0xFC,
  0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x3F, 0x83, 0xF8, 0x0F, 0xE0, 0xFC, 0x03,
  0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xC0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x7F, 0xC0, 0x1F,
  0xF8, 0x00, 0xE0, 0x07, 0xFC, 0x00, 0x08, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0x01, 0x00, 0x00, 0x7F, 0xC0, 0x60, 0x00, 0x3F,
  0xE0, 0x3F, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x0F, 0xC0, 0x07, 0xE1,
  0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x00, 0x7C, 0x1F, 0x01,
  0xFC, 0x00, 0x3F, 0x07, 0xC0, 0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x3F, 0x00,
  0x03, 0xE0, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x0F, 0xC0, 0x00, 0x3E,
  0x0F, 0x87, 0xE0, 0x00, 0x0F, 0x87, 0xE3, 0xF8, 0x00, 0x03, 0xF3, 0xF1,
  0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0xFE, 0x3F, 0x00,
  0x00, 0x07, 0xFF, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0x8F, 0xC0, 0x00, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0x8F, 0xFE, 0x00, 0x00, 0x0F, 0xE7, 0xFF, 0xC0,
  0x00, 0x07, 0xF3, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0xFF, 0xFC, 0x00, 0x00,
  0xFC, 0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x87, 0xC0, 0x00, 0x3F, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x7C, 0x00, 0x0F, 0xE0, 0xFC, 0x1F,
  0x00, 0x03, 0xF0, 0x3E, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x83, 0xF0, 0x00,
  0xFC, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0x3F, 0x80,
  0x3E, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x83, 0xF8, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0xF8, 0x1F, 0xC1, 0xFF, 0xFF,
  0x07, 0xF0, 0xFF, 0xBF, 0xC3, 0xF8, 0x7F, 0xCF, 0xF8, 0xFE, 0x1F, 0xC1,
  0xFF, 0x7F, 0x0F, 0xF0, 0x3F, 0xDF, 0xC3, 0xF8, 0x0F, 0xFF, 0xE1, 0xFE,
  0x01, 0xFF, 0xF8, 0x7F, 0x00, 0x3F, 0xFC, 0x1F, 0xC0, 0x0F, 0xFE, 0x07,
  0xF0, 0x01, 0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x1F, 0xF8,
  0x1F, 0xE0, 0x0F, 0xFE, 0x07, 0xFC, 0x0F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x7F, 0x81, 0xFF, 0xFF,
  0x9F, 0xE0, 0x3F, 0xFF, 0x87, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x1F, 0xF1, 0xFF, 0x3F, 0xF3, 0xFE, 0x3F, 0xE3, 0xFE,
  0x7F, 0xE7, 0xFC, 0x7F, 0xC7, 0xFC, 0x7F, 0xC7, 0xF8, 0x7F, 0x87, 0xF0,
  0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xC0, 0x7F, 0x01, 0x87, 0xC3,
  0xF8, 0x3C, 0x3F, 0x0F, 0xC7, 0xE3, 0xFE, 0x7C, 0xFF, 0x9F, 0xFB, 0xEF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x7F, 0xDF,
  0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0xE3, 0xFF, 0x01, 0xFE, 0x0F, 0xF0,
  0x07, 0xF0, 0x7F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x80, 0x20, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F,
  0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83,
  0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xF8, 0x0F, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF8,
  0x03, 0xF0, 0x01, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0x07, 0x01, 0xFE, 0x3F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xE3, 0xFC, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0x81,
  0xFF, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x1F, 0xE0, 0xFF, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0,
  0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0,
  0x00, 0x3F, 0xCF, 0xF8, 0x7C, 0x1F, 0xE7, 0xF8, 0x7F, 0x0F, 0xF3, 0xFC,
  0x3F, 0x87, 0xF9, 0xFE, 0x3F, 0xC7, 0xFD, 0xFF, 0x1F, 0xE3, 0xFC, 0xFF,
  0x0F, 0xF1, 0xFE, 0x7F, 0x87, 0xF0, 0xFF, 0x3F, 0xC3, 0xF0, 0x7F, 0x9F,
  0xE0, 0xF0, 0x7F, 0x8F, 0xF0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE,
  0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF,
  0x01, 0xFF, 0xCF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xFE, 0x7F, 0x80, 0x3F, 0xCF, 0xF8, 0x03,
  0xF0, 0xFF, 0x80, 0x1C, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xE0,
  0x0F, 0xC0, 0x0F, 0xFC, 0x00, 0xE0, 0x00, 0xFF, 0x80, 0x10, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xBF, 0xFF,
  0x00, 0x0F, 0x00, 0x7F, 0xE0, 0x01, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x01, 0x00, 0x00, 0x7F, 0xE0, 0x38, 0x00, 0x1F, 0xFC, 0x0F,
  0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x03, 0xFE, 0x7F, 0x80, 0x00, 0x3F,
  0xCF, 0xF8, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x81, 0xFE,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F,
  0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x20,
  0x00, 0x1F, 0xF8, 0x03, 0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x20, 0x00, 0x0F, 0xF1,
  0xFF, 0xC0, 0x03, 0xFD, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xC0, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x1F, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xE0, 0x01, 0xFE, 0x0F, 0xF8,
  0x00, 0xFF, 0x83, 0xFF, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x3F, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xF0,
  0x01, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x81, 0xFF, 0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFE, 0xFF, 0xF0, 0x03,
  0xFE, 0x1F, 0xFC, 0x03, 0xFC, 0x07, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x83,
  0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xF1, 0xFE, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x03, 0xFE, 0x3F, 0xC0, 0x01, 0xFF,
  0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0xFF,
  0xC3, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0x01, 0xFF,
  0x81, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xF8, 0x3F, 0xE0, 0x01,
  0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x7F, 0xC3, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xEF, 0xF0, 0x00, 0xFF, 0xE7, 0xFC, 0x00, 0x02, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F,
  0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xC0,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0x80, 0x7F,
  0xC0, 0x7F, 0xF0, 0x7F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07,
  0xFF, 0x83, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0x00, 0xFF, 0xE1, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFC, 0xFF, 0xE0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xFF, 0xF0, 0xFE, 0x03, 0xFF, 0xFE, 0x1F, 0xC0, 0x7F, 0xFF,
  0xE1, 0xFC, 0x0F, 0xFF, 0xFE, 0x1F, 0x81, 0xFF, 0xFF, 0xE3, 0xF8, 0x3F,
  0xFF, 0xFE, 0x3F, 0x83, 0xFF, 0xFF, 0xC3, 0xF0, 0x7F, 0xC1, 0xFC, 0x3F,
  0x07, 0xF8, 0x3F, 0xC7, 0xF0, 0xFF, 0x03, 0xFC, 0x7F, 0x0F, 0xE0, 0x3F,
  0x87, 0xE0, 0xFE, 0x03, 0xF8, 0x7E, 0x0F, 0xE0, 0x7F, 0x87, 0xE1, 0xFE,
  0x07, 0xF8, 0x7E, 0x1F, 0xC0, 0x7F, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0xFE,
  0x1F, 0xC0, 0xFF, 0x0F, 0xE1, 0xFC, 0x0F, 0xF0, 0xFE, 0x1F, 0xC0, 0xFE,
  0x0F, 0xE1, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xE0, 0xFE, 0x0F, 0xE1, 0xFF,
  0x1F, 0xE0, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFE,
  0x07, 0xFF, 0xFC, 0x07, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0x03, 0xFF, 0xF8,
  0x07, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0x06, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x04, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x07, 0xF8,
  0x0F, 0xE0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xC0, 0x01,
  0xFF, 0x1F, 0xF0, 0x00, 0x7F, 0xC7, 0xF8, 0x00, 0x1F, 0xF3, 0xFE, 0x00,
  0x07, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xC0, 0x00, 0x7F, 0xDF, 0xF0,
  0x00, 0x1F, 0xF7, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFC, 0x07, 0xFF, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x01, 0xFF, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x0F, 0xFC, 0x1F, 0xE0, 0x03, 0xFF,
  0x83, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xE0, 0x3E, 0x01, 0xFF, 0xC0, 0x03, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x08,
  0x03, 0xFF, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x7F,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x01, 0xFF,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x07, 0xFC, 0x0F, 0xF0, 0x00,
  0xFF, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x03, 0xFC, 0x0F, 0xF8,
  0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x03, 0xFE, 0x0F,
  0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE,
  0x0F, 0xF8, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xF0, 0x3F, 0xE0,
  0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xF0, 0x3F,
  0xE0, 0x3F, 0xFC, 0x07, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x00, 0x16, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x1F, 0x00, 0xFF, 0xE0, 0x00,
  0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF0,
  0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F,
  0xC3, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x80, 0x0F, 0xF8, 0x3F, 0xE0, 0x03,
  0xFE, 0x0F, 0xF8, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80,
  0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFF, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x02, 0x00, 0x07, 0xFC,
  0x00, 0x3C, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0x81,
  0xFF, 0x80, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xF8, 0x00, 0x01, 0xFE,
  0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFF, 0x00, 0x00, 0x0F, 0xF1,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0xE0, 0x00, 0x1F,
  0xE0, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x1F, 0xFE, 0x00, 0x7E, 0xF8, 0x3F, 0xFC, 0x00, 0x7E, 0xF8, 0x3E,
  0xFC, 0x00, 0xFE, 0xF8, 0x7E, 0xFC, 0x00, 0xFE, 0xF8, 0x7D, 0xFC, 0x00,
  0xFC, 0xF8, 0xFD, 0xFC, 0x01, 0xFC, 0xF8, 0xF9, 0xF8, 0x01, 0xFC, 0xF9,
  0xF9, 0xF8, 0x01, 0xFC, 0xF9, 0xF3, 0xF8, 0x01, 0xF8, 0xFB, 0xF3, 0xF8,
  0x03, 0xF8, 0xFB, 0xE3, 0xF8, 0x03, 0xF8, 0xFF, 0xE3, 0xF8, 0x03, 0xF8,
  0xFF, 0xC7, 0xF0, 0x07, 0xF0, 0xFF, 0xC7, 0xF0, 0x07, 0xF0, 0x7F, 0x87,
  0xF0, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0x0F,
  0xF0, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x01,
  0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0xF8,
  0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x07, 0xF8,
  0x00, 0xFF, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0xFC, 0x07, 0xF0, 0x01, 0xFE,
  0xFC, 0x07, 0xF0, 0x01, 0xFE, 0xFC, 0x0F, 0xF0, 0x01, 0xFC, 0xFE, 0x0F,
  0xF0, 0x01, 0xFC, 0x7E, 0x0F, 0xF0, 0x03, 0xFC, 0x7E, 0x0F, 0xE0, 0x03,
  0xFC, 0x7E, 0x1F, 0xE0, 0x03, 0xFC, 0x7F, 0x1F, 0xE0, 0x03, 0xF8, 0x3F,
  0x1F, 0xE0, 0x07, 0xF8, 0x3F, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0x3F, 0xC0,
  0x07, 0xF8, 0x3F, 0xBF, 0xC0, 0x07, 0xF0, 0x3F, 0xBF, 0xC0, 0x0F, 0xF0,
  0x1F, 0xBF, 0x80, 0x0F, 0xF0, 0x1F, 0xBF, 0x80, 0x0F, 0xF0, 0x1F, 0xFF,
  0x80, 0x0F, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xFF, 0x00, 0x1F,
  0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xFE, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80,
  0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xF8, 0x7F, 0xC0,
  0x03, 0xFC, 0x7F, 0xC0, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xF0,
  0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xE7, 0xFC,
  0x00, 0x1F, 0xF3, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF,
  0x00, 0x03, 0xFE, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0xFF, 0xBF, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xCF,
  0xF8, 0x00, 0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF9,
  0xFF, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC,
  0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x0F, 0xFC, 0x03, 0xFF,
  0x03, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F,
  0xF8, 0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3F, 0xC0,
  0x3F, 0xE0, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F,
  0xC0, 0x1F, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0x80, 0x3F, 0xE0,
  0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0xC0, 0x07, 0xF8, 0x7F, 0xC0, 0x03, 0xFC,
  0x3F, 0xC0, 0x01, 0xFE, 0x3F, 0xE0, 0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x7F,
  0x9F, 0xF0, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x1F,
  0xF3, 0xFC, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x07, 0xFD, 0xFF, 0x00, 0x03,
  0xFE, 0xFF, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0xFF, 0x9F, 0xE0, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0x3F, 0xCF, 0xF8, 0x00,
  0x3F, 0xE7, 0xFC, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0x0F, 0xF1, 0xFF, 0x00,
  0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xE0,
  0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0x03, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xF0, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x1F, 0xF0, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0xF8, 0x00, 0x18, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x01, 0x00, 0x00, 0x7F, 0xC0, 0x18, 0x00, 0x07, 0xFC, 0x03, 0xF0, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F,
  0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F,
  0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xF8,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00,
  0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x3F, 0xE0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F,
  0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x0F, 0xFB, 0xFE, 0x00, 0x03,
  0xFC, 0xFF, 0x80, 0x01, 0xFF, 0x3F, 0xE0, 0x00, 0x7F, 0xCF, 0xF8, 0x00,
  0x3F, 0xE3, 0xFE, 0x00, 0x0F, 0xF8, 0xFF, 0x80, 0x07, 0xFC, 0x3F, 0xE0,
  0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x0F, 0xF0, 0x3F, 0xE0, 0x07, 0xFC, 0x0F, 0xF8, 0x01, 0xFE, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x7E, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE1, 0xFF, 0x0F, 0xE0, 0x0F, 0xE1, 0xFF, 0x0F, 0xE0,
  0x0F, 0xE3, 0xFF, 0x0F, 0xE0, 0x0F, 0xE3, 0xFF, 0x1F, 0xC0, 0x1F, 0xC7,
  0xFF, 0x1F, 0xC0, 0x1F, 0xC7, 0xDF, 0x1F, 0xC0, 0x1F, 0xCF, 0xDF, 0x1F,
  0x80, 0x1F, 0xCF, 0x9F, 0x3F, 0x80, 0x1F, 0x9F, 0x9F, 0x3F, 0x80, 0x1F,
  0x9F, 0x1F, 0x3F, 0x80, 0x3F, 0xBF, 0x1F, 0x3F, 0x00, 0x3F, 0xBE, 0x1F,
  0x7F, 0x00, 0x3F, 0x7E, 0x1F, 0x7F, 0x00, 0x3F, 0x7C, 0x1F, 0x7E, 0x00,
  0x3F, 0xFC, 0x1F, 0x7E, 0x00, 0x3F, 0xF8, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC1, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x9F, 0xF0, 0x00,
  0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xBF, 0xC0, 0x00, 0x00, 0x1F, 0xF7, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xE1, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x0F,
  0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xDF, 0xE0, 0x00, 0x3F,
  0xE7, 0xF8, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x80, 0x03,
  0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0x87, 0xFC, 0x00, 0x7F, 0xC1, 0xFF, 0x00,
  0x3F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0xC0, 0x07,
  0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0xC0,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F,
  0xE0, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0,
  0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7F,
  0xC1, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0x81,
  0xFE, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xF8, 0x1F, 0xF0,
  0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0x8F, 0xF8,
  0x03, 0xFF, 0x0F, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xFC,
  0x0F, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x03, 0xFE, 0x3F, 0xF0, 0x03, 0xFE,
  0x7F, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0x7F, 0x80, 0x01, 0xFF, 0x1F, 0x00, 0x00, 0xFC, 0x06, 0x00, 0x00, 0xE0,
  0x02, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFE, 0x08, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x7F,
  0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0x07, 0xFE, 0x01, 0xFC, 0x00,
  0x7C, 0x00, 0x18, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFE, 0x03, 0xFE, 0x1F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x3F,
  0xE0, 0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x07, 0xFC, 0x7F,
  0xC0, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF,
  0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F, 0xF0, 0xFF,
  0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x3F, 0xE0, 0xFF,
  0xC0, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xCF, 0xF8, 0x07, 0xFF, 0x07, 0xF0, 0x00, 0xF8, 0x04, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x1F, 0x00, 0x00, 0xFF, 0x7F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFE,
  0x03, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0x7F, 0xC1, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F,
  0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0x03, 0xFE, 0x1F, 0xF0, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x7F, 0xC3,
  0xFE, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xF0,
  0xFF, 0x80, 0x1F, 0xF8, 0x7F, 0xC0, 0x1F, 0xF8, 0x3F, 0xE0, 0x1F, 0xFC,
  0x1F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x08, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0,
  0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0x9F, 0xF0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xC0, 0x1F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xF9, 0xFF, 0x00, 0x07, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x20,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x1F, 0xF8, 0x03,
  0xFE, 0x3F, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xF9, 0xFE, 0x00, 0x0F,
  0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF0, 0x00, 0xFF, 0x9F, 0xE0, 0x07, 0xFF,
  0x7F, 0x80, 0x7F, 0xFC, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x03, 0x03, 0xFF,
  0xE0, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x30, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xE0,
  0x03, 0xFF, 0x87, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xF8,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x10, 0x00, 0x1F,
  0xF8, 0x00, 0x78, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x9F,
  0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFE, 0x01,
  0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01,
  0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01,
  0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8, 0x03,
  0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x03,
  0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0, 0x07,
  0xFC, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0, 0x0F,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F,
  0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80, 0x1F,
  0xE0, 0x00, 0x00, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x60, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x10,
  0x00, 0xFF, 0x80, 0x03, 0xC0, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x7F, 0xE0, 0x01,
  0xFE, 0x0F, 0xFC, 0x00, 0x3F, 0xE1, 0xFF, 0x80, 0x03, 0xFE, 0x3F, 0xF0,
  0x00, 0x3F, 0xE7, 0xFE, 0x00, 0x03, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xDF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF3, 0xFE, 0x00, 0x01, 0xFF, 0x3F,
  0xF0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0xFF, 0x80, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0xC0,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x81, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x80, 0x04, 0x00, 0x03, 0xFF, 0x87, 0xF8, 0x01, 0xFF,
  0xFD, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x87, 0xF8,
  0xFF, 0x03, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0x87, 0xF0, 0xFF, 0x07, 0xF8,
  0x7F, 0x0F, 0xE0, 0x7F, 0x07, 0xF0, 0xFE, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0x7F, 0x0F, 0xE0, 0xFE, 0x07, 0xF0, 0xFE, 0x1F, 0xC0, 0xFE, 0x0F, 0xE1,
  0xFC, 0x0F, 0xE0, 0xFC, 0x1F, 0xC0, 0xFE, 0x1F, 0xC1, 0xFC, 0x0F, 0xE1,
  0xFC, 0x3F, 0xC1, 0xFC, 0x1F, 0xC3, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0x81,
  0xFC, 0x20, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFE,
  0x01, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0xFF, 0x03, 0xFC,
  0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0x07, 0xFC,
  0x01, 0xFF, 0x07, 0xF8, 0x01, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF8,
  0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0,
  0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0xF8, 0x3F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x7F, 0xC0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFC, 0x07,
  0xFE, 0x3F, 0xF0, 0x0F, 0xFC, 0x7F, 0xC0, 0x0F, 0xF9, 0xFF, 0x00, 0x1F,
  0xF3, 0xFE, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF, 0xF0, 0x00, 0xFF,
  0xBF, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00, 0x3F, 0xEF, 0xF8, 0x00, 0x7F, 0xDF,
  0xF0, 0x00, 0xFF, 0xBF, 0xE0, 0x03, 0xFE, 0x7F, 0xC0, 0x07, 0xFC, 0xFF,
  0x80, 0x1F, 0xF1, 0xFF, 0x80, 0x7F, 0xE3, 0xFF, 0x01, 0xFF, 0x83, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x1F, 0xF0, 0x1F, 0xF0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x1F,
  0xF0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x07, 0xFC, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F,
  0xC0, 0x7F, 0xF8, 0x07, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xA0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0x07, 0xFE,
  0x00, 0xFF, 0x07, 0xFE, 0x00, 0xFF, 0x83, 0xFE, 0x00, 0x7F, 0xC3, 0xFE,
  0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0xFF,
  0x80, 0x0F, 0xF8, 0x7F, 0xC0, 0x07, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F,
  0xE0, 0x03, 0xFE, 0x0F, 0xF0, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0xFF, 0x87,
  0xFC, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0,
  0x7F, 0x80, 0x1F, 0xF0, 0x3F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xBF, 0xE0, 0x00, 0x1C, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x7C, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xF8,
  0x03, 0xFE, 0x00, 0x08, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x10, 0x00, 0x1F, 0xF0,
  0x3E, 0x00, 0x3F, 0xF0, 0x3F, 0xF7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x01,
  0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x1F,
  0xF0, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC, 0x01, 0xFF,
  0x0F, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0xC0, 0x1F, 0xF0,
  0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0xFF, 0x0F,
  0xF8, 0x03, 0xFE, 0x1F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0, 0x0F, 0xF8, 0x7F,
  0x80, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0xFF, 0x87, 0xFC,
  0x01, 0xFF, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0,
  0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xCF,
  0xF0, 0x0F, 0xFE, 0x1F, 0xC0, 0x03, 0xE0, 0x10, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFE, 0xFF, 0x80, 0x07, 0xFC, 0xFF, 0x80, 0x07,
  0xFC, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0x0F, 0xF8, 0xFF, 0x80, 0x0F,
  0xF8, 0xFF, 0x80, 0x1F, 0xF0, 0xFF, 0x80, 0x1F, 0xF0, 0x7F, 0x80, 0x3F,
  0xE0, 0x7F, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x3F, 0xC3, 0xFC,
  0x00, 0x3F, 0xC7, 0xFC, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF8, 0x1F, 0x81, 0xFC, 0x7F, 0x03, 0xF8,
  0x3F, 0x87, 0xF0, 0x3F, 0x83, 0xF8, 0x7F, 0x07, 0xF8, 0x3F, 0x87, 0xF0,
  0x7F, 0x83, 0xF0, 0x7F, 0x0F, 0xF8, 0x7F, 0x07, 0xF0, 0xFF, 0x87, 0xF0,
  0x7E, 0x1F, 0xF8, 0x7E, 0x07, 0xE1, 0xFF, 0x8F, 0xE0, 0x7E, 0x3F, 0xF8,
  0xFE, 0x0F, 0xE3, 0xEF, 0x8F, 0xC0, 0xFE, 0x7E, 0xF9, 0xFC, 0x0F, 0xE7,
  0xEF, 0x9F, 0x80, 0xFC, 0xFC, 0xF9, 0xF8, 0x0F, 0xCF, 0x8F, 0xBF, 0x80,
  0xFD, 0xF8, 0xFB, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0xFF,
  0xE0, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFC,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x7F, 0xC0, 0x00, 0x1F, 0xF1, 0xFF, 0x00, 0x00, 0x3F, 0xEF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xF7, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xF8,
  0x00, 0x07, 0xFC, 0x3F, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0xFF, 0xC0,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0xC7, 0xFC, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0xDF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x10, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x08, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x08,
  0x00, 0xFF, 0xE0, 0x07, 0xE0, 0x7F, 0xFC, 0x01, 0xFC, 0x3F, 0xFF, 0xC0,
  0xFE, 0x1F, 0xFF, 0xFC, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xC0,
  0xFF, 0xFE, 0x0F, 0xE0, 0x0F, 0xFF, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x04,
  0x00, 0x1F, 0x00, 0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 20, 45, 35, 9, -44 },
  { 114, 26, 20, 35, 11, -48 },
  { 179, 37, 44, 35, 0, -44 },
  { 383, 34, 56, 35, 1, -49 },
  { 621, 42, 46, 35, -2, -45 },
  { 863, 34, 46, 35, 0, -45 },
  { 1059, 12, 21, 35, 17, -48 },
  { 1091, 28, 62, 35, 7, -50 },
  { 1308, 29, 62, 35, 0, -50 },
  { 1533, 29, 28, 35, 6, -44 },
  { 1635, 31, 31, 35, 2, -34 },
  { 1756, 17, 23, 35, 4, -12 },
  { 1805, 22, 8, 35, 7, -22 },
  { 1827, 12, 13, 35, 9, -12 },
  { 1847, 41, 61, 35, -3, -49 },
  { 2160, 33, 46, 35, 2, -45 },
  { 2350, 28, 44, 35, 2, -44 },
  { 2504, 35, 45, 35, 0, -45 },
  { 2701, 35, 46, 35, -1, -45 },
  { 2903, 36, 44, 35, 0, -44 },
  { 3101, 37, 45, 35, 0, -44 },
  { 3310, 34, 45, 35, 3, -44 },
  { 3502, 33, 44, 35, 6, -44 },
  { 3684, 33, 46, 35, 2, -45 },
  { 3874, 34, 45, 35, 1, -45 },
  { 4066, 17, 34, 35, 9, -33 },
  { 4139, 22, 44, 35, 4, -33 },
  { 4260, 32, 30, 35, 3, -33 },
  { 4380, 35, 21, 35, 0, -29 },
  { 4472, 32, 30, 35, 1, -33 },
  { 4592, 27, 46, 35, 8, -45 },
  { 4748, 36, 55, 35, 1, -45 },
  { 4996, 34, 44, 35, -3, -44 },
  { 5183, 35, 45, 35, 0, -44 },
  { 5380, 33, 46, 35, 4, -45 },
  { 5570, 35, 45, 35, 0, -44 },
  { 5767, 36, 44, 35, 1, -44 },
  { 5965, 38, 44, 35, 1, -44 },
  { 6174, 34, 46, 35, 3, -45 },
  { 6370, 40, 44, 35, -1, -44 },
  { 6590, 38, 44, 35, 0, -44 },
  { 6799, 37, 45, 35, 0, -44 },
  { 7008, 40, 44, 35, 0, -44 },
  { 7228, 29, 44, 35, 0, -44 },
  { 7388, 40, 44, 35, -2, -44 },
  { 7608, 40, 44, 35, -1, -44 },
  { 7828, 33, 46, 35, 2, -45 },
  { 8018, 37, 44, 35, 0, -44 },
  { 8222, 33, 57, 35, 2, -45 },
  { 8458, 35, 44, 35, 0, -44 },
  { 8651, 36, 46, 35, 0, -45 },
  { 8858, 34, 44, 35, 6, -44 },
  { 9045, 36, 45, 35, 2, -44 },
  { 9248, 34, 44, 35, 7, -44 },
  { 9435, 40, 44, 35, 0, -44 },
  { 9655, 43, 44, 35, -3, -44 },
  { 9892, 34, 44, 35, 7, -44 },
  { 10079, 39, 44, 35, -1, -44 },
  { 10294, 34, 61, 35, 4, -49 },
  { 10554, 14, 61, 35, 12, -49 },
  { 10661, 35, 61, 35, -2, -49 },
  { 10928, 32, 26, 35, 3, -44 },
  { 11032, 33, 8, 35, -5, 4 },
  { 11065, 16, 13, 35, 14, -49 },
  { 11091, 32, 35, 35, 2, -34 },
  { 11231, 33, 50, 35, 0, -49 },
  { 11438, 32, 35, 35, 3, -34 },
  { 11578, 37, 50, 35, 2, -49 },
  { 11810, 31, 35, 35, 3, -34 },
  { 11946, 44, 61, 35, -5, -49 },
  { 12282, 38, 46, 35, -3, -34 },
  { 12501, 32, 49, 35, 0, -49 },
  { 12697, 25, 51, 35, 5, -50 },
  { 12857, 36, 62, 35, -3, -50 },
  { 13136, 36, 49, 35, 1, -49 },
  { 13357, 21, 50, 35, 8, -49 },
  { 13489, 36, 34, 35, -1, -34 },
  { 13642, 32, 34, 35, 0, -34 },
  { 13778, 31, 35, 35, 2, -34 },
  { 13914, 36, 46, 35, -3, -34 },
  { 14121, 33, 46, 35, 2, -34 },
  { 14311, 33, 34, 35, 2, -34 },
  { 14452, 32, 35, 35, 1, -34 },
  { 14592, 30, 44, 35, 5, -43 },
  { 14757, 31, 34, 35, 3, -33 },
  { 14889, 32, 33, 35, 5, -33 },
  { 15021, 36, 33, 35, 2, -33 },
  { 15170, 38, 33, 35, -2, -33 },
  { 15327, 42, 45, 35, -6, -33 },
  { 15564, 34, 33, 35, 1, -33 },
  { 15705, 34, 61, 35, 4, -49 },
  { 15965, 24, 61, 35, 6, -49 },
  { 16148, 33, 61, 35, -2, -49 },
  { 16400, 34, 13, 35, 1, -25 },
};

const GFXfont UbuntuSansMono_BoldItalic63pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic63pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic63pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _UBUNTUSANSMONO_BOLDITALIC63PT7B_H_
