#ifndef _UBUNTUSANSMONO_BOLDITALIC6PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic6pt7bBitmaps[] PROGMEM = {
  0x00, 0x62, 0xF0, 0x7E, 0xEC, 0x2D, 0x1E, 0x80, 0xDE, 0x6E, 0x6B, 0xF0,
  0xC0, 0x5A, 0xA0, 0x44, 0x95, 0x00, 0xF0, 0x5D, 0x00, 0x70, 0xC0, 0x80,
  0x12, 0x24, 0x88, 0x7E, 0xF0, 0x65, 0x70, 0x65, 0x70, 0x6C, 0xF0, 0x2F,
  0x90, 0x68, 0xF0, 0x7E, 0xF0, 0xEA, 0x40, 0x6E, 0xF0, 0x75, 0xE0, 0xC8,
  0x61, 0x60, 0x78, 0x80, 0xFC, 0xCE, 0x00, 0xDA, 0x7A, 0xEE, 0x60, 0x6F,
  0xD0, 0x7E, 0xF0, 0x78, 0x86, 0x76, 0xF0, 0x76, 0x8E, 0x76, 0x88, 0x78,
  0xAE, 0x56, 0xAA, 0x74, 0x4E, 0x64, 0xE0, 0x74, 0xCA, 0x4A, 0x70, 0x5E,
  0xEA, 0x56, 0xAA, 0x76, 0xF0, 0x6F, 0x40, 0x76, 0xF6, 0x77, 0xD0, 0x68,
  0xF0, 0xF2, 0x40, 0x5A, 0xAE, 0xBB, 0x40, 0x5D, 0xEA, 0x76, 0x6A, 0xBA,
  0x40, 0x72, 0x4E, 0x34, 0x44, 0x4C, 0xFC, 0x64, 0xA5, 0x80, 0x7C, 0xE0,
  0x90, 0x77, 0x80, 0x49, 0xDE, 0x73, 0x80, 0x12, 0x6A, 0xE0, 0x7F, 0x80,
  0x34, 0x64, 0x48, 0x75, 0xE0, 0x49, 0xDA, 0x23, 0x26, 0x21, 0x95, 0x80,
  0x45, 0x6C, 0xA0, 0xEA, 0xC0, 0xFE, 0x80, 0x76, 0x80, 0x77, 0x80, 0x77,
  0xC0, 0x77, 0x90, 0x72, 0x00, 0x6F, 0x80, 0x5D, 0x30, 0xF7, 0x80, 0xAD,
  0x00, 0xDE, 0xA0, 0xEA, 0x80, 0x53, 0x2C, 0x6B, 0x80, 0x32, 0x4C, 0x44,
  0x5A, 0xA0, 0x45, 0x35, 0x80, 0xE0,
};

const GFXglyph UbuntuSansMono_BoldItalic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 4, 3, 1, -4 },
  { 2, 2, 2, 3, 1, -5 },
  { 3, 4, 4, 3, 0, -4 },
  { 5, 3, 6, 3, 0, -5 },
  { 8, 4, 4, 3, 0, -4 },
  { 10, 3, 4, 3, 0, -4 },
  { 12, 1, 2, 3, 2, -5 },
  { 13, 2, 6, 3, 1, -5 },
  { 15, 3, 6, 3, 0, -5 },
  { 18, 2, 2, 3, 1, -4 },
  { 19, 3, 3, 3, 0, -3 },
  { 21, 2, 2, 3, 0, -1 },
  { 22, 2, 1, 3, 1, -2 },
  { 23, 1, 1, 3, 1, -1 },
  { 24, 4, 6, 3, 0, -5 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 1, -4 },
  { 43, 3, 4, 3, 0, -4 },
  { 45, 3, 4, 3, 0, -4 },
  { 47, 2, 3, 3, 1, -3 },
  { 48, 3, 4, 3, 0, -3 },
  { 50, 3, 3, 3, 0, -3 },
  { 52, 3, 2, 3, 0, -3 },
  { 53, 3, 3, 3, 0, -3 },
  { 55, 2, 4, 3, 1, -4 },
  { 56, 4, 5, 3, 0, -4 },
  { 59, 3, 4, 3, 0, -4 },
  { 61, 3, 4, 3, 0, -4 },
  { 63, 4, 4, 3, 0, -4 },
  { 65, 3, 4, 3, 0, -4 },
  { 67, 4, 4, 3, 0, -4 },
  { 69, 4, 4, 3, 0, -4 },
  { 71, 4, 4, 3, 0, -4 },
  { 73, 4, 4, 3, 0, -4 },
  { 75, 4, 4, 3, 0, -4 },
  { 77, 3, 4, 3, 0, -4 },
  { 79, 4, 4, 3, 0, -4 },
  { 81, 3, 4, 3, 0, -4 },
  { 83, 4, 4, 3, 0, -4 },
  { 85, 4, 4, 3, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 3, 5, 3, 0, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 3, 4, 3, 1, -4 },
  { 99, 4, 4, 3, 0, -4 },
  { 101, 3, 4, 3, 1, -4 },
  { 103, 4, 4, 3, 0, -4 },
  { 105, 4, 4, 3, 0, -4 },
  { 107, 3, 4, 3, 1, -4 },
  { 109, 4, 4, 3, 0, -4 },
  { 111, 4, 6, 3, 0, -5 },
  { 114, 1, 6, 3, 1, -5 },
  { 115, 3, 6, 3, 0, -5 },
  { 118, 3, 2, 3, 0, -4 },
  { 119, 3, 1, 3, 0, 0 },
  { 120, 2, 2, 3, 1, -5 },
  { 121, 3, 3, 3, 0, -3 },
  { 123, 3, 5, 3, 0, -5 },
  { 125, 3, 3, 3, 0, -3 },
  { 127, 4, 5, 3, 0, -5 },
  { 130, 3, 3, 3, 0, -3 },
  { 132, 4, 6, 3, 0, -5 },
  { 135, 3, 4, 3, 0, -3 },
  { 137, 3, 5, 3, 0, -5 },
  { 139, 3, 5, 3, 0, -5 },
  { 141, 3, 6, 3, 0, -5 },
  { 144, 4, 5, 3, 0, -5 },
  { 147, 2, 5, 3, 1, -5 },
  { 149, 3, 3, 3, 0, -3 },
  { 151, 3, 3, 3, 0, -3 },
  { 153, 3, 3, 3, 0, -3 },
  { 155, 3, 4, 3, 0, -3 },
  { 157, 3, 4, 3, 0, -3 },
  { 159, 3, 3, 3, 0, -3 },
  { 161, 3, 3, 3, 0, -3 },
  { 163, 3, 4, 3, 0, -4 },
  { 165, 3, 3, 3, 0, -3 },
  { 167, 3, 3, 3, 0, -3 },
  { 169, 4, 3, 3, 0, -3 },
  { 171, 3, 3, 3, 0, -3 },
  { 173, 4, 4, 3, -1, -3 },
  { 175, 3, 3, 3, 0, -3 },
  { 177, 4, 6, 3, 0, -5 },
  { 180, 2, 6, 3, 1, -5 },
  { 182, 3, 6, 3, 0, -5 },
  { 185, 3, 1, 3, 0, -2 },
};

const GFXfont UbuntuSansMono_BoldItalic6pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic6pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic6pt7bGlyphs,
  0x20, 0x7E, 7
};

#endif // _UBUNTUSANSMONO_BOLDITALIC6PT7B_H_
