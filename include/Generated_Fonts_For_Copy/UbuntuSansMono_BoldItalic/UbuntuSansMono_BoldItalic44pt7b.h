#ifndef _UBUNTUSANSMONO_BOLDITALIC44PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x01, 0xF8, 0x01, 0x00, 0x00, 0x7F, 0x1F, 0xDF, 0x87,
  0xE7, 0xE3, 0xF9, 0xF8, 0xFE, 0xFE, 0x3F, 0x3F, 0x0F, 0xCF, 0xC3, 0xF3,
  0xF0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x0F, 0x03, 0xC3, 0xC1, 0xF0, 0xF0,
  0x78, 0x00, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC3,
  0xE0, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8,
  0x47, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x81, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFE, 0x1F, 0x01,
  0xFC, 0x01, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x07, 0x00, 0x7F, 0x03, 0xF0, 0xFF, 0x83, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x04, 0x03, 0xF8,
  0x01, 0xE0, 0x1F, 0xF0, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x03, 0xCF, 0x01,
  0xE0, 0x1E, 0x3C, 0x0F, 0x00, 0x78, 0xF0, 0x78, 0x01, 0xE3, 0xC3, 0xC0,
  0x07, 0x8F, 0x1F, 0x00, 0x1C, 0x3C, 0xF8, 0x00, 0x79, 0xE3, 0xC0, 0x01,
  0xFF, 0x9E, 0x00, 0x07, 0xFC, 0xF0, 0x00, 0x0F, 0xE7, 0x80, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x8C, 0x00, 0x00, 0x3C,
  0xFE, 0x00, 0x01, 0xE7, 0xF8, 0x00, 0x0F, 0x3F, 0xF0, 0x00, 0x7C, 0xF3,
  0xC0, 0x03, 0xE7, 0x8F, 0x00, 0x1F, 0x1E, 0x3C, 0x00, 0x78, 0x78, 0xF0,
  0x03, 0xC1, 0xC3, 0xC0, 0x1E, 0x0F, 0x1E, 0x00, 0xF8, 0x3C, 0x78, 0x07,
  0xC0, 0xF3, 0xE0, 0x3E, 0x01, 0xFF, 0x00, 0xF0, 0x07, 0xF8, 0x0F, 0x80,
  0x0F, 0xC0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF0, 0x7C,
  0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8,
  0x03, 0xE1, 0xF0, 0x03, 0xE3, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0x07, 0xFE, 0x1F, 0x0F, 0xFE, 0x3E,
  0x1F, 0xBF, 0x3E, 0x3E, 0x1F, 0xBE, 0x7E, 0x1F, 0xFC, 0x7C, 0x0F, 0xF8,
  0x7C, 0x07, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0,
  0x7E, 0x1F, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFE, 0xF8, 0x3F, 0xFC, 0xFC,
  0x1F, 0xF0, 0xFC, 0x3F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0xFC, 0xFC,
  0xFC, 0xF8, 0xF8, 0xF0, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0x78, 0x00, 0x03, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x03,
  0xC0, 0x00, 0x30, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x41, 0xF0, 0x03, 0x8F, 0x8E, 0x3E, 0x79, 0xF1, 0xFD, 0xDF, 0xCF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x07, 0xFC,
  0x00, 0x7D, 0xF0, 0x07, 0xEF, 0xC0, 0x7E, 0x7F, 0x07, 0xF1, 0xF8, 0x0F,
  0x0F, 0x80, 0x38, 0x38, 0x00, 0x81, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0xFE, 0x0F,
  0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFE, 0x03, 0xE0, 0x3C, 0x0F,
  0xCF, 0xF8, 0xFF, 0x0F, 0xE0, 0xF8, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF,
  0xF3, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0x80, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x0F,
  0xC0, 0x3E, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF0,
  0x03, 0xE7, 0xE3, 0x87, 0xCF, 0x8F, 0x8F, 0x9F, 0x1F, 0x3F, 0x7E, 0x7E,
  0x7E, 0xFC, 0xFC, 0xFD, 0xF8, 0xF1, 0xFB, 0xE0, 0x83, 0xE7, 0xC0, 0x0F,
  0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x7E, 0x3E, 0x00, 0xFC, 0x7C, 0x03, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xFD, 0xFF, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07, 0xCF, 0xC0, 0x70, 0xFC,
  0x04, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x7F, 0x01, 0xC0, 0x3F, 0x01,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x00, 0xC0, 0x7F, 0x00, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x60, 0x03, 0xF8, 0x7C, 0x1F, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F,
  0x80, 0x3E, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x3F, 0x03,
  0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x27, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x20, 0x07, 0xF8, 0x1F, 0xCF, 0xFC, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0x8F, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xF0, 0x7F, 0x9F, 0xE0, 0x3F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x7F, 0x07,
  0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x07,
  0xC0, 0x7E, 0x07, 0xE0, 0xFC, 0x07, 0xF1, 0xFC, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x1F, 0xDF, 0xE0, 0x3F,
  0x87, 0xF0, 0x3F, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0xFC,
  0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF0, 0xFF,
  0x0F, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xE0, 0xFE, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7E, 0x1F,
  0xC1, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03,
  0xFE, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xE0, 0x7F, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0xF0, 0x7E, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x7F, 0x07, 0xF8, 0xFF, 0x8F, 0xF8, 0xFF, 0x87, 0xF0, 0x7E,
  0x00, 0x80, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x80, 0x7E, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x1F, 0x83, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00, 0x7F,
  0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x01,
  0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x07, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF,
  0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCE, 0x07, 0xF2, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x83, 0xF0, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0xF7, 0xCF, 0x83,
  0xFF, 0xC7, 0xC3, 0xFF, 0xE3, 0xC3, 0xFF, 0xF3, 0xE1, 0xFF, 0xF9, 0xF1,
  0xF8, 0xF8, 0xF0, 0xF8, 0x7C, 0x78, 0xF8, 0x3E, 0x7C, 0x7C, 0x1F, 0x3E,
  0x3E, 0x1F, 0x9F, 0x1F, 0x0F, 0x8F, 0x9F, 0x07, 0xC7, 0x8F, 0x83, 0xE3,
  0xC7, 0xC3, 0xF1, 0xE1, 0xF1, 0xF0, 0xF0, 0xFE, 0xF8, 0x7C, 0x7F, 0xFC,
  0x3E, 0x1F, 0xFE, 0x1F, 0x0F, 0xFE, 0x0F, 0x81, 0xFE, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xBE, 0x00,
  0x1F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x3E, 0x01,
  0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xF0, 0x3E, 0x07, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x1F, 0x83, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F,
  0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x3F,
  0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x7E,
  0x00, 0xFC, 0x3F, 0x01, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1,
  0xFF, 0x07, 0x83, 0xF8, 0x02, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x03, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFB, 0xFE, 0x07,
  0xF0, 0x7F, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F,
  0x01, 0xFC, 0x7F, 0x03, 0xF8, 0x7E, 0x07, 0xF8, 0x7E, 0x1F, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFC, 0x1E, 0x0F, 0xF0, 0x04, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFE,
  0x07, 0xF0, 0xFE, 0x07, 0xE0, 0x7F, 0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x01,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x40, 0x1F, 0xC0, 0x38,
  0x0F, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x0F, 0xF0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x03, 0xF8,
  0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x01, 0xFB, 0xF8,
  0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03,
  0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E,
  0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xFC, 0x0F,
  0xE0, 0x0F, 0xE0, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x07, 0xB8, 0x7F, 0xC0,
  0x3D, 0xC3, 0xFC, 0x03, 0xEE, 0x3D, 0xE0, 0x1F, 0x71, 0xFF, 0x00, 0xFB,
  0x9E, 0xF8, 0x07, 0x9C, 0xF7, 0xC0, 0x7C, 0xFF, 0x3C, 0x03, 0xE7, 0xFB,
  0xE0, 0x1F, 0x3F, 0x9F, 0x01, 0xF1, 0xFC, 0xF8, 0x0F, 0x8F, 0xC7, 0xC0,
  0x7C, 0x7C, 0x7C, 0x03, 0xE3, 0xE3, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x03, 0xE0, 0x1F, 0xC0,
  0x3E, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0xE0, 0x7E, 0x03, 0xFE, 0x07, 0xC0,
  0x3F, 0xE0, 0x7C, 0x03, 0xFF, 0x0F, 0xC0, 0x7F, 0xF0, 0xFC, 0x07, 0xCF,
  0x0F, 0x80, 0x7C, 0xF0, 0xF8, 0x07, 0xCF, 0x8F, 0x80, 0xFC, 0xF9, 0xF8,
  0x0F, 0xC7, 0x9F, 0x00, 0xF8, 0x79, 0xF0, 0x0F, 0x87, 0x9F, 0x01, 0xF8,
  0x7F, 0xF0, 0x1F, 0x87, 0xFE, 0x01, 0xF0, 0x3F, 0xE0, 0x1F, 0x03, 0xFE,
  0x03, 0xF0, 0x3F, 0xE0, 0x3F, 0x03, 0xFC, 0x03, 0xE0, 0x1F, 0xC0, 0x3E,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xFC, 0x07, 0xC0, 0x1F,
  0x80, 0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xF8, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0, 0x7F, 0x1F, 0xC0, 0x3F, 0x1F,
  0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFC, 0xFE,
  0x01, 0xF8, 0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x7F,
  0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x80, 0xFE, 0x7F, 0xE0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0,
  0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F,
  0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x0F, 0xF0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xC0,
  0x7F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0x7E, 0x03,
  0xF8, 0x7E, 0x07, 0xF0, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x03, 0xF0, 0xFF, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0,
  0x7F, 0x0F, 0xC0, 0xFE, 0x0F, 0xC3, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x7E, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xC0, 0x70, 0x1F, 0x80, 0x08, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x20, 0x01,
  0xF8, 0x1C, 0x01, 0xFC, 0x1F, 0xEF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0,
  0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x0F,
  0xC0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xFC,
  0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x03,
  0xF8, 0x3F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0x7E,
  0x0F, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07,
  0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0xF8,
  0x00, 0x7D, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0xF8, 0x1F, 0x8F, 0x0F, 0x81, 0xF1, 0xF0, 0xF8, 0x1F, 0x1F,
  0x0F, 0x81, 0xF3, 0xF9, 0xF0, 0x1F, 0x3F, 0x9F, 0x03, 0xE7, 0xF9, 0xF0,
  0x3E, 0x7F, 0x9E, 0x03, 0xEF, 0x7B, 0xE0, 0x3E, 0xF7, 0xBE, 0x03, 0xDE,
  0x7B, 0xE0, 0x3D, 0xE7, 0xBC, 0x07, 0xFC, 0x7B, 0xC0, 0x7F, 0xC7, 0xFC,
  0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0x3F, 0x80, 0x7E,
  0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F, 0x00,
  0x7E, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFC,
  0x7C, 0x01, 0xFC, 0x7E, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x3E, 0x0F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x00, 0xFC, 0x3F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x07, 0xE1,
  0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x3E,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xF9,
  0xF8, 0x07, 0xF3, 0xF0, 0x1F, 0xC3, 0xF0, 0x7F, 0x07, 0xE1, 0xFC, 0x0F,
  0xC7, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x80, 0x3F, 0x9E, 0x00, 0x3C,
  0x18, 0x00, 0x60, 0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x10, 0x07, 0x01, 0xF0, 0x3F, 0x8F,
  0xF8, 0x7F, 0xC3, 0xF0, 0x3E, 0x01, 0x80, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x87, 0xF0, 0x3F, 0x1F, 0xC0, 0x7E, 0x3F, 0x01, 0xF8, 0xFE, 0x03, 0xF1,
  0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x9F, 0x80, 0x7E, 0x3F,
  0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xFC, 0x0F, 0xE1, 0xF8,
  0x3F, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x07, 0xF8, 0xFC, 0x03, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC6, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0x80, 0xFC, 0x3F,
  0x01, 0xF8, 0xFE, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x9F, 0xC0, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFC, 0x07,
  0xE3, 0xF8, 0x1F, 0xC7, 0xE0, 0x7F, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xE3, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x04, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x27, 0xE0, 0x01, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xC0, 0xFC, 0x0F, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xFC,
  0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x3F,
  0x03, 0xF8, 0x1F, 0xC0, 0x7E, 0x0F, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x03, 0xFC, 0x7E, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x87, 0xF3, 0xF8, 0x0F, 0xCF, 0xC0,
  0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x7F, 0xBF, 0x7F, 0xFC,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x04, 0x1F, 0xF9, 0xF0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xC1, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x20, 0x03, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x02, 0x1F, 0xE0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0x87, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F,
  0x81, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0,
  0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xE0, 0x7E, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xBF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0x80, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xCE, 0x00, 0x1F,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0x81, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07,
  0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0, 0xFE,
  0x1F, 0x81, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC3,
  0xF0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E,
  0x07, 0xE1, 0xFC, 0x0F, 0xC0, 0x00, 0x10, 0x00, 0x3E, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x87, 0xFF, 0xC3, 0xFF,
  0xE1, 0xFF, 0xE0, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x04, 0x3F, 0xFE, 0x1F,
  0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xC0, 0x06, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x02, 0x01, 0xF8, 0x01, 0xC1, 0xFC, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xF0, 0x3F, 0x07, 0xF0, 0x3F, 0x87, 0xF0,
  0x1F, 0x87, 0xF0, 0x0F, 0xC7, 0xF0, 0x07, 0xE7, 0xF0, 0x03, 0xF7, 0xF0,
  0x03, 0xF7, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF8,
  0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xC7,
  0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xF8,
  0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x00,
  0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xF8, 0x7F, 0xF8, 0xFF, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x02, 0x3F, 0xFE,
  0x3F, 0xFE, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFC, 0x00, 0xC0, 0x01, 0xFE,
  0x7F, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7C,
  0xFC, 0xF8, 0x7C, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F, 0x1F, 0x0F,
  0x8F, 0x8F, 0x8F, 0x8F, 0x8F, 0x87, 0xC7, 0xC7, 0xC3, 0xE3, 0xE3, 0xE1,
  0xF1, 0xF1, 0xF1, 0xF1, 0xF1, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x0F, 0xC0, 0xFE,
  0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x3F, 0x87, 0xE0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E,
  0x07, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x0F, 0xC0,
  0xFE, 0x1F, 0x81, 0xF8, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F, 0xDF, 0xF1,
  0xFC, 0x1F, 0xCF, 0xE0, 0x3F, 0x3F, 0x00, 0xFD, 0xFC, 0x03, 0xF7, 0xE0,
  0x0F, 0xDF, 0x80, 0x3F, 0x7E, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x1F,
  0xBF, 0x00, 0x7E, 0xFE, 0x03, 0xFB, 0xF8, 0x1F, 0xC7, 0xE0, 0xFF, 0x1F,
  0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC3, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC1,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xFC,
  0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x7F,
  0x07, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xEF,
  0xF3, 0xFC, 0x1F, 0x8F, 0xE0, 0x7E, 0x7F, 0x01, 0xF9, 0xF8, 0x07, 0xEF,
  0xE0, 0x3F, 0x3F, 0x00, 0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0,
  0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xE0, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0x00, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x03, 0xF8, 0x04, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0xC3, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0x00,
  0x7E, 0x1F, 0xDF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0x83, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x60, 0x00,
  0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x8F, 0xE0, 0x7E, 0x3F,
  0x01, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0xC0, 0xFC, 0x7E, 0x03,
  0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFC, 0x07, 0xE3,
  0xF0, 0x1F, 0x8F, 0xC0, 0xFE, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF8,
  0x7F, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x81, 0xFE, 0x3E, 0x00, 0x40, 0x00, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xF9,
  0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x3F, 0x8F, 0xC0, 0x7E, 0x1F,
  0x81, 0xFC, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0xFC, 0x1F, 0x81, 0xF8,
  0x7E, 0x03, 0xF0, 0xFC, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xDF,
  0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1,
  0xF1, 0xF8, 0xF8, 0x7C, 0x7E, 0x3E, 0x1F, 0x1F, 0x8F, 0x07, 0xCF, 0xE3,
  0xC1, 0xE3, 0xF9, 0xF0, 0x79, 0xEE, 0x78, 0x1E, 0xFB, 0x9E, 0x07, 0xBC,
  0xEF, 0x81, 0xFF, 0x3B, 0xC0, 0xFF, 0x8E, 0xF0, 0x3F, 0xC3, 0xF8, 0x0F,
  0xF0, 0xFE, 0x03, 0xF8, 0x3F, 0x80, 0xFE, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xF7, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x1F, 0xC0, 0x7F, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xF8,
  0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x01, 0x00, 0x00, 0x1F, 0xC0, 0x38, 0x7F, 0xE0, 0xF9, 0xFF, 0xF3,
  0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0x3F, 0xFE, 0x7C, 0x1F, 0xF8,
  0x70, 0x0F, 0xE0, 0x00, 0x04, 0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 14, 31, 25, 6, -30 },
  { 56, 18, 13, 25, 8, -33 },
  { 86, 26, 30, 25, 0, -30 },
  { 184, 25, 39, 25, 0, -34 },
  { 306, 30, 32, 25, -2, -31 },
  { 426, 24, 31, 25, 0, -31 },
  { 519, 8, 14, 25, 12, -33 },
  { 533, 20, 43, 25, 5, -35 },
  { 641, 20, 43, 25, 0, -35 },
  { 749, 21, 19, 25, 4, -30 },
  { 799, 22, 22, 25, 1, -24 },
  { 860, 12, 15, 25, 3, -8 },
  { 883, 15, 6, 25, 5, -16 },
  { 895, 9, 9, 25, 6, -8 },
  { 906, 29, 42, 25, -2, -34 },
  { 1059, 23, 32, 25, 2, -31 },
  { 1151, 20, 30, 25, 1, -30 },
  { 1226, 24, 31, 25, 0, -31 },
  { 1319, 24, 32, 25, 0, -31 },
  { 1415, 25, 30, 25, 0, -30 },
  { 1509, 26, 31, 25, 0, -30 },
  { 1610, 24, 32, 25, 2, -31 },
  { 1706, 23, 30, 25, 4, -30 },
  { 1793, 24, 32, 25, 1, -31 },
  { 1889, 24, 31, 25, 1, -31 },
  { 1982, 12, 24, 25, 6, -23 },
  { 2018, 15, 30, 25, 3, -23 },
  { 2075, 22, 21, 25, 2, -23 },
  { 2133, 25, 14, 25, 0, -20 },
  { 2177, 22, 21, 25, 1, -23 },
  { 2235, 18, 32, 25, 6, -31 },
  { 2307, 25, 38, 25, 1, -31 },
  { 2426, 24, 30, 25, -2, -30 },
  { 2516, 25, 31, 25, 0, -31 },
  { 2613, 23, 32, 25, 3, -31 },
  { 2705, 24, 31, 25, 0, -31 },
  { 2798, 25, 30, 25, 1, -30 },
  { 2892, 26, 30, 25, 1, -30 },
  { 2990, 24, 32, 25, 2, -31 },
  { 3086, 28, 30, 25, -1, -30 },
  { 3191, 27, 30, 25, 0, -30 },
  { 3293, 26, 31, 25, 0, -30 },
  { 3394, 28, 30, 25, 0, -30 },
  { 3499, 20, 30, 25, 0, -30 },
  { 3574, 29, 30, 25, -2, -30 },
  { 3683, 28, 30, 25, -1, -30 },
  { 3788, 24, 32, 25, 1, -31 },
  { 3884, 26, 31, 25, 0, -31 },
  { 3985, 24, 39, 25, 1, -31 },
  { 4102, 24, 31, 25, 0, -31 },
  { 4195, 25, 32, 25, 0, -31 },
  { 4295, 24, 30, 25, 4, -30 },
  { 4385, 26, 31, 25, 1, -30 },
  { 4486, 24, 30, 25, 5, -30 },
  { 4576, 28, 30, 25, 0, -30 },
  { 4681, 30, 30, 25, -2, -30 },
  { 4794, 24, 30, 25, 5, -30 },
  { 4884, 26, 30, 25, 0, -30 },
  { 4982, 23, 42, 25, 3, -34 },
  { 5103, 10, 42, 25, 8, -34 },
  { 5156, 24, 42, 25, -1, -34 },
  { 5282, 23, 17, 25, 2, -30 },
  { 5331, 24, 5, 25, -4, 3 },
  { 5346, 11, 9, 25, 10, -34 },
  { 5359, 23, 25, 25, 1, -24 },
  { 5431, 23, 35, 25, 0, -34 },
  { 5532, 22, 25, 25, 2, -24 },
  { 5601, 26, 35, 25, 1, -34 },
  { 5715, 22, 25, 25, 2, -24 },
  { 5784, 31, 42, 25, -4, -34 },
  { 5947, 26, 32, 25, -2, -24 },
  { 6051, 23, 34, 25, 0, -34 },
  { 6149, 17, 36, 25, 4, -35 },
  { 6226, 25, 43, 25, -2, -35 },
  { 6361, 25, 34, 25, 1, -34 },
  { 6468, 16, 35, 25, 5, -34 },
  { 6538, 25, 23, 25, -1, -23 },
  { 6610, 23, 24, 25, 0, -24 },
  { 6679, 22, 25, 25, 1, -24 },
  { 6748, 25, 32, 25, -2, -24 },
  { 6848, 22, 32, 25, 2, -24 },
  { 6936, 23, 24, 25, 2, -24 },
  { 7005, 22, 25, 25, 1, -24 },
  { 7074, 20, 31, 25, 4, -30 },
  { 7152, 22, 24, 25, 2, -23 },
  { 7218, 23, 23, 25, 3, -23 },
  { 7285, 26, 23, 25, 1, -23 },
  { 7360, 26, 23, 25, -1, -23 },
  { 7435, 29, 31, 25, -4, -23 },
  { 7548, 23, 23, 25, 1, -23 },
  { 7615, 24, 42, 25, 3, -34 },
  { 7741, 17, 42, 25, 4, -34 },
  { 7831, 24, 42, 25, -2, -34 },
  { 7957, 23, 10, 25, 1, -18 },
};

const GFXfont UbuntuSansMono_BoldItalic44pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic44pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic44pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _UBUNTUSANSMONO_BOLDITALIC44PT7B_H_
