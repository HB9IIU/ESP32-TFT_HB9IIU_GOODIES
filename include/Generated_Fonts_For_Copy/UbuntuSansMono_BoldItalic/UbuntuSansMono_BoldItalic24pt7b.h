#ifndef _UBUNTUSANSMONO_BOLDITALIC24PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic24pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1E, 0x1C, 0x1C, 0x3C, 0x38, 0x38,
  0x00, 0x00, 0x70, 0x78, 0xF8, 0x70, 0x7B, 0xDC, 0xF7, 0x3B, 0xCE, 0xE3,
  0xB8, 0xCC, 0x70, 0x03, 0x9C, 0x0E, 0x70, 0x31, 0x81, 0xCE, 0x3F, 0xFC,
  0xFF, 0xF7, 0xFF, 0xC3, 0x18, 0x1C, 0xE0, 0x73, 0x8F, 0xFF, 0xBF, 0xFE,
  0xFF, 0xF1, 0xCE, 0x07, 0x30, 0x39, 0xC0, 0xE7, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x0F, 0xE0, 0xFF, 0x8F, 0xFC, 0x70, 0x03, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xCC, 0x1E, 0x7F,
  0xE7, 0xFE, 0x07, 0xC0, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x03, 0x0F,
  0x86, 0x19, 0x8E, 0x19, 0x9C, 0x1B, 0x98, 0x3B, 0x30, 0x1F, 0x60, 0x1E,
  0xC0, 0x01, 0xC0, 0x03, 0xB8, 0x03, 0x7C, 0x06, 0xEC, 0x0C, 0xCC, 0x18,
  0xCC, 0x38, 0xDC, 0x70, 0xF8, 0xE0, 0xF0, 0x03, 0xE0, 0x3F, 0x83, 0xFC,
  0x38, 0xE1, 0xC7, 0x0E, 0x70, 0x77, 0x01, 0xF0, 0x1F, 0x39, 0xF9, 0xDC,
  0xEC, 0xC7, 0xEE, 0x1E, 0x70, 0xF3, 0xCF, 0x8F, 0xFE, 0x3E, 0x70, 0xFF,
  0xEE, 0xEC, 0xCC, 0x00, 0x80, 0x70, 0x7C, 0x3E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0x70, 0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0x80, 0x40, 0x03, 0x00, 0xE0,
  0x1E, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x78, 0x1F,
  0x07, 0xC1, 0xE0, 0x18, 0x02, 0x00, 0x0E, 0x01, 0xC1, 0x38, 0x33, 0x77,
  0xFF, 0xFF, 0xC3, 0xC0, 0xFC, 0x3B, 0xCF, 0x38, 0x44, 0x00, 0x03, 0x80,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xE0, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x3D, 0xF7, 0xCF, 0x18, 0xEF, 0x30, 0xFF, 0xFF,
  0xFE, 0xFE, 0x7F, 0xFE, 0xE0, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xC7, 0x38, 0x77, 0x07,
  0x70, 0x77, 0x77, 0xE7, 0x7E, 0x67, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x1C,
  0xF7, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0xE0, 0x78, 0x1F, 0x1F, 0xE3, 0xFC,
  0x77, 0x08, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1C,
  0x3F, 0xF7, 0xFE, 0xFF, 0xC0, 0x03, 0xE0, 0x7F, 0x87, 0xFE, 0x18, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x01, 0xFF, 0xDF, 0xFC, 0xFF, 0xE0, 0x07, 0xE0, 0xFF,
  0x83, 0xFE, 0x10, 0xF0, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0xFC, 0x0F, 0xC0,
  0x7F, 0x00, 0x3C, 0x00, 0xE0, 0x0F, 0x00, 0x79, 0x8F, 0x9F, 0xF8, 0xFF,
  0x80, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xB8, 0x1D, 0xC0,
  0xE7, 0x07, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0xFF, 0xBF, 0xFE, 0xFF, 0xF0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F,
  0x83, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07, 0xE0, 0x3F, 0xE0, 0x0F,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x87, 0x7E, 0x3F, 0xF0, 0xFF,
  0x80, 0x00, 0x78, 0x1F, 0xC3, 0xFE, 0x3E, 0x03, 0xC0, 0x1C, 0x01, 0xC0,
  0x0F, 0xF8, 0xFF, 0xE7, 0x87, 0x38, 0x3D, 0xC1, 0xEE, 0x0E, 0x78, 0x71,
  0xEF, 0x8F, 0xF8, 0x3F, 0x80, 0x7F, 0xFB, 0xFF, 0xDF, 0xFC, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x7F,
  0x87, 0xFC, 0x78, 0xF3, 0x87, 0x1C, 0x38, 0xF3, 0xC3, 0xFC, 0x1F, 0x81,
  0xFE, 0x1C, 0x79, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0xCF, 0x1F, 0xF8, 0x7F,
  0x00, 0x07, 0xC0, 0x7F, 0x87, 0xFE, 0x78, 0xF3, 0x83, 0x9C, 0x1C, 0xE0,
  0xE7, 0x07, 0x3F, 0xF8, 0xFF, 0xC1, 0xDC, 0x00, 0xE0, 0x0E, 0x01, 0xF1,
  0xFF, 0x0F, 0xE0, 0xFC, 0x00, 0x1E, 0x7C, 0xF8, 0xE0, 0x00, 0x00, 0x00,
  0x79, 0xF3, 0xE3, 0x80, 0x0F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x7C, 0x7C, 0x3C, 0x18, 0x38, 0xF0, 0xC0, 0x00, 0x10, 0x07, 0x03,
  0xF0, 0xFF, 0x7F, 0x8F, 0xC0, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xC0, 0x04, 0x3F, 0xF9, 0xFF, 0xDF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF9,
  0xFF, 0xDF, 0xFE, 0x10, 0x00, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0x7C, 0x07, 0xC1, 0xFE, 0x7F, 0x87, 0xF0, 0x1C, 0x00, 0x80, 0x00, 0x1F,
  0x9F, 0xF7, 0xFD, 0x07, 0x01, 0xC0, 0xF0, 0x78, 0x7C, 0x3C, 0x0E, 0x07,
  0x80, 0x00, 0x00, 0x1C, 0x0F, 0x83, 0xC0, 0xF0, 0x00, 0x01, 0xF0, 0x1F,
  0xE0, 0xF3, 0xC7, 0x07, 0x38, 0x1C, 0xE3, 0xF3, 0x3F, 0xDC, 0xFF, 0x67,
  0x39, 0x9C, 0xE6, 0x63, 0x99, 0x8E, 0xE6, 0x73, 0x9F, 0xC6, 0x7F, 0x18,
  0xFC, 0x70, 0x01, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0x80, 0x00, 0xF0,
  0x07, 0x80, 0x7C, 0x03, 0xE0, 0x3B, 0x03, 0x98, 0x1C, 0xC1, 0xC7, 0x0E,
  0x38, 0xF1, 0xC7, 0xFE, 0x7F, 0xF3, 0xFF, 0xBC, 0x1D, 0xC0, 0xEE, 0x0F,
  0xE0, 0x78, 0x07, 0xE0, 0x7F, 0x87, 0xFE, 0x38, 0x71, 0xC3, 0x8E, 0x1C,
  0xF1, 0xE7, 0xFE, 0x3F, 0xE1, 0xFF, 0x8E, 0x1C, 0xF0, 0xF7, 0x07, 0x38,
  0x79, 0xFF, 0xDF, 0xFC, 0xFF, 0x80, 0x03, 0xF0, 0x3F, 0xC3, 0xFE, 0x3C,
  0x23, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x38, 0x01, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0,
  0x7F, 0x07, 0xFC, 0x38, 0xF1, 0xC3, 0x8E, 0x1C, 0xF0, 0xE7, 0x07, 0x38,
  0x39, 0xC3, 0xDE, 0x1E, 0xE0, 0xE7, 0x0F, 0x38, 0xF3, 0xFF, 0x1F, 0xF0,
  0xFF, 0x00, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0xFC, 0x3F, 0xE0, 0xFF, 0x83, 0x80, 0x0E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0xFF, 0x1F, 0xF8, 0xFF, 0xE0, 0x1F, 0xFC, 0x7F, 0xE1,
  0xFF, 0x87, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0F, 0xF8, 0x3F, 0xE1,
  0xFF, 0x87, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x03, 0xF0, 0x3F, 0xC7, 0xFE, 0x3C, 0x23, 0xC0, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0xF7, 0x87, 0xB8, 0x39, 0xC1, 0xCF, 0x0E, 0x78,
  0xF1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x0E, 0x1E, 0x3C, 0x38, 0x78, 0x70,
  0xE0, 0xE1, 0xC3, 0xC7, 0x87, 0x8F, 0x0E, 0x1F, 0xFC, 0x3F, 0xF8, 0xFF,
  0xF1, 0xE1, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x1E, 0x3C, 0x38, 0x70, 0x70,
  0xE1, 0xE0, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC0, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x07, 0xFE, 0x3F, 0xF8, 0xFF, 0xE0, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE1, 0x07, 0x87, 0xFC, 0x3F, 0xF0,
  0x7F, 0x00, 0x0E, 0x1E, 0x1C, 0x38, 0x78, 0xF0, 0xE3, 0xC1, 0xCF, 0x03,
  0xBC, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x01, 0xEE, 0x03, 0x9E,
  0x07, 0x1C, 0x0E, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0xE0, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1F, 0xFB, 0xFF, 0xFF, 0xE0, 0x07, 0x0E,
  0x0E, 0x1C, 0x3C, 0x78, 0x78, 0xF0, 0xF3, 0xE3, 0xE7, 0xC7, 0xDB, 0x8D,
  0xB6, 0x3B, 0xDC, 0x73, 0xB8, 0xE6, 0x71, 0x80, 0xE7, 0x03, 0x8E, 0x07,
  0x1C, 0x0E, 0x38, 0x1C, 0xE0, 0x70, 0x0E, 0x0E, 0x3C, 0x18, 0x78, 0x70,
  0xF0, 0xE1, 0xF1, 0xC7, 0x63, 0x8E, 0xCE, 0x1D, 0x9C, 0x3B, 0xB8, 0xE3,
  0x71, 0xC7, 0xC3, 0x8F, 0x87, 0x1F, 0x0C, 0x3E, 0x38, 0x38, 0x70, 0x70,
  0xE0, 0xE0, 0x07, 0xC0, 0x7F, 0x07, 0xFC, 0x78, 0xE7, 0x87, 0x38, 0x3D,
  0xC1, 0xDE, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x3D, 0xC1, 0xCE, 0x0E, 0x70,
  0xE3, 0xFF, 0x0F, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0xE1, 0xFF, 0x87,
  0x8F, 0x1C, 0x3C, 0x70, 0x71, 0xC3, 0xCF, 0x0E, 0x3F, 0xF8, 0xFF, 0xC3,
  0xFC, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x07, 0xC0, 0xFE, 0x1F, 0xF3, 0xC7, 0x78, 0x77, 0x07, 0x70, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x1C, 0xFF, 0xC7, 0xF8,
  0x3F, 0x01, 0x80, 0x1C, 0x01, 0xF8, 0x07, 0x80, 0x10, 0x07, 0xC0, 0x7F,
  0x87, 0xFE, 0x38, 0xF1, 0xC3, 0x8E, 0x1C, 0xF0, 0xE7, 0x0F, 0x3F, 0xF1,
  0xFF, 0x1F, 0xE0, 0xE3, 0x87, 0x1C, 0x38, 0xF3, 0xC3, 0x9E, 0x1C, 0xE0,
  0xF0, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0x87, 0x02, 0x1C, 0x00, 0x70, 0x01,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF1,
  0x03, 0xC7, 0xBE, 0x3F, 0xF0, 0x7F, 0x80, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF,
  0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x00, 0x1C,
  0x3C, 0xF0, 0xE3, 0x83, 0x8E, 0x1E, 0x38, 0x79, 0xE1, 0xC7, 0x07, 0x1C,
  0x3C, 0x70, 0xF3, 0xC3, 0x8E, 0x0E, 0x38, 0x38, 0xE1, 0xE3, 0x87, 0x0F,
  0xFC, 0x3F, 0xE0, 0x7F, 0x00, 0xE0, 0x7F, 0x03, 0xB8, 0x3D, 0xC1, 0xCE,
  0x1E, 0x70, 0xE3, 0x8F, 0x1C, 0x70, 0xE3, 0x87, 0x38, 0x39, 0xC1, 0xDC,
  0x0E, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x00, 0x1C, 0x0E, 0x38,
  0x1C, 0x70, 0x39, 0xC0, 0x73, 0x81, 0xC7, 0x03, 0x8E, 0xE7, 0x19, 0xCC,
  0x77, 0xB8, 0xEF, 0x71, 0xF6, 0xE3, 0x6D, 0x87, 0x9B, 0x0F, 0x3E, 0x3C,
  0x78, 0x78, 0x70, 0xE0, 0xE0, 0x0E, 0x07, 0x0F, 0x0F, 0x07, 0x1E, 0x07,
  0x9C, 0x03, 0xB8, 0x03, 0xF8, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x70, 0x1C, 0x70, 0x3C, 0x70, 0x78,
  0x78, 0xF0, 0x78, 0xE0, 0x7F, 0x07, 0xB8, 0x39, 0xC3, 0xCF, 0x1C, 0x39,
  0xC1, 0xDE, 0x0E, 0xE0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0xFF,
  0xE0, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0xBC, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0xBC, 0xE0, 0x03, 0xF8, 0x1F, 0xC1, 0xFE, 0x00,
  0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x3F, 0x83, 0xFC, 0x00, 0x01, 0xC0, 0x3C, 0x07,
  0xC0, 0xFE, 0x1E, 0xE1, 0xCE, 0x38, 0xF7, 0x87, 0xF0, 0x72, 0x06, 0x7F,
  0xFF, 0xFF, 0x80, 0x21, 0xCF, 0x9F, 0x1C, 0x07, 0xE1, 0xFF, 0x3F, 0xF7,
  0x8F, 0x70, 0xEF, 0x0E, 0xE1, 0xEE, 0x1E, 0xE1, 0xCE, 0x1C, 0xFF, 0xCF,
  0xFC, 0x7E, 0xE0, 0x01, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1D, 0xC1, 0xFF, 0x3F, 0xF3, 0xC7, 0x38, 0x73, 0x87, 0x38, 0x77, 0x87,
  0x70, 0xF7, 0x0E, 0x7F, 0xEF, 0xFC, 0xFF, 0x00, 0x03, 0xF1, 0xFF, 0x3F,
  0xF7, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xFF,
  0xC7, 0xFC, 0x3F, 0xC0, 0x00, 0x04, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x7F, 0x07, 0xFC, 0x3F, 0xF1, 0xE3, 0xC7, 0x0E, 0x3C,
  0x38, 0xE1, 0xE3, 0x87, 0x8E, 0x1C, 0x38, 0x70, 0xFF, 0xC3, 0xFF, 0x07,
  0xEE, 0x00, 0x07, 0xC1, 0xFE, 0x3F, 0xF7, 0x87, 0x70, 0x7F, 0x0F, 0xFF,
  0xEF, 0xF8, 0xF0, 0x0E, 0x00, 0xFC, 0xC7, 0xFC, 0x3F, 0xC0, 0x00, 0x06,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x1E, 0x20, 0x0E, 0x00, 0x07, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x40,
  0x00, 0x01, 0xF8, 0x1F, 0xF0, 0xFF, 0xC7, 0x8F, 0x1C, 0x38, 0xF0, 0xE3,
  0x83, 0x8E, 0x1E, 0x38, 0x78, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x00, 0xF0,
  0x03, 0x86, 0x3E, 0x3F, 0xF0, 0xFF, 0x80, 0x60, 0x00, 0x01, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1F, 0xE1, 0xFF, 0x1F, 0xF3, 0xC7,
  0x3C, 0x73, 0x87, 0x38, 0x77, 0x8F, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x1E,
  0xF1, 0xE0, 0x06, 0x07, 0x83, 0xC1, 0xE0, 0x00, 0x01, 0xF9, 0xFC, 0xFE,
  0x0F, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0x9F, 0xC7, 0xE0,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE1,
  0xFE, 0x0F, 0xF0, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x86, 0x78, 0x7F, 0xC3,
  0xFC, 0x01, 0x00, 0x01, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x38, 0x01, 0xE3, 0xC7, 0x9E, 0x1C, 0x70, 0x73, 0x83, 0xFC, 0x0F, 0xE0,
  0x3F, 0x80, 0xEE, 0x03, 0xBC, 0x1E, 0x70, 0x71, 0xE1, 0xC3, 0x8F, 0x0F,
  0x00, 0x7E, 0xFE, 0xFE, 0x1E, 0x1C, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x38,
  0x78, 0x78, 0x70, 0x70, 0x70, 0x7F, 0x7F, 0x3F, 0x0E, 0x71, 0xFF, 0xCF,
  0xFE, 0x77, 0x73, 0x3B, 0xB9, 0x9D, 0xCC, 0xEE, 0xE6, 0x60, 0x77, 0x03,
  0xB8, 0x1D, 0xC0, 0xCC, 0x0E, 0x00, 0x07, 0xE1, 0xFF, 0x1F, 0xF3, 0xC7,
  0x3C, 0x73, 0x87, 0x38, 0x77, 0x8F, 0x78, 0xE7, 0x0E, 0x70, 0xE7, 0x1E,
  0xF1, 0xC0, 0x07, 0x81, 0xFE, 0x3F, 0xE7, 0x8E, 0x70, 0xFF, 0x0F, 0xE0,
  0xEE, 0x0E, 0xE0, 0xEE, 0x1C, 0xFF, 0xCF, 0xF8, 0x7F, 0x00, 0x07, 0xE0,
  0x3F, 0xE0, 0xFF, 0x87, 0x8E, 0x1C, 0x3C, 0x70, 0xF1, 0xC3, 0x8F, 0x0E,
  0x38, 0x78, 0xE3, 0xC3, 0xFF, 0x1F, 0xF8, 0x7F, 0x81, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0x07, 0xE1, 0xFF, 0x3F, 0xF7, 0x8F, 0x70, 0xEF,
  0x0E, 0xE0, 0xEE, 0x1E, 0xE1, 0xEE, 0x1C, 0xFF, 0xC7, 0xFC, 0x7F, 0xC0,
  0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x07, 0xF1, 0xFF, 0x3F, 0xF3, 0xC2,
  0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x00, 0x07, 0xF8, 0x7F, 0x87, 0xFC, 0x38, 0x01, 0xC0, 0x0F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x1E, 0xF8, 0xFF, 0x8F, 0xF8, 0x00,
  0x0E, 0x01, 0xC0, 0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0x1F, 0xE1, 0xFC, 0x38, 0x73,
  0x87, 0x78, 0xF7, 0x0E, 0x70, 0xE7, 0x0E, 0xF1, 0xEF, 0x1C, 0xE1, 0xCE,
  0x1C, 0xFF, 0xCF, 0xFC, 0x7D, 0xE0, 0xE0, 0xFE, 0x0E, 0xE0, 0xEE, 0x1E,
  0xE1, 0xCF, 0x3C, 0xF3, 0x87, 0x70, 0x7F, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x38, 0x00, 0x70, 0x1D, 0x80, 0xEE, 0x03, 0xB9, 0xCC, 0xE7, 0x33, 0xBD,
  0xCC, 0xF6, 0x36, 0xD8, 0xDB, 0xE3, 0xCF, 0x0F, 0x3C, 0x38, 0xE0, 0xE3,
  0x80, 0x1C, 0x1E, 0x3C, 0x78, 0x38, 0xE0, 0x7B, 0x80, 0x7F, 0x00, 0xFC,
  0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x3D, 0xC0, 0xF3, 0xC1, 0xC3, 0x8F,
  0x07, 0x80, 0x0E, 0x0F, 0x0F, 0x0E, 0x0F, 0x0E, 0x0F, 0x1E, 0x0F, 0x1C,
  0x0F, 0x3C, 0x07, 0x38, 0x07, 0x78, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x5F, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x20, 0x00, 0x1F, 0xF8, 0xFF, 0xC7, 0xFE, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0xF8, 0xFF, 0xCF, 0xFE, 0x00,
  0x00, 0xF8, 0x1F, 0x81, 0xFC, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x01, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x03, 0x81, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x1E, 0x0E,
  0x07, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x0E, 0x0F,
  0x07, 0x03, 0x83, 0xC0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x3C, 0x01, 0xF0,
  0x1F, 0x81, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x3F, 0x03, 0xF0, 0x00, 0x08, 0x21, 0xF9, 0xDF, 0xFE, 0xFF,
  0xEE, 0x3E, 0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 17, 13, 3, -17 },
  { 18, 10, 7, 13, 4, -18 },
  { 27, 14, 17, 13, 0, -17 },
  { 57, 13, 22, 13, 0, -19 },
  { 93, 16, 17, 13, -1, -17 },
  { 127, 13, 17, 13, 0, -17 },
  { 155, 4, 8, 13, 7, -18 },
  { 159, 10, 24, 13, 3, -19 },
  { 189, 11, 24, 13, 0, -19 },
  { 222, 11, 11, 13, 2, -17 },
  { 238, 12, 12, 13, 1, -13 },
  { 256, 6, 8, 13, 2, -4 },
  { 262, 8, 4, 13, 3, -9 },
  { 266, 5, 4, 13, 3, -4 },
  { 269, 16, 23, 13, -1, -19 },
  { 315, 12, 17, 13, 1, -17 },
  { 341, 11, 17, 13, 1, -17 },
  { 365, 13, 17, 13, 0, -17 },
  { 393, 13, 17, 13, 0, -17 },
  { 421, 14, 17, 13, 0, -17 },
  { 451, 14, 17, 13, 0, -17 },
  { 481, 13, 17, 13, 1, -17 },
  { 509, 13, 17, 13, 2, -17 },
  { 537, 13, 17, 13, 1, -17 },
  { 565, 13, 17, 13, 0, -17 },
  { 593, 7, 12, 13, 3, -12 },
  { 604, 8, 16, 13, 2, -12 },
  { 620, 12, 12, 13, 1, -13 },
  { 638, 13, 8, 13, 0, -11 },
  { 651, 13, 12, 13, 0, -13 },
  { 671, 10, 17, 13, 3, -17 },
  { 693, 14, 21, 13, 0, -17 },
  { 730, 13, 17, 13, -1, -17 },
  { 758, 13, 17, 13, 0, -17 },
  { 786, 13, 17, 13, 1, -17 },
  { 814, 13, 17, 13, 0, -17 },
  { 842, 14, 17, 13, 0, -17 },
  { 872, 14, 17, 13, 1, -17 },
  { 902, 13, 17, 13, 1, -17 },
  { 930, 15, 17, 13, 0, -17 },
  { 962, 14, 17, 13, 0, -17 },
  { 992, 14, 17, 13, 0, -17 },
  { 1022, 15, 17, 13, 0, -17 },
  { 1054, 11, 17, 13, 0, -17 },
  { 1078, 15, 17, 13, -1, -17 },
  { 1110, 15, 17, 13, 0, -17 },
  { 1142, 13, 17, 13, 1, -17 },
  { 1170, 14, 17, 13, 0, -17 },
  { 1200, 12, 22, 13, 1, -17 },
  { 1233, 13, 17, 13, 0, -17 },
  { 1261, 14, 17, 13, 0, -17 },
  { 1291, 13, 17, 13, 2, -17 },
  { 1319, 14, 17, 13, 1, -17 },
  { 1349, 13, 17, 13, 3, -17 },
  { 1377, 15, 17, 13, 0, -17 },
  { 1409, 16, 17, 13, -1, -17 },
  { 1443, 13, 17, 13, 3, -17 },
  { 1471, 14, 17, 13, 0, -17 },
  { 1501, 13, 23, 13, 1, -19 },
  { 1539, 5, 23, 13, 5, -19 },
  { 1554, 13, 23, 13, -1, -19 },
  { 1592, 12, 10, 13, 1, -17 },
  { 1607, 13, 2, 13, -2, 2 },
  { 1611, 6, 5, 13, 5, -19 },
  { 1615, 12, 13, 13, 1, -13 },
  { 1635, 12, 19, 13, 0, -19 },
  { 1664, 12, 13, 13, 1, -13 },
  { 1684, 14, 19, 13, 1, -19 },
  { 1718, 12, 13, 13, 1, -13 },
  { 1738, 17, 24, 13, -2, -19 },
  { 1789, 14, 18, 13, -1, -13 },
  { 1821, 12, 19, 13, 0, -19 },
  { 1850, 9, 19, 13, 2, -19 },
  { 1872, 13, 24, 13, -1, -19 },
  { 1911, 14, 19, 13, 0, -19 },
  { 1945, 8, 19, 13, 3, -19 },
  { 1964, 13, 13, 13, 0, -13 },
  { 1986, 12, 13, 13, 0, -13 },
  { 2006, 12, 13, 13, 1, -13 },
  { 2026, 14, 17, 13, -1, -13 },
  { 2056, 12, 17, 13, 1, -13 },
  { 2082, 12, 13, 13, 1, -13 },
  { 2102, 13, 13, 13, 0, -13 },
  { 2124, 11, 16, 13, 2, -16 },
  { 2146, 12, 13, 13, 1, -13 },
  { 2166, 12, 13, 13, 2, -13 },
  { 2186, 14, 13, 13, 1, -13 },
  { 2209, 15, 13, 13, -1, -13 },
  { 2234, 16, 18, 13, -2, -13 },
  { 2270, 13, 13, 13, 0, -13 },
  { 2292, 13, 23, 13, 2, -19 },
  { 2330, 9, 23, 13, 2, -19 },
  { 2356, 13, 23, 13, -1, -19 },
  { 2394, 13, 5, 13, 0, -10 },
};

const GFXfont UbuntuSansMono_BoldItalic24pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic24pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic24pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _UBUNTUSANSMONO_BOLDITALIC24PT7B_H_
