#ifndef _UBUNTUSANSMONO_BOLDITALIC26PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x38, 0x38,
  0x00, 0x00, 0x20, 0xF0, 0xF0, 0xF0, 0xF0, 0xF3, 0xFC, 0xFF, 0x3F, 0x8E,
  0xE3, 0xB9, 0xEC, 0x73, 0x1C, 0x01, 0xCE, 0x07, 0x1C, 0x0E, 0x70, 0x1C,
  0xE3, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0xA7, 0x38, 0x0E, 0x70, 0x38, 0xE0,
  0x73, 0x87, 0xFF, 0xEF, 0xFF, 0x9F, 0xFF, 0x1C, 0x70, 0x39, 0xC0, 0xE3,
  0x81, 0xCE, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x3F, 0xF0, 0xFF,
  0xC3, 0xF3, 0x87, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x70, 0xF0, 0xFF,
  0xE3, 0xFF, 0x80, 0xFC, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x00, 0x0F,
  0x81, 0xC3, 0xE0, 0xC1, 0xD8, 0x70, 0x66, 0x38, 0x19, 0x9C, 0x06, 0x6E,
  0x01, 0xF3, 0x00, 0x7D, 0x80, 0x04, 0xE0, 0x00, 0x72, 0x00, 0x3B, 0xE0,
  0x1D, 0xF8, 0x06, 0x66, 0x03, 0x19, 0x81, 0xCE, 0x60, 0xE3, 0xB8, 0x70,
  0xFC, 0x38, 0x1E, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0xF3, 0x83, 0x8E, 0x0E,
  0x38, 0x39, 0xC0, 0xEE, 0x03, 0xF0, 0x0F, 0x98, 0x7E, 0x73, 0xB9, 0xDC,
  0xFE, 0xF1, 0xFB, 0x83, 0xCF, 0x0F, 0x3E, 0xFC, 0x7F, 0xF8, 0xFC, 0xE0,
  0x7B, 0xDE, 0xEF, 0x7B, 0x9C, 0xC0, 0x00, 0x20, 0x0E, 0x01, 0xF0, 0x3E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x80, 0x01, 0x00, 0x38,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0x70, 0x04, 0x00,
  0x07, 0x00, 0x70, 0x47, 0x17, 0x77, 0x7F, 0xFF, 0xFF, 0x07, 0x01, 0xDC,
  0x3D, 0xE3, 0xDE, 0x18, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x7F, 0xFF, 0xFF, 0xDF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x00, 0x1C, 0x7C, 0xF9, 0xF3, 0xC3, 0x8F, 0x7C, 0xE0, 0x7F,
  0xFF, 0xBF, 0xC0, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x3F, 0xC1, 0xFF, 0x8F, 0x0E, 0x38, 0x39, 0xE0, 0xF7,
  0x03, 0x9C, 0xCE, 0xF7, 0x3B, 0xDC, 0xEE, 0x27, 0xB8, 0x1C, 0xE0, 0x73,
  0xC3, 0xCF, 0x1E, 0x3F, 0xF0, 0x7F, 0xC0, 0xFC, 0x00, 0x00, 0xE0, 0x7C,
  0x1F, 0x9F, 0xF3, 0xFC, 0x73, 0x88, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC7, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xF8,
  0x3F, 0xF1, 0xFF, 0xC3, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x1E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x1F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xF0, 0xFF, 0xC2,
  0x0F, 0x00, 0x1C, 0x00, 0xF0, 0x07, 0x81, 0xFC, 0x07, 0xC0, 0x1F, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE4, 0x0F, 0x3F, 0xFC, 0xFF, 0xE3,
  0xFE, 0x00, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0,
  0xF7, 0x01, 0xCE, 0x07, 0x1C, 0x1C, 0x78, 0x70, 0xE1, 0xC1, 0xC3, 0xFF,
  0xEF, 0xFF, 0xDF, 0xFF, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x10, 0x3C, 0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC7, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1D, 0xF8,
  0x7F, 0xF3, 0xE3, 0xCF, 0x07, 0xBC, 0x1E, 0xF0, 0x7B, 0xC1, 0xCF, 0x0F,
  0x1F, 0xF8, 0x7F, 0xE0, 0x7E, 0x00, 0x3F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0xC0, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xF7, 0x8F, 0x0F, 0x3C, 0x3C, 0xF0,
  0xE3, 0xC7, 0x87, 0xFC, 0x0F, 0xC0, 0xFF, 0x87, 0x9E, 0x3C, 0x3C, 0xE0,
  0x73, 0x81, 0xCE, 0x0F, 0x3E, 0xF8, 0x7F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0xFF, 0x8F, 0xFE, 0xF0, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xEF, 0x07, 0x7F,
  0xF9, 0xFF, 0xC7, 0xFE, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x1F, 0x1F, 0xF0,
  0xFE, 0x07, 0xC0, 0x00, 0x1C, 0x7C, 0xF9, 0xF3, 0xC0, 0x00, 0x00, 0x00,
  0xE3, 0xE7, 0xCF, 0x9E, 0x00, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x0F, 0x87, 0xC3, 0xE1, 0xE0, 0x70, 0x78, 0xF8,
  0x70, 0x00, 0x00, 0x08, 0x01, 0xC0, 0x7E, 0x0F, 0xF3, 0xFC, 0x3F, 0x03,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xC0, 0x02, 0x00,
  0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xBF, 0xFE, 0xFF, 0xF8, 0x10, 0x00, 0x70, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xF0, 0x07, 0x80, 0xFE, 0x1F, 0xF3, 0xFE, 0x07, 0xE0, 0x1C,
  0x00, 0x80, 0x00, 0x7F, 0xC7, 0xFC, 0xFF, 0x90, 0xF0, 0x1E, 0x03, 0xC0,
  0xF0, 0x7C, 0x1F, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x1E, 0x07,
  0xC0, 0xF8, 0x0E, 0x00, 0x03, 0xF8, 0x3F, 0xF1, 0xE1, 0xCF, 0x07, 0x38,
  0x1D, 0xC3, 0xF7, 0x3F, 0xF9, 0xFF, 0xE7, 0x3B, 0xB8, 0xEC, 0xE3, 0xB3,
  0x8E, 0xCE, 0x73, 0x39, 0xCC, 0xFF, 0x31, 0xFC, 0xE3, 0xE3, 0x80, 0x0F,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0x00, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x7E, 0x03, 0xF8, 0x0E, 0xE0, 0x7B, 0x81, 0xCE, 0x0F, 0x3C, 0x38,
  0xF1, 0xE3, 0xC7, 0xFF, 0x3F, 0xFC, 0xFF, 0xF7, 0x83, 0xDC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xF0, 0xF0, 0xE1, 0xE1,
  0xE3, 0x83, 0x87, 0x0F, 0x1F, 0xFC, 0x3F, 0xE0, 0x7F, 0xF0, 0xE1, 0xE1,
  0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x1C, 0x1E, 0x3F, 0xF8, 0xFF, 0xE1, 0xFF,
  0x80, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0xC7, 0x81, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x82, 0x1F, 0xF8, 0x3F, 0xE0, 0x7F, 0x80, 0x0F, 0xE0, 0x3F,
  0xE0, 0xFF, 0x87, 0x8F, 0x1E, 0x3C, 0x70, 0x71, 0xC1, 0xCF, 0x07, 0x3C,
  0x3C, 0xE0, 0xF3, 0x83, 0xDE, 0x0E, 0x78, 0x79, 0xC3, 0xE7, 0x1F, 0x3F,
  0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0xFC, 0x3F, 0xF8, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3F, 0xF8, 0x7F,
  0xF1, 0xFF, 0xE0, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF0, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE1, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x00, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0xC7, 0x81, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0xC1, 0xEF, 0x07, 0x3C, 0x1C, 0xF0, 0xF3,
  0xC3, 0xCF, 0x8F, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF, 0x80, 0x0F, 0x0F, 0x0E,
  0x0F, 0x1E, 0x0E, 0x1E, 0x0E, 0x1E, 0x1E, 0x1C, 0x1E, 0x3C, 0x1C, 0x3F,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x78, 0x38, 0x78, 0x38, 0x78, 0x78, 0x70,
  0x78, 0xF0, 0x70, 0xF0, 0x70, 0xF0, 0xF0, 0xE0, 0xF0, 0x0F, 0xFF, 0x0F,
  0xFE, 0x0F, 0xFE, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x7F, 0xF0, 0xFF, 0xF0, 0xFF, 0xE0, 0x03, 0xFE, 0x0F,
  0xFC, 0x1F, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x18,
  0x78, 0x3F, 0xF0, 0xFF, 0xC0, 0xFF, 0x00, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E,
  0x3E, 0x1E, 0x3C, 0x1E, 0x78, 0x1C, 0xF0, 0x1D, 0xE0, 0x3F, 0xC0, 0x3F,
  0x80, 0x3F, 0x80, 0x3B, 0xC0, 0x79, 0xE0, 0x79, 0xE0, 0x70, 0xF0, 0x70,
  0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0xFF, 0x7F, 0xFF, 0xFF, 0x07, 0x07,
  0x83, 0xC3, 0x83, 0xE3, 0xC1, 0xF1, 0xE0, 0xD9, 0xF0, 0x6C, 0xF8, 0x76,
  0xDC, 0x3B, 0xEC, 0x1D, 0xEE, 0x1C, 0xF7, 0x0E, 0x73, 0x87, 0x39, 0xC3,
  0x81, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xF0, 0x3C, 0x70, 0x1C,
  0x00, 0x0E, 0x07, 0x0F, 0x0F, 0x1F, 0x0E, 0x1F, 0x0E, 0x1F, 0x0E, 0x1F,
  0x9E, 0x3F, 0x9C, 0x39, 0x9C, 0x39, 0x9C, 0x39, 0xDC, 0x79, 0xF8, 0x71,
  0xF8, 0x70, 0xF8, 0x70, 0xF8, 0xF0, 0xF0, 0xE0, 0xF0, 0xE0, 0xF0, 0xE0,
  0x70, 0x07, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0E, 0x3C, 0x3D, 0xE0, 0xF7,
  0x83, 0xDC, 0x0E, 0xF0, 0x3B, 0xC0, 0xEF, 0x07, 0xB8, 0x1E, 0xE0, 0x73,
  0xC3, 0xCF, 0x1E, 0x3F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xF8, 0x3F, 0xF8, 0xF0, 0xF1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x8E, 0x0F,
  0x3C, 0x7C, 0x7F, 0xF0, 0xFF, 0xC1, 0xFC, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0xE1, 0xFF,
  0x8F, 0x0E, 0x3C, 0x3D, 0xE0, 0xF7, 0x83, 0xDC, 0x0E, 0xF0, 0x3B, 0xC0,
  0xEF, 0x07, 0xB8, 0x1E, 0xE0, 0x73, 0xC3, 0xCF, 0x1E, 0x3F, 0xF8, 0x7F,
  0xC0, 0xFC, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x18, 0x00,
  0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0xC7, 0x8F, 0x1E, 0x1C, 0x70, 0x71, 0xC3,
  0xCF, 0x0F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0x1E, 0x70, 0x79, 0xE1, 0xE3,
  0x87, 0x0F, 0x3C, 0x1C, 0xF0, 0x73, 0xC1, 0xE0, 0x03, 0xFC, 0x1F, 0xFC,
  0x3F, 0xF0, 0xF0, 0x21, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x10, 0x3C,
  0x3F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x1C, 0x1E, 0x38, 0x38, 0xF0, 0x71, 0xE1, 0xE3, 0x83, 0xC7, 0x07, 0x1E,
  0x0E, 0x3C, 0x3C, 0x70, 0x78, 0xE0, 0xE3, 0xC1, 0xC7, 0x87, 0x8F, 0x0F,
  0x1C, 0x1C, 0x3C, 0x78, 0x7F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0xF0, 0x3F,
  0xC0, 0xEE, 0x07, 0xB8, 0x1C, 0xE0, 0xF3, 0x83, 0x8E, 0x1E, 0x38, 0x70,
  0xE3, 0xC3, 0x8E, 0x0E, 0x38, 0x3D, 0xC0, 0xF7, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0x8E, 0x03, 0x87, 0x01,
  0xC3, 0x80, 0xE3, 0xC0, 0xE1, 0xC0, 0x70, 0xE7, 0x38, 0x73, 0x9C, 0x3B,
  0xDC, 0x3B, 0xEE, 0x1D, 0xB7, 0x0F, 0xDB, 0x07, 0xCF, 0x83, 0xE7, 0xC1,
  0xE3, 0xE1, 0xF1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x00, 0x0F, 0x03, 0xC1,
  0xC1, 0xE0, 0x78, 0xF0, 0x0E, 0x78, 0x03, 0xDC, 0x00, 0xFF, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x0F, 0x78, 0x07, 0x9E, 0x01, 0xE3, 0x80, 0xF0, 0xE0, 0x78, 0x38, 0x3C,
  0x0F, 0x00, 0xF0, 0x3F, 0xC1, 0xEF, 0x07, 0x1C, 0x3C, 0x71, 0xE1, 0xC7,
  0x07, 0xBC, 0x1F, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0xFF,
  0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x07, 0xFC,
  0x1F, 0xE0, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xE3, 0x8F, 0x3C, 0xF3, 0xC7, 0x1C,
  0x71, 0xC7, 0x1C, 0x79, 0xE7, 0x9E, 0x78, 0xE3, 0x8E, 0x38, 0xE3, 0x8F,
  0x3C, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80,
  0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x03, 0xFC, 0x0F, 0xF0, 0x79, 0xC3, 0xC7,
  0x9E, 0x1E, 0xF0, 0x39, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0x80,
  0x41, 0xCF, 0x8F, 0x18, 0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0xF8, 0xF7, 0x87,
  0x78, 0x3B, 0xC3, 0xDC, 0x1E, 0xE0, 0xE7, 0x07, 0x3C, 0x79, 0xFF, 0xC7,
  0xFE, 0x3F, 0x78, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xFE, 0x07, 0xFC, 0x1F, 0xF8, 0xF1, 0xE3, 0xC3, 0x8F, 0x0F,
  0x38, 0x38, 0xE0, 0xE7, 0x87, 0x9E, 0x1E, 0x70, 0xF1, 0xFF, 0xCF, 0xFE,
  0x3F, 0xE0, 0x03, 0xF8, 0x7F, 0xC7, 0xFE, 0x7C, 0x27, 0x80, 0x3C, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xFF, 0xC7, 0xFE, 0x0F,
  0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0xFE, 0x07, 0xFC, 0x3F, 0xF8, 0xF8, 0xF1, 0xE1, 0xC7, 0x83, 0x8F,
  0x0F, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0x70, 0xF1, 0xE1, 0xFF, 0xC1, 0xFF,
  0x83, 0xF7, 0x80, 0x07, 0xE0, 0x7F, 0x8F, 0xFE, 0x78, 0xF7, 0x83, 0xB8,
  0x3F, 0xCF, 0xDF, 0xFC, 0xFF, 0x87, 0x80, 0x3C, 0x00, 0xFF, 0xC7, 0xFE,
  0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0x02, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x13, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x07, 0xFC, 0x3F, 0xF8, 0x78, 0xF1, 0xE1, 0xE3, 0x83, 0x8F, 0x0F,
  0x1E, 0x1E, 0x3C, 0x3C, 0x78, 0x70, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x80,
  0x0E, 0x00, 0x3C, 0x30, 0xF8, 0xFF, 0xE1, 0xFF, 0x80, 0xFC, 0x00, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x7F, 0xC3, 0xFF,
  0x1F, 0xF8, 0xE3, 0xCF, 0x0E, 0x78, 0x73, 0xC7, 0x9C, 0x3D, 0xE1, 0xEF,
  0x0E, 0x78, 0xF3, 0x87, 0x9C, 0x3D, 0xE1, 0xC0, 0x07, 0x81, 0xE0, 0x78,
  0x1C, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0xFF, 0x03, 0xC0, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xC0, 0x70, 0x3C, 0x07, 0xF1, 0xFC, 0x3F, 0x00, 0x1C, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C,
  0x0C, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0, 0x7E, 0x00, 0x07, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x87, 0x8F, 0x1E, 0x1E,
  0x78, 0x3D, 0xE0, 0x77, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x0E, 0xF0,
  0x1C, 0xF0, 0x79, 0xE0, 0xF1, 0xE1, 0xC3, 0xC7, 0x83, 0xC0, 0x7F, 0x7F,
  0xBF, 0xC1, 0xC0, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x1E, 0x0F, 0x07, 0x03,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0xDF, 0xE7, 0xF0, 0x0F, 0x38, 0x7F,
  0xF3, 0xFF, 0xCE, 0x77, 0x39, 0x9C, 0xCE, 0x77, 0x39, 0xDC, 0xE6, 0x73,
  0x39, 0xC0, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x73, 0x81, 0xC0, 0x07, 0xE0,
  0xFF, 0xC7, 0xFE, 0x38, 0xF3, 0xC3, 0x9E, 0x1C, 0xF1, 0xE7, 0x0F, 0x78,
  0x7B, 0xC3, 0x9E, 0x3C, 0xE1, 0xE7, 0x0F, 0x78, 0x70, 0x07, 0xC0, 0xFF,
  0x8F, 0xFC, 0xF9, 0xE7, 0x87, 0xF8, 0x3F, 0xC1, 0xFC, 0x0E, 0xE0, 0x77,
  0x07, 0xBC, 0x79, 0xFF, 0xC7, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x1F, 0xF0,
  0x3F, 0xF0, 0x70, 0xE1, 0xE1, 0xE3, 0xC3, 0xC7, 0x07, 0x8E, 0x0E, 0x3C,
  0x3C, 0x78, 0x78, 0xE1, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0xF8, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x7F, 0xC7,
  0xFE, 0x78, 0xF7, 0x87, 0xB8, 0x3B, 0xC1, 0xDE, 0x1E, 0xF0, 0xF7, 0x87,
  0x3C, 0x39, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0xF8, 0xFF, 0xC7, 0xFE, 0x7E, 0x63, 0xC0, 0x1E,
  0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x00, 0x03, 0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0x82, 0x1E, 0x00, 0x7C,
  0x01, 0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x03, 0xC4, 0x0F, 0x1F, 0xFC, 0xFF,
  0xE1, 0xFF, 0x00, 0x01, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x7F, 0xF7, 0xFF,
  0xFF, 0xF1, 0xC0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x78, 0x07, 0xFC, 0x3F, 0xC1, 0xFC, 0x3C, 0x39, 0xC3, 0xCE, 0x1E, 0xF0,
  0xE7, 0x87, 0x3C, 0x79, 0xC3, 0xDE, 0x1C, 0xF0, 0xE7, 0x8F, 0x3C, 0x79,
  0xFF, 0xC7, 0xFE, 0x3F, 0x78, 0xF0, 0x7F, 0x83, 0xFC, 0x3D, 0xE1, 0xEF,
  0x0E, 0x78, 0xF1, 0xC7, 0x0E, 0x78, 0x77, 0x83, 0xB8, 0x1F, 0xC0, 0xFC,
  0x03, 0xC0, 0x1E, 0x00, 0x70, 0x0E, 0xE0, 0x39, 0xC0, 0x77, 0x18, 0xEE,
  0x71, 0x9C, 0xE7, 0x3B, 0xEE, 0x77, 0xD8, 0xFF, 0xF1, 0xB3, 0xE3, 0xE7,
  0x87, 0x8F, 0x0F, 0x1C, 0x1C, 0x38, 0x00, 0x1E, 0x0F, 0x0E, 0x1E, 0x0F,
  0x1C, 0x07, 0x3C, 0x07, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07,
  0xE0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3C, 0x78, 0x38, 0x78, 0xF8, 0x3C, 0x0F,
  0x07, 0x87, 0x83, 0x83, 0xC3, 0xC1, 0xE1, 0xE0, 0x70, 0xE0, 0x38, 0xF0,
  0x1C, 0x70, 0x0E, 0x78, 0x07, 0xB8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x01, 0x1F, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFC, 0x3F, 0xF1, 0xFF, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F,
  0xFC, 0x7F, 0xF3, 0xFF, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x3E, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xF8, 0x0F, 0xC0, 0x1F,
  0x00, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F,
  0x07, 0x83, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0E, 0x07,
  0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x7C, 0x07, 0xE0, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x07, 0xF0, 0x3F, 0x80,
  0xF8, 0x00, 0x1F, 0x1C, 0xFF, 0x77, 0xFF, 0x9C, 0xFE, 0xE0, 0xE0,
};

const GFXglyph UbuntuSansMono_BoldItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 8, 18, 15, 4, -18 },
  { 19, 10, 8, 15, 5, -20 },
  { 29, 15, 18, 15, 0, -18 },
  { 63, 15, 23, 15, 0, -20 },
  { 107, 18, 18, 15, -1, -18 },
  { 148, 14, 18, 15, 0, -18 },
  { 180, 5, 9, 15, 7, -20 },
  { 186, 12, 26, 15, 3, -21 },
  { 225, 12, 26, 15, 0, -21 },
  { 264, 12, 11, 15, 2, -18 },
  { 281, 13, 13, 15, 1, -14 },
  { 303, 7, 9, 15, 2, -5 },
  { 311, 9, 3, 15, 3, -9 },
  { 315, 5, 5, 15, 4, -5 },
  { 319, 17, 25, 15, -1, -20 },
  { 373, 14, 18, 15, 1, -18 },
  { 405, 11, 18, 15, 1, -18 },
  { 430, 14, 18, 15, 0, -18 },
  { 462, 14, 18, 15, 0, -18 },
  { 494, 15, 18, 15, 0, -18 },
  { 528, 15, 18, 15, 0, -18 },
  { 562, 14, 18, 15, 1, -18 },
  { 594, 14, 18, 15, 2, -18 },
  { 626, 14, 18, 15, 1, -18 },
  { 658, 13, 18, 15, 1, -18 },
  { 688, 7, 14, 15, 4, -14 },
  { 701, 9, 18, 15, 2, -14 },
  { 722, 13, 13, 15, 1, -14 },
  { 744, 14, 9, 15, 0, -12 },
  { 760, 14, 13, 15, 0, -14 },
  { 783, 11, 18, 15, 3, -18 },
  { 808, 14, 22, 15, 1, -18 },
  { 847, 14, 18, 15, -1, -18 },
  { 879, 15, 18, 15, 0, -18 },
  { 913, 14, 18, 15, 1, -18 },
  { 945, 14, 18, 15, 0, -18 },
  { 977, 15, 18, 15, 0, -18 },
  { 1011, 15, 18, 15, 1, -18 },
  { 1045, 14, 18, 15, 1, -18 },
  { 1077, 16, 18, 15, 0, -18 },
  { 1113, 16, 18, 15, 0, -18 },
  { 1149, 15, 18, 15, 0, -18 },
  { 1183, 16, 18, 15, 0, -18 },
  { 1219, 12, 18, 15, 0, -18 },
  { 1246, 17, 18, 15, -1, -18 },
  { 1285, 16, 18, 15, 0, -18 },
  { 1321, 14, 18, 15, 1, -18 },
  { 1353, 15, 18, 15, 0, -18 },
  { 1387, 14, 23, 15, 1, -18 },
  { 1428, 14, 18, 15, 0, -18 },
  { 1460, 15, 18, 15, 0, -18 },
  { 1494, 13, 18, 15, 3, -18 },
  { 1524, 15, 18, 15, 1, -18 },
  { 1558, 14, 18, 15, 3, -18 },
  { 1590, 17, 18, 15, 0, -18 },
  { 1629, 18, 18, 15, -1, -18 },
  { 1670, 14, 18, 15, 3, -18 },
  { 1702, 16, 18, 15, 0, -18 },
  { 1738, 14, 25, 15, 2, -20 },
  { 1782, 6, 25, 15, 5, -20 },
  { 1801, 15, 25, 15, -1, -20 },
  { 1848, 14, 10, 15, 1, -18 },
  { 1866, 14, 3, 15, -2, 2 },
  { 1872, 6, 5, 15, 6, -20 },
  { 1876, 13, 14, 15, 1, -14 },
  { 1899, 14, 20, 15, 0, -20 },
  { 1934, 13, 14, 15, 1, -14 },
  { 1957, 15, 20, 15, 1, -20 },
  { 1995, 13, 14, 15, 1, -14 },
  { 2018, 18, 25, 15, -2, -20 },
  { 2075, 15, 19, 15, -1, -14 },
  { 2111, 13, 20, 15, 0, -20 },
  { 2144, 10, 20, 15, 2, -20 },
  { 2169, 15, 25, 15, -1, -20 },
  { 2216, 15, 20, 15, 0, -20 },
  { 2254, 9, 20, 15, 3, -20 },
  { 2277, 14, 14, 15, 0, -14 },
  { 2302, 13, 14, 15, 0, -14 },
  { 2325, 13, 14, 15, 1, -14 },
  { 2348, 15, 19, 15, -1, -14 },
  { 2384, 13, 19, 15, 1, -14 },
  { 2415, 13, 14, 15, 1, -14 },
  { 2438, 14, 14, 15, 0, -14 },
  { 2463, 12, 18, 15, 2, -18 },
  { 2490, 13, 14, 15, 1, -14 },
  { 2513, 13, 14, 15, 2, -14 },
  { 2536, 15, 14, 15, 1, -14 },
  { 2563, 16, 14, 15, -1, -14 },
  { 2591, 17, 19, 15, -2, -14 },
  { 2632, 14, 14, 15, 0, -14 },
  { 2657, 14, 25, 15, 2, -20 },
  { 2701, 9, 25, 15, 3, -20 },
  { 2730, 14, 25, 15, -1, -20 },
  { 2774, 14, 5, 15, 0, -10 },
};

const GFXfont UbuntuSansMono_BoldItalic26pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic26pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic26pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _UBUNTUSANSMONO_BOLDITALIC26PT7B_H_
