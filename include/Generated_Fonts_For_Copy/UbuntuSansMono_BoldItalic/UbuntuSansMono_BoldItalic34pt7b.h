#ifndef _UBUNTUSANSMONO_BOLDITALIC34PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC,
  0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xC0, 0x7C, 0x7D,
  0xF3, 0xE7, 0xCF, 0x9E, 0x3E, 0xF8, 0xFB, 0xE3, 0xCF, 0x0F, 0x3C, 0x3C,
  0xF0, 0xE3, 0x87, 0x8E, 0x1C, 0x00, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xE1, 0xC0, 0x1E, 0x3C, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFE, 0x07, 0x8F, 0x00, 0x78, 0xF0,
  0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xCF, 0xFF, 0xF8, 0x3C, 0x78, 0x03, 0x87, 0x00, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7E,
  0x04, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC2, 0x00, 0xF0, 0x70, 0x7E, 0x1F, 0xFF,
  0xC7, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x1E, 0x0F, 0xE0, 0x38,
  0x3F, 0xC0, 0xE0, 0x73, 0x83, 0x80, 0xE7, 0x0E, 0x03, 0x8E, 0x3C, 0x07,
  0x1C, 0xF0, 0x0E, 0x71, 0xC0, 0x1C, 0xE7, 0x00, 0x3F, 0x9C, 0x00, 0x3F,
  0x70, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x3B,
  0xF8, 0x00, 0xE7, 0xF0, 0x03, 0x9C, 0x70, 0x0F, 0x38, 0xC0, 0x3C, 0x73,
  0x80, 0xF0, 0xE7, 0x01, 0xC1, 0x8E, 0x07, 0x03, 0xB8, 0x1C, 0x07, 0xF0,
  0x78, 0x0F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x01, 0xF7, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x01, 0xE1, 0xC0, 0x3C,
  0x78, 0x07, 0x9E, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x90, 0xFE,
  0x1C, 0x3F, 0xE7, 0x8F, 0x3C, 0xF3, 0xC7, 0xFC, 0x78, 0x7F, 0x9F, 0x07,
  0xE3, 0xC0, 0xF8, 0x7C, 0x1F, 0x0F, 0xCF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFB,
  0xE1, 0xFE, 0x3C, 0x3E, 0xFD, 0xF3, 0xE7, 0xCF, 0x1E, 0x7C, 0xF1, 0xE3,
  0x87, 0x00, 0x00, 0x0C, 0x00, 0x38, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x01, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x43, 0xC0, 0x73, 0xCE, 0x7D, 0xDE, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0x78, 0x3E, 0x7C, 0x1E, 0x38, 0x0C, 0x30,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xC0,
  0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x0F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0x7C, 0x1E, 0x1E,
  0x3E, 0x7E, 0x3E, 0x18, 0x00, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F,
  0xFE, 0x0F, 0x87, 0xC7, 0xC1, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03,
  0xDF, 0x18, 0xF7, 0xCE, 0x7D, 0xE7, 0x9F, 0x79, 0xE7, 0x9E, 0x79, 0xEF,
  0x80, 0x7B, 0xE0, 0x3E, 0xF8, 0x0F, 0x3E, 0x07, 0xCF, 0x81, 0xE1, 0xE0,
  0xF8, 0x7E, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x02, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0xF0, 0x7F, 0xC3, 0xFF,
  0x87, 0xFF, 0x0F, 0x3E, 0x0C, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x78, 0x7E, 0x0C, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xF0,
  0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF9, 0x00, 0x7C, 0x78, 0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF,
  0xC0, 0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xBE, 0x03,
  0xE7, 0x80, 0xF8, 0xF0, 0x1E, 0x3E, 0x07, 0x87, 0xC1, 0xE0, 0xF0, 0x78,
  0x1E, 0x1E, 0x07, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xDF, 0xFF, 0xF8, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x04, 0x01, 0xF0, 0x7D, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x07, 0xFC, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x9F, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xF0,
  0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF1, 0xE0,
  0x3C, 0x3E, 0x0F, 0x87, 0xF7, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F,
  0x80, 0x01, 0x80, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF,
  0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x0F, 0x87, 0xC7, 0xC0, 0xF1,
  0xF0, 0x3C, 0x7C, 0x1F, 0x1F, 0x07, 0x83, 0xE3, 0xE0, 0xFF, 0xF0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x07, 0xFF, 0x87, 0xC3, 0xE1, 0xE0, 0x7C, 0xF8, 0x1F,
  0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xE0, 0x7C, 0xFC, 0x7E, 0x1F, 0xFF, 0x87,
  0xFF, 0xC0, 0x7F, 0xC0, 0x01, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80,
  0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x0F, 0x8F, 0x81, 0xF3, 0xC0, 0x7C, 0xF0,
  0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xF3, 0xE0, 0x7C, 0xFC, 0xFF, 0x3F, 0xFF,
  0x87, 0xFF, 0xE0, 0x7E, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xF0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xF8, 0x03, 0xF0,
  0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7C, 0x00, 0x01, 0xE0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80,
  0xF8, 0x07, 0x80, 0xF0, 0x3E, 0x0F, 0xC0, 0xF8, 0x0C, 0x00, 0x00, 0x01,
  0x80, 0x03, 0xC0, 0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xE0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x30, 0x1F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF,
  0x80, 0x18, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFF, 0x83, 0xFF,
  0x8F, 0xFF, 0x0F, 0xFC, 0x07, 0xF0, 0x03, 0xE0, 0x01, 0x80, 0x00, 0x07,
  0xF0, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0xF3, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0x07, 0xE1, 0xF0, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00,
  0x79, 0xE0, 0xFF, 0x78, 0x7F, 0xEF, 0x1F, 0xF9, 0xC7, 0xFF, 0x78, 0xF1,
  0xEF, 0x3C, 0x3D, 0xE7, 0x8F, 0x38, 0xF1, 0xE7, 0x1C, 0x3C, 0xE3, 0x87,
  0x9C, 0x71, 0xE3, 0x8F, 0x3C, 0x71, 0xFF, 0x8E, 0x3F, 0xF1, 0xE3, 0xFC,
  0x3C, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x80, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0xF0, 0x07, 0xDE,
  0x00, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xE0, 0x3C, 0x3C,
  0x0F, 0x87, 0x81, 0xE0, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0xFF,
  0xC0, 0x1F, 0x01, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0,
  0x78, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x0F, 0x03, 0xC3,
  0xE1, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F,
  0x81, 0xE1, 0xF0, 0x3E, 0x3C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x3E, 0x3E,
  0x0F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x0F, 0xC1, 0x87, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x10, 0x7F, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0xF8, 0xFC, 0x1F, 0x0F, 0x83, 0xE0,
  0xF8, 0x78, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F, 0x8F, 0x01,
  0xF3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xE0, 0x3E, 0x7C, 0x0F,
  0x8F, 0x83, 0xF1, 0xF0, 0x7C, 0x3C, 0x3F, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF,
  0x87, 0xFF, 0xE0, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xE0,
  0x7F, 0xFC, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF,
  0xF0, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x3F, 0xFE, 0x1F,
  0xC1, 0x87, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x3C, 0x07, 0xCF, 0x01, 0xF3,
  0xC0, 0x78, 0xF0, 0x3E, 0x3C, 0x0F, 0x8F, 0x83, 0xE3, 0xE0, 0xF0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0x00, 0x00, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xE0, 0x3C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F,
  0x07, 0xC0, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x03, 0xE0, 0xF8,
  0x1F, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0xF8, 0x1F, 0x07, 0x80, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x03,
  0xE0, 0xF0, 0x1E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x1E,
  0x07, 0xC0, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x03,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF,
  0xE0, 0x1F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x03, 0x07, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0,
  0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x07, 0xC0, 0xFC, 0x1F,
  0x07, 0xE0, 0x7C, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x87, 0xC0, 0x3E, 0x3F,
  0x00, 0xF9, 0xF8, 0x03, 0xCF, 0xC0, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0x9F, 0x00, 0x3C, 0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x07, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x3E,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x3E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x83, 0xF8, 0xFC,
  0x0F, 0x67, 0x70, 0x39, 0xBB, 0xC0, 0xE6, 0xEF, 0x07, 0x9F, 0x3C, 0x1E,
  0x7C, 0xE0, 0x79, 0xE7, 0x83, 0xC7, 0x9E, 0x0F, 0x1C, 0x78, 0x3C, 0x01,
  0xE0, 0xF0, 0x0F, 0x87, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3,
  0xE0, 0x1F, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x3E,
  0x07, 0xC1, 0xF0, 0x3C, 0x1F, 0x81, 0xE0, 0xFC, 0x0F, 0x07, 0xF0, 0xF8,
  0x3F, 0x87, 0x81, 0xFC, 0x3C, 0x1E, 0xF1, 0xE0, 0xF7, 0x8F, 0x07, 0x9C,
  0xF0, 0x3C, 0xE7, 0x83, 0xC7, 0x3C, 0x1E, 0x3D, 0xE0, 0xF0, 0xFE, 0x07,
  0x87, 0xF0, 0x7C, 0x3F, 0x83, 0xC1, 0xFC, 0x1E, 0x0F, 0xE0, 0xF0, 0x3E,
  0x0F, 0x81, 0xF0, 0x78, 0x0F, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0x00,
  0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x87, 0xC7, 0xC1,
  0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D,
  0xE0, 0x1F, 0x78, 0x07, 0xFE, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8,
  0x0F, 0x3E, 0x07, 0xCF, 0x83, 0xF3, 0xE0, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF,
  0x03, 0xFF, 0x00, 0x7F, 0x80, 0x03, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0x87, 0xE0, 0xF8, 0x3F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1,
  0xF0, 0xFE, 0x1F, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x87, 0xC7, 0xC1, 0xF3, 0xE0, 0x7C,
  0xF8, 0x1F, 0x3C, 0x07, 0xDF, 0x01, 0xF7, 0xC0, 0x7D, 0xE0, 0x1F, 0x78,
  0x07, 0xFE, 0x01, 0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0x3E, 0x07,
  0xCF, 0x83, 0xF3, 0xE0, 0xF8, 0x7F, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x78, 0x1F, 0x0F,
  0x03, 0xE3, 0xE0, 0xF8, 0x7C, 0x3F, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F,
  0xFC, 0x0F, 0xFE, 0x01, 0xF3, 0xE0, 0x3C, 0x3C, 0x0F, 0x87, 0xC1, 0xF0,
  0xF8, 0x3E, 0x0F, 0x07, 0x81, 0xF1, 0xF0, 0x3E, 0x3E, 0x03, 0xC7, 0xC0,
  0x7C, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xF8,
  0x0C, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFC,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x30, 0x0F,
  0x87, 0xEF, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0x00,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE8, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x81,
  0xF0, 0xF8, 0x1E, 0x0F, 0x03, 0xE1, 0xF0, 0x3E, 0x1F, 0x03, 0xE1, 0xF0,
  0x3C, 0x1E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x78, 0x3C,
  0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x78, 0x1F, 0x0F,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0x02, 0x00,
  0x00, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F,
  0x3C, 0x07, 0xCF, 0x01, 0xE3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3C, 0x1F, 0x0F,
  0x07, 0x83, 0xC3, 0xE0, 0xF0, 0xF0, 0x3C, 0x7C, 0x0F, 0x1E, 0x03, 0xE7,
  0x80, 0xFB, 0xC0, 0x3E, 0xF0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x71, 0xE7, 0x83, 0xCF,
  0x9E, 0x0F, 0x3E, 0x78, 0x3D, 0xF9, 0xC0, 0xE7, 0xEF, 0x03, 0xBB, 0xBC,
  0x1E, 0xEE, 0xF0, 0x7F, 0x3B, 0x81, 0xDC, 0xEE, 0x07, 0xE3, 0xF8, 0x1F,
  0x8F, 0xC0, 0x7C, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0x81, 0xE0, 0x3E, 0x07,
  0x80, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x07,
  0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07,
  0xDF, 0x00, 0x0F, 0x9E, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE0,
  0xF8, 0x07, 0xC0, 0xF0, 0x1F, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xFE, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x7C, 0x78, 0x1F, 0x1E, 0x0F, 0x87,
  0x87, 0xC1, 0xF1, 0xF0, 0x7C, 0xF8, 0x0F, 0x7C, 0x03, 0xDF, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x07,
  0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0xF8, 0x78, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E,
  0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0xC0, 0x7D, 0xF0, 0x3E, 0x3C, 0x1F, 0x8F, 0x8F, 0xC3, 0xE3, 0xE0, 0x7B,
  0xF0, 0x1F, 0x78, 0x07, 0xC4, 0x00, 0x80, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x70, 0xFC, 0xFE, 0x3F, 0x0E, 0x02, 0x01,
  0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x0F, 0x9F, 0x83,
  0xC7, 0xC0, 0xF1, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE3,
  0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x0F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F,
  0xFE, 0x0F, 0xE7, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xFE,
  0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x1F, 0x0F, 0xC7, 0xC1, 0xF1,
  0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x81, 0xE3, 0xC0, 0xF8, 0xF0,
  0x3E, 0x7C, 0x1F, 0x1F, 0x0F, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x1F, 0xFC, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8,
  0x7F, 0xFE, 0x3F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x87, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F,
  0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0x0F, 0x87, 0xE0, 0xF0, 0x7C, 0x0F, 0x07,
  0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x81, 0xF0, 0xF8, 0x1E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x7F, 0xFE,
  0x03, 0xF9, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFB, 0xF3,
  0xE0, 0x79, 0xE0, 0x3D, 0xF0, 0x3E, 0xF0, 0x3F, 0x7F, 0xFF, 0x7F, 0xFF,
  0x3F, 0xFE, 0x1F, 0xC0, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xFE, 0x78, 0x7F,
  0xFC, 0x3F, 0xFE, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F, 0x03, 0xE1,
  0xF0, 0x3C, 0x1E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0xE0, 0x78,
  0x1F, 0x0F, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xDF,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x04, 0x03, 0xE0, 0x7F, 0xFC, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F, 0x0F, 0xC7,
  0xC1, 0xF1, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x8F, 0x83, 0xE3, 0xE0,
  0xF8, 0xF8, 0x3C, 0x3C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x78,
  0x78, 0x3E, 0x3E, 0x0F, 0x80, 0x00, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x3F, 0xF1, 0xFF,
  0x8F, 0xFC, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0x1F, 0xF8, 0x7F, 0xC1,
  0xFE, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x20,
  0x7C, 0x07, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x87, 0xE1, 0xE0, 0xF8,
  0x7C, 0x3E, 0x0F, 0x8F, 0x81, 0xF3, 0xE0, 0x3C, 0xF8, 0x0F, 0xBE, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xBE, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x07,
  0xCF, 0x80, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x1E,
  0x07, 0xE0, 0x7F, 0xE7, 0xFC, 0xFF, 0xCF, 0xFC, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7F,
  0xF7, 0xFF, 0x3F, 0xF1, 0xFE, 0x03, 0xF3, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xF7, 0xDF, 0x0E, 0x38, 0xF1, 0xE3, 0x8F, 0x1E, 0x79, 0xE1, 0xE7,
  0x9E, 0x1C, 0x79, 0xE3, 0xC7, 0x1E, 0x3C, 0xF1, 0xC3, 0xC0, 0x3C, 0x3C,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0x87, 0x80, 0x78, 0x78, 0x07, 0x8F,
  0x00, 0x78, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0xFF, 0xF8, 0x3F, 0xFE, 0x1F,
  0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x78, 0x7C, 0x3E, 0x1E, 0x0F, 0x8F, 0x83,
  0xE3, 0xE0, 0xF0, 0xF8, 0x3C, 0x3C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1,
  0xF0, 0x78, 0x78, 0x3E, 0x3E, 0x0F, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0x03,
  0xFF, 0xC3, 0xFF, 0xE3, 0xE1, 0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF0, 0x1F,
  0xF8, 0x0F, 0xFC, 0x07, 0xBE, 0x03, 0xDF, 0x03, 0xEF, 0x81, 0xF7, 0xC1,
  0xF3, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xF0, 0x0F, 0xF0, 0x01, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x1F, 0x0F, 0x81, 0xF0, 0xF8,
  0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0xFC, 0x1F,
  0xFF, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x0F, 0x8F,
  0x83, 0xE7, 0xC0, 0xF9, 0xF0, 0x3C, 0x78, 0x1F, 0x3E, 0x07, 0xCF, 0x81,
  0xF3, 0xE0, 0x78, 0xF8, 0x3E, 0x3E, 0x0F, 0x87, 0xFF, 0xE1, 0xFF, 0xF0,
  0x3F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFE, 0x1F, 0x81, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xF8, 0x3F, 0xFE, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x08, 0x07, 0xC3, 0xEF, 0xE1, 0xFF, 0xF8, 0xFF,
  0xFC, 0x0F, 0xFE, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x0F, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x08, 0x7F, 0xF8, 0x3F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF8, 0x1F, 0x07, 0xC7, 0x81, 0xE1, 0xE0, 0xF8, 0xF8,
  0x3E, 0x3E, 0x0F, 0x8F, 0x83, 0xC3, 0xC1, 0xF1, 0xF0, 0x7C, 0x7C, 0x1F,
  0x1F, 0x07, 0x87, 0x83, 0xE1, 0xE0, 0xF8, 0xF8, 0x3E, 0x3E, 0x1F, 0x87,
  0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xE7, 0x80, 0xF0, 0x0F, 0xFC,
  0x0F, 0xBE, 0x07, 0xDF, 0x07, 0xCF, 0x83, 0xE7, 0xC3, 0xE3, 0xE1, 0xF1,
  0xF0, 0xF0, 0xF8, 0xF8, 0x3C, 0xF8, 0x1E, 0x7C, 0x0F, 0x7C, 0x07, 0xBC,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0xE3,
  0xC7, 0x9E, 0x3C, 0x71, 0xE3, 0x87, 0x3E, 0x38, 0xF3, 0xE7, 0x8F, 0x77,
  0x70, 0xF7, 0x77, 0x0F, 0xE7, 0xF0, 0xEE, 0x7E, 0x0F, 0xC7, 0xE0, 0xFC,
  0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x07, 0x80, 0x0F, 0x81, 0xF8,
  0x7C, 0x0F, 0x81, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x3E, 0xF8, 0x01, 0xF7,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xCF, 0x80, 0x7C, 0x7C,
  0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x87, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x0F,
  0x83, 0xC0, 0x3E, 0x1F, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x8F,
  0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x03, 0xFC, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x03, 0xF0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x02, 0x00, 0x01, 0xF8, 0x3C, 0x7F, 0x8F, 0x1F, 0xFF, 0xE7,
  0xFF, 0xF8, 0xF1, 0xFE, 0x3C, 0x1F, 0x80,
};

const GFXglyph UbuntuSansMono_BoldItalic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 11, 24, 19, 5, -24 },
  { 34, 14, 11, 19, 6, -26 },
  { 54, 20, 24, 19, 0, -24 },
  { 114, 19, 30, 19, 0, -26 },
  { 186, 23, 25, 19, -1, -24 },
  { 258, 19, 24, 19, 0, -24 },
  { 315, 7, 12, 19, 9, -26 },
  { 326, 15, 33, 19, 4, -27 },
  { 388, 15, 33, 19, 0, -27 },
  { 450, 16, 15, 19, 3, -24 },
  { 480, 17, 18, 19, 1, -19 },
  { 519, 9, 12, 19, 2, -6 },
  { 533, 11, 5, 19, 4, -12 },
  { 540, 6, 6, 19, 5, -6 },
  { 545, 23, 33, 19, -2, -27 },
  { 640, 18, 25, 19, 1, -24 },
  { 697, 15, 24, 19, 1, -24 },
  { 742, 19, 24, 19, 0, -24 },
  { 799, 18, 25, 19, 0, -24 },
  { 856, 19, 24, 19, 0, -24 },
  { 913, 20, 25, 19, 0, -24 },
  { 976, 19, 25, 19, 1, -24 },
  { 1036, 18, 24, 19, 3, -24 },
  { 1090, 18, 25, 19, 1, -24 },
  { 1147, 18, 24, 19, 1, -24 },
  { 1201, 9, 18, 19, 5, -18 },
  { 1222, 12, 24, 19, 2, -18 },
  { 1258, 17, 16, 19, 2, -18 },
  { 1292, 19, 12, 19, 0, -16 },
  { 1321, 17, 16, 19, 1, -18 },
  { 1355, 15, 24, 19, 4, -24 },
  { 1400, 19, 29, 19, 1, -24 },
  { 1469, 19, 24, 19, -2, -24 },
  { 1526, 19, 24, 19, 0, -24 },
  { 1583, 18, 25, 19, 2, -24 },
  { 1640, 19, 24, 19, 0, -24 },
  { 1697, 19, 24, 19, 1, -24 },
  { 1754, 20, 24, 19, 1, -24 },
  { 1814, 18, 25, 19, 2, -24 },
  { 1871, 21, 24, 19, 0, -24 },
  { 1934, 21, 24, 19, 0, -24 },
  { 1997, 20, 25, 19, 0, -24 },
  { 2060, 22, 24, 19, 0, -24 },
  { 2126, 16, 24, 19, 0, -24 },
  { 2174, 22, 24, 19, -1, -24 },
  { 2240, 21, 24, 19, 0, -24 },
  { 2303, 18, 25, 19, 1, -24 },
  { 2360, 20, 24, 19, 0, -24 },
  { 2420, 18, 30, 19, 1, -24 },
  { 2488, 19, 24, 19, 0, -24 },
  { 2545, 19, 25, 19, 0, -24 },
  { 2605, 19, 24, 19, 3, -24 },
  { 2662, 20, 25, 19, 1, -24 },
  { 2725, 18, 24, 19, 4, -24 },
  { 2779, 22, 24, 19, 0, -24 },
  { 2845, 23, 24, 19, -1, -24 },
  { 2914, 18, 24, 19, 4, -24 },
  { 2968, 20, 24, 19, 0, -24 },
  { 3028, 18, 33, 19, 2, -27 },
  { 3103, 8, 33, 19, 6, -27 },
  { 3136, 19, 33, 19, -1, -27 },
  { 3215, 18, 14, 19, 1, -24 },
  { 3247, 18, 4, 19, -3, 2 },
  { 3256, 8, 7, 19, 8, -26 },
  { 3263, 18, 18, 19, 1, -18 },
  { 3304, 18, 27, 19, 0, -26 },
  { 3365, 18, 18, 19, 1, -18 },
  { 3406, 20, 26, 19, 1, -26 },
  { 3471, 17, 18, 19, 1, -18 },
  { 3510, 24, 32, 19, -3, -26 },
  { 3606, 20, 24, 19, -1, -18 },
  { 3666, 18, 26, 19, 0, -26 },
  { 3725, 13, 27, 19, 3, -27 },
  { 3769, 20, 33, 19, -2, -27 },
  { 3852, 19, 26, 19, 1, -26 },
  { 3914, 12, 26, 19, 4, -26 },
  { 3953, 20, 18, 19, -1, -18 },
  { 3998, 18, 18, 19, 0, -18 },
  { 4039, 17, 19, 19, 1, -18 },
  { 4080, 20, 24, 19, -2, -18 },
  { 4140, 18, 24, 19, 1, -18 },
  { 4194, 18, 18, 19, 1, -18 },
  { 4235, 18, 19, 19, 0, -18 },
  { 4278, 16, 23, 19, 3, -23 },
  { 4324, 18, 18, 19, 1, -18 },
  { 4365, 17, 18, 19, 3, -18 },
  { 4404, 20, 18, 19, 1, -18 },
  { 4449, 21, 18, 19, -1, -18 },
  { 4497, 22, 24, 19, -3, -18 },
  { 4563, 19, 18, 19, 0, -18 },
  { 4606, 19, 33, 19, 2, -27 },
  { 4685, 13, 33, 19, 3, -27 },
  { 4739, 18, 33, 19, -1, -27 },
  { 4814, 19, 7, 19, 0, -14 },
};

const GFXfont UbuntuSansMono_BoldItalic34pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic34pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic34pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _UBUNTUSANSMONO_BOLDITALIC34PT7B_H_
