#ifndef _UBUNTUSANSMONO_BOLDITALIC45PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x04,
  0x00, 0x7F, 0x1F, 0xDF, 0xC7, 0xF7, 0xF1, 0xF9, 0xF8, 0x7E, 0x7E, 0x1F,
  0xBF, 0x8F, 0xEF, 0xC3, 0xF3, 0xF0, 0xFC, 0xFC, 0x3F, 0x3E, 0x0F, 0x8F,
  0x83, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0E, 0x00, 0x00, 0x0F, 0x87,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x01, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x80, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0xFE, 0x01, 0x80, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x02, 0x00, 0x3F, 0x83, 0x80, 0x1F,
  0xC1, 0xFC, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7C, 0x07, 0xFC, 0x01, 0xE0, 0x0F,
  0xF8, 0x07, 0xC0, 0x3C, 0xF8, 0x1F, 0x00, 0x78, 0xF0, 0x7C, 0x01, 0xE1,
  0xE0, 0xF0, 0x03, 0xC3, 0x83, 0xC0, 0x07, 0x8F, 0x0F, 0x00, 0x0F, 0x1E,
  0x3E, 0x00, 0x1E, 0x3C, 0xF8, 0x00, 0x3C, 0xF3, 0xE0, 0x00, 0x7F, 0xE7,
  0x80, 0x00, 0xFF, 0x9E, 0x00, 0x00, 0xFE, 0x78, 0x00, 0x00, 0x71, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0x3C, 0xFE,
  0x00, 0x00, 0xF3, 0xFE, 0x00, 0x03, 0xCF, 0xFC, 0x00, 0x0F, 0x9E, 0x78,
  0x00, 0x3E, 0x3C, 0x70, 0x00, 0xF8, 0xF0, 0xE0, 0x01, 0xE1, 0xE3, 0xC0,
  0x07, 0x83, 0xC7, 0x80, 0x1E, 0x07, 0x0F, 0x00, 0x7C, 0x0E, 0x3C, 0x01,
  0xF0, 0x1E, 0x78, 0x07, 0xC0, 0x3F, 0xE0, 0x0F, 0x00, 0x7F, 0xC0, 0x7C,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F,
  0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x01,
  0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x7E, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x19, 0x03, 0xFC, 0x1F,
  0x07, 0xFF, 0x0F, 0x87, 0xFF, 0xC7, 0xC7, 0xE7, 0xE7, 0xC3, 0xE1, 0xFB,
  0xE3, 0xF0, 0x7F, 0xE1, 0xF0, 0x3F, 0xF0, 0xF8, 0x0F, 0xF0, 0xFC, 0x03,
  0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x01, 0xFE, 0x0F, 0xE3, 0xFF, 0x07, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xF1, 0xF0, 0x1F, 0xE0, 0xFC, 0x3F,
  0x9F, 0xCF, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7C, 0x3E, 0x3F, 0x1F,
  0x0F, 0x87, 0x83, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0x80, 0x00, 0x30, 0x00, 0x01, 0x00, 0x00, 0x00, 0x04, 0x00,
  0x00, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x03, 0x0F, 0x82, 0x1E, 0x3C, 0x79, 0xFD, 0xEF, 0xCF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xF0,
  0x03, 0xEF, 0xC0, 0x3F, 0x7F, 0x03, 0xF9, 0xFC, 0x3F, 0x8F, 0xC0, 0x7C,
  0x3C, 0x00, 0xC1, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xA0,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0xFF, 0x0F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F,
  0xF0, 0x7F, 0x01, 0xE0, 0x3E, 0x0F, 0xC7, 0xF8, 0xFF, 0x0F, 0xE0, 0xF8,
  0x0C, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0x80, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0xFC, 0x08,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0x3F, 0x83, 0xF8, 0x1F, 0x8F, 0xE0, 0x3F,
  0x1F, 0x80, 0x7E, 0x7F, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF7,
  0xE0, 0x07, 0xEF, 0xC7, 0x8F, 0xDF, 0x9F, 0x1F, 0xBE, 0x3E, 0x3F, 0xFC,
  0x7C, 0x7D, 0xF8, 0xF9, 0xFB, 0xF1, 0xE3, 0xF7, 0xE0, 0x07, 0xEF, 0xC0,
  0x0F, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x7E, 0x7C, 0x01, 0xF8, 0xFC, 0x03,
  0xF1, 0xF8, 0x0F, 0xC3, 0xF8, 0x3F, 0x87, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xEF, 0xC0,
  0x3E, 0x7E, 0x01, 0xC3, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x5F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0x80, 0xFE, 0x03, 0x00, 0x3F, 0x01,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xF0, 0xFF, 0x00, 0x80, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x60, 0x03, 0xF8, 0x7F,
  0x1F, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x3E, 0x00, 0x1F,
  0x9F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x81, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x0C, 0x00, 0xFE, 0x07, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x0E, 0x00, 0x7E, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x03, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x01, 0xF8,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0x7E, 0x07, 0xF0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xF8, 0x7F, 0x07, 0xE0, 0x3F,
  0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x3F,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0xFE, 0x03, 0xFB, 0xFC, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xCF, 0xF0,
  0x3F, 0x83, 0xF8, 0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xFC, 0x7C, 0x00, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFC, 0xFC, 0x01, 0xF8, 0xFE, 0x03, 0xF8,
  0x7F, 0x8F, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xF1, 0xFE,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0x7F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F,
  0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x3F, 0x1F, 0xF3, 0xFF, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x01, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x83, 0xFE, 0x1F,
  0xF0, 0xFF, 0x87, 0xF8, 0x3F, 0xC0, 0xFC, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7F, 0x83, 0xFC, 0x3F,
  0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0x81, 0xF8, 0x01, 0x00, 0x00, 0x7E, 0x00,
  0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00,
  0xFC, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x0F,
  0xC0, 0x7F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE,
  0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x08, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0x04, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7C, 0x3F, 0xCC, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xF7, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x3E, 0x1F,
  0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0xFF, 0xE7,
  0xC1, 0xFF, 0xF3, 0xE1, 0xFF, 0xFB, 0xE1, 0xFF, 0xF9, 0xF0, 0xFF, 0xFC,
  0xF8, 0xFC, 0x3E, 0x78, 0x7C, 0x3F, 0x3C, 0x7E, 0x1F, 0x3E, 0x3E, 0x0F,
  0x9F, 0x1F, 0x07, 0xCF, 0x8F, 0x87, 0xE7, 0xC7, 0xC3, 0xF3, 0xE3, 0xE1,
  0xF1, 0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0x7C, 0x7C, 0x7F, 0xFE, 0x3E, 0x3F,
  0xFE, 0x1F, 0x0F, 0xFF, 0x0F, 0x83, 0xFF, 0x87, 0xC0, 0xFF, 0x81, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xBE,
  0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xF8, 0x3F,
  0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC,
  0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xE0, 0x7F, 0x83,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x7F, 0x1F, 0x80, 0xFF,
  0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xF0,
  0x0C, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x01,
  0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x1F, 0xC1, 0xF8, 0x0F, 0xE0, 0xFC, 0x03, 0xF0, 0xFE, 0x01, 0xF8,
  0x7E, 0x01, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x7E, 0x1F, 0xC0, 0x3F,
  0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F, 0xE3, 0xF8, 0x07,
  0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x03, 0xF8, 0x7F, 0x03,
  0xFC, 0x3F, 0x03, 0xFC, 0x1F, 0x87, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x1F, 0xE0, 0x18, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0xFE, 0x3F, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0xC3, 0xF0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF0, 0x7F, 0x01, 0xF8, 0x1F, 0xC1,
  0xF8, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x10, 0x07, 0xF0, 0x0F, 0x03, 0xFC, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xF0, 0x1F,
  0x80, 0xFE, 0x03, 0xF8, 0x1F, 0xE0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x3F,
  0x80, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x1F, 0x9F,
  0xC0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00,
  0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xFC,
  0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0x7F, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xDE, 0x01,
  0xEF, 0x1F, 0xF0, 0x1F, 0x79, 0xEF, 0x80, 0xFB, 0xCF, 0x78, 0x07, 0xDE,
  0xF3, 0xC0, 0x3C, 0xF7, 0xBE, 0x03, 0xE7, 0xF9, 0xF0, 0x1F, 0x3F, 0xCF,
  0x80, 0xF9, 0xFC, 0x7C, 0x0F, 0x8F, 0xE7, 0xC0, 0x7C, 0x7E, 0x3E, 0x03,
  0xE3, 0xF1, 0xF0, 0x1F, 0x0F, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0x80,
  0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0xE0, 0x3E, 0x00, 0xFF, 0x01, 0xF0, 0x0F, 0xF8, 0x0F,
  0x80, 0x7F, 0xC0, 0xFC, 0x03, 0xFF, 0x07, 0xE0, 0x1F, 0xF8, 0x3E, 0x01,
  0xFB, 0xC1, 0xF0, 0x0F, 0xDF, 0x1F, 0x80, 0x7C, 0xF8, 0xFC, 0x03, 0xE7,
  0xC7, 0xC0, 0x3F, 0x1E, 0x3E, 0x01, 0xF8, 0xF3, 0xF0, 0x0F, 0x87, 0xDF,
  0x80, 0x7C, 0x3E, 0xF8, 0x07, 0xE0, 0xF7, 0xC0, 0x3F, 0x07, 0xFE, 0x01,
  0xF0, 0x3F, 0xF0, 0x0F, 0x81, 0xFF, 0x00, 0xFC, 0x0F, 0xF8, 0x07, 0xE0,
  0x3F, 0xC0, 0x3E, 0x01, 0xFE, 0x01, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x7C, 0x03,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07, 0xF0,
  0x7F, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3F, 0x3F, 0x80, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00,
  0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0xFE, 0x00, 0xFC, 0xFE, 0x01,
  0xFC, 0xFE, 0x01, 0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7F, 0x0F,
  0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0x3F, 0x03, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x0F,
  0xC1, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x03, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x8F,
  0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x7F, 0x00, 0xFC, 0xFC, 0x01, 0xFB, 0xF8,
  0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07,
  0xEF, 0xC0, 0x1F, 0xDF, 0x80, 0x3F, 0x3F, 0x00, 0xFE, 0x7E, 0x01, 0xF8,
  0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC3, 0xF8, 0x7F, 0x87, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xC0, 0xFE, 0x07,
  0xE0, 0x7F, 0x07, 0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x3F, 0x03, 0xF8,
  0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x1F,
  0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x80,
  0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xC3, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x07,
  0xC0, 0x3F, 0x00, 0x20, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x08, 0x00, 0x7F, 0x03, 0x80, 0x3F, 0x81, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7E,
  0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF8, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x7E,
  0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xE0,
  0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F,
  0xC1, 0xF8, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0xFC, 0xFC, 0x01,
  0xFC, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xFC,
  0x00, 0x7C, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x0F, 0x81,
  0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0,
  0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x07,
  0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x3F, 0x1F, 0x1F, 0x81,
  0xF1, 0xF8, 0xF8, 0x0F, 0x8F, 0xC7, 0xC0, 0x7C, 0xFE, 0x3E, 0x03, 0xE7,
  0xF1, 0xE0, 0x3E, 0x7F, 0x9F, 0x01, 0xF3, 0xFC, 0xF8, 0x0F, 0xBD, 0xE7,
  0xC0, 0x7D, 0xEF, 0x3C, 0x03, 0xDE, 0x3B, 0xE0, 0x1E, 0xF1, 0xDF, 0x01,
  0xFF, 0x0E, 0xF0, 0x0F, 0xF8, 0x77, 0x80, 0x7F, 0x83, 0xFC, 0x03, 0xFC,
  0x1F, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x7E,
  0x3F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x7E, 0x7E, 0x00, 0xFE, 0x7E, 0x01, 0xFC, 0x7E, 0x01,
  0xF8, 0x7E, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x3F, 0x0F,
  0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x1F, 0x3F,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x83, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFD, 0xF8, 0x07, 0xF3, 0xF8, 0x0F, 0xC3,
  0xF0, 0x3F, 0x87, 0xE0, 0xFE, 0x0F, 0xE3, 0xF8, 0x0F, 0xCF, 0xE0, 0x1F,
  0xBF, 0x80, 0x3F, 0xBF, 0x00, 0x3F, 0x3C, 0x00, 0x78, 0x10, 0x00, 0xC0,
  0x3F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0x10, 0x07, 0x00, 0xF0, 0x3F, 0x8F, 0xF8, 0xFF, 0x87,
  0xF8, 0x3E, 0x01, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0x01, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xF0, 0xFE, 0x1F, 0xC0,
  0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7F, 0x01, 0xFC, 0x7E, 0x01,
  0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0xFE, 0x03, 0xF8, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0x0F,
  0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFD,
  0xF8, 0x0F, 0xF1, 0xF8, 0x01, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xF0, 0xFE, 0x1F, 0x80, 0xFC, 0x3F,
  0x01, 0xF8, 0x7E, 0x03, 0xF1, 0xFC, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x8F, 0xC0, 0x3F, 0x3F, 0x80, 0x7E, 0x7E, 0x01, 0xFC, 0xFC, 0x03,
  0xF1, 0xF8, 0x0F, 0xE7, 0xF0, 0x3F, 0x8F, 0xC0, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0x03, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0x83, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xF0, 0xFE,
  0x03, 0xF8, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xF0,
  0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01,
  0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xBF, 0x00, 0x3F, 0xC7,
  0xE0, 0x00, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xC0, 0x3F,
  0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x03, 0xF3, 0xF8, 0x0F,
  0xCF, 0xC0, 0x3F, 0x7E, 0x00, 0xFD, 0xF8, 0x07, 0xFF, 0xC0, 0x7F, 0xBF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x02, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0xFF, 0x9C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x21, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFC, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0xC0, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF8,
  0x0F, 0xE0, 0x7E, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xE0, 0x1F,
  0xC0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xF0, 0xFE, 0x1F, 0xC1, 0xFC, 0x3F, 0x81,
  0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F,
  0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0xFE, 0x07, 0xE1,
  0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0xC0, 0xFE, 0x3F,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0xC0, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0,
  0x03, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x87, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7F, 0x04, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xC0,
  0xFF, 0xE0, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x02, 0x01, 0xFC, 0x01,
  0x81, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0xFF, 0x07, 0xE0, 0x3F, 0x81, 0xF8, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x1F,
  0x87, 0xF0, 0x0F, 0xE3, 0xF8, 0x03, 0xF1, 0xFC, 0x00, 0xFC, 0xFE, 0x00,
  0x3F, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xCF, 0xE0, 0x03, 0xF1,
  0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x07,
  0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x00, 0xFE,
  0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x7F, 0xF8, 0x81, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x83, 0x3F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF,
  0x0F, 0xFE, 0x00, 0xA0, 0x00, 0x7E, 0x1E, 0x00, 0xFF, 0xDF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xF1, 0xF1, 0xF0,
  0xF8, 0x78, 0x7C, 0x3E, 0x3E, 0x3F, 0x0F, 0x8F, 0x8F, 0x83, 0xE3, 0xE3,
  0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x7C, 0x7E, 0x1F, 0x1F, 0x1F, 0x07, 0xC7,
  0xC7, 0xC3, 0xF1, 0xF1, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xE0, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0xFE, 0x07, 0xE1, 0xF8, 0x0F, 0xC3,
  0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x1F, 0xC0, 0xFC, 0x3F, 0x01, 0xF8, 0x7E,
  0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0xFC, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xFC, 0x3F,
  0x87, 0xF0, 0x3F, 0x1F, 0xC0, 0x7F, 0x3F, 0x00, 0xFE, 0xFE, 0x01, 0xFD,
  0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x0F, 0xDF, 0xC0, 0x1F, 0xBF,
  0x80, 0x7F, 0x7F, 0x00, 0xFC, 0xFE, 0x03, 0xF9, 0xFC, 0x07, 0xE1, 0xFC,
  0x1F, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0xFE, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x1F,
  0xC0, 0xFC, 0x07, 0xF0, 0x7E, 0x01, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x3F, 0xE0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0x20, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F,
  0x80, 0xFE, 0x7F, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x07, 0xE7, 0xE0,
  0x1F, 0xCF, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0x7E, 0x03,
  0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF8, 0x3F, 0x87, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xFC, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xFC,
  0x03, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE1,
  0xC0, 0x1F, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x04, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x18, 0x00, 0x1F, 0xC0, 0xFE, 0x3F,
  0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE3, 0xF8, 0x1F, 0xC7, 0xE0,
  0x3F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xFC, 0x7F, 0x03, 0xF8, 0xFC, 0x07,
  0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0x1F, 0xC0, 0xFC,
  0x3F, 0x01, 0xF8, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0xC3,
  0xF8, 0x7F, 0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xF1, 0xF8, 0x01, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0xFC,
  0x01, 0xFD, 0xF8, 0x03, 0xF3, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0x8F, 0xC0,
  0x7F, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x7E, 0x07, 0xE0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x3F, 0x03, 0xF8, 0x7E, 0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xF0,
  0x0F, 0xCF, 0xC0, 0x1F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF3,
  0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x87, 0x87,
  0xE7, 0xC3, 0xE1, 0xF1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x1F, 0x1F, 0x1F,
  0x8F, 0x87, 0xC7, 0xE3, 0xE1, 0xF3, 0xFC, 0xF8, 0x78, 0xFF, 0x3C, 0x1E,
  0x7B, 0xDF, 0x07, 0x9E, 0xF7, 0x81, 0xEF, 0x3D, 0xE0, 0x7F, 0xCF, 0xF8,
  0x3F, 0xE3, 0xFC, 0x0F, 0xF8, 0xFF, 0x03, 0xFC, 0x3F, 0x80, 0xFE, 0x0F,
  0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x1E, 0x00, 0x07,
  0xE0, 0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x1F,
  0xC0, 0x1F, 0x87, 0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFE, 0x7E, 0x00,
  0x1F, 0x8F, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x01, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00,
  0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8, 0xFC,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x04, 0x0F, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x08,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xC0,
  0x18, 0x0F, 0xF0, 0x1F, 0x1F, 0xFC, 0x3E, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFC, 0xF8, 0x7F, 0xF8, 0xF8, 0x1F, 0xF0, 0x70, 0x0F,
  0xE0,
};

const GFXglyph UbuntuSansMono_BoldItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 15, 32, 25, 6, -31 },
  { 61, 18, 14, 25, 8, -34 },
  { 93, 27, 31, 25, 0, -31 },
  { 198, 25, 40, 25, 0, -35 },
  { 323, 31, 33, 25, -2, -32 },
  { 451, 25, 32, 25, 0, -32 },
  { 551, 9, 15, 25, 12, -34 },
  { 568, 20, 45, 25, 5, -36 },
  { 681, 20, 45, 25, 0, -36 },
  { 794, 21, 20, 25, 4, -31 },
  { 847, 23, 23, 25, 1, -25 },
  { 914, 12, 16, 25, 3, -8 },
  { 938, 15, 6, 25, 5, -16 },
  { 950, 9, 9, 25, 6, -8 },
  { 961, 29, 43, 25, -2, -35 },
  { 1117, 23, 33, 25, 2, -32 },
  { 1212, 21, 31, 25, 1, -31 },
  { 1294, 25, 32, 25, 0, -32 },
  { 1394, 24, 33, 25, 0, -32 },
  { 1493, 26, 31, 25, 0, -31 },
  { 1594, 26, 32, 25, 0, -31 },
  { 1698, 24, 32, 25, 2, -31 },
  { 1794, 24, 31, 25, 4, -31 },
  { 1887, 24, 33, 25, 1, -32 },
  { 1986, 24, 32, 25, 1, -32 },
  { 2082, 13, 24, 25, 6, -23 },
  { 2121, 16, 31, 25, 3, -23 },
  { 2183, 23, 22, 25, 2, -24 },
  { 2247, 25, 15, 25, 0, -21 },
  { 2294, 23, 22, 25, 1, -24 },
  { 2358, 19, 33, 25, 6, -32 },
  { 2437, 25, 39, 25, 1, -32 },
  { 2559, 24, 31, 25, -2, -31 },
  { 2652, 25, 32, 25, 0, -32 },
  { 2752, 24, 33, 25, 3, -32 },
  { 2851, 25, 32, 25, 0, -32 },
  { 2951, 26, 31, 25, 1, -31 },
  { 3052, 27, 31, 25, 1, -31 },
  { 3157, 25, 33, 25, 2, -32 },
  { 3261, 29, 31, 25, -1, -31 },
  { 3374, 27, 31, 25, 0, -31 },
  { 3479, 26, 32, 25, 0, -31 },
  { 3583, 28, 31, 25, 0, -31 },
  { 3692, 21, 31, 25, 0, -31 },
  { 3774, 29, 31, 25, -2, -31 },
  { 3887, 29, 31, 25, -1, -31 },
  { 4000, 24, 33, 25, 1, -32 },
  { 4099, 26, 32, 25, 0, -32 },
  { 4203, 23, 41, 25, 2, -32 },
  { 4321, 25, 32, 25, 0, -32 },
  { 4421, 26, 33, 25, 0, -32 },
  { 4529, 23, 31, 25, 5, -31 },
  { 4619, 26, 32, 25, 1, -31 },
  { 4723, 24, 31, 25, 5, -31 },
  { 4816, 29, 31, 25, 0, -31 },
  { 4929, 31, 31, 25, -2, -31 },
  { 5050, 24, 31, 25, 5, -31 },
  { 5143, 28, 31, 25, -1, -31 },
  { 5252, 24, 43, 25, 3, -35 },
  { 5381, 10, 43, 25, 8, -35 },
  { 5435, 24, 43, 25, -1, -35 },
  { 5564, 23, 18, 25, 2, -31 },
  { 5616, 24, 5, 25, -4, 3 },
  { 5631, 11, 9, 25, 10, -35 },
  { 5644, 24, 25, 25, 1, -24 },
  { 5719, 23, 36, 25, 0, -35 },
  { 5823, 23, 25, 25, 2, -24 },
  { 5895, 27, 36, 25, 1, -35 },
  { 6017, 22, 25, 25, 2, -24 },
  { 6086, 32, 43, 25, -4, -35 },
  { 6258, 27, 32, 25, -2, -24 },
  { 6366, 23, 35, 25, 0, -35 },
  { 6467, 17, 36, 25, 4, -35 },
  { 6544, 25, 44, 25, -2, -35 },
  { 6682, 26, 35, 25, 1, -35 },
  { 6796, 16, 36, 25, 5, -35 },
  { 6868, 26, 24, 25, -1, -24 },
  { 6946, 23, 24, 25, 0, -24 },
  { 7015, 23, 25, 25, 1, -24 },
  { 7087, 26, 32, 25, -2, -24 },
  { 7191, 23, 32, 25, 2, -24 },
  { 7283, 23, 24, 25, 2, -24 },
  { 7352, 23, 25, 25, 1, -24 },
  { 7424, 21, 32, 25, 4, -31 },
  { 7508, 23, 25, 25, 2, -24 },
  { 7580, 23, 24, 25, 3, -24 },
  { 7649, 26, 24, 25, 1, -24 },
  { 7727, 27, 24, 25, -1, -24 },
  { 7808, 30, 32, 25, -4, -24 },
  { 7928, 24, 24, 25, 1, -24 },
  { 8000, 24, 43, 25, 3, -35 },
  { 8129, 17, 43, 25, 4, -35 },
  { 8221, 24, 43, 25, -2, -35 },
  { 8350, 24, 9, 25, 1, -18 },
};

const GFXfont UbuntuSansMono_BoldItalic45pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic45pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic45pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _UBUNTUSANSMONO_BOLDITALIC45PT7B_H_
