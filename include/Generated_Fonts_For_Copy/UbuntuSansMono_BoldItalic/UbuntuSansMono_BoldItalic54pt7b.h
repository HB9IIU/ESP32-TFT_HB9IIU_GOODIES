#ifndef _UBUNTUSANSMONO_BOLDITALIC54PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x03, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F,
  0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0xC0, 0x00, 0x3F, 0xC3,
  0xFC, 0xFF, 0x0F, 0xF3, 0xFC, 0x3F, 0xCF, 0xF0, 0xFF, 0x3F, 0x87, 0xF9,
  0xFE, 0x1F, 0xE7, 0xF8, 0x7F, 0x9F, 0xC1, 0xFC, 0x7F, 0x07, 0xF1, 0xFC,
  0x1F, 0xC7, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xC1, 0xF0, 0x1F,
  0x0F, 0xC0, 0xFC, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x0E,
  0x03, 0xFC, 0x00, 0x10, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x81, 0x80, 0x03, 0xFC, 0x0F, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x08,
  0x03, 0xFE, 0x00, 0x0F, 0x80, 0x3F, 0xF8, 0x00, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0x80, 0x1F, 0xBE, 0x00, 0xF8, 0x00, 0xF8, 0xF8, 0x0F, 0xC0, 0x0F,
  0x87, 0xC0, 0xFC, 0x00, 0x7C, 0x3C, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x7C,
  0x00, 0x1E, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x7C, 0x00, 0x0F, 0x87,
  0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x7E, 0x00, 0x03, 0xF7, 0xE7, 0xE0, 0x00,
  0x0F, 0xFE, 0x3E, 0x00, 0x00, 0x7F, 0xF3, 0xE0, 0x00, 0x03, 0xFF, 0x3E,
  0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x08, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x01, 0xF1, 0xFE,
  0x00, 0x00, 0x1F, 0x1F, 0xF0, 0x00, 0x01, 0xF9, 0xFF, 0xC0, 0x00, 0x1F,
  0x9F, 0xFE, 0x00, 0x01, 0xF8, 0xF8, 0xF0, 0x00, 0x0F, 0x8F, 0x87, 0x80,
  0x00, 0xF8, 0x7C, 0x3C, 0x00, 0x0F, 0x83, 0xC1, 0xE0, 0x00, 0xFC, 0x3E,
  0x1F, 0x00, 0x0F, 0xC1, 0xF0, 0xF8, 0x00, 0xFC, 0x0F, 0x87, 0xC0, 0x07,
  0xC0, 0x7C, 0x7C, 0x00, 0x7C, 0x03, 0xE3, 0xE0, 0x07, 0xC0, 0x1F, 0xFE,
  0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x07, 0xE0, 0x03, 0xFF, 0x00, 0x7E, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xF0,
  0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x03,
  0xF3, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x3E, 0x03, 0xFF, 0x03, 0xF0, 0x7F, 0xFC, 0x1F,
  0x87, 0xFF, 0xF0, 0xFC, 0x7F, 0xBF, 0x8F, 0xC3, 0xF0, 0xFE, 0x7E, 0x3F,
  0x07, 0xFF, 0xE3, 0xF8, 0x1F, 0xFF, 0x1F, 0x80, 0x7F, 0xF0, 0xFC, 0x03,
  0xFF, 0x87, 0xE0, 0x0F, 0xF8, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x03, 0xFC,
  0x0F, 0xE0, 0x3F, 0xF0, 0x7F, 0x87, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x9F, 0x81, 0xFF, 0xF8, 0xFE, 0x07, 0xFF,
  0x07, 0xF0, 0x01, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF3, 0xFD, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF1, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x02, 0x03, 0xF0, 0x01, 0xC1, 0xF0,
  0x70, 0xF8, 0xF8, 0xFC, 0xFF, 0x7C, 0xFE, 0x7F, 0xDF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x07, 0xF7, 0xF0, 0x07,
  0xF9, 0xFC, 0x07, 0xF8, 0xFF, 0x03, 0xFC, 0x7F, 0x80, 0x7C, 0x1F, 0x80,
  0x1E, 0x07, 0x00, 0x02, 0x03, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x1F, 0xE0, 0x7F, 0xC3, 0xFF, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x3F, 0x8F, 0xFE, 0x3F, 0xF0, 0xFF, 0x03, 0xF8, 0x0F, 0x00, 0x00,
  0x3F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF, 0x7F, 0xFF, 0x9F,
  0xFF, 0xEF, 0xFF, 0xF8, 0x1F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x1F,
  0xE0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F,
  0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF3, 0xF8, 0x00,
  0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x78, 0x7F, 0x7F, 0x0F, 0xC7, 0xF7,
  0xF1, 0xFC, 0x7F, 0x7F, 0x1F, 0xC7, 0xE7, 0xF1, 0xF8, 0xFE, 0x7E, 0x1F,
  0x8F, 0xEF, 0xE1, 0xF0, 0xFE, 0xFE, 0x06, 0x0F, 0xEF, 0xE0, 0x01, 0xFC,
  0xFE, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xF0, 0xFF, 0x01, 0xFE,
  0x07, 0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x07,
  0xF3, 0xF8, 0x07, 0xC3, 0xF8, 0x03, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0xFF, 0xC0, 0x3E,
  0x00, 0xFF, 0x00, 0xE0, 0x03, 0xFC, 0x01, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xE0, 0x3F, 0xE0, 0x04, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x21, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x80, 0x00, 0xFF, 0x06,
  0x00, 0x1F, 0xF0, 0x7F, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x07,
  0xE0, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x04, 0x00, 0x07,
  0xF8, 0x0E, 0x00, 0x3F, 0xE0, 0x3F, 0xC7, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x03, 0x00, 0x07, 0xF3, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFC, 0x07,
  0xFC, 0x3F, 0x80, 0x1F, 0xE3, 0xFC, 0x00, 0x7F, 0x1F, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x07, 0xF1, 0xFC,
  0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFE, 0x01,
  0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xE3, 0xFF, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xF8, 0x1F, 0xE0,
  0x7F, 0x80, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0, 0xFE,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xE7, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xE0, 0x07, 0xFD, 0xFF, 0x80, 0x7F, 0x83, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0x80, 0x3F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0,
  0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xFC,
  0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x01,
  0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x7F, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0xFE,
  0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x80,
  0x7F, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xBF, 0x80, 0x07, 0xE1, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xF0, 0xFF, 0xE1,
  0xFF, 0xC3, 0xFF, 0x07, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x03, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFE, 0x03, 0xF8, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xC0, 0xFF, 0x8C, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0xFF, 0xE1, 0xF8, 0x0F, 0xFF, 0xC3, 0xF0, 0x3F, 0xFF, 0x8F, 0xC0,
  0xFF, 0xFF, 0x1F, 0x83, 0xFF, 0xFE, 0x3E, 0x0F, 0xFF, 0xF8, 0xFC, 0x3F,
  0xC3, 0xF1, 0xF8, 0x7F, 0x07, 0xE3, 0xF0, 0xFC, 0x1F, 0xC7, 0xC3, 0xF8,
  0x3F, 0x0F, 0x87, 0xE0, 0x7E, 0x3F, 0x0F, 0xC0, 0xFC, 0x7E, 0x1F, 0x83,
  0xF8, 0xFC, 0x7F, 0x07, 0xE1, 0xF8, 0xFC, 0x0F, 0xC3, 0xF1, 0xF8, 0x1F,
  0x87, 0xE3, 0xF8, 0x7F, 0x0F, 0xC7, 0xF0, 0xFC, 0x1F, 0x87, 0xF1, 0xF8,
  0x3F, 0x0F, 0xFF, 0xF0, 0x7E, 0x1F, 0xFF, 0xE0, 0xFC, 0x1F, 0xFF, 0xC1,
  0xF8, 0x1F, 0xFF, 0x01, 0xF8, 0x1F, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x0C, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xF8, 0xFE,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8,
  0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE,
  0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFF, 0x3F, 0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x3F, 0xDF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xF1, 0xFF,
  0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0,
  0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0xFF, 0x01, 0xFE, 0x7F, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFE, 0x01, 0xFF,
  0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE,
  0x00, 0x3F, 0xC3, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFE, 0x0F, 0x80, 0xFF,
  0xC0, 0x0C, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x10, 0x0F, 0xF8, 0x03, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0x03,
  0xFE, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x3F,
  0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0,
  0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xF0, 0x03,
  0xFC, 0x1F, 0xC0, 0x0F, 0xF0, 0x7F, 0x00, 0x3F, 0xC3, 0xFC, 0x01, 0xFE,
  0x0F, 0xF0, 0x0F, 0xF8, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x01, 0xFF, 0x07,
  0xF8, 0x1F, 0xF8, 0x1F, 0xE1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x1F,
  0x00, 0xFF, 0xC0, 0x0C, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x07,
  0xF8, 0x7F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xFC,
  0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x0F,
  0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFE,
  0x01, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x01, 0x00, 0x0F, 0xF0, 0x03, 0x00, 0x3F, 0xE0, 0x0F, 0x80, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x3F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x07, 0xF0,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F,
  0x87, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x01,
  0xFE, 0xFF, 0x80, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF9, 0xFE,
  0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x07,
  0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0xC1, 0xFF, 0x80, 0x1F, 0x78, 0x3D, 0xF0, 0x07, 0xEF,
  0x0F, 0xBE, 0x00, 0xFD, 0xE1, 0xEF, 0xC0, 0x1F, 0xBC, 0x7D, 0xF8, 0x03,
  0xE7, 0x9F, 0x3E, 0x00, 0xFC, 0xFB, 0xEF, 0xC0, 0x1F, 0x9F, 0xF9, 0xF8,
  0x03, 0xF3, 0xFF, 0x3F, 0x00, 0xFC, 0x7F, 0xC7, 0xE0, 0x1F, 0x8F, 0xF9,
  0xF8, 0x03, 0xF1, 0xFE, 0x3F, 0x00, 0x7E, 0x3F, 0xC7, 0xE0, 0x1F, 0xC3,
  0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x3F, 0x80, 0x7E, 0x0F, 0x87, 0xE0, 0x1F,
  0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x03, 0xFE, 0x00,
  0x7E, 0x00, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFC,
  0x03, 0xF0, 0x07, 0xFF, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0x00, 0x7F,
  0xF8, 0x1F, 0xC0, 0x1F, 0xFE, 0x07, 0xF0, 0x0F, 0xEF, 0x81, 0xF8, 0x03,
  0xFB, 0xE0, 0xFE, 0x00, 0xFE, 0xFC, 0x3F, 0x80, 0x3F, 0x3F, 0x0F, 0xE0,
  0x1F, 0xC7, 0xC3, 0xF0, 0x07, 0xF1, 0xF0, 0xFC, 0x01, 0xFC, 0x7E, 0x7F,
  0x00, 0x7E, 0x1F, 0x9F, 0xC0, 0x3F, 0x83, 0xE7, 0xE0, 0x0F, 0xE0, 0xF9,
  0xF8, 0x03, 0xF8, 0x3E, 0xFE, 0x00, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0x03,
  0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0xF0, 0x07, 0xF0, 0x1F, 0xFC, 0x01, 0xF8,
  0x07, 0xFF, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0x3F, 0x80, 0x3F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF8, 0x03, 0xF0, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xFC,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x3F, 0xF0, 0x7F,
  0xC0, 0xFF, 0x0F, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x07,
  0xF1, 0xFE, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x3F,
  0x80, 0x07, 0xF7, 0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF0, 0x00,
  0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00,
  0x1F, 0xCF, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x3F, 0xCF, 0xE0, 0x07, 0xF8,
  0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8,
  0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x01, 0xFE,
  0x01, 0xFE, 0x03, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0,
  0x07, 0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x1F,
  0xF8, 0x1F, 0xC1, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x0F,
  0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0x1F, 0xE0, 0x07, 0xF1, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xF3, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF7,
  0xF8, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00,
  0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFE,
  0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xE0,
  0x03, 0xFC, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7F,
  0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0x01, 0xFF, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xE1, 0xFF, 0x80, 0x7F, 0x01,
  0xFF, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xC0, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x80, 0x3F, 0x81, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0x1F,
  0xC0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xE0,
  0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC,
  0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0x3E, 0x00, 0xFE, 0x00,
  0x18, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x0C, 0x00, 0x0F, 0xF0, 0x1E, 0x00, 0x3F, 0xC0, 0x7F, 0xE7,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x03,
  0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x03, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x3F, 0xC0, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF8,
  0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xBF,
  0xC0, 0x03, 0xFD, 0xFE, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFE, 0x7F, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xFE, 0x0F,
  0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0,
  0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x81, 0xFC,
  0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x03, 0xF9,
  0xFC, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x3F,
  0x00, 0x7E, 0x3F, 0x87, 0xE0, 0x0F, 0xC7, 0xF0, 0xFC, 0x03, 0xF1, 0xFE,
  0x1F, 0x80, 0x7E, 0x3F, 0xC7, 0xE0, 0x0F, 0xCF, 0xF8, 0xFC, 0x01, 0xF9,
  0xFF, 0x1F, 0x80, 0x3E, 0x7D, 0xF3, 0xF0, 0x0F, 0xCF, 0x3E, 0xFC, 0x01,
  0xFB, 0xE7, 0xDF, 0x80, 0x3F, 0x78, 0xFB, 0xF0, 0x07, 0xDF, 0x1F, 0x7C,
  0x00, 0xFB, 0xC3, 0xEF, 0x80, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFE, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x01, 0xFC,
  0x3F, 0xC0, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x0F,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x7F,
  0x9F, 0xC0, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x03, 0xFC, 0x3F,
  0x80, 0x1F, 0xC1, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80,
  0xFF, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x07, 0xF8,
  0x01, 0xFC, 0x7F, 0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x03,
  0xFB, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0xFF,
  0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F,
  0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F,
  0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x1F,
  0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F, 0xC1, 0xFC, 0x1F,
  0xE1, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xF3, 0xF8, 0x03, 0xFE,
  0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x01, 0xFE,
  0x1F, 0xE0, 0x1F, 0xE3, 0xFE, 0x00, 0xFE, 0x7F, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0x3F, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x7C, 0x06, 0x00, 0x07,
  0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x10, 0x00,
  0xE0, 0x0F, 0x80, 0x7E, 0x07, 0xFC, 0x7F, 0xF1, 0xFF, 0xC3, 0xFF, 0x07,
  0xF8, 0x0F, 0x80, 0x18, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xC3, 0xFF, 0x07, 0xF0, 0xFF, 0x80, 0xFE, 0x3F, 0xE0, 0x3F, 0xC7, 0xF8,
  0x07, 0xF9, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xCF, 0xF0, 0x03, 0xF9,
  0xFE, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0x1F, 0xC0, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0xFF, 0x87, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xBF, 0x80, 0xFF, 0xC7, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xE3, 0xFF, 0x07, 0xF8, 0x0F, 0xF0,
  0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0x0F, 0xF0,
  0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF1, 0xFE, 0x00, 0xFF,
  0x1F, 0xE0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xFC,
  0x01, 0xFE, 0x3F, 0xC0, 0x1F, 0xE3, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x7F,
  0xC7, 0xF8, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFC, 0x0F, 0xFF, 0x87, 0xC0, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0,
  0x0E, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x02,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0xFE, 0x01, 0xFF, 0x01, 0xFC, 0x07,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0x7F,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0,
  0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x80,
  0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01,
  0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0x7F, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFE, 0x07,
  0xF8, 0xFF, 0x00, 0x7F, 0x1F, 0xC0, 0x0F, 0xE7, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0x3F, 0xBF, 0x80, 0x0F, 0xF7, 0xF0, 0x07, 0xFC, 0xFE, 0x3F, 0xFF,
  0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0x83, 0xFF, 0xC7, 0xF0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xF7, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xC1, 0xFE,
  0x01, 0xFF, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x01, 0xFC,
  0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xF8,
  0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF8,
  0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x30, 0x00, 0xFF, 0x00, 0x3E, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xE7, 0xFF, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0x80,
  0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xE0,
  0xFF, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0,
  0x1F, 0xE1, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xC1, 0xFC, 0x03, 0xFC,
  0x1F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xF8, 0x3F, 0xC0, 0x3F, 0x83, 0xF8,
  0x07, 0xF8, 0x3F, 0x80, 0x7F, 0x87, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x7F,
  0x07, 0xF0, 0x0F, 0xF0, 0x7F, 0x00, 0xFF, 0x0F, 0xF0, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x83, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x10, 0x7F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0x80, 0x7F, 0xC0, 0x07, 0xE3,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x40, 0x7F, 0x00, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x3F, 0xC0,
  0x0F, 0xE0, 0xFF, 0x80, 0x3F, 0xC3, 0xFC, 0x00, 0x7F, 0x8F, 0xF0, 0x00,
  0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0xFE, 0x0F, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x1F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x87,
  0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x33, 0xFF,
  0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xF0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xFF, 0x8F, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xC1, 0xF8, 0x7E, 0x3F, 0x83, 0xF0, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0xFE, 0x0F, 0xC3, 0xE1, 0xF8, 0x3F, 0x0F, 0xC3, 0xF0, 0x7E,
  0x1F, 0x87, 0xE0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF8, 0x7E, 0x3F, 0x07, 0xF1,
  0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0xFC, 0x1F, 0x87, 0xE1, 0xF8, 0x3F, 0x0F,
  0xC7, 0xE0, 0x7E, 0x20, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xFE, 0x7F, 0xF0, 0x3F, 0x81,
  0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0x07, 0xF0, 0x0F, 0xF0,
  0x7F, 0x00, 0xFE, 0x0F, 0xF0, 0x0F, 0xE0, 0xFF, 0x00, 0xFE, 0x0F, 0xE0,
  0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F, 0xC1, 0xFE, 0x01, 0xFC,
  0x1F, 0xC0, 0x3F, 0xC1, 0xFC, 0x03, 0xFC, 0x3F, 0xC0, 0x3F, 0x83, 0xFC,
  0x03, 0xF8, 0x3F, 0x80, 0x7F, 0x83, 0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F,
  0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF0, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE1, 0xFF,
  0x8F, 0xFC, 0x7F, 0x80, 0xFF, 0x3F, 0xC0, 0x3F, 0xCF, 0xE0, 0x07, 0xF7,
  0xF8, 0x01, 0xFD, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x0F, 0xEF, 0xE0, 0x07, 0xFB, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0x3F,
  0xC0, 0x7F, 0xCF, 0xF8, 0x3F, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0xC0, 0xFF,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x1F,
  0xE0, 0x7F, 0x00, 0x7F, 0x83, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x1F, 0xF0,
  0x3F, 0x80, 0xFF, 0x80, 0xFE, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFE, 0xE8, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFE, 0x1F, 0xE1, 0xFF, 0x01, 0xFE,
  0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x3F, 0xC7, 0xF8,
  0x03, 0xFC, 0x7F, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF8, 0xFF, 0x00, 0x7F,
  0x8F, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xF0, 0xFE,
  0x00, 0x7F, 0x0F, 0xF0, 0x0F, 0xF0, 0xFF, 0x00, 0xFF, 0x0F, 0xF0, 0x0F,
  0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x18, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xC0, 0x08, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x04, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x40, 0x01, 0xFE, 0x0E, 0x00, 0x7F,
  0xC3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x01, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x01, 0xFC,
  0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x3F, 0xC0,
  0x3F, 0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0xC0, 0x3F, 0x87,
  0xF8, 0x07, 0xF0, 0xFE, 0x01, 0xFE, 0x1F, 0xC0, 0x3F, 0xC7, 0xF8, 0x07,
  0xF0, 0xFF, 0x00, 0xFE, 0x1F, 0xC0, 0x3F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F,
  0x00, 0xFE, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x80, 0xFF,
  0x0F, 0xF0, 0x1F, 0xE1, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xF9, 0xFC,
  0x07, 0xFE, 0x3F, 0x80, 0x1C, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x7F, 0x80, 0x1F, 0xEF, 0xF0, 0x07, 0xF8,
  0xFE, 0x00, 0xFF, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x07, 0xF8, 0x7F, 0x00,
  0xFE, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x07,
  0xF8, 0x3F, 0x80, 0xFF, 0x0F, 0xF0, 0x0F, 0xE1, 0xFC, 0x01, 0xFC, 0x7F,
  0x80, 0x3F, 0x9F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x1F, 0x8F, 0xC1, 0xF8, 0x3F, 0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x07, 0xE1,
  0xF8, 0x7E, 0x1F, 0xC3, 0xF0, 0xFC, 0x3F, 0x87, 0xC1, 0xF0, 0xFF, 0x1F,
  0x87, 0xE1, 0xFE, 0x3F, 0x0F, 0xC7, 0xFC, 0x7C, 0x1F, 0x8F, 0xF9, 0xF8,
  0x3F, 0x3F, 0xF3, 0xF0, 0x7E, 0x7F, 0xE7, 0xC0, 0xF9, 0xF7, 0xCF, 0x81,
  0xF3, 0xE7, 0xBF, 0x03, 0xEF, 0x8F, 0x7C, 0x07, 0xFF, 0x1E, 0xF8, 0x0F,
  0xFC, 0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x7F,
  0x81, 0xFE, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80,
  0x07, 0xF0, 0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x1F, 0xF0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC1,
  0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x01,
  0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0x03,
  0xFF, 0x80, 0x7E, 0x3F, 0xFF, 0x07, 0xE1, 0xFF, 0xFE, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFC, 0x0F, 0xFF,
  0x87, 0xE0, 0x3F, 0xF8, 0x0E, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x40, 0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 17, 38, 30, 8, -37 },
  { 82, 22, 17, 30, 9, -41 },
  { 129, 32, 37, 30, 0, -37 },
  { 277, 29, 48, 30, 1, -42 },
  { 451, 37, 39, 30, -2, -38 },
  { 632, 29, 39, 30, 0, -38 },
  { 774, 10, 18, 30, 15, -41 },
  { 797, 24, 53, 30, 6, -43 },
  { 956, 25, 53, 30, 0, -43 },
  { 1122, 25, 23, 30, 5, -37 },
  { 1194, 27, 27, 30, 2, -29 },
  { 1286, 14, 19, 30, 4, -10 },
  { 1320, 18, 7, 30, 6, -19 },
  { 1336, 10, 11, 30, 8, -10 },
  { 1350, 36, 52, 30, -3, -42 },
  { 1584, 28, 39, 30, 2, -38 },
  { 1721, 24, 37, 30, 2, -37 },
  { 1832, 30, 38, 30, 0, -38 },
  { 1975, 29, 39, 30, 0, -38 },
  { 2117, 31, 37, 30, 0, -37 },
  { 2261, 31, 38, 30, 0, -37 },
  { 2409, 29, 39, 30, 2, -38 },
  { 2551, 29, 37, 30, 5, -37 },
  { 2686, 29, 39, 30, 1, -38 },
  { 2828, 29, 38, 30, 1, -38 },
  { 2966, 15, 29, 30, 8, -28 },
  { 3021, 19, 37, 30, 4, -28 },
  { 3109, 28, 26, 30, 2, -29 },
  { 3200, 30, 18, 30, 0, -25 },
  { 3268, 28, 26, 30, 1, -29 },
  { 3359, 23, 39, 30, 7, -38 },
  { 3472, 31, 46, 30, 1, -38 },
  { 3651, 30, 37, 30, -3, -37 },
  { 3790, 30, 38, 30, 0, -38 },
  { 3933, 29, 39, 30, 3, -38 },
  { 4075, 30, 38, 30, 0, -38 },
  { 4218, 31, 37, 30, 1, -37 },
  { 4362, 32, 37, 30, 1, -37 },
  { 4510, 30, 39, 30, 2, -38 },
  { 4657, 34, 37, 30, -1, -37 },
  { 4815, 33, 37, 30, 0, -37 },
  { 4968, 31, 38, 30, 0, -37 },
  { 5116, 34, 37, 30, 0, -37 },
  { 5274, 25, 37, 30, 0, -37 },
  { 5390, 35, 37, 30, -2, -37 },
  { 5552, 34, 37, 30, -1, -37 },
  { 5710, 28, 39, 30, 2, -38 },
  { 5847, 31, 38, 30, 0, -38 },
  { 5995, 28, 48, 30, 2, -38 },
  { 6163, 30, 38, 30, 0, -38 },
  { 6306, 31, 39, 30, 0, -38 },
  { 6458, 28, 37, 30, 6, -37 },
  { 6588, 31, 38, 30, 2, -37 },
  { 6736, 29, 37, 30, 6, -37 },
  { 6871, 35, 37, 30, 0, -37 },
  { 7033, 37, 37, 30, -2, -37 },
  { 7205, 29, 37, 30, 6, -37 },
  { 7340, 33, 37, 30, -1, -37 },
  { 7493, 30, 52, 30, 3, -42 },
  { 7688, 12, 52, 30, 10, -42 },
  { 7766, 29, 52, 30, -1, -42 },
  { 7955, 28, 21, 30, 2, -37 },
  { 8029, 28, 6, 30, -4, 4 },
  { 8050, 13, 11, 30, 12, -42 },
  { 8068, 27, 30, 30, 2, -29 },
  { 8170, 28, 43, 30, 0, -42 },
  { 8321, 28, 30, 30, 2, -29 },
  { 8426, 31, 43, 30, 2, -42 },
  { 8593, 27, 30, 30, 2, -29 },
  { 8695, 37, 52, 30, -4, -42 },
  { 8936, 32, 39, 30, -2, -29 },
  { 9092, 28, 42, 30, 0, -42 },
  { 9239, 21, 43, 30, 4, -42 },
  { 9352, 31, 52, 30, -3, -42 },
  { 9554, 31, 42, 30, 1, -42 },
  { 9717, 19, 43, 30, 6, -42 },
  { 9820, 31, 29, 30, -1, -29 },
  { 9933, 28, 29, 30, 0, -29 },
  { 10035, 26, 30, 30, 2, -29 },
  { 10133, 30, 39, 30, -2, -29 },
  { 10280, 28, 39, 30, 2, -29 },
  { 10417, 28, 29, 30, 2, -29 },
  { 10519, 27, 30, 30, 1, -29 },
  { 10621, 26, 38, 30, 4, -37 },
  { 10745, 27, 29, 30, 2, -28 },
  { 10843, 27, 28, 30, 4, -28 },
  { 10938, 31, 28, 30, 2, -28 },
  { 11047, 33, 28, 30, -2, -28 },
  { 11163, 36, 38, 30, -5, -28 },
  { 11334, 29, 28, 30, 1, -28 },
  { 11436, 29, 52, 30, 4, -42 },
  { 11625, 20, 52, 30, 5, -42 },
  { 11755, 29, 52, 30, -2, -42 },
  { 11944, 29, 12, 30, 1, -22 },
};

const GFXfont UbuntuSansMono_BoldItalic54pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic54pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic54pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _UBUNTUSANSMONO_BOLDITALIC54PT7B_H_
