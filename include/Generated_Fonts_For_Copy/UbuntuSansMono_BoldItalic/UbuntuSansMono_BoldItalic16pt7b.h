#ifndef _UBUNTUSANSMONO_BOLDITALIC16PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0xCE, 0x63, 0x19, 0x80, 0x67, 0x38, 0xEF, 0x3D, 0xF6, 0x98,
  0x0D, 0x86, 0xC6, 0x4F, 0xF1, 0x31, 0xB3, 0xFF, 0xFE, 0x6C, 0x66, 0x36,
  0x00, 0x06, 0x07, 0x8F, 0xE6, 0x23, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0x23,
  0xBF, 0x8F, 0x83, 0x01, 0x80, 0x1C, 0x66, 0x98, 0x92, 0x16, 0x83, 0xA0,
  0x0C, 0x03, 0xE0, 0xD6, 0x32, 0xC4, 0xD3, 0x0E, 0x00, 0x1F, 0x0D, 0x8C,
  0xC6, 0xC3, 0xC1, 0xCD, 0xB5, 0x9E, 0xC6, 0x7F, 0x9E, 0xC0, 0x6D, 0xEC,
  0x04, 0x1C, 0x71, 0xC7, 0x0C, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x0C,
  0x1C, 0x10, 0x08, 0x38, 0x30, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x1C, 0x30,
  0xE3, 0x8E, 0x38, 0x20, 0x31, 0x67, 0x7F, 0xE7, 0x9D, 0x92, 0x00, 0x18,
  0x18, 0x18, 0xFF, 0xFE, 0x30, 0x30, 0x30, 0x37, 0x73, 0xE8, 0xFF, 0xC0,
  0x7F, 0x80, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0x3E, 0x7F, 0x63, 0xC3, 0xDB, 0xDB, 0xC6, 0xC6, 0xCE, 0xFC, 0x78, 0x07,
  0x1E, 0x3E, 0x26, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x7F, 0xFE, 0x1F, 0x1F,
  0xC8, 0x60, 0x70, 0x70, 0x70, 0x70, 0x60, 0x60, 0x7F, 0xBF, 0x80, 0x3F,
  0x0F, 0xC0, 0xE0, 0x61, 0xE0, 0xF0, 0x1C, 0x06, 0x07, 0x7F, 0x3F, 0x00,
  0x03, 0x83, 0xC3, 0xC3, 0x63, 0x33, 0x19, 0x9B, 0xFE, 0x06, 0x03, 0x03,
  0x80, 0x1F, 0x8F, 0xC6, 0x06, 0x03, 0xC1, 0xF0, 0x1C, 0x06, 0x07, 0x7F,
  0x3F, 0x00, 0x0F, 0x3F, 0x70, 0x60, 0xFC, 0xFE, 0xC6, 0xC6, 0xC6, 0xFE,
  0x7C, 0x7F, 0xBF, 0xC1, 0xC1, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30,
  0x38, 0x00, 0x1F, 0x1D, 0xCC, 0x66, 0x33, 0xF1, 0xF1, 0x9C, 0xC6, 0xE3,
  0x3F, 0x9F, 0x80, 0x1F, 0x1F, 0x9C, 0x6C, 0x36, 0x19, 0xFC, 0x7C, 0x06,
  0x0E, 0x3E, 0x3C, 0x00, 0x31, 0xCC, 0x00, 0x33, 0x9C, 0x18, 0x71, 0x80,
  0x00, 0xC7, 0x1C, 0x33, 0x88, 0x00, 0x01, 0x07, 0x1F, 0xF8, 0xE0, 0xF8,
  0x3E, 0x04, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x20, 0x30, 0x7C, 0x0F,
  0x07, 0x3E, 0xF8, 0xC0, 0x7C, 0xFC, 0x38, 0x63, 0x86, 0x18, 0x00, 0x61,
  0xC3, 0x80, 0x0F, 0x9C, 0xCC, 0x2C, 0xF6, 0xFA, 0xCF, 0x67, 0xB6, 0xDB,
  0x67, 0x90, 0x0C, 0x03, 0xE0, 0x03, 0x03, 0x83, 0x61, 0xB1, 0x98, 0xCC,
  0xC6, 0x7F, 0x71, 0xB0, 0xF8, 0x60, 0x1F, 0x1F, 0xCC, 0x66, 0x33, 0xF3,
  0xF1, 0x8C, 0xC6, 0x63, 0x7F, 0xBF, 0x00, 0x1F, 0x9F, 0x9C, 0x0C, 0x0E,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x1F, 0x8C, 0xE6,
  0x37, 0x1B, 0x1D, 0x8C, 0xC6, 0xE7, 0x7F, 0x3E, 0x00, 0x1F, 0xC7, 0xE3,
  0x80, 0xC0, 0x3F, 0x0F, 0xC7, 0x01, 0x80, 0x60, 0x1F, 0xCF, 0xE0, 0x1F,
  0xC7, 0xE3, 0x80, 0xC0, 0x3F, 0x0F, 0xC7, 0x01, 0x80, 0x60, 0x18, 0x0E,
  0x00, 0x1F, 0x9F, 0x9C, 0x0C, 0x0C, 0x06, 0x3B, 0x19, 0x8C, 0xC6, 0x7F,
  0x1F, 0x00, 0x39, 0xCC, 0x63, 0x18, 0xC6, 0x7F, 0x9F, 0xC6, 0x31, 0x8C,
  0xE3, 0x31, 0xCC, 0x60, 0x3F, 0xCF, 0xE0, 0xE0, 0x30, 0x0C, 0x03, 0x01,
  0xC0, 0x60, 0x18, 0x3F, 0x8F, 0xE0, 0x1F, 0x8F, 0xC0, 0xE0, 0x60, 0x30,
  0x18, 0x0C, 0x0C, 0x46, 0x7F, 0x1F, 0x00, 0x39, 0xCC, 0xE3, 0x30, 0xD8,
  0x7C, 0x1F, 0x06, 0xC1, 0xB8, 0xE6, 0x31, 0xCC, 0x30, 0x18, 0x70, 0xC1,
  0x83, 0x0E, 0x18, 0x30, 0x61, 0xFF, 0xF8, 0x1C, 0xE3, 0x98, 0x77, 0x0A,
  0xE3, 0x7C, 0x6D, 0x8D, 0xB3, 0x0C, 0x61, 0x8C, 0x33, 0x86, 0x00, 0x38,
  0xCE, 0x63, 0x98, 0xE6, 0x6D, 0x9B, 0x46, 0xF1, 0x9C, 0xC7, 0x31, 0xCC,
  0x60, 0x3E, 0x7F, 0x63, 0xE3, 0xC3, 0xC3, 0xC7, 0xC6, 0xCE, 0xFC, 0x78,
  0x1F, 0x1F, 0xCC, 0x66, 0x33, 0x1B, 0xF9, 0xF8, 0xC0, 0x60, 0x70, 0x30,
  0x00, 0x3E, 0x7F, 0x63, 0xE3, 0xC3, 0xC3, 0xC7, 0xC6, 0xCE, 0xFC, 0x78,
  0x20, 0x3C, 0x18, 0x3F, 0x1F, 0xCC, 0x66, 0x37, 0x33, 0xF9, 0xF0, 0xCC,
  0x66, 0x63, 0x30, 0xC0, 0x1F, 0x9F, 0xCC, 0x06, 0x03, 0xC0, 0xF0, 0x1C,
  0x06, 0x07, 0x7F, 0x3F, 0x00, 0xFF, 0xFF, 0x38, 0x30, 0x30, 0x30, 0x70,
  0x60, 0x60, 0x60, 0xE0, 0x73, 0xB1, 0x98, 0xCC, 0x6C, 0x76, 0x33, 0x19,
  0x8C, 0xCE, 0x7E, 0x3E, 0x00, 0xC3, 0xC7, 0xC6, 0xC6, 0xCC, 0xCC, 0xD8,
  0xD8, 0xF0, 0xF0, 0xE0, 0x30, 0xCC, 0x32, 0x0D, 0x86, 0x6D, 0x9B, 0x65,
  0x51, 0x5C, 0xE7, 0x39, 0xCC, 0x60, 0x18, 0x61, 0x98, 0x36, 0x07, 0xC0,
  0x70, 0x0C, 0x03, 0xC0, 0xD8, 0x3B, 0x06, 0x73, 0x86, 0x00, 0xC3, 0xC6,
  0xCE, 0x6C, 0x78, 0x78, 0x70, 0x60, 0x60, 0x60, 0xE0, 0x3F, 0xCF, 0xE0,
  0x30, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xCF, 0xE0, 0x0F,
  0x8F, 0x86, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C,
  0x06, 0x03, 0x03, 0xE1, 0xF0, 0xCC, 0xCC, 0xCE, 0x66, 0x66, 0x66, 0x66,
  0x67, 0x1F, 0x1F, 0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0C, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0xF8, 0xF8, 0x0C, 0x1E, 0x36, 0x76, 0xE7, 0xC3, 0xFF,
  0xFF, 0xCF, 0x20, 0x06, 0x1F, 0xCC, 0xCC, 0x66, 0x37, 0x39, 0x98, 0xFE,
  0x7B, 0x00, 0x18, 0x38, 0x30, 0x34, 0x3F, 0x33, 0x73, 0x63, 0x63, 0x67,
  0xFE, 0xFC, 0x0E, 0x3F, 0x72, 0xE0, 0xC0, 0xC0, 0xC0, 0xFC, 0x7E, 0x01,
  0xC0, 0x60, 0x18, 0x16, 0x1F, 0x8C, 0xC6, 0x31, 0x8C, 0xE7, 0x19, 0x87,
  0xF1, 0xEC, 0x0C, 0x3E, 0x67, 0xC7, 0xFE, 0xF8, 0xC0, 0xFC, 0x7C, 0x03,
  0xE0, 0xE8, 0x18, 0x03, 0x01, 0xFC, 0x5C, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x81, 0xF0, 0x38, 0x00, 0x03, 0x03, 0xF1, 0x98,
  0xC6, 0x31, 0x8C, 0x63, 0x38, 0xFC, 0x03, 0x01, 0xC7, 0xE3, 0xF0, 0x18,
  0x18, 0x38, 0x36, 0x3F, 0x33, 0x73, 0x63, 0x63, 0x67, 0xE6, 0xC6, 0x08,
  0x38, 0x70, 0x00, 0x0F, 0x26, 0x1C, 0x30, 0x60, 0xC1, 0xF3, 0xE0, 0x00,
  0x80, 0xC0, 0x60, 0x00, 0x00, 0xFC, 0x0C, 0x06, 0x03, 0x03, 0x81, 0x80,
  0xC0, 0x62, 0x71, 0xF1, 0xF0, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x39, 0xB8,
  0xF8, 0xF8, 0x6C, 0x37, 0x19, 0x9C, 0xE0, 0xFF, 0x8C, 0x63, 0x39, 0x8C,
  0x67, 0x3E, 0xF0, 0x11, 0x3F, 0xDB, 0x6D, 0xB6, 0x92, 0xDB, 0x0D, 0x86,
  0xC2, 0x00, 0x0E, 0x3F, 0x33, 0x73, 0x63, 0x63, 0x66, 0xE6, 0xC6, 0x0C,
  0x3F, 0x33, 0x63, 0x63, 0x63, 0xE7, 0x7E, 0x7C, 0x06, 0x0F, 0xC6, 0x67,
  0x33, 0x19, 0x8C, 0xCE, 0xFE, 0x7E, 0x30, 0x18, 0x1C, 0x00, 0x0C, 0x3F,
  0x77, 0xC6, 0xC6, 0xC6, 0xCE, 0xFC, 0xFC, 0x0C, 0x1C, 0x18, 0x0E, 0x7F,
  0x7A, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0x0E, 0x3F, 0x31, 0x30, 0x3C,
  0x0E, 0x06, 0x7E, 0xFC, 0x18, 0x18, 0x38, 0x7F, 0xB0, 0x30, 0x70, 0x60,
  0x62, 0x7C, 0x3C, 0x67, 0xE6, 0xC6, 0xC6, 0xCE, 0xCC, 0xFC, 0xF6, 0xE3,
  0xE6, 0xE6, 0x6C, 0x6C, 0x78, 0x78, 0x70, 0x60, 0xDB, 0x66, 0xD9, 0x74,
  0x57, 0x1D, 0xC6, 0x63, 0x18, 0x39, 0xC6, 0xE0, 0xF0, 0x38, 0x0E, 0x07,
  0xC3, 0x33, 0x8E, 0x38, 0xCE, 0x61, 0x98, 0x6E, 0x1B, 0x07, 0x81, 0xE0,
  0x30, 0x18, 0x3E, 0x0E, 0x00, 0x3F, 0x83, 0x83, 0x83, 0x83, 0x83, 0x81,
  0xF9, 0xFC, 0x03, 0x87, 0x83, 0x03, 0x01, 0x80, 0xC0, 0x61, 0xE0, 0xE0,
  0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0xF0, 0x70, 0x1C, 0x61, 0x86, 0x38,
  0xC3, 0x0C, 0x71, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0x0C, 0x07, 0x84, 0xC0,
  0x60, 0x30, 0x30, 0x18, 0x07, 0x07, 0x83, 0x03, 0x01, 0x80, 0xC0, 0xC1,
  0xE1, 0xE0, 0x79, 0xBF, 0xB1, 0x80,
};

const GFXglyph UbuntuSansMono_BoldItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 11, 9, 2, -11 },
  { 8, 6, 5, 9, 3, -12 },
  { 12, 9, 11, 9, 0, -11 },
  { 25, 9, 14, 9, 0, -12 },
  { 41, 11, 11, 9, -1, -11 },
  { 57, 9, 11, 9, 0, -11 },
  { 70, 3, 5, 9, 4, -12 },
  { 72, 7, 16, 9, 2, -13 },
  { 86, 7, 16, 9, 0, -13 },
  { 100, 7, 7, 9, 2, -11 },
  { 107, 8, 8, 9, 1, -9 },
  { 115, 4, 6, 9, 1, -3 },
  { 118, 5, 2, 9, 2, -6 },
  { 120, 3, 3, 9, 2, -3 },
  { 122, 11, 16, 9, -1, -13 },
  { 144, 8, 11, 9, 1, -11 },
  { 155, 8, 11, 9, 0, -11 },
  { 166, 9, 11, 9, 0, -11 },
  { 179, 9, 11, 9, 0, -11 },
  { 192, 9, 11, 9, 0, -11 },
  { 205, 9, 11, 9, 0, -11 },
  { 218, 8, 11, 9, 1, -11 },
  { 229, 9, 11, 9, 1, -11 },
  { 242, 9, 11, 9, 0, -11 },
  { 255, 9, 11, 9, 0, -11 },
  { 268, 5, 8, 9, 2, -8 },
  { 273, 6, 11, 9, 1, -8 },
  { 282, 8, 8, 9, 1, -9 },
  { 290, 9, 5, 9, 0, -7 },
  { 296, 8, 8, 9, 0, -9 },
  { 304, 7, 11, 9, 2, -11 },
  { 314, 9, 13, 9, 0, -11 },
  { 329, 9, 11, 9, -1, -11 },
  { 342, 9, 11, 9, 0, -11 },
  { 355, 9, 11, 9, 1, -11 },
  { 368, 9, 11, 9, 0, -11 },
  { 381, 10, 11, 9, 0, -11 },
  { 395, 10, 11, 9, 0, -11 },
  { 409, 9, 11, 9, 1, -11 },
  { 422, 10, 11, 9, 0, -11 },
  { 436, 10, 11, 9, 0, -11 },
  { 450, 9, 11, 9, 0, -11 },
  { 463, 10, 11, 9, 0, -11 },
  { 477, 7, 11, 9, 0, -11 },
  { 487, 11, 11, 9, -1, -11 },
  { 503, 10, 11, 9, 0, -11 },
  { 517, 8, 11, 9, 1, -11 },
  { 528, 9, 11, 9, 0, -11 },
  { 541, 8, 14, 9, 1, -11 },
  { 555, 9, 11, 9, 0, -11 },
  { 568, 9, 11, 9, 0, -11 },
  { 581, 8, 11, 9, 2, -11 },
  { 592, 9, 11, 9, 1, -11 },
  { 605, 8, 11, 9, 2, -11 },
  { 616, 10, 11, 9, 0, -11 },
  { 630, 11, 11, 9, -1, -11 },
  { 646, 8, 11, 9, 2, -11 },
  { 657, 10, 11, 9, 0, -11 },
  { 671, 9, 16, 9, 1, -13 },
  { 689, 4, 16, 9, 3, -13 },
  { 697, 8, 16, 9, 0, -13 },
  { 713, 8, 6, 9, 1, -11 },
  { 719, 8, 2, 9, -1, 1 },
  { 721, 4, 3, 9, 4, -12 },
  { 723, 9, 9, 9, 0, -9 },
  { 734, 8, 12, 9, 0, -12 },
  { 746, 8, 9, 9, 1, -9 },
  { 755, 10, 12, 9, 0, -12 },
  { 770, 8, 9, 9, 1, -9 },
  { 779, 11, 15, 9, -1, -12 },
  { 800, 10, 12, 9, -1, -9 },
  { 815, 8, 12, 9, 0, -12 },
  { 827, 7, 13, 9, 1, -13 },
  { 839, 9, 16, 9, -1, -13 },
  { 857, 9, 12, 9, 0, -12 },
  { 871, 5, 12, 9, 2, -12 },
  { 879, 9, 9, 9, 0, -9 },
  { 890, 8, 9, 9, 0, -9 },
  { 899, 8, 9, 9, 0, -9 },
  { 908, 9, 12, 9, -1, -9 },
  { 922, 8, 12, 9, 1, -9 },
  { 934, 8, 9, 9, 1, -9 },
  { 943, 8, 9, 9, 0, -9 },
  { 952, 8, 11, 9, 1, -11 },
  { 963, 8, 8, 9, 1, -8 },
  { 971, 8, 8, 9, 1, -8 },
  { 979, 10, 8, 9, 0, -8 },
  { 989, 10, 8, 9, -1, -8 },
  { 999, 10, 11, 9, -1, -8 },
  { 1013, 9, 8, 9, 0, -8 },
  { 1022, 9, 16, 9, 1, -13 },
  { 1040, 6, 16, 9, 2, -13 },
  { 1052, 9, 16, 9, -1, -13 },
  { 1070, 9, 3, 9, 0, -6 },
};

const GFXfont UbuntuSansMono_BoldItalic16pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic16pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic16pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _UBUNTUSANSMONO_BOLDITALIC16PT7B_H_
