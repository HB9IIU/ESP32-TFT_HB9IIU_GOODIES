#ifndef _UBUNTUSANSMONO_BOLDITALIC43PT7B_H_
#define _UBUNTUSANSMONO_BOLDITALIC43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuSansMono-BoldItalic.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuSansMono_BoldItalic43pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFE, 0x01, 0xF0, 0x01, 0x00, 0x00, 0x3F, 0x0F, 0xCF, 0xC7,
  0xF3, 0xF1, 0xF9, 0xFC, 0x7E, 0x7E, 0x1F, 0x9F, 0x87, 0xE7, 0xE1, 0xF1,
  0xF0, 0xFC, 0x7C, 0x3F, 0x1F, 0x0F, 0x87, 0x83, 0xE1, 0xE0, 0xF0, 0x70,
  0x3C, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF1, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0xF0, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x00, 0x3E, 0x1F,
  0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFE,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x0C,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x30, 0x03, 0xF8, 0x3E, 0x0F, 0xF0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x7C, 0x07, 0xF8, 0x03, 0xE0, 0x1F, 0xF0, 0x1F, 0x00,
  0xF3, 0xC0, 0x78, 0x03, 0xCF, 0x03, 0xC0, 0x1E, 0x3C, 0x1E, 0x00, 0x78,
  0xF0, 0xF0, 0x01, 0xE3, 0xC7, 0xC0, 0x07, 0x0E, 0x3E, 0x00, 0x1C, 0x78,
  0xF0, 0x00, 0x7B, 0xE7, 0x80, 0x01, 0xFF, 0x3C, 0x00, 0x07, 0xF9, 0xE0,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x3F, 0x00, 0x00, 0x79, 0xFE, 0x00, 0x03, 0xCF, 0xF8, 0x00,
  0x1E, 0x3D, 0xE0, 0x00, 0xF9, 0xE3, 0x80, 0x07, 0xC7, 0x8E, 0x00, 0x1E,
  0x3C, 0x38, 0x00, 0xF0, 0xF1, 0xE0, 0x07, 0x83, 0xC7, 0x80, 0x3C, 0x0F,
  0x1E, 0x01, 0xF0, 0x3C, 0xF0, 0x0F, 0x80, 0xFF, 0xC0, 0x3C, 0x01, 0xFE,
  0x03, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0x8F, 0x80,
  0x7E, 0x0F, 0x00, 0xF8, 0x1E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x07,
  0xC3, 0xE0, 0x0F, 0x8F, 0x80, 0x1F, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x87, 0x83, 0xFE, 0x0F, 0x0F, 0xFE, 0x3E, 0x3F, 0xFC,
  0x7C, 0xF8, 0xFD, 0xF3, 0xF0, 0xFF, 0xE7, 0xC1, 0xFF, 0x8F, 0x81, 0xFF,
  0x3F, 0x01, 0xFC, 0x7E, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x3F, 0xE1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF, 0xCF, 0x83, 0xFE, 0x1F, 0x80,
  0x3F, 0x7F, 0x7E, 0x7E, 0x7E, 0xFE, 0xFC, 0xFC, 0xFC, 0xF8, 0xF8, 0xF8,
  0xF0, 0xF0, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x00, 0x08, 0x00, 0x01, 0xC0,
  0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x38,
  0x00, 0x03, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x20, 0xF0, 0x47, 0x8F, 0x1E, 0x7E, 0xF7, 0xE7, 0xF7, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFE,
  0x00, 0xFD, 0xF0, 0x1F, 0x9F, 0x83, 0xF9, 0xFC, 0x1F, 0x0F, 0x80, 0x70,
  0xE0, 0x02, 0x04, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0xFE, 0x0F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFE, 0x1F,
  0xE0, 0xFE, 0x03, 0xE0, 0x7C, 0x0F, 0x8F, 0xF8, 0xFF, 0x0F, 0xC0, 0xF0,
  0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0,
  0x1E, 0x3F, 0x9F, 0xDF, 0xFF, 0xF7, 0xFB, 0xFC, 0xFC, 0x10, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFE, 0x0F, 0xFB, 0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F,
  0x3F, 0x00, 0x7C, 0xFC, 0x03, 0xF7, 0xE0, 0x0F, 0xDF, 0x84, 0x3F, 0x7C,
  0x78, 0xFD, 0xF1, 0xF3, 0xFF, 0xCF, 0xCF, 0xBF, 0x3E, 0x3E, 0xF8, 0xF8,
  0xFB, 0xE1, 0x87, 0xEF, 0x80, 0x1F, 0xBE, 0x00, 0x7C, 0xF8, 0x03, 0xF3,
  0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3E, 0x03, 0xF0, 0xFC, 0x1F, 0xC3, 0xFD,
  0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xFC,
  0x0F, 0xEF, 0xC0, 0x79, 0xF8, 0x06, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xE0,
  0x7F, 0x01, 0x80, 0x3F, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1F, 0x9F, 0xE0, 0x30, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x60, 0x07,
  0xF0, 0xF8, 0x3F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xE0,
  0xF8, 0x0F, 0xC1, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x01,
  0xF0, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x20, 0x07, 0xF0, 0x3F, 0x0F, 0xF8, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0xF0,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8,
  0xFC, 0x03, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0xFE,
  0x07, 0xE0, 0xFF, 0x3F, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F,
  0x8F, 0xE0, 0xFC, 0x0F, 0xC1, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0xC0,
  0x7E, 0x1F, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xC0, 0x3F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x3F, 0x1F, 0xE0, 0xFC, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x9F,
  0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xFE,
  0x1F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0x87, 0xE0,
  0x3F, 0x8F, 0x80, 0x3F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xE3, 0xF0, 0x1F, 0xC7, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFD, 0xF8, 0x03, 0xC7, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x7E, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7F, 0x07, 0xF0, 0xFF,
  0x8F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x01, 0x00, 0x00, 0x78, 0x01, 0xF8,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7C, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03,
  0xFC, 0x03, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x03, 0xFE, 0x07, 0xF8,
  0x0F, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x7F, 0xFE,
  0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x80, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x04, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0x7F, 0xCC, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x3F, 0x07,
  0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3E,
  0x07, 0xFF, 0x3E, 0x1F, 0xFF, 0x3C, 0x3F, 0xFF, 0x7C, 0x3F, 0xFE, 0x7C,
  0x7E, 0x3E, 0x78, 0xFC, 0x3E, 0x78, 0xF8, 0x7E, 0xF8, 0xF8, 0x7C, 0xF8,
  0xF0, 0x7C, 0xF9, 0xF0, 0x7C, 0xF1, 0xF0, 0x7C, 0xF1, 0xF0, 0xF8, 0xF1,
  0xF0, 0xF8, 0xF1, 0xF0, 0xF8, 0xF0, 0xFC, 0xF8, 0xF0, 0xFF, 0xF0, 0xF8,
  0xFF, 0xF0, 0xF8, 0x7F, 0xF0, 0xF8, 0x3F, 0xE0, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x3F,
  0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xE3, 0xF0, 0x0F, 0xC7,
  0xE0, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F, 0x80, 0xF8, 0x3F, 0x03, 0xF0, 0x7E,
  0x07, 0xC0, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x8F, 0xC0, 0x3F, 0x3F, 0x00, 0x7E, 0x7E,
  0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03, 0xF0, 0x7F, 0x03, 0xE0, 0x3F, 0x07,
  0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x7E, 0x0F,
  0xC0, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x81, 0xFC, 0x1F, 0x00, 0xFC, 0x3F,
  0x00, 0x7C, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x7E,
  0x01, 0xFC, 0x7E, 0x03, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x07,
  0xF0, 0x0C, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0xFE, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x7E, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x7E,
  0x03, 0xF8, 0x7E, 0x07, 0xF0, 0x7E, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xF0,
  0x0C, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x03,
  0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x07,
  0xE0, 0xFC, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x7F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x20, 0x0F, 0xC0, 0x38, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x1F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xE1, 0xFC, 0x01, 0xF8, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F,
  0x3F, 0x80, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x7E, 0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07,
  0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x7C,
  0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x7E,
  0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0xE0, 0xFE, 0x01, 0xFE, 0x1F, 0xE0, 0x1F,
  0xE1, 0xDE, 0x03, 0xFE, 0x3F, 0xE0, 0x3F, 0xE3, 0xBE, 0x03, 0xCE, 0x7B,
  0xC0, 0x3C, 0xE7, 0x3C, 0x07, 0xCE, 0xF7, 0xC0, 0x7C, 0xEE, 0x7C, 0x07,
  0xCF, 0xE7, 0xC0, 0xF8, 0xFC, 0x78, 0x0F, 0x8F, 0xCF, 0x80, 0xF8, 0xF8,
  0xF8, 0x0F, 0x8F, 0x8F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x3F,
  0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x7C,
  0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x81, 0xF0, 0x1F, 0xF0, 0x7E, 0x03, 0xFE,
  0x0F, 0x80, 0xFF, 0xC1, 0xF0, 0x1F, 0x7C, 0x3E, 0x03, 0xE7, 0x8F, 0xC0,
  0x7C, 0xF1, 0xF0, 0x1F, 0x9E, 0x3E, 0x03, 0xE3, 0xE7, 0xC0, 0x7C, 0x7D,
  0xF8, 0x0F, 0x87, 0xBE, 0x03, 0xF0, 0xF7, 0xC0, 0x7C, 0x1E, 0xF8, 0x0F,
  0x83, 0xFF, 0x01, 0xF0, 0x3F, 0xE0, 0x7E, 0x07, 0xF8, 0x0F, 0xC0, 0xFF,
  0x01, 0xF0, 0x1F, 0xE0, 0x3E, 0x03, 0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFE, 0x1F, 0xC3, 0xF8, 0x1F, 0x87, 0xE0, 0x3F,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF3,
  0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x3E, 0x7E,
  0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0,
  0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0x80, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x0F,
  0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F,
  0x83, 0xFC, 0x0F, 0xC0, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0,
  0x7E, 0x03, 0xF8, 0x3F, 0x0F, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFE, 0x1F, 0xC3, 0xF8,
  0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x7E, 0x3F, 0x00, 0xFC, 0xFC, 0x01,
  0xF9, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x1F,
  0xBF, 0x00, 0x3E, 0x7E, 0x00, 0xFC, 0xFC, 0x01, 0xF9, 0xF0, 0x03, 0xF3,
  0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x7F, 0x3F, 0x80, 0xFC, 0x3F,
  0x03, 0xF8, 0x7E, 0x0F, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x01, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xF0,
  0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x3F, 0x07, 0xE0,
  0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE, 0x0F, 0xC1,
  0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F,
  0xC0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x7E, 0x03,
  0xF0, 0x7E, 0x03, 0xF0, 0xFC, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x03, 0xFE, 0xFE, 0x07, 0xF0, 0x0C, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x20, 0x01,
  0xF8, 0x30, 0x03, 0xF0, 0x7F, 0x1F, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xC0, 0xFC,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0,
  0x7E, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x1F,
  0xC1, 0xF8, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0,
  0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x00, 0xFC, 0x7E, 0x01,
  0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xC0, 0x7E, 0x1F, 0x80,
  0xFC, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xF1, 0xF0, 0x07, 0xE7, 0xE0, 0x0F,
  0xCF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E,
  0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0, 0xFC,
  0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F,
  0x80, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF1, 0xF1, 0xF0, 0x1F,
  0x1F, 0x1F, 0x01, 0xF3, 0xF1, 0xF0, 0x1E, 0x3F, 0x1F, 0x03, 0xE7, 0xF1,
  0xE0, 0x3E, 0x7F, 0x3E, 0x03, 0xEF, 0x73, 0xE0, 0x3C, 0xF7, 0x3C, 0x03,
  0xDE, 0x73, 0xC0, 0x3D, 0xC7, 0xFC, 0x07, 0xFC, 0x7F, 0xC0, 0x7B, 0x87,
  0xF8, 0x07, 0xF8, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0x7F, 0x00,
  0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0,
  0x3E, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x3F, 0x0F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x3F, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x7F,
  0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x01,
  0xFB, 0xF0, 0x07, 0xF3, 0xE0, 0x0F, 0xC7, 0xC0, 0x3F, 0x0F, 0xC0, 0xFE,
  0x1F, 0x81, 0xF8, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0x7C, 0x3F, 0x00,
  0xF8, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF7, 0xE0, 0x03, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x7F, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF8, 0x7E, 0x1F, 0x87,
  0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFD, 0xF8, 0x07, 0xF3,
  0xF0, 0x3F, 0x8F, 0xC1, 0xFC, 0x3F, 0x07, 0xE0, 0x7E, 0x3F, 0x01, 0xF9,
  0xFC, 0x07, 0xEF, 0xE0, 0x0F, 0xDF, 0x00, 0x3E, 0x18, 0x00, 0xE0, 0x00,
  0x02, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF8, 0x30, 0x1E, 0x07, 0xC3, 0xFC, 0xFF, 0x8F, 0xF0,
  0xF8, 0x0E, 0x01, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x83, 0xF3, 0xF8, 0x1F, 0x8F,
  0xC0, 0x7E, 0x7F, 0x01, 0xF9, 0xF8, 0x07, 0xE7, 0xE0, 0x3F, 0x1F, 0x00,
  0xFC, 0xFC, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x7E, 0x3F, 0x01, 0xF8,
  0xFC, 0x07, 0xE1, 0xF8, 0x3F, 0x87, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0x3F, 0x00, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0xFC, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC3, 0xF8, 0x7F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF1,
  0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x03, 0xF3, 0xF0,
  0x0F, 0xCF, 0xC0, 0x3F, 0x3F, 0x01, 0xF8, 0xFC, 0x07, 0xE7, 0xE0, 0x3F,
  0x9F, 0x81, 0xFC, 0x7F, 0x7F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x7F, 0xC0,
  0x43, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x3F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0xC0,
  0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x83, 0xF0,
  0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC1, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xF3, 0xF0, 0x01, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x9F, 0xC0, 0xFC, 0xFC, 0x03, 0xEF, 0xC0, 0x3F, 0x7E, 0x01,
  0xFF, 0xE0, 0x1F, 0xFF, 0x0F, 0xFD, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0x83, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x02,
  0x1F, 0xF0, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F,
  0xFE, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x11, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0xF3, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x0E,
  0x03, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC3, 0xF0, 0x7F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC3,
  0xF0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x87, 0xE0,
  0x7E, 0x3F, 0x01, 0xF8, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC,
  0x7E, 0x03, 0xF1, 0xF8, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0xFC,
  0x07, 0xE0, 0x00, 0x70, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xFC, 0x01, 0xF8, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x00, 0x20,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x20, 0x1F, 0x80,
  0x38, 0x7F, 0x80, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7E,
  0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0x8F, 0xE0, 0x0F, 0xCF, 0xE0, 0x07,
  0xCF, 0xE0, 0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0x3F, 0x00,
  0x1F, 0x9F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF8, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0xFC, 0x03,
  0xF0, 0x00, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x13, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF,
  0x8F, 0xFF, 0x0F, 0xFC, 0x01, 0x00, 0x00, 0xFC, 0x3C, 0x03, 0xFF, 0x7F,
  0x81, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFD, 0xF8, 0x7C, 0x7C,
  0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F, 0x1E, 0x0F, 0x8F, 0x1F, 0x0F, 0x8F,
  0x8F, 0x87, 0xC7, 0xC7, 0xC3, 0xE3, 0xE3, 0xC1, 0xF1, 0xE3, 0xE1, 0xF1,
  0xF1, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x1E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0x83,
  0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0x07, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x3F, 0x03, 0xF1, 0xF8, 0x0F,
  0xC7, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x07, 0xE3, 0xF0, 0x1F, 0x8F,
  0xC0, 0xFC, 0x3F, 0x03, 0xF0, 0xFC, 0x0F, 0xC7, 0xE0, 0x3F, 0x1F, 0x81,
  0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x7F, 0x0F, 0xE3, 0xF8, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x00, 0xFD, 0xF8,
  0x03, 0xE7, 0xE0, 0x0F, 0x9F, 0x80, 0x7E, 0xFC, 0x01, 0xFB, 0xF0, 0x07,
  0xEF, 0xC0, 0x3F, 0x3F, 0x00, 0xFC, 0xFE, 0x07, 0xF1, 0xF8, 0x3F, 0x87,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFF,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xC0, 0xFC, 0x07, 0xE0, 0x7C, 0x03, 0xF0, 0x7E, 0x01, 0xF8,
  0x3F, 0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC1, 0xFE, 0x0F, 0xC1, 0xFE,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFF, 0x07, 0xE3, 0xF8, 0x1F,
  0x9F, 0xC0, 0xFC, 0x7E, 0x03, 0xF3, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0x3F,
  0x00, 0xF8, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x3F, 0x01,
  0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x3F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFF,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x3F, 0x00, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE1, 0x80, 0x3F, 0x87, 0xE7, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFD, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x10, 0x1F,
  0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x10, 0x00, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7, 0xE0, 0x7E, 0x7E,
  0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x81, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0, 0x7E,
  0x7E, 0x03, 0xF3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7E, 0x07, 0xE3, 0xF0, 0x3F, 0x1F, 0x81, 0xF8, 0xFC, 0x0F, 0xC7,
  0xE0, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFB,
  0xF0, 0xFF, 0x9F, 0x80, 0x40, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xEF,
  0xE0, 0x1F, 0xBF, 0x80, 0xFE, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x7E, 0x1F, 0x81, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8,
  0x1F, 0x87, 0xE0, 0x7E, 0x3F, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xE0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xC0,
  0x01, 0xF3, 0xE1, 0xF0, 0xF1, 0xF0, 0xF8, 0xF8, 0xF8, 0xFC, 0x7C, 0x7C,
  0x7E, 0x3C, 0x3E, 0x3F, 0x3E, 0x1E, 0x3F, 0x9F, 0x0F, 0x3F, 0xCF, 0x07,
  0x9F, 0xE7, 0x83, 0xDE, 0xF7, 0xC1, 0xEF, 0x7B, 0xC1, 0xFF, 0x3D, 0xE0,
  0xFF, 0x8F, 0xE0, 0x7F, 0x87, 0xF0, 0x3F, 0xC3, 0xF8, 0x1F, 0xC1, 0xF8,
  0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0xE0,
  0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF8, 0xFE, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x01, 0x07, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xC0, 0x30, 0x3F, 0xE0, 0x7C, 0xFF, 0xF1, 0xF3,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x3E, 0x1F, 0xFC, 0x78,
  0x0F, 0xF0, 0x10, 0x07, 0x00,
};

const GFXglyph UbuntuSansMono_BoldItalic43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 14, 31, 24, 6, -30 },
  { 56, 18, 14, 24, 7, -33 },
  { 88, 26, 30, 24, 0, -30 },
  { 186, 24, 38, 24, 0, -33 },
  { 300, 30, 31, 24, -2, -30 },
  { 417, 23, 30, 24, 0, -30 },
  { 504, 8, 15, 24, 12, -33 },
  { 519, 19, 42, 24, 5, -34 },
  { 619, 20, 42, 24, 0, -34 },
  { 724, 20, 19, 24, 4, -30 },
  { 772, 22, 21, 24, 1, -23 },
  { 830, 12, 15, 24, 3, -8 },
  { 853, 14, 6, 24, 5, -15 },
  { 864, 9, 9, 24, 6, -8 },
  { 875, 28, 42, 24, -2, -34 },
  { 1022, 22, 31, 24, 2, -30 },
  { 1108, 20, 30, 24, 1, -30 },
  { 1183, 24, 30, 24, 0, -30 },
  { 1273, 23, 31, 24, 0, -30 },
  { 1363, 24, 30, 24, 0, -30 },
  { 1453, 25, 31, 24, 0, -30 },
  { 1550, 23, 31, 24, 2, -30 },
  { 1640, 23, 30, 24, 4, -30 },
  { 1727, 23, 31, 24, 1, -30 },
  { 1817, 23, 30, 24, 1, -30 },
  { 1904, 12, 24, 24, 6, -23 },
  { 1940, 15, 30, 24, 3, -23 },
  { 1997, 22, 21, 24, 2, -23 },
  { 2055, 24, 15, 24, 0, -20 },
  { 2100, 22, 21, 24, 1, -23 },
  { 2158, 18, 31, 24, 6, -30 },
  { 2228, 24, 37, 24, 1, -30 },
  { 2339, 23, 30, 24, -2, -30 },
  { 2426, 24, 30, 24, 0, -30 },
  { 2516, 24, 31, 24, 2, -30 },
  { 2609, 24, 30, 24, 0, -30 },
  { 2699, 25, 30, 24, 1, -30 },
  { 2793, 25, 30, 24, 1, -30 },
  { 2887, 24, 31, 24, 2, -30 },
  { 2980, 27, 30, 24, -1, -30 },
  { 3082, 26, 30, 24, 0, -30 },
  { 3180, 25, 31, 24, 0, -30 },
  { 3277, 27, 30, 24, 0, -30 },
  { 3379, 20, 30, 24, 0, -30 },
  { 3454, 28, 30, 24, -2, -30 },
  { 3559, 27, 30, 24, -1, -30 },
  { 3661, 23, 31, 24, 1, -30 },
  { 3751, 25, 30, 24, 0, -30 },
  { 3845, 23, 38, 24, 1, -30 },
  { 3955, 24, 30, 24, 0, -30 },
  { 4045, 24, 31, 24, 0, -30 },
  { 4138, 23, 30, 24, 4, -30 },
  { 4225, 25, 31, 24, 1, -30 },
  { 4322, 23, 30, 24, 5, -30 },
  { 4409, 28, 30, 24, 0, -30 },
  { 4514, 30, 30, 24, -2, -30 },
  { 4627, 23, 30, 24, 5, -30 },
  { 4714, 26, 30, 24, 0, -30 },
  { 4812, 24, 42, 24, 2, -34 },
  { 4938, 10, 42, 24, 8, -34 },
  { 4991, 23, 42, 24, -1, -34 },
  { 5112, 22, 18, 24, 2, -30 },
  { 5162, 22, 5, 24, -3, 3 },
  { 5176, 10, 9, 24, 10, -33 },
  { 5188, 22, 24, 24, 1, -23 },
  { 5254, 22, 34, 24, 0, -33 },
  { 5348, 22, 24, 24, 2, -23 },
  { 5414, 25, 34, 24, 1, -33 },
  { 5521, 21, 24, 24, 2, -23 },
  { 5584, 30, 41, 24, -3, -33 },
  { 5738, 26, 31, 24, -2, -23 },
  { 5839, 22, 33, 24, 0, -33 },
  { 5930, 16, 35, 24, 4, -34 },
  { 6000, 24, 42, 24, -2, -34 },
  { 6126, 25, 33, 24, 1, -33 },
  { 6230, 15, 34, 24, 5, -33 },
  { 6294, 25, 23, 24, -1, -23 },
  { 6366, 22, 23, 24, 0, -23 },
  { 6430, 22, 24, 24, 1, -23 },
  { 6496, 25, 31, 24, -2, -23 },
  { 6593, 22, 31, 24, 2, -23 },
  { 6679, 23, 23, 24, 1, -23 },
  { 6746, 22, 24, 24, 1, -23 },
  { 6812, 21, 30, 24, 3, -29 },
  { 6891, 21, 24, 24, 2, -23 },
  { 6954, 22, 23, 24, 3, -23 },
  { 7018, 25, 23, 24, 1, -23 },
  { 7090, 26, 23, 24, -1, -23 },
  { 7165, 29, 31, 24, -4, -23 },
  { 7278, 23, 23, 24, 1, -23 },
  { 7345, 23, 42, 24, 3, -34 },
  { 7466, 16, 42, 24, 4, -34 },
  { 7550, 23, 42, 24, -2, -34 },
  { 7671, 23, 9, 24, 1, -17 },
};

const GFXfont UbuntuSansMono_BoldItalic43pt7b PROGMEM = {
  (uint8_t  *)UbuntuSansMono_BoldItalic43pt7bBitmaps,
  (GFXglyph *)UbuntuSansMono_BoldItalic43pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _UBUNTUSANSMONO_BOLDITALIC43PT7B_H_
