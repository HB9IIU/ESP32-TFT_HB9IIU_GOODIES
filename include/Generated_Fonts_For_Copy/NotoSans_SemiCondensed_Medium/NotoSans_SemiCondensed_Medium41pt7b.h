#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM41PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBD, 0xEF, 0x79, 0xCE, 0x73,
  0x9C, 0xE0, 0x00, 0x00, 0xF7, 0xFF, 0xFF, 0x00, 0xF8, 0xFB, 0xC7, 0xDE,
  0x3C, 0xF1, 0xE7, 0x87, 0x3C, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83,
  0x80, 0x00, 0xE0, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1C, 0x00, 0x70, 0x70,
  0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0xF0, 0x7F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0x03, 0x83,
  0x80, 0x0E, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x03,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x0F, 0x0E, 0x00, 0x38,
  0x38, 0x00, 0xE0, 0xE0, 0x03, 0x83, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x78,
  0x01, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF,
  0xF1, 0xE3, 0x0C, 0xF0, 0xC0, 0x3C, 0x30, 0x0F, 0x0C, 0x03, 0xC3, 0x00,
  0xF8, 0xC0, 0x1F, 0xB0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x03, 0x3E, 0x00, 0xC7, 0x80, 0x31, 0xF0, 0x0C,
  0x7C, 0x03, 0x1E, 0xC0, 0xCF, 0xBF, 0xBF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF0,
  0x1F, 0xF0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xF0, 0x1F, 0xF0, 0x07, 0x00, 0xF7,
  0x80, 0x78, 0x0F, 0x1E, 0x03, 0x80, 0x70, 0x70, 0x3C, 0x03, 0x83, 0x81,
  0xC0, 0x1C, 0x1C, 0x1E, 0x00, 0xE0, 0xE0, 0xE0, 0x07, 0x07, 0x0F, 0x00,
  0x38, 0x38, 0x70, 0x01, 0xC1, 0xC7, 0x80, 0x0E, 0x0E, 0x38, 0x78, 0x70,
  0x73, 0xCF, 0xF3, 0xC7, 0x9C, 0x7F, 0x8F, 0x79, 0xE7, 0x9E, 0x7F, 0xCE,
  0x38, 0x71, 0xFC, 0xF3, 0xC3, 0xC3, 0x87, 0x1E, 0x1E, 0x00, 0x38, 0xF0,
  0xF0, 0x03, 0xC7, 0x87, 0x80, 0x1C, 0x3C, 0x3C, 0x01, 0xE1, 0xE1, 0xE0,
  0x0E, 0x0F, 0x0F, 0x00, 0xF0, 0x78, 0x78, 0x07, 0x01, 0xC3, 0x80, 0x78,
  0x0E, 0x1C, 0x03, 0x80, 0x7F, 0xE0, 0x3C, 0x01, 0xFE, 0x03, 0xC0, 0x07,
  0xE0, 0x01, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x80, 0x03,
  0xEF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xE0, 0x3C, 0x3F, 0xF8, 0x1E, 0x3E, 0x7C, 0x1F, 0x3E, 0x1F, 0x0F,
  0x1F, 0x07, 0xC7, 0x8F, 0x01, 0xF7, 0xC7, 0x80, 0x7F, 0xC3, 0xC0, 0x1F,
  0xE1, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x03, 0xFC, 0x1F, 0x87,
  0xFE, 0x0F, 0xFF, 0xEF, 0x83, 0xFF, 0xE3, 0xE0, 0x7F, 0xC0, 0xFC, 0xFB,
  0xDE, 0xF7, 0xBD, 0xCE, 0x73, 0x80, 0x07, 0x87, 0x83, 0xC3, 0xC1, 0xE1,
  0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF8, 0x3C, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF8, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x1C, 0x38, 0x67, 0xEF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x3F, 0x00, 0x1E, 0xE0, 0x0F, 0x3C, 0x03,
  0xCF, 0x81, 0xE1, 0xF0, 0x38, 0x78, 0x04, 0x08, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x7D, 0xF7, 0xDE, 0x79, 0xEF, 0x3C, 0xE3, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xFF,
  0xF8, 0x3E, 0x1F, 0x1F, 0x03, 0xC7, 0x80, 0xF9, 0xE0, 0x1E, 0xF8, 0x07,
  0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x80, 0x79, 0xE0, 0x3E, 0x78, 0x0F,
  0x1F, 0x07, 0xC3, 0xE3, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x01, 0xFE, 0x00,
  0x01, 0xE0, 0x7C, 0x1F, 0x8F, 0xF3, 0xFE, 0xFB, 0xFE, 0x7B, 0x8F, 0x21,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x01, 0xC0, 0x07, 0xFE, 0x07, 0xFF, 0xC3, 0xFF,
  0xF8, 0xF8, 0x3F, 0x18, 0x03, 0xC2, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x03, 0xE0, 0x1F, 0xFC, 0x1F, 0xFF, 0x9F, 0xFF, 0xE7, 0x81, 0xF3, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x7F, 0xE0, 0x3F, 0x80, 0x1F, 0xF8, 0x0F, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x0F, 0xFC, 0x0F, 0xDF, 0xFF, 0xCF,
  0xFF, 0xC3, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x1E, 0xF0,
  0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x8F, 0x00, 0x70, 0xF0, 0x0F, 0x0F,
  0x01, 0xE0, 0xF0, 0x1C, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80,
  0xF0, 0xF0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xCF,
  0xFF, 0xE7, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xF0, 0xE3,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0x7C, 0x3F,
  0xBF, 0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xC0,
  0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0xF3, 0xFC,
  0x3D, 0xFF, 0x8F, 0xFF, 0xF3, 0xF8, 0x3E, 0xF8, 0x07, 0xBE, 0x01, 0xEF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7D, 0xE0,
  0x1E, 0x78, 0x07, 0x9F, 0x03, 0xE3, 0xF3, 0xF0, 0x7F, 0xFC, 0x0F, 0xFE,
  0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x1F, 0x1E,
  0x03, 0xE7, 0x80, 0x7B, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xE7, 0xC0,
  0xF0, 0xF8, 0x7C, 0x3F, 0x7E, 0x07, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x1F, 0xFE, 0x1F, 0x8F, 0xC7, 0x81, 0xFB, 0xE0, 0x1E, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xE7, 0xC1,
  0xF9, 0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xC0, 0x03, 0xFE,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x3F, 0x3E, 0x03, 0xCF, 0x00, 0xFB,
  0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFD, 0xF0, 0xFE, 0x7F, 0xFF, 0x8F, 0xFD,
  0xE0, 0xFE, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x84, 0x0F, 0xC1, 0xFF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xF0, 0x00, 0x27, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3D, 0xFF, 0xFF, 0xC0, 0x08, 0x7C, 0xF9, 0xF3, 0xE7,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF9,
  0xF3, 0xC7, 0x8F, 0x3C, 0x78, 0xF1, 0xC7, 0x80, 0x00, 0x00, 0x40, 0x00,
  0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xF0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x3E, 0x00, 0x0E, 0x00,
  0x02, 0x00, 0x00, 0x03, 0x80, 0x3F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x78,
  0x3E, 0x20, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xBF, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0xF0, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x20, 0x0E, 0x38, 0x0F, 0xF8, 0x73,
  0xC1, 0xFF, 0xC3, 0xDC, 0x1F, 0x0E, 0x0E, 0xE0, 0xF0, 0x70, 0x77, 0x0F,
  0x03, 0x83, 0xF8, 0x78, 0x1C, 0x1F, 0xC3, 0x80, 0xE0, 0xFC, 0x1C, 0x07,
  0x07, 0xE0, 0xE0, 0x78, 0x3F, 0x07, 0x03, 0xC1, 0xF8, 0x38, 0x1E, 0x0F,
  0xC1, 0xC0, 0xF0, 0xFF, 0x0F, 0x0F, 0x87, 0x78, 0x3E, 0xEE, 0xF9, 0xC1,
  0xFF, 0x7F, 0x8F, 0x07, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x40,
  0x03, 0xFE, 0x7E, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01,
  0xE7, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x07,
  0xC3, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x81, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7C, 0x0F, 0xEF,
  0x80, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7B, 0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC7, 0xFF, 0xFE, 0xF8, 0x07, 0xDF, 0x00, 0x7F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x07, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xC0, 0xE1,
  0xF8, 0x02, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x01, 0x1F, 0xF3, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x1F, 0xFC, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3E, 0x1F,
  0xF0, 0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x3E,
  0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB,
  0xE0, 0x03, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0xF8, 0x0F, 0xE3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xE0, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFF, 0x0F, 0xE0, 0x78, 0x7E, 0x00, 0x23, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7F, 0xFE, 0x01, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78,
  0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x3F, 0x00,
  0x3C, 0x7E, 0x00, 0xF0, 0xFF, 0x0F, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xC0, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFD, 0xFF, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xDF, 0xFB, 0xFE, 0x7F, 0x8F, 0xE0, 0xF0,
  0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F,
  0x03, 0xE0, 0xF0, 0x7C, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x1F, 0x00,
  0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFD, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF8, 0x0F, 0x07,
  0xC0, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0,
  0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x03, 0xF0,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xDE, 0x00, 0x3F, 0xFB, 0xC0, 0x07, 0xFF, 0x78, 0x00,
  0xEF, 0xE7, 0x80, 0x3D, 0xFC, 0xF0, 0x07, 0xBF, 0x9E, 0x00, 0xE7, 0xF1,
  0xE0, 0x3C, 0xFF, 0x3C, 0x07, 0x9F, 0xE7, 0x80, 0xE3, 0xFC, 0x70, 0x3C,
  0x7F, 0x8F, 0x07, 0x8F, 0xF1, 0xE0, 0xE1, 0xFE, 0x1C, 0x3C, 0x3F, 0xC3,
  0xC7, 0x87, 0xF8, 0x78, 0xE0, 0xFF, 0x07, 0x3C, 0x1F, 0xE0, 0xF7, 0x83,
  0xFC, 0x1E, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xFE, 0x07,
  0xE0, 0x3F, 0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xE0, 0x1E,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x3F, 0xBC, 0x01, 0xFD, 0xF0, 0x0F, 0xE7, 0xC0, 0x7F,
  0x3E, 0x03, 0xF8, 0xF8, 0x1F, 0xC3, 0xC0, 0xFE, 0x1F, 0x07, 0xF8, 0x78,
  0x3F, 0xC3, 0xE1, 0xFE, 0x0F, 0x0F, 0xF0, 0x7C, 0x7F, 0x81, 0xF3, 0xFC,
  0x0F, 0x8F, 0xE0, 0x3E, 0x7F, 0x00, 0xF3, 0xF8, 0x07, 0xDF, 0xC0, 0x1E,
  0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC1, 0xF8, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F,
  0x9E, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x00,
  0x7B, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xBE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x7E, 0x07, 0xF9, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xE3, 0xFE,
  0xF8, 0x0F, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x0F, 0xBE, 0x07, 0xEF, 0xFF,
  0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F,
  0xC1, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00,
  0x1F, 0x3E, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x7E, 0x07, 0xF9, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x0F, 0x87, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x07, 0xCF, 0x80,
  0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8,
  0x0F, 0x8F, 0x87, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0x87, 0xC0, 0xF8, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x1E, 0x0F, 0x81, 0xF0,
  0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x03,
  0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x07, 0xFF, 0x0F, 0xFF,
  0xC7, 0xFF, 0xE7, 0xE0, 0xF7, 0xC0, 0x13, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x60,
  0x0F, 0xBF, 0x1F, 0xDF, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7D, 0xE0, 0x03, 0xEF,
  0x80, 0x1E, 0x7E, 0x01, 0xF1, 0xFE, 0x7F, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x79, 0xE0, 0x00,
  0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3E,
  0x1F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x7C, 0x07, 0xC0,
  0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x7C, 0x01, 0xE0, 0xF0, 0x03,
  0xC1, 0xE0, 0x07, 0x87, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x3E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0x00,
  0x7D, 0xE0, 0x07, 0xC0, 0x0F, 0x3C, 0x00, 0xFC, 0x01, 0xE7, 0xC0, 0x3F,
  0x80, 0x3C, 0x78, 0x07, 0xF0, 0x0F, 0x8F, 0x00, 0xEE, 0x01, 0xF1, 0xE0,
  0x1D, 0xE0, 0x3C, 0x3E, 0x07, 0xBC, 0x07, 0x83, 0xC0, 0xF7, 0x80, 0xF0,
  0x78, 0x1E, 0x70, 0x3E, 0x0F, 0x03, 0x8F, 0x07, 0x81, 0xE0, 0xF1, 0xE0,
  0xF0, 0x1E, 0x1E, 0x3C, 0x1E, 0x03, 0xC3, 0xC3, 0x87, 0xC0, 0x78, 0x70,
  0x78, 0xF0, 0x0F, 0x1E, 0x0F, 0x1E, 0x01, 0xF3, 0xC1, 0xE3, 0xC0, 0x1E,
  0x78, 0x1C, 0xF8, 0x03, 0xCE, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x7B, 0xC0,
  0x0F, 0x78, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0xEF, 0x00, 0x1F, 0xC0, 0x1D,
  0xC0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xE0, 0x1F, 0x07, 0x80, 0x78, 0x1F, 0x03,
  0xE0, 0x3E, 0x0F, 0x00, 0x78, 0x7C, 0x01, 0xF1, 0xE0, 0x03, 0xCF, 0x80,
  0x0F, 0xBC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x3C, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0x87, 0x80, 0x3E, 0x1F, 0x00,
  0xF0, 0x3C, 0x07, 0xC0, 0xF8, 0x1E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xC0, 0x07,
  0xDF, 0x00, 0x3C, 0x78, 0x03, 0xE3, 0xE0, 0x1E, 0x0F, 0x01, 0xF0, 0x7C,
  0x0F, 0x01, 0xE0, 0xF8, 0x0F, 0x87, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0,
  0x07, 0xBE, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3B, 0xC0, 0x07, 0x9C, 0x00, 0x71, 0xE0, 0x0F, 0x0E, 0x00, 0xE0, 0xF0,
  0x1E, 0x07, 0x01, 0xC0, 0x78, 0x3C, 0x03, 0x83, 0xC0, 0x3C, 0x78, 0x01,
  0xC7, 0x80, 0x1E, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0xC0, 0x0F, 0xFC, 0x3F, 0xFE,
  0x3F, 0xFE, 0x18, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F, 0x8F, 0xF8, 0x0F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFF, 0xF7,
  0x7F, 0xE7, 0x3F, 0xC7, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x20,
  0x3C, 0xFF, 0x0F, 0x7F, 0xE3, 0xFF, 0xFC, 0xFE, 0x1F, 0xBF, 0x03, 0xEF,
  0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFE, 0x01, 0xFF, 0xC0, 0xFB, 0xF8, 0x7E, 0xFF, 0xFF, 0x3D, 0xFF, 0x8E,
  0x1F, 0xC0, 0x00, 0x40, 0x0F, 0xFC, 0x7F, 0xF9, 0xFF, 0xE3, 0xE0, 0xCF,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01,
  0xF0, 0x09, 0xF8, 0x73, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x01, 0x83, 0xC3, 0xFC, 0xF1, 0xFF, 0xBC, 0xFF,
  0xFF, 0x7E, 0x1F, 0xDF, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0x7D, 0xF8,
  0x7F, 0x3F, 0xFF, 0xC7, 0xFE, 0xF0, 0xFF, 0x1C, 0x00, 0xC0, 0x01, 0xFE,
  0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x3E, 0x1F, 0x1F, 0x03, 0xE7, 0x80, 0x7B,
  0xE0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x08, 0xFC, 0x0C, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xE0,
  0x03, 0xFC, 0x1F, 0xE0, 0xFF, 0x87, 0xC2, 0x1F, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x01, 0xFF, 0xCF, 0xFF, 0x3F, 0xFC, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x03, 0xFC, 0x71,
  0xFF, 0xBC, 0xFF, 0xFF, 0x7E, 0x1F, 0xDF, 0x01, 0xF7, 0x80, 0x7F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xDE, 0x01, 0xF7,
  0xC0, 0x7D, 0xF8, 0x7F, 0x3F, 0xFF, 0xC7, 0xFE, 0xF0, 0xFF, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x60, 0x0F,
  0x9F, 0xFF, 0xE7, 0xFF, 0xF1, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x20, 0x78, 0xFE, 0x3D, 0xFF, 0xDF, 0xFF, 0xEF,
  0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1E, 0x27, 0xBF, 0xFF, 0x10, 0x00, 0x07, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0,
  0x01, 0x01, 0xE0, 0x7C, 0x1F, 0x07, 0x80, 0x40, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0xBF, 0xEF,
  0xF3, 0xF8, 0x7C, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x03, 0xEF, 0x01, 0xF3, 0xC0, 0xF8, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F,
  0x0F, 0x83, 0xC7, 0xC0, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x7C, 0x03, 0xFF,
  0x00, 0xFF, 0xE0, 0x3F, 0x7C, 0x0F, 0x8F, 0x03, 0xC3, 0xE0, 0xF0, 0x7C,
  0x3C, 0x1F, 0x0F, 0x03, 0xE3, 0xC0, 0x78, 0xF0, 0x1F, 0x3C, 0x03, 0xEF,
  0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x20, 0x02, 0x07, 0x9F, 0xE0,
  0xFE, 0x3D, 0xFF, 0x9F, 0xFD, 0xFF, 0xFE, 0xFF, 0xEF, 0xE1, 0xFE, 0x1F,
  0xFE, 0x07, 0xE0, 0x7F, 0xE0, 0x3E, 0x01, 0xFF, 0x01, 0xF0, 0x0F, 0xF8,
  0x07, 0x80, 0x7F, 0x80, 0x3C, 0x03, 0xFC, 0x01, 0xE0, 0x1F, 0xE0, 0x0F,
  0x00, 0xFF, 0x00, 0x78, 0x07, 0xF8, 0x03, 0xC0, 0x3F, 0xC0, 0x1E, 0x01,
  0xFE, 0x00, 0xF0, 0x0F, 0xF0, 0x07, 0x80, 0x7F, 0x80, 0x3C, 0x03, 0xFC,
  0x01, 0xE0, 0x1F, 0xE0, 0x0F, 0x00, 0xFF, 0x00, 0x78, 0x07, 0xF8, 0x03,
  0xC0, 0x3F, 0xC0, 0x1E, 0x01, 0xE0, 0x00, 0x20, 0x79, 0xFE, 0x3D, 0xFF,
  0xDF, 0xFF, 0xEF, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0x40, 0x00, 0xFF, 0x80,
  0x7F, 0xF8, 0x1F, 0xFF, 0x83, 0xE0, 0xF8, 0xF8, 0x0F, 0x9E, 0x01, 0xF7,
  0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1E, 0x78, 0x03, 0xCF,
  0x00, 0xF9, 0xF0, 0x1E, 0x1F, 0x07, 0xC1, 0xFF, 0xF0, 0x1F, 0xFC, 0x01,
  0xFF, 0x00, 0x00, 0x20, 0x3C, 0xFF, 0x0F, 0x7F, 0xE3, 0xFF, 0xFC, 0xFE,
  0x1F, 0xBF, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xEF, 0xC0, 0xFB, 0xF8, 0x7E, 0xFF,
  0xFF, 0x3D, 0xFF, 0x8F, 0x1F, 0xC3, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x80, 0x03, 0xFC, 0x71, 0xFF, 0xBC,
  0xFF, 0xFF, 0x7E, 0x1F, 0xDF, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0x7D,
  0xF8, 0x7F, 0x3F, 0xFF, 0xC7, 0xFE, 0xF0, 0xFF, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x2E, 0x1F, 0xF3,
  0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0x00, 0x7F, 0xE7, 0xFF,
  0xDF, 0xFE, 0xF8, 0x1B, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF8,
  0x07, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0xF8, 0x1F, 0xFF, 0xFB, 0xFF, 0xC7, 0xFE, 0x00,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF1,
  0x1F, 0xF0, 0xFF, 0x07, 0xF0, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xDF, 0x0F, 0xEF, 0xFF, 0xF3,
  0xFF, 0x38, 0xFF, 0x1C, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x03, 0xE7,
  0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x7C, 0x3C, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x0F, 0x81, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x1E,
  0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x03, 0xBC, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3D, 0xE0, 0x3F, 0x01, 0xF7, 0x80, 0xFC, 0x07, 0x9F, 0x03,
  0xF0, 0x1E, 0x3C, 0x0F, 0xE0, 0x78, 0xF0, 0x7B, 0x83, 0xE3, 0xC1, 0xEE,
  0x0F, 0x0F, 0x07, 0x38, 0x3C, 0x1E, 0x1C, 0xF0, 0xF0, 0x78, 0xF3, 0xC7,
  0x81, 0xE3, 0xC7, 0x1E, 0x07, 0x8E, 0x1C, 0x78, 0x0F, 0x38, 0x79, 0xE0,
  0x3D, 0xE1, 0xE7, 0x00, 0xF7, 0x83, 0xBC, 0x03, 0xDC, 0x0E, 0xF0, 0x07,
  0x70, 0x3F, 0xC0, 0x1D, 0xC0, 0xFE, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xF8,
  0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x07,
  0xDE, 0x01, 0xE7, 0xC0, 0xF8, 0xF8, 0x7C, 0x1E, 0x1E, 0x07, 0xCF, 0x80,
  0xF3, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xF7, 0xC0, 0x7C, 0xF0, 0x1E, 0x1E,
  0x0F, 0x87, 0xC3, 0xC0, 0xF1, 0xF0, 0x3E, 0xF8, 0x07, 0xFC, 0x01, 0xF0,
  0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0xC0, 0x3C, 0x3C, 0x03,
  0xC3, 0xC0, 0x7C, 0x3E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xF0,
  0xF0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07,
  0x9E, 0x00, 0x3B, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xF8, 0x1F, 0xC0, 0xFE, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3E, 0x03, 0xE0, 0xFE, 0x07, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3E, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x3E, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xC0, 0x7E,
  0x0F, 0xE0, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0xFF, 0x07, 0xF0,
  0x3F, 0x01, 0x80, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0x80, 0x7F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Medium41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 29, 11, 3, -29 },
  { 20, 13, 10, 17, 2, -29 },
  { 37, 22, 29, 24, 1, -29 },
  { 117, 18, 33, 21, 2, -31 },
  { 192, 29, 30, 33, 2, -30 },
  { 301, 25, 30, 27, 2, -30 },
  { 395, 5, 10, 9, 2, -29 },
  { 402, 9, 35, 13, 2, -29 },
  { 442, 10, 35, 13, 1, -29 },
  { 486, 18, 17, 20, 1, -31 },
  { 525, 18, 19, 21, 2, -24 },
  { 568, 6, 10, 11, 2, -5 },
  { 576, 10, 4, 13, 1, -13 },
  { 581, 5, 5, 11, 3, -5 },
  { 585, 15, 29, 16, 0, -29 },
  { 640, 18, 30, 21, 2, -30 },
  { 708, 11, 29, 21, 3, -29 },
  { 748, 18, 30, 21, 2, -30 },
  { 816, 17, 30, 21, 2, -30 },
  { 880, 20, 29, 21, 1, -29 },
  { 953, 17, 29, 21, 2, -29 },
  { 1015, 18, 30, 21, 2, -30 },
  { 1083, 19, 29, 21, 1, -29 },
  { 1152, 18, 30, 21, 2, -30 },
  { 1220, 18, 30, 21, 2, -30 },
  { 1288, 5, 23, 11, 3, -23 },
  { 1303, 7, 28, 11, 1, -23 },
  { 1328, 18, 20, 21, 2, -25 },
  { 1373, 18, 11, 21, 2, -20 },
  { 1398, 18, 20, 21, 2, -25 },
  { 1443, 16, 30, 17, 0, -30 },
  { 1503, 29, 32, 33, 2, -29 },
  { 1619, 24, 29, 24, 0, -29 },
  { 1706, 19, 29, 24, 3, -29 },
  { 1775, 20, 30, 23, 2, -30 },
  { 1850, 22, 29, 27, 3, -29 },
  { 1930, 14, 29, 21, 4, -29 },
  { 1981, 14, 29, 20, 4, -29 },
  { 2032, 22, 30, 27, 2, -30 },
  { 2115, 20, 29, 28, 4, -29 },
  { 2188, 11, 29, 14, 1, -29 },
  { 2228, 11, 37, 11, -3, -29 },
  { 2279, 20, 29, 23, 4, -29 },
  { 2352, 16, 29, 20, 3, -29 },
  { 2410, 27, 29, 35, 4, -29 },
  { 2508, 21, 29, 29, 4, -29 },
  { 2585, 25, 30, 29, 2, -30 },
  { 2679, 18, 29, 23, 3, -29 },
  { 2745, 25, 37, 29, 2, -30 },
  { 2861, 20, 29, 24, 3, -29 },
  { 2934, 17, 30, 21, 2, -30 },
  { 2998, 20, 29, 21, 0, -29 },
  { 3071, 21, 29, 27, 3, -29 },
  { 3148, 23, 29, 23, 0, -29 },
  { 3232, 35, 29, 35, 0, -29 },
  { 3359, 22, 29, 22, 0, -29 },
  { 3439, 21, 29, 21, 0, -29 },
  { 3516, 18, 29, 21, 1, -29 },
  { 3582, 9, 36, 13, 3, -29 },
  { 3623, 15, 29, 16, 0, -29 },
  { 3678, 9, 36, 13, 1, -29 },
  { 3719, 20, 17, 22, 1, -29 },
  { 3762, 18, 2, 18, 0, 4 },
  { 3767, 9, 6, 12, 2, -31 },
  { 3774, 16, 23, 21, 2, -23 },
  { 3820, 18, 31, 23, 3, -31 },
  { 3890, 15, 23, 18, 2, -23 },
  { 3934, 18, 31, 23, 2, -31 },
  { 4004, 18, 23, 21, 2, -23 },
  { 4056, 14, 31, 13, 1, -31 },
  { 4111, 18, 33, 23, 2, -23 },
  { 4186, 17, 31, 23, 3, -31 },
  { 4252, 5, 31, 10, 3, -31 },
  { 4272, 10, 41, 10, -2, -31 },
  { 4324, 18, 31, 21, 3, -31 },
  { 4394, 4, 31, 10, 3, -31 },
  { 4410, 29, 23, 35, 3, -23 },
  { 4494, 17, 23, 23, 3, -23 },
  { 4543, 19, 23, 23, 2, -23 },
  { 4598, 18, 33, 23, 3, -23 },
  { 4673, 18, 33, 23, 2, -23 },
  { 4748, 12, 23, 16, 3, -23 },
  { 4783, 14, 23, 18, 2, -23 },
  { 4824, 12, 27, 14, 1, -27 },
  { 4865, 17, 22, 23, 3, -22 },
  { 4912, 20, 22, 20, 0, -22 },
  { 4967, 30, 22, 30, 0, -22 },
  { 5050, 18, 22, 20, 1, -22 },
  { 5100, 20, 32, 20, 0, -22 },
  { 5180, 15, 22, 17, 1, -22 },
  { 5222, 13, 36, 15, 1, -29 },
  { 5281, 3, 41, 21, 9, -31 },
  { 5297, 13, 36, 15, 1, -29 },
  { 5356, 18, 5, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_Medium41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium41pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM41PT7B_H_
