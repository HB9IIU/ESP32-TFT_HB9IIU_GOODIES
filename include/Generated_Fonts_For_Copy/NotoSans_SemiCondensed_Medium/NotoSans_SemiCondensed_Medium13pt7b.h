#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM13PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium13pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA2, 0xC0, 0xBB, 0xA0, 0x14, 0x29, 0xF9, 0x22, 0x5F, 0xCA,
  0x14, 0x48, 0x23, 0xEB, 0x4E, 0x38, 0xA5, 0xF9, 0x08, 0xE6, 0x52, 0x2B,
  0x15, 0x6E, 0xD8, 0xA4, 0x52, 0x49, 0x63, 0x00, 0x71, 0xB3, 0x43, 0x8E,
  0x32, 0xE3, 0x46, 0xF6, 0xE0, 0x7A, 0x49, 0x24, 0x99, 0x80, 0xCC, 0x92,
  0x49, 0x2F, 0x00, 0x10, 0x4F, 0xCC, 0x68, 0xA0, 0x21, 0x09, 0xF2, 0x10,
  0x80, 0x69, 0x60, 0xF0, 0xB0, 0x18, 0x84, 0x42, 0x31, 0x08, 0xC0, 0xF4,
  0xE3, 0x18, 0xC6, 0x33, 0x70, 0x3F, 0xB3, 0x33, 0x33, 0x30, 0xF4, 0xC2,
  0x31, 0x11, 0x10, 0xF8, 0xF0, 0xC2, 0x27, 0x04, 0x33, 0xF0, 0x08, 0x30,
  0xA1, 0x44, 0x89, 0x3F, 0x84, 0x08, 0xFC, 0x21, 0xE9, 0x84, 0x33, 0xF0,
  0x7E, 0x21, 0x6D, 0xC6, 0x39, 0x70, 0xFC, 0x10, 0xC2, 0x18, 0x41, 0x0C,
  0x60, 0xFC, 0x63, 0xE7, 0x4E, 0x31, 0xF0, 0xF4, 0xE3, 0x1D, 0xB4, 0x22,
  0xE0, 0xE0, 0x2C, 0x68, 0x00, 0x92, 0xC0, 0x08, 0xD9, 0x06, 0x0C, 0xF8,
  0x3E, 0x86, 0x0C, 0x17, 0x60, 0xF8, 0x42, 0x22, 0x10, 0x04, 0x60, 0x3E,
  0x20, 0xA7, 0x36, 0x9A, 0x4D, 0x26, 0xD5, 0x34, 0x40, 0x1F, 0x00, 0x18,
  0x38, 0x28, 0x24, 0x64, 0x7C, 0x46, 0xC2, 0xC3, 0xFA, 0x38, 0xE2, 0xFA,
  0x18, 0x63, 0xF8, 0x7F, 0x08, 0x20, 0x82, 0x0C, 0x30, 0x7C, 0xF9, 0x1A,
  0x1C, 0x38, 0x70, 0xE1, 0x46, 0xF8, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0xF8,
  0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x80, 0x7F, 0x82, 0x04, 0x08, 0xF0, 0xF1,
  0xA3, 0x7E, 0x87, 0x0E, 0x1C, 0x3F, 0xF0, 0xE1, 0xC3, 0x86, 0xF6, 0x66,
  0x66, 0x66, 0xF0, 0x24, 0x92, 0x49, 0x27, 0xE0, 0x8E, 0x29, 0x28, 0xF3,
  0x49, 0xA3, 0x84, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0xC1, 0xF1, 0xE8,
  0xB4, 0x5B, 0x6C, 0xA6, 0x53, 0x39, 0x88, 0x80, 0xC3, 0xC6, 0x8D, 0x99,
  0x33, 0x63, 0xC3, 0x86, 0x7D, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xE3, 0x7C,
  0xFA, 0x38, 0xE3, 0xFA, 0x08, 0x20, 0x80, 0x7D, 0x8E, 0x0C, 0x18, 0x30,
  0x60, 0xE3, 0x7C, 0x18, 0x18, 0xFA, 0x38, 0xE2, 0xFA, 0x49, 0xA3, 0x84,
  0xFC, 0x21, 0x87, 0x0C, 0x33, 0xF0, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE2, 0x78, 0xC2, 0x8D, 0x13,
  0x26, 0xC5, 0x0A, 0x1C, 0x18, 0xC4, 0x39, 0xCD, 0x29, 0x25, 0x26, 0xA4,
  0xF3, 0x8C, 0x71, 0x8C, 0x31, 0x80, 0xC6, 0xD8, 0xA1, 0xC1, 0x05, 0x1B,
  0x22, 0xC6, 0xC6, 0x89, 0xA1, 0x43, 0x82, 0x04, 0x08, 0x10, 0xFC, 0x30,
  0x84, 0x30, 0x86, 0x10, 0xFC, 0xF2, 0x49, 0x24, 0x93, 0x80, 0xC2, 0x10,
  0x42, 0x18, 0x42, 0x18, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x10, 0x50, 0xA2,
  0x2C, 0x60, 0xFC, 0x90, 0xF0, 0xC3, 0xF8, 0xCF, 0xA0, 0x82, 0x08, 0x2E,
  0xCA, 0x38, 0xE3, 0xCA, 0xE0, 0x7C, 0x88, 0x8C, 0x70, 0x08, 0x42, 0xF8,
  0xC6, 0x31, 0x8B, 0xC0, 0x74, 0x63, 0xF8, 0x61, 0xE0, 0x3B, 0x19, 0xE6,
  0x31, 0x8C, 0x63, 0x00, 0x7C, 0x63, 0x18, 0xC5, 0xE1, 0x8F, 0x80, 0x84,
  0x21, 0x7C, 0xC6, 0x31, 0x8C, 0x40, 0xDF, 0xC0, 0x24, 0x12, 0x49, 0x24,
  0x9E, 0x82, 0x08, 0x26, 0x92, 0x8E, 0x2C, 0x9A, 0x30, 0xFF, 0xC0, 0xBF,
  0xE6, 0x62, 0x31, 0x18, 0x8C, 0x46, 0x22, 0xBE, 0x63, 0x18, 0xC6, 0x20,
  0x72, 0x28, 0xE3, 0x8E, 0x27, 0x00, 0xBB, 0x28, 0xE3, 0x8F, 0x2B, 0xA0,
  0x82, 0x00, 0x7C, 0x63, 0x18, 0xC5, 0xE1, 0x08, 0x40, 0xBC, 0x88, 0x88,
  0x80, 0xF8, 0x86, 0x19, 0xF0, 0x44, 0xF4, 0x44, 0x44, 0x70, 0x8C, 0x63,
  0x18, 0xC7, 0xE0, 0xC5, 0x34, 0x92, 0x38, 0xC3, 0x00, 0xCC, 0xD3, 0x25,
  0xC9, 0x56, 0x73, 0x0C, 0xC3, 0x30, 0xCD, 0xA3, 0x8C, 0x39, 0x2C, 0xC0,
  0xC5, 0x34, 0x9A, 0x38, 0xC3, 0x0C, 0x23, 0x80, 0x78, 0xC4, 0x46, 0x23,
  0xE0, 0x32, 0x22, 0x2C, 0x22, 0x22, 0x30, 0xFF, 0xF8, 0xE1, 0x08, 0x42,
  0x0C, 0x84, 0x21, 0x30, 0x0F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Medium13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 9, 3, 1, -9 },
  { 4, 4, 3, 5, 1, -9 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 5, 11, 7, 1, -10 },
  { 21, 9, 9, 10, 1, -9 },
  { 32, 7, 9, 8, 1, -9 },
  { 40, 1, 3, 3, 1, -9 },
  { 41, 3, 11, 4, 1, -9 },
  { 46, 3, 11, 4, 0, -9 },
  { 51, 6, 6, 6, 0, -10 },
  { 56, 5, 7, 7, 1, -8 },
  { 61, 3, 4, 3, 0, -2 },
  { 63, 4, 1, 4, 0, -4 },
  { 64, 2, 2, 3, 1, -2 },
  { 65, 5, 9, 5, 0, -9 },
  { 71, 5, 9, 7, 1, -9 },
  { 77, 4, 9, 7, 1, -9 },
  { 82, 5, 9, 7, 1, -9 },
  { 88, 5, 9, 7, 1, -9 },
  { 94, 7, 9, 7, 0, -9 },
  { 102, 5, 9, 7, 1, -9 },
  { 108, 5, 9, 7, 1, -9 },
  { 114, 6, 9, 7, 0, -9 },
  { 121, 5, 9, 7, 1, -9 },
  { 127, 5, 9, 7, 1, -9 },
  { 133, 2, 7, 3, 1, -7 },
  { 135, 3, 9, 3, 0, -7 },
  { 139, 5, 6, 7, 1, -8 },
  { 143, 5, 3, 7, 1, -6 },
  { 145, 5, 6, 7, 1, -8 },
  { 149, 5, 9, 5, 0, -9 },
  { 155, 9, 10, 11, 1, -9 },
  { 167, 8, 9, 8, 0, -9 },
  { 176, 6, 9, 8, 1, -9 },
  { 183, 6, 9, 7, 1, -9 },
  { 190, 7, 9, 9, 1, -9 },
  { 198, 5, 9, 7, 1, -9 },
  { 204, 5, 9, 6, 1, -9 },
  { 210, 7, 9, 9, 1, -9 },
  { 218, 7, 9, 9, 1, -9 },
  { 226, 4, 9, 4, 0, -9 },
  { 231, 3, 12, 4, -1, -9 },
  { 236, 6, 9, 7, 1, -9 },
  { 243, 5, 9, 6, 1, -9 },
  { 249, 9, 9, 11, 1, -9 },
  { 260, 7, 9, 9, 1, -9 },
  { 268, 7, 9, 9, 1, -9 },
  { 276, 6, 9, 7, 1, -9 },
  { 283, 7, 11, 9, 1, -9 },
  { 293, 6, 9, 7, 1, -9 },
  { 300, 5, 9, 7, 1, -9 },
  { 306, 6, 9, 7, 0, -9 },
  { 313, 7, 9, 9, 1, -9 },
  { 321, 7, 9, 7, 0, -9 },
  { 329, 11, 9, 11, 0, -9 },
  { 342, 7, 9, 7, 0, -9 },
  { 350, 7, 9, 7, 0, -9 },
  { 358, 6, 9, 7, 0, -9 },
  { 365, 3, 11, 4, 1, -9 },
  { 370, 5, 9, 5, 0, -9 },
  { 376, 3, 11, 4, 0, -9 },
  { 381, 7, 5, 7, 0, -9 },
  { 386, 6, 1, 6, 0, 1 },
  { 387, 2, 2, 4, 1, -10 },
  { 388, 5, 7, 7, 1, -7 },
  { 393, 6, 10, 7, 1, -10 },
  { 401, 4, 7, 6, 1, -7 },
  { 405, 5, 10, 7, 1, -10 },
  { 412, 5, 7, 7, 1, -7 },
  { 417, 5, 10, 4, 0, -10 },
  { 424, 5, 10, 7, 1, -7 },
  { 431, 5, 10, 7, 1, -10 },
  { 438, 1, 10, 3, 1, -10 },
  { 440, 3, 13, 3, -1, -10 },
  { 445, 6, 10, 7, 1, -10 },
  { 453, 1, 10, 3, 1, -10 },
  { 455, 9, 7, 11, 1, -7 },
  { 463, 5, 7, 7, 1, -7 },
  { 468, 6, 7, 7, 1, -7 },
  { 474, 6, 10, 7, 1, -7 },
  { 482, 5, 10, 7, 1, -7 },
  { 489, 4, 7, 5, 1, -7 },
  { 493, 4, 7, 6, 1, -7 },
  { 497, 4, 9, 4, 0, -9 },
  { 502, 5, 7, 7, 1, -7 },
  { 507, 6, 7, 6, 0, -7 },
  { 513, 10, 7, 10, 0, -7 },
  { 522, 6, 7, 6, 0, -7 },
  { 528, 6, 10, 6, 0, -7 },
  { 536, 5, 7, 5, 0, -7 },
  { 541, 4, 11, 5, 0, -9 },
  { 547, 1, 13, 7, 3, -10 },
  { 549, 5, 11, 5, 0, -9 },
  { 556, 5, 2, 7, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_Medium13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium13pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM13PT7B_H_
