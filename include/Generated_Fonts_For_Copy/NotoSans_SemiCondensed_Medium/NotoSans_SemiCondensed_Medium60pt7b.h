#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM60PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium60pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0xFC, 0x1F, 0xFE,
  0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xF7, 0x80,
  0xFB, 0xC0, 0x7D, 0xE0, 0x3C, 0xF0, 0x1E, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0xC0, 0x78, 0x03, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x03, 0xC0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFC, 0x70, 0x38, 0xFE, 0x1C, 0x02, 0x3F,
  0x07, 0x00, 0x0F, 0xC1, 0xC0, 0x03, 0xF0, 0x70, 0x00, 0xFC, 0x1C, 0x00,
  0x3F, 0x07, 0x00, 0x0F, 0xE1, 0xC0, 0x01, 0xFE, 0x70, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x1C, 0xFF, 0x80, 0x07, 0x0F, 0xE0, 0x01, 0xC1, 0xF8, 0x00, 0x70,
  0x7E, 0x00, 0x1C, 0x0F, 0xC0, 0x07, 0x03, 0xF0, 0x01, 0xC1, 0xFA, 0x00,
  0x70, 0x7E, 0xE0, 0x1C, 0x3F, 0xBF, 0x87, 0x3F, 0xCF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x00, 0x1F, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x81, 0xF0,
  0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x00,
  0x3E, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xC0, 0x3E, 0x1F, 0x00, 0x00, 0x7C,
  0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0xF8, 0x3F, 0x81, 0xF0, 0x3E,
  0x1F, 0x1F, 0xFC, 0x3E, 0x07, 0xC7, 0xC3, 0xFF, 0x83, 0xE1, 0xF8, 0xF8,
  0xFF, 0xF8, 0x7C, 0x3E, 0x3E, 0x3F, 0x1F, 0x8F, 0xFF, 0xC7, 0xC7, 0xC1,
  0xF0, 0xFF, 0xF1, 0xF0, 0xF8, 0x3E, 0x0F, 0xFC, 0x3E, 0x3F, 0x03, 0xE0,
  0xFF, 0x0F, 0x87, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x00,
  0x7C, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x3E, 0x00, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x81, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x7C,
  0x00, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x01, 0xF0, 0x00,
  0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xE3, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3E, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xF0,
  0x3F, 0xFF, 0x80, 0x3F, 0x83, 0xFF, 0xFE, 0x01, 0xF8, 0x1F, 0xC7, 0xF0,
  0x0F, 0xC1, 0xFC, 0x1F, 0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0x07, 0xF0, 0xFE,
  0x01, 0xFC, 0x3F, 0x07, 0xE0, 0x0F, 0xF3, 0xF8, 0x3F, 0x00, 0x3F, 0xDF,
  0x83, 0xF8, 0x00, 0xFF, 0xFC, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0xFE, 0x00,
  0x0F, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE7, 0xF8, 0x0F,
  0xFF, 0xFE, 0x1F, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0x80, 0x7F, 0xF8, 0x01,
  0xFE, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xBE, 0x79, 0xE7, 0x9E, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7F, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x70, 0x1E,
  0x03, 0x9F, 0xC7, 0x8F, 0xE7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x1F,
  0x03, 0xE0, 0x01, 0x80, 0x60, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC7, 0xF1, 0xF8,
  0x7E, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C,
  0x1E, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x38, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03,
  0xFC, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xE7, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0x83, 0xFC, 0x1F, 0xE0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF,
  0x3F, 0xDF, 0xBF, 0xCF, 0xFF, 0x87, 0xE7, 0x83, 0xF3, 0x81, 0xF8, 0x80,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0x01, 0xFE, 0x0F,
  0x80, 0x1F, 0xE0, 0xE0, 0x01, 0xFC, 0x08, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xC0, 0x3F,
  0xC3, 0xC0, 0x03, 0xF8, 0x40, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xBE, 0x00, 0x3F, 0xEF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFC,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7D, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E, 0x7E, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x80,
  0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x3F, 0x01, 0xF8,
  0x01, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x1C, 0x00, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x40, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xEC, 0x00, 0x0F, 0xF7,
  0xC0, 0x0F, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x1D, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x1F, 0xE0, 0x3F, 0x1F, 0xFE, 0x0F, 0xCF, 0xFF, 0xC3,
  0xF7, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0xCF, 0xF8, 0x03,
  0xFB, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07,
  0xE7, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87, 0xF0,
  0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0x80, 0xFF, 0x0F, 0xE0, 0x07, 0xE1, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x07, 0xE0,
  0x0F, 0xE0, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0xFF, 0x7F, 0x80,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xE1, 0xFF, 0x07,
  0xF8, 0x0F, 0xF0, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE7, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xE7, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xFC, 0x7F, 0xE0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0x0B, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFE,
  0x0F, 0xE0, 0x1F, 0xC1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFD,
  0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7, 0xF0, 0x00, 0x7F, 0x7E, 0x00,
  0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0xBF, 0x80, 0x0F, 0xF7,
  0xF0, 0x03, 0xFE, 0x7F, 0x80, 0xFF, 0xCF, 0xFF, 0xFD, 0xF0, 0xFF, 0xFF,
  0xBE, 0x0F, 0xFF, 0xEF, 0xC0, 0xFF, 0xF9, 0xF8, 0x07, 0xFC, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x7E,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x38, 0x0F, 0x0F, 0xE3, 0xF8, 0xFF,
  0x3F, 0xCF, 0xF3, 0xF8, 0x7E, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F,
  0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF9, 0xF0, 0x1F, 0xE7, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xFF, 0xC0, 0xF8, 0x7E, 0x01,
  0xFF, 0xFC, 0x0F, 0x8F, 0x80, 0x7F, 0xFF, 0x81, 0xF1, 0xF0, 0x1F, 0xFF,
  0xF0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xCF, 0x80, 0xF8, 0x07, 0xC0,
  0x7D, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0xBC, 0x07, 0xC0, 0x1F, 0x01, 0xFF,
  0x80, 0xF8, 0x03, 0xE0, 0x3F, 0xF0, 0x3F, 0x00, 0x7C, 0x07, 0xFE, 0x07,
  0xC0, 0x0F, 0x80, 0xFF, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x00,
  0x7E, 0x03, 0xFF, 0x03, 0xE0, 0x0F, 0xC0, 0x7F, 0xE0, 0x7C, 0x01, 0xF8,
  0x0F, 0x7C, 0x0F, 0x80, 0x3E, 0x03, 0xEF, 0x81, 0xF0, 0x07, 0xC0, 0x7D,
  0xF0, 0x1F, 0x01, 0xFC, 0x0F, 0xBE, 0x03, 0xE0, 0x3F, 0x83, 0xE7, 0xC0,
  0x7E, 0x0F, 0xF8, 0xFC, 0x7C, 0x07, 0xFF, 0xCF, 0xFF, 0x0F, 0x80, 0xFF,
  0xF9, 0xFF, 0xC1, 0xF0, 0x0F, 0xFE, 0x1F, 0xF0, 0x1F, 0x00, 0x7F, 0x01,
  0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00,
  0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xC0, 0x7F, 0xFC,
  0xFC, 0x00, 0x3F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC,
  0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F,
  0xC0, 0x1F, 0xF8, 0xFC, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0xFE, 0xFC, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x3F,
  0xEF, 0xC0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0xF8, 0x3F, 0xE0, 0x00, 0xC1,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0x03, 0xFF, 0x00, 0x78, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF8, 0x3F, 0x00, 0x1F, 0xF8, 0x7E, 0x00, 0x0F, 0xF8, 0xFC, 0x00, 0x0F,
  0xF1, 0xF8, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x0F, 0xF3, 0xF0, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0xFF, 0x0F, 0xC0, 0x07,
  0xFE, 0x1F, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xF0,
  0x1F, 0xF0, 0x00, 0x30, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xBF, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x07, 0xF0, 0xFF, 0x80, 0x03, 0xF8, 0x3F, 0xF0, 0x01, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x01, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF,
  0x1F, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xBF, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E,
  0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00,
  0xFE, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x0F, 0xE0,
  0x0F, 0xC0, 0x7F, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x3F,
  0x80, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xDF, 0xF0, 0x00, 0x7F, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0x9F, 0xC0, 0x07,
  0xF8, 0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0,
  0x7F, 0x80, 0x7E, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x3F,
  0x80, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07, 0xF8, 0x3F, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x7F, 0x9F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x3F, 0xBF, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xDF, 0xFE, 0xF8, 0x00, 0x03, 0xEF, 0xFF, 0x7C, 0x00, 0x03, 0xF7,
  0xFF, 0xBF, 0x00, 0x01, 0xF3, 0xFF, 0xCF, 0x80, 0x00, 0xF9, 0xFF, 0xE7,
  0xC0, 0x00, 0xFC, 0xFF, 0xF3, 0xF0, 0x00, 0x7C, 0x7F, 0xF9, 0xF8, 0x00,
  0x3E, 0x3F, 0xFC, 0x7C, 0x00, 0x3F, 0x1F, 0xFE, 0x3F, 0x00, 0x1F, 0x0F,
  0xFF, 0x1F, 0x80, 0x0F, 0x87, 0xFF, 0x87, 0xC0, 0x0F, 0xC3, 0xFF, 0xC3,
  0xF0, 0x07, 0xC1, 0xFF, 0xE1, 0xF8, 0x03, 0xE0, 0xFF, 0xF0, 0x7C, 0x03,
  0xF0, 0x7F, 0xF8, 0x3F, 0x01, 0xF0, 0x3F, 0xFC, 0x1F, 0x80, 0xF8, 0x1F,
  0xFE, 0x07, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x7C, 0x07, 0xFF, 0x81,
  0xF8, 0x3E, 0x03, 0xFF, 0xC0, 0x7C, 0x3F, 0x01, 0xFF, 0xE0, 0x3F, 0x1F,
  0x00, 0xFF, 0xF0, 0x1F, 0x8F, 0x80, 0x7F, 0xF8, 0x07, 0xCF, 0xC0, 0x3F,
  0xFC, 0x03, 0xF7, 0xC0, 0x1F, 0xFE, 0x01, 0xFB, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFD, 0xF8, 0x00, 0x3F, 0xFD, 0xFC, 0x00, 0x3F, 0xFC, 0xFE, 0x00,
  0x3F, 0xFC, 0xFE, 0x00, 0x3F, 0xFC, 0x7F, 0x00, 0x3F, 0xFC, 0x7F, 0x00,
  0x3F, 0xFC, 0x3F, 0x80, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x1F, 0xC0,
  0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x07, 0xF0,
  0x3F, 0xFC, 0x07, 0xF0, 0x3F, 0xFC, 0x03, 0xF8, 0x3F, 0xFC, 0x03, 0xF8,
  0x3F, 0xFC, 0x01, 0xFC, 0x3F, 0xFC, 0x00, 0xFC, 0x3F, 0xFC, 0x00, 0xFE,
  0x3F, 0xFC, 0x00, 0x7E, 0x1F, 0xFC, 0x00, 0x7F, 0x1F, 0xFC, 0x00, 0x3F,
  0x9F, 0xFC, 0x00, 0x3F, 0x9F, 0xFC, 0x00, 0x1F, 0xDF, 0xFC, 0x00, 0x1F,
  0xDF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0xC0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF, 0xC0, 0x0F, 0xF3, 0xF0,
  0x01, 0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0,
  0x03, 0xFB, 0xF0, 0x01, 0xFC, 0xFC, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xF0, 0x03, 0xFE,
  0x1F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x3F,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x01, 0xFE, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0x01, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFE, 0x07, 0xE0,
  0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03,
  0xF8, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFC,
  0xFC, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFE, 0x01,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE3, 0xFE, 0x07, 0xF1, 0xFC, 0x00, 0x30, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xD0, 0x00, 0x0F, 0xEE, 0x00, 0x0F, 0xF7, 0xE0, 0x1F, 0xF3, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x02, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x0F,
  0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x3E, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xDF, 0x80, 0x1F, 0xC1,
  0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x3E, 0x00, 0x7E,
  0x03, 0xF0, 0x07, 0xE7, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0xF8, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xE1, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC,
  0x0F, 0x81, 0xF8, 0x00, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0x1F, 0x83,
  0xE0, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x07, 0xE1, 0xFC, 0x00, 0x7E,
  0x1F, 0x80, 0x7C, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x0F, 0xC7, 0xE0, 0x00,
  0xFC, 0x7C, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0x80, 0x1F, 0x1F, 0x80,
  0x03, 0xF3, 0xF0, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x7C, 0xFC,
  0x00, 0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0xFB,
  0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x03,
  0xEF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0,
  0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x07,
  0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xF8, 0x18, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x8F, 0xFF, 0x0F, 0xCF, 0xF0, 0x07, 0xEF, 0xE0,
  0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xDF, 0x80, 0x1F, 0xEF,
  0xE0, 0x1F, 0xF7, 0xFC, 0x7F, 0xF9, 0xFF, 0xFE, 0x7C, 0xFF, 0xFE, 0x3E,
  0x3F, 0xFE, 0x1F, 0x07, 0xFE, 0x0F, 0x80, 0x30, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x8F, 0xFE,
  0x07, 0xF3, 0xFF, 0xE0, 0xFC, 0xFF, 0xFE, 0x1F, 0xBF, 0xFF, 0xE3, 0xFF,
  0xC3, 0xFE, 0x7F, 0xE0, 0x1F, 0xCF, 0xF8, 0x01, 0xFD, 0xFE, 0x00, 0x3F,
  0xBF, 0xC0, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFD, 0xFE, 0x00, 0x1F, 0xBF, 0xC0, 0x07, 0xF7, 0xFC, 0x01,
  0xFC, 0xFF, 0xC0, 0x7F, 0x9F, 0xFF, 0xFF, 0xE3, 0xF7, 0xFF, 0xFC, 0x7E,
  0x7F, 0xFF, 0x0F, 0xC7, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x7F, 0xC7, 0xE3, 0xFC, 0x01, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x4F, 0xF0, 0x06, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x1F, 0xC0, 0xFF,
  0xE3, 0xF8, 0x3F, 0xFE, 0x7F, 0x0F, 0xFF, 0xE7, 0xE3, 0xFF, 0xFE, 0xFC,
  0xFF, 0x87, 0xFF, 0x9F, 0xC0, 0x3F, 0xF7, 0xF0, 0x03, 0xFE, 0xFE, 0x00,
  0x3F, 0xDF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xDF, 0xC0, 0x07, 0xFB, 0xFC,
  0x01, 0xFF, 0x3F, 0xC0, 0x7F, 0xE7, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xDF,
  0x87, 0xFF, 0xF3, 0xF0, 0x7F, 0xFC, 0x7E, 0x03, 0xFE, 0x07, 0xC0, 0x06,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x07,
  0xF0, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xE0,
  0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x10, 0xFF, 0x00, 0x1C, 0x1F, 0xFC, 0xFF,
  0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x30, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0xFC, 0x1F, 0xFF, 0x1F, 0x87, 0xFF, 0xF3, 0xF1, 0xFF, 0xFF, 0x7E, 0x7F,
  0xC3, 0xFF, 0xCF, 0xE0, 0x1F, 0xFB, 0xF8, 0x01, 0xFF, 0x7F, 0x00, 0x1F,
  0xEF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFB,
  0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xFD, 0xFE, 0x00,
  0xFF, 0x9F, 0xE0, 0x3F, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xEF, 0xC3,
  0xFF, 0xFB, 0xF8, 0x3F, 0xFE, 0x7F, 0x01, 0xFF, 0x8F, 0xE0, 0x02, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x20, 0x00, 0x3F,
  0x87, 0x80, 0x1F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x0F, 0xE3, 0xFF, 0x83, 0xF9, 0xFF,
  0xF8, 0xFC, 0xFF, 0xFF, 0x3F, 0x7F, 0xFF, 0xCF, 0xFF, 0x1F, 0xFB, 0xFF,
  0x00, 0xFE, 0xFF, 0x80, 0x1F, 0xBF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xF0, 0x38, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x0F, 0x80, 0xFE,
  0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F,
  0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xFB, 0xFF,
  0xDF, 0xFC, 0xFF, 0xE7, 0xFE, 0x3F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x01, 0xFD, 0xF8, 0x01, 0xFC, 0xFC, 0x01, 0xFC,
  0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0xFE,
  0x07, 0xE0, 0xFE, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x7E,
  0x00, 0x7E, 0x7F, 0x00, 0x3F, 0x7F, 0x00, 0x1F, 0x3F, 0x80, 0x0F, 0xBF,
  0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0x3F, 0x80, 0x7F, 0x0F, 0xC0, 0x3F, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x0F,
  0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x83, 0xF0, 0x0F, 0xE1, 0xF8, 0x07, 0xF0,
  0xFC, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x9F, 0x80, 0x0F,
  0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x87, 0xFF, 0x01, 0xFF, 0xC3, 0xF3,
  0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFD, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xBF, 0xE0, 0x1F, 0xFC,
  0x07, 0xF7, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xFF, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF0, 0x00,
  0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x3F, 0x0F, 0xFE, 0x0F, 0xC7, 0xFF, 0xE3, 0xF3, 0xFF, 0xFC, 0xFD,
  0xFF, 0xFF, 0x3F, 0xFC, 0x3F, 0xEF, 0xFC, 0x03, 0xFB, 0xFE, 0x00, 0x7E,
  0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xCF, 0xE0,
  0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0xBF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x87, 0xFF, 0x03,
  0xF1, 0xFF, 0xF0, 0x7E, 0x7F, 0xFF, 0x0F, 0xDF, 0xFF, 0xF1, 0xFF, 0xC1,
  0xFF, 0x3F, 0xF0, 0x0F, 0xE7, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xDF,
  0xE0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x7E, 0xFF, 0x00, 0x1F, 0xDF, 0xE0, 0x03, 0xFB, 0xFE, 0x00, 0xFE,
  0x7F, 0xE0, 0x3F, 0xCF, 0xFF, 0xFF, 0xF1, 0xFB, 0xFF, 0xFE, 0x3F, 0x3F,
  0xFF, 0x87, 0xF3, 0xFF, 0xE0, 0xFE, 0x1F, 0xF0, 0x1F, 0xC0, 0x60, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0xFC, 0x1F, 0xFF, 0x1F, 0x87, 0xFF, 0xF3, 0xF1, 0xFF, 0xFF,
  0x7E, 0x7F, 0xC3, 0xFF, 0xCF, 0xE0, 0x1F, 0xFB, 0xF8, 0x01, 0xFF, 0x7F,
  0x00, 0x1F, 0xEF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFD,
  0xFE, 0x00, 0xFF, 0x9F, 0xE0, 0x3F, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xEF, 0xC3, 0xFF, 0xFB, 0xF8, 0x3F, 0xFE, 0x7F, 0x01, 0xFF, 0x0F, 0xE0,
  0x02, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFE, 0x7F, 0x81, 0xF3, 0xF0, 0x01, 0x9F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xC0, 0x0F, 0xEF, 0xF3, 0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x03, 0xFF, 0x00, 0x0C, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x7E,
  0x00, 0x3F, 0xDF, 0xC0, 0x1F, 0xF7, 0xF8, 0x0F, 0xFD, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xEF, 0xC7, 0xFF, 0xF3, 0xF0, 0xFF, 0xF8, 0x7C, 0x1F, 0xFC,
  0x1F, 0x00, 0x30, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F,
  0x9F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00,
  0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFB,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0xE0, 0x07, 0xE7, 0xE0,
  0x07, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x1F, 0x80, 0x3F,
  0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xDF, 0x00, 0xFC, 0x3F, 0x00, 0xFB, 0xE0,
  0x1F, 0x87, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0xFC, 0x07, 0xCF, 0x80, 0xFC,
  0x0F, 0xC0, 0xF8, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x1F, 0x03, 0xF0, 0x3F,
  0x07, 0xC3, 0xE0, 0xFC, 0x07, 0xE0, 0xF8, 0x7C, 0x1F, 0x80, 0x7E, 0x1F,
  0x07, 0xC3, 0xF0, 0x0F, 0xC7, 0xE0, 0xF8, 0x7C, 0x01, 0xF8, 0xF8, 0x1F,
  0x1F, 0x80, 0x3F, 0x1F, 0x03, 0xE3, 0xF0, 0x03, 0xE3, 0xE0, 0x7E, 0x7E,
  0x00, 0x7E, 0x7C, 0x07, 0xCF, 0x80, 0x0F, 0xDF, 0x00, 0xF9, 0xF0, 0x01,
  0xFB, 0xE0, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x03, 0xEF, 0xC0, 0x03, 0xEF,
  0x80, 0x3F, 0xF0, 0x00, 0x7D, 0xE0, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x3F, 0x87, 0xE0, 0x03, 0xF1, 0xFC, 0x00,
  0x7F, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x3F,
  0x07, 0xE0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC,
  0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x9F, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F,
  0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0xC0,
  0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x03, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0x00, 0x08, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x27, 0xFF,
  0x80, 0x0D, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xB0, 0x00, 0xFF, 0xE4, 0x00, 0x07, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Medium60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 8, 44, 16, 4, -43 },
  { 45, 17, 16, 25, 4, -43 },
  { 79, 33, 43, 35, 1, -43 },
  { 257, 26, 49, 31, 3, -46 },
  { 417, 43, 44, 48, 2, -43 },
  { 654, 37, 44, 39, 2, -43 },
  { 858, 6, 16, 14, 4, -43 },
  { 870, 14, 52, 18, 3, -43 },
  { 961, 14, 52, 18, 2, -43 },
  { 1052, 26, 25, 30, 2, -46 },
  { 1134, 27, 29, 31, 2, -36 },
  { 1232, 10, 15, 15, 2, -7 },
  { 1251, 14, 6, 18, 2, -19 },
  { 1262, 8, 9, 15, 4, -8 },
  { 1271, 21, 43, 23, 1, -43 },
  { 1384, 26, 45, 31, 3, -44 },
  { 1531, 17, 43, 31, 4, -43 },
  { 1623, 27, 43, 31, 2, -43 },
  { 1769, 26, 44, 31, 2, -43 },
  { 1912, 29, 43, 31, 1, -43 },
  { 2068, 25, 44, 31, 3, -43 },
  { 2206, 26, 44, 31, 3, -43 },
  { 2349, 27, 43, 31, 2, -43 },
  { 2495, 27, 44, 31, 2, -43 },
  { 2644, 27, 44, 31, 2, -43 },
  { 2793, 8, 34, 16, 4, -33 },
  { 2827, 10, 41, 16, 2, -33 },
  { 2879, 27, 29, 31, 2, -36 },
  { 2977, 26, 17, 31, 3, -30 },
  { 3033, 27, 29, 31, 2, -36 },
  { 3131, 22, 44, 24, 1, -43 },
  { 3252, 43, 48, 49, 3, -43 },
  { 3510, 35, 43, 35, 0, -43 },
  { 3699, 28, 43, 36, 5, -43 },
  { 3850, 29, 44, 34, 3, -43 },
  { 4010, 31, 43, 39, 5, -43 },
  { 4177, 22, 43, 30, 5, -43 },
  { 4296, 22, 43, 29, 5, -43 },
  { 4415, 33, 44, 40, 3, -43 },
  { 4597, 30, 43, 41, 5, -43 },
  { 4759, 16, 43, 20, 2, -43 },
  { 4845, 15, 55, 16, -4, -43 },
  { 4949, 29, 43, 34, 5, -43 },
  { 5105, 22, 43, 29, 5, -43 },
  { 5224, 41, 43, 51, 5, -43 },
  { 5445, 32, 43, 42, 5, -43 },
  { 5617, 36, 45, 42, 3, -44 },
  { 5820, 26, 43, 33, 5, -43 },
  { 5960, 36, 54, 42, 3, -44 },
  { 6203, 29, 43, 35, 5, -43 },
  { 6359, 25, 44, 30, 3, -43 },
  { 6497, 28, 43, 30, 1, -43 },
  { 6648, 30, 44, 40, 5, -43 },
  { 6813, 33, 43, 33, 0, -43 },
  { 6991, 51, 43, 52, 0, -43 },
  { 7266, 32, 43, 32, 0, -43 },
  { 7438, 31, 43, 31, 0, -43 },
  { 7605, 26, 43, 30, 2, -43 },
  { 7745, 14, 53, 19, 4, -43 },
  { 7838, 21, 43, 23, 1, -43 },
  { 7951, 13, 53, 19, 2, -43 },
  { 8038, 28, 26, 32, 2, -43 },
  { 8129, 26, 4, 26, 0, 5 },
  { 8142, 13, 10, 18, 2, -46 },
  { 8159, 25, 34, 31, 2, -33 },
  { 8266, 27, 47, 34, 4, -46 },
  { 8425, 22, 34, 27, 3, -33 },
  { 8519, 27, 47, 34, 3, -46 },
  { 8678, 26, 34, 31, 3, -33 },
  { 8789, 21, 46, 19, 1, -46 },
  { 8910, 27, 47, 34, 3, -33 },
  { 9069, 26, 46, 34, 4, -46 },
  { 9219, 7, 45, 15, 4, -45 },
  { 9259, 13, 59, 15, -2, -45 },
  { 9355, 25, 46, 31, 5, -46 },
  { 9499, 7, 46, 15, 4, -46 },
  { 9540, 43, 33, 51, 4, -33 },
  { 9718, 26, 33, 34, 4, -33 },
  { 9826, 27, 34, 33, 3, -33 },
  { 9941, 27, 47, 34, 4, -33 },
  { 10100, 27, 47, 34, 3, -33 },
  { 10259, 18, 33, 23, 4, -33 },
  { 10334, 21, 34, 26, 3, -33 },
  { 10424, 18, 41, 21, 1, -40 },
  { 10517, 26, 33, 34, 4, -32 },
  { 10625, 29, 32, 29, 0, -32 },
  { 10741, 43, 32, 44, 1, -32 },
  { 10913, 27, 32, 29, 1, -32 },
  { 11021, 29, 46, 29, 0, -32 },
  { 11188, 21, 32, 25, 2, -32 },
  { 11272, 18, 53, 22, 2, -43 },
  { 11392, 6, 60, 30, 12, -46 },
  { 11437, 19, 53, 22, 2, -43 },
  { 11563, 27, 8, 31, 2, -25 },
};

const GFXfont NotoSans_SemiCondensed_Medium60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium60pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM60PT7B_H_
