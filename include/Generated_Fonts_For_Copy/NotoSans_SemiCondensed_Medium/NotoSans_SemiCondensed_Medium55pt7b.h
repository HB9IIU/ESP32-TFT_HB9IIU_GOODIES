#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM55PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3C, 0x78, 0xF1,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x18,
  0xFC, 0x1F, 0xFE, 0x0F, 0xDF, 0x07, 0xCF, 0x83, 0xE7, 0xC1, 0xF3, 0xE0,
  0xF9, 0xF0, 0x7C, 0xF8, 0x3E, 0x7C, 0x1F, 0x3E, 0x0F, 0x9F, 0x07, 0xCF,
  0x81, 0xE7, 0x80, 0xF3, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x3C, 0x07,
  0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3E, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x3C,
  0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFC, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C,
  0x0F, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x7F, 0xF8, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF3, 0xF8, 0xE0, 0xE7, 0xE1, 0xC0, 0x0F, 0x83, 0x80, 0x1F, 0x07,
  0x00, 0x3E, 0x0E, 0x00, 0x7C, 0x1C, 0x00, 0xFC, 0x38, 0x01, 0xFC, 0x70,
  0x01, 0xFE, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0xE3, 0xF8, 0x01, 0xC3, 0xF0, 0x03, 0x83, 0xE0, 0x07, 0x07, 0xC0,
  0x0E, 0x0F, 0x80, 0x1C, 0x1F, 0x80, 0x38, 0x7F, 0xC0, 0x71, 0xFB, 0xF8,
  0xFF, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x00,
  0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0xE0,
  0x01, 0xE0, 0x03, 0xE7, 0xE0, 0x07, 0xC0, 0x0F, 0x87, 0xC0, 0x0F, 0x00,
  0x1E, 0x07, 0x80, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x78, 0x00, 0xF8, 0x1F,
  0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x03, 0xE0, 0x7C, 0x0F, 0x80,
  0x07, 0xC0, 0xF8, 0x1E, 0x00, 0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x1F, 0x03,
  0xE0, 0xF0, 0x00, 0x3E, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x0F, 0x87, 0x80,
  0x00, 0x78, 0x1F, 0x1F, 0x0F, 0xE0, 0xF0, 0x3E, 0x3E, 0x3F, 0xE1, 0xE0,
  0x78, 0xF8, 0xFF, 0xE3, 0xE1, 0xF1, 0xF3, 0xFF, 0xE3, 0xE7, 0xE7, 0xC7,
  0xC7, 0xC7, 0xFF, 0x8F, 0x8F, 0x07, 0xC7, 0xFE, 0x3E, 0x3E, 0x0F, 0x87,
  0xF8, 0x7C, 0x7C, 0x1F, 0x03, 0xC1, 0xF0, 0xF0, 0x1E, 0x00, 0x03, 0xE1,
  0xE0, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0xF0,
  0x00, 0x3C, 0x0F, 0x01, 0xE0, 0x00, 0xF8, 0x1E, 0x03, 0xC0, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0xF8, 0x1E,
  0x00, 0x3E, 0x01, 0xF0, 0x7C, 0x00, 0x78, 0x03, 0xE0, 0xF8, 0x01, 0xF0,
  0x03, 0xE1, 0xE0, 0x03, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0x80, 0x07, 0xFF,
  0x00, 0x1E, 0x00, 0x07, 0xFC, 0x00, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0x03, 0xFF, 0xE0, 0x0F,
  0xC1, 0xFD, 0xFC, 0x03, 0xE0, 0xFE, 0x3F, 0x81, 0xF8, 0x7F, 0x07, 0xF0,
  0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0x07, 0xE0, 0x1F, 0xCF, 0xC3, 0xF0, 0x03,
  0xFB, 0xF0, 0xFC, 0x00, 0xFF, 0xF8, 0x3F, 0x00, 0x1F, 0xFE, 0x0F, 0xC0,
  0x03, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x1F,
  0x80, 0x0F, 0xFC, 0x07, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xDF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0xFE, 0x07, 0xFF, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0x07,
  0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x00, 0xFF, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x30,
  0x1E, 0x07, 0x7E, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xF7,
  0xC0, 0x03, 0xEF, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x80, 0x7C, 0x1F,
  0x81, 0xF8, 0x3F, 0x80, 0xF0, 0x3C, 0x00, 0x40, 0x60, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x9F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF1, 0xF8, 0xFC, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x7E, 0x7F, 0xFF, 0x7F,
  0x7E, 0x7E, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xC3, 0xFC, 0x1F,
  0x80, 0xFC, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E,
  0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0xFC, 0x1F, 0xF7, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x3E, 0x01, 0xFC,
  0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xEF, 0xBF, 0x9F, 0xFE,
  0x3E, 0xF8, 0x7D, 0xE0, 0xF9, 0x81, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0x7F, 0x83, 0xFC, 0x3C, 0x00, 0xFC, 0x18, 0x00, 0xFE, 0x10, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x7F, 0x03, 0xFC, 0x38, 0x00, 0xFE, 0x10, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0xE0, 0x01, 0xFE, 0xFE, 0x0F, 0xFC, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x00, 0x20,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0xDF, 0x80, 0x01,
  0xF3, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF8,
  0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xF8,
  0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x7C, 0x00,
  0xFC, 0x1F, 0x00, 0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x87, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE1, 0xF9, 0xFF, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x80, 0x01, 0xFD,
  0xC0, 0x07, 0xF3, 0xF8, 0x7F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F,
  0xF0, 0x08, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0xF8, 0xFF, 0xE0, 0xF9,
  0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x81, 0xFC, 0xFE,
  0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xFC,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0xC7, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFC, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x7C,
  0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x03, 0xF0,
  0x3F, 0x83, 0xF0, 0x0F, 0xF7, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x7F, 0x9F,
  0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x00, 0xFE, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x0F, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x9F,
  0xC0, 0x1F, 0xCF, 0xF0, 0x1F, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x3F, 0xC3, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7E, 0x00,
  0x7E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F, 0x81,
  0xFF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0xDF, 0x0F, 0xFF, 0x9F, 0x07, 0xFE,
  0x3F, 0x00, 0x78, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x10, 0x3F, 0xF0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0x3C, 0x7E, 0x7F, 0xFF, 0x7F, 0x7F, 0x7E, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x7E, 0x7F, 0xFF, 0x7F, 0x7F, 0x7E, 0x18, 0x1E, 0x1F, 0x8F, 0xEF,
  0xF3, 0xF9, 0xF8, 0xFC, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x9F, 0x8F, 0xC7, 0xE3, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3E, 0x1F,
  0x0F, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE7, 0xC0, 0xFE, 0x60, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x3E, 0x00, 0x01, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xBF, 0xF8, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x78, 0x01, 0xFE,
  0x01, 0xF1, 0xF0, 0x0F, 0xFF, 0x83, 0xE3, 0xC0, 0x3F, 0xFF, 0x03, 0xCF,
  0x80, 0xFF, 0xFE, 0x07, 0x9F, 0x03, 0xF0, 0x3C, 0x0F, 0xBC, 0x0F, 0xC0,
  0xF8, 0x1F, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0xF0, 0x3C, 0x03, 0xE0, 0x3F,
  0xE0, 0xF8, 0x07, 0xC0, 0x7F, 0x81, 0xF0, 0x0F, 0x80, 0xFF, 0x03, 0xE0,
  0x1F, 0x01, 0xFE, 0x07, 0xC0, 0x3E, 0x03, 0xFC, 0x0F, 0x80, 0x7C, 0x07,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0xF0, 0x3E, 0x01, 0xF0, 0x3F, 0xE0, 0x7C,
  0x07, 0xE0, 0x7B, 0xC0, 0xF8, 0x0F, 0xC0, 0xF7, 0xC0, 0xF8, 0x1F, 0x83,
  0xCF, 0x81, 0xF8, 0x77, 0x8F, 0x9F, 0x01, 0xFF, 0xEF, 0xFE, 0x1E, 0x03,
  0xFF, 0x8F, 0xFC, 0x3E, 0x03, 0xFE, 0x0F, 0xE0, 0x7C, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xFF, 0x81, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xC0,
  0x07, 0xF3, 0xE0, 0x01, 0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C,
  0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF7,
  0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x03, 0xF8, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC7, 0xC0, 0x0F, 0xF3, 0xE0, 0x01, 0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0x7C, 0x00, 0x7F, 0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0x03, 0xFC, 0x00, 0x60, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x06, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x1F,
  0xF0, 0xF8, 0x00, 0x7F, 0x8F, 0x80, 0x03, 0xFC, 0xF8, 0x00, 0x1F, 0xCF,
  0x80, 0x00, 0xFE, 0xF8, 0x00, 0x0F, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0xF8,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xEF, 0x80, 0x00,
  0xFC, 0xF8, 0x00, 0x1F, 0xCF, 0x80, 0x03, 0xF8, 0xF8, 0x00, 0xFF, 0x0F,
  0x80, 0x3F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xC0,
  0xFF, 0x80, 0x07, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0xFD, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0xFC, 0x7F, 0x80, 0x03, 0xF0, 0xFF, 0x80, 0x0F,
  0xC1, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFE, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x7F, 0xC3, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC0, 0xF8, 0x00,
  0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x07,
  0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x3F,
  0x1F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x1F, 0xC0,
  0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0,
  0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x7E, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x03, 0xF8,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7B, 0xFF, 0xF8,
  0x00, 0x07, 0xDF, 0xFB, 0xE0, 0x00, 0x3E, 0xFF, 0xDF, 0x00, 0x01, 0xE7,
  0xFE, 0xF8, 0x00, 0x1F, 0x3F, 0xF3, 0xE0, 0x00, 0xF9, 0xFF, 0x9F, 0x00,
  0x07, 0x8F, 0xFC, 0xF8, 0x00, 0x7C, 0xFF, 0xE3, 0xE0, 0x03, 0xE7, 0xFF,
  0x1F, 0x00, 0x1E, 0x3F, 0xF8, 0xF8, 0x01, 0xF1, 0xFF, 0xC3, 0xE0, 0x0F,
  0x8F, 0xFE, 0x1F, 0x00, 0x78, 0x7F, 0xF0, 0xF8, 0x07, 0xC3, 0xFF, 0x83,
  0xE0, 0x3E, 0x1F, 0xFC, 0x1F, 0x01, 0xE0, 0xFF, 0xE0, 0xF8, 0x1F, 0x07,
  0xFF, 0x03, 0xE0, 0xF8, 0x3F, 0xF8, 0x1F, 0x07, 0x81, 0xFF, 0xC0, 0xF8,
  0x7C, 0x0F, 0xFE, 0x03, 0xE3, 0xE0, 0x7F, 0xF0, 0x1F, 0x1E, 0x03, 0xFF,
  0x80, 0xF9, 0xF0, 0x1F, 0xFC, 0x03, 0xEF, 0x80, 0xFF, 0xE0, 0x1F, 0x78,
  0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xC0,
  0x1F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xDF, 0x80, 0x07, 0xFE, 0xFE, 0x00, 0x3F, 0xF3, 0xF0, 0x01, 0xFF, 0x8F,
  0xC0, 0x0F, 0xFC, 0x7E, 0x00, 0x7F, 0xE1, 0xF8, 0x03, 0xFF, 0x0F, 0xC0,
  0x1F, 0xF8, 0x3F, 0x00, 0xFF, 0xC1, 0xFC, 0x07, 0xFE, 0x07, 0xE0, 0x3F,
  0xF0, 0x3F, 0x81, 0xFF, 0x80, 0xFC, 0x0F, 0xFC, 0x07, 0xF0, 0x7F, 0xE0,
  0x1F, 0x83, 0xFF, 0x00, 0x7E, 0x1F, 0xF8, 0x03, 0xF0, 0xFF, 0xC0, 0x0F,
  0xC7, 0xFE, 0x00, 0x7F, 0x3F, 0xF0, 0x01, 0xF9, 0xFF, 0x80, 0x0F, 0xEF,
  0xFC, 0x00, 0x3F, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xE0,
  0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x01,
  0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x02,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0x00, 0x7F, 0xBE, 0x00, 0x7F, 0x7C,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xFB, 0xE0, 0x1F, 0xE7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xC0, 0x7F, 0x80, 0x1F,
  0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC,
  0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x02, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3E,
  0x00, 0xFF, 0x0F, 0x80, 0x0F, 0xE3, 0xE0, 0x03, 0xF8, 0xF8, 0x00, 0x7E,
  0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x03, 0xF0, 0xF8,
  0x01, 0xFC, 0x3E, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xE0, 0x7E,
  0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xE0,
  0x1F, 0xC0, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFE, 0x0F, 0x80, 0x1F, 0x83,
  0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07,
  0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0xBE, 0x00, 0x07, 0xEF, 0x80,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xE1, 0xFF, 0xFF, 0xC7, 0xFC, 0x3F, 0x8F, 0xC0, 0x06, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xA0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0x1F, 0xFD, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x3F,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFD, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0x8F, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0x1E, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7D, 0xF0, 0x03, 0xF0, 0x7E, 0x00,
  0xFB, 0xE0, 0x07, 0xE0, 0xFC, 0x01, 0xF7, 0xC0, 0x0F, 0x81, 0xF8, 0x03,
  0xE7, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0x8F, 0x80, 0x7E, 0x03, 0xE0, 0x1F,
  0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3E, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7C,
  0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0xC0, 0x1F, 0x03, 0xE0,
  0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xC1, 0xF0, 0x3E, 0x00, 0x7E, 0x0F, 0x81,
  0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x07,
  0xC3, 0xF0, 0x01, 0xF8, 0xF8, 0x0F, 0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x0F,
  0x8F, 0x80, 0x07, 0xE7, 0xC0, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x3E,
  0x7E, 0x00, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x7D,
  0xF0, 0x00, 0x3F, 0x78, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xF7,
  0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0x9F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0x80,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xFC, 0x3F, 0xC1,
  0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xC0, 0x7E, 0xFE, 0x00,
  0xFD, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x7E, 0x01, 0xFE, 0xFE, 0x0F, 0xFD,
  0xFF, 0xFE, 0xF9, 0xFF, 0xF9, 0xF1, 0xFF, 0xE3, 0xE1, 0xFF, 0x87, 0xC0,
  0x60, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x3F, 0xC0, 0xFC, 0xFF, 0xE0, 0xFD, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0x7E,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x7E, 0xFF, 0x00, 0xFE, 0xFF, 0xC1, 0xFC, 0xFB, 0xFF, 0xFC,
  0xF9, 0xFF, 0xF8, 0xF8, 0xFF, 0xF0, 0xF8, 0x7F, 0xC0, 0x00, 0x0C, 0x00,
  0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE3, 0xF8, 0x04, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x23, 0xFE, 0x3E, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x1F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x3F, 0x07, 0xFF, 0x3F,
  0x0F, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0xFF, 0xFF, 0x7F, 0x81, 0xFF,
  0x7F, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F, 0xC3, 0xFF,
  0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F, 0x0F, 0xFF, 0x1F, 0x03, 0xFE, 0x1F,
  0x00, 0x30, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xFC, 0x3F, 0x87, 0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0x3F,
  0x00, 0x3E, 0x7C, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x0C, 0x7F, 0xC0, 0xF8, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x3F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x1F, 0x07, 0xFF, 0x1F, 0x0F, 0xFF, 0x9F, 0x1F, 0xFF,
  0xDF, 0x3F, 0xFF, 0xFF, 0x3F, 0x81, 0xFF, 0x7F, 0x00, 0xFF, 0x7E, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x7F, 0x7F, 0x00, 0xFF, 0x3F, 0xC3, 0xFF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF,
  0x9F, 0x0F, 0xFF, 0x3F, 0x03, 0xFE, 0x3F, 0x00, 0x30, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x40, 0x00, 0x7E, 0x38, 0x01, 0xFE, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC3, 0xFC, 0x1F,
  0x9F, 0xFE, 0x3F, 0x7F, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x7B,
  0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x07, 0xEF, 0xFE, 0xFF, 0xEF, 0xFC,
  0xFF, 0x8F, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8,
  0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0,
  0xFC, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7E, 0x00,
  0xFC, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x3F, 0x00, 0xFE, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0xFC, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xFC,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x3F, 0xC0, 0x3F, 0xC1, 0xF1, 0xFF,
  0xC1, 0xFF, 0xE3, 0xE7, 0xFF, 0xC7, 0xFF, 0xE7, 0xDF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xC0,
  0x3F, 0xC0, 0x1F, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0x80,
  0x07, 0xFF, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0xFC,
  0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xF0,
  0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xC0, 0x03, 0xFF,
  0x80, 0x0F, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0x00, 0x0F, 0xFE, 0x00, 0x3E,
  0x00, 0x1F, 0xFC, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x7F,
  0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xC0, 0x07,
  0xC0, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x3F, 0xC1, 0xF1,
  0xFF, 0xE3, 0xE7, 0xFF, 0xE7, 0xDF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC1, 0xFC, 0x07, 0xF1, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xF7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0xFE, 0x1F, 0xE0, 0xFE, 0x07, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x20, 0x00,
  0xF8, 0x3F, 0xC0, 0xF8, 0xFF, 0xE0, 0xF9, 0xFF, 0xF8, 0xFB, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7E,
  0xFF, 0x00, 0xFE, 0xFF, 0xC3, 0xFC, 0xFB, 0xFF, 0xFC, 0xFD, 0xFF, 0xF8,
  0xFC, 0xFF, 0xF0, 0xFC, 0x7F, 0xC0, 0xFC, 0x0C, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x1F,
  0x07, 0xFF, 0x1F, 0x0F, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0xFF, 0xFF,
  0x7F, 0x81, 0xFF, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF,
  0x3F, 0xC3, 0xFF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F, 0x0F, 0xFF, 0x3F,
  0x03, 0xFE, 0x3F, 0x00, 0x30, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x7F, 0xF8, 0xFF,
  0xF9, 0xFF, 0xFB, 0xFF, 0xFB, 0xE1, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0x07, 0xC7, 0xE0, 0x0C, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xEF, 0x80, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x60, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7F, 0xFC, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC1,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xC1, 0x0F, 0xFF, 0x83, 0xFF,
  0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xFE, 0x01, 0xFE, 0xFF, 0x0F, 0xFD, 0xFF, 0xFE,
  0xF9, 0xFF, 0xFD, 0xF1, 0xFF, 0xF3, 0xE1, 0xFF, 0x83, 0xC0, 0x10, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xF9, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x03, 0xF0, 0x3F, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x1F, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xE7, 0xC0,
  0x1F, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0xE0, 0x1F, 0x9F, 0x80, 0x7B, 0xC0,
  0x3F, 0x3F, 0x01, 0xF7, 0x80, 0x7C, 0x3E, 0x03, 0xEF, 0x80, 0xF8, 0x7C,
  0x07, 0xDF, 0x03, 0xF0, 0xFC, 0x0F, 0x3E, 0x07, 0xE1, 0xF8, 0x3E, 0x3C,
  0x0F, 0x81, 0xF0, 0x7C, 0x7C, 0x1F, 0x03, 0xE0, 0xF8, 0xF8, 0x7E, 0x07,
  0xE1, 0xE1, 0xF0, 0xFC, 0x0F, 0xC7, 0xC1, 0xE1, 0xF0, 0x0F, 0x8F, 0x83,
  0xE3, 0xE0, 0x1F, 0x1F, 0x07, 0xCF, 0xC0, 0x3E, 0x3C, 0x0F, 0x9F, 0x80,
  0x7E, 0xF8, 0x0F, 0x3E, 0x00, 0x7D, 0xF0, 0x1E, 0x7C, 0x00, 0xFB, 0xE0,
  0x3E, 0xF8, 0x01, 0xF7, 0x80, 0x7F, 0xE0, 0x03, 0xEF, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xBF, 0x00, 0x1F,
  0x9F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F,
  0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0xC7, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xFB,
  0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x1F, 0x80, 0xFC,
  0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xE7, 0xE0, 0x03,
  0xF7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3,
  0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x1F,
  0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x01, 0xF0,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x03, 0xE1, 0xF8, 0x00,
  0xFC, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFE, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC,
  0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8,
  0x03, 0xF8, 0x01, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xBF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x00, 0xFF, 0xFA,
  0x00, 0x1F, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Medium55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 40, 14, 4, -39 },
  { 36, 17, 14, 23, 3, -39 },
  { 66, 30, 39, 32, 1, -39 },
  { 213, 23, 45, 29, 3, -42 },
  { 343, 39, 41, 44, 2, -40 },
  { 543, 34, 41, 36, 2, -40 },
  { 718, 6, 14, 13, 3, -39 },
  { 729, 13, 48, 17, 2, -39 },
  { 807, 12, 48, 17, 2, -39 },
  { 879, 23, 23, 27, 2, -42 },
  { 946, 24, 27, 29, 2, -33 },
  { 1027, 9, 13, 14, 2, -6 },
  { 1042, 13, 5, 17, 2, -17 },
  { 1051, 8, 8, 14, 3, -7 },
  { 1059, 20, 39, 21, 1, -39 },
  { 1157, 24, 41, 29, 2, -40 },
  { 1280, 15, 39, 29, 4, -39 },
  { 1354, 24, 40, 29, 2, -40 },
  { 1474, 24, 41, 29, 2, -40 },
  { 1597, 27, 39, 29, 1, -39 },
  { 1729, 23, 40, 29, 3, -39 },
  { 1844, 24, 41, 29, 3, -40 },
  { 1967, 25, 39, 29, 2, -39 },
  { 2089, 25, 41, 29, 2, -40 },
  { 2218, 24, 41, 29, 2, -40 },
  { 2341, 8, 31, 14, 3, -30 },
  { 2372, 9, 37, 14, 2, -30 },
  { 2414, 25, 27, 29, 2, -33 },
  { 2499, 24, 15, 29, 2, -27 },
  { 2544, 25, 27, 29, 2, -33 },
  { 2629, 20, 41, 22, 1, -40 },
  { 2732, 39, 44, 45, 3, -39 },
  { 2947, 32, 39, 32, 0, -39 },
  { 3103, 25, 39, 33, 5, -39 },
  { 3225, 27, 41, 31, 3, -40 },
  { 3364, 28, 39, 36, 5, -39 },
  { 3501, 20, 39, 28, 5, -39 },
  { 3599, 20, 39, 26, 5, -39 },
  { 3697, 30, 41, 36, 3, -40 },
  { 3851, 27, 39, 37, 5, -39 },
  { 3983, 14, 39, 18, 2, -39 },
  { 4052, 14, 50, 15, -4, -39 },
  { 4140, 27, 39, 31, 5, -39 },
  { 4272, 20, 39, 26, 5, -39 },
  { 4370, 37, 39, 47, 5, -39 },
  { 4551, 29, 39, 39, 5, -39 },
  { 4693, 33, 41, 39, 3, -40 },
  { 4863, 23, 39, 30, 5, -39 },
  { 4976, 33, 49, 39, 3, -40 },
  { 5179, 26, 39, 32, 5, -39 },
  { 5306, 23, 41, 28, 2, -40 },
  { 5424, 26, 39, 28, 1, -39 },
  { 5551, 28, 40, 37, 4, -39 },
  { 5691, 31, 39, 31, 0, -39 },
  { 5843, 47, 39, 47, 0, -39 },
  { 6073, 30, 39, 30, 0, -39 },
  { 6220, 29, 39, 29, 0, -39 },
  { 6362, 24, 39, 28, 2, -39 },
  { 6479, 12, 48, 18, 4, -39 },
  { 6551, 20, 39, 21, 1, -39 },
  { 6649, 13, 48, 18, 1, -39 },
  { 6727, 26, 23, 29, 2, -39 },
  { 6802, 24, 3, 24, 0, 5 },
  { 6811, 12, 9, 16, 2, -42 },
  { 6825, 23, 31, 29, 2, -30 },
  { 6915, 24, 43, 31, 4, -42 },
  { 7044, 20, 31, 24, 3, -30 },
  { 7122, 24, 43, 31, 3, -42 },
  { 7251, 23, 31, 29, 3, -30 },
  { 7341, 19, 42, 18, 1, -42 },
  { 7441, 24, 43, 31, 3, -30 },
  { 7570, 23, 42, 31, 4, -42 },
  { 7691, 6, 41, 14, 4, -41 },
  { 7722, 12, 54, 14, -2, -41 },
  { 7803, 24, 42, 28, 4, -42 },
  { 7929, 6, 42, 14, 4, -42 },
  { 7961, 39, 30, 47, 4, -30 },
  { 8108, 23, 30, 31, 4, -30 },
  { 8195, 25, 31, 31, 3, -30 },
  { 8292, 24, 43, 31, 4, -30 },
  { 8421, 24, 43, 31, 3, -30 },
  { 8550, 16, 30, 21, 4, -30 },
  { 8610, 20, 31, 24, 2, -30 },
  { 8688, 17, 37, 19, 1, -36 },
  { 8767, 23, 31, 31, 4, -30 },
  { 8857, 26, 30, 26, 0, -30 },
  { 8955, 39, 30, 41, 1, -30 },
  { 9102, 25, 30, 27, 1, -30 },
  { 9196, 26, 43, 26, 0, -30 },
  { 9336, 19, 30, 23, 2, -30 },
  { 9408, 18, 48, 21, 1, -39 },
  { 9516, 5, 55, 28, 11, -42 },
  { 9551, 17, 48, 21, 2, -39 },
  { 9653, 25, 7, 29, 2, -23 },
};

const GFXfont NotoSans_SemiCondensed_Medium55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium55pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM55PT7B_H_
