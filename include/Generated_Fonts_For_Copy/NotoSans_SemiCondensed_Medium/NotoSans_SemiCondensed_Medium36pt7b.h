#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM36PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium36pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x80, 0x00, 0x19, 0xFF, 0xFB, 0xC0, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1E, 0xE3, 0xDC, 0x73, 0x8E, 0x70, 0xCC, 0x18, 0x01, 0xC3, 0x80, 0x30,
  0x60, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1,
  0x80, 0x18, 0x30, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x1C, 0x38, 0x03, 0x87,
  0x00, 0x70, 0xC0, 0x0C, 0x38, 0x03, 0x87, 0x00, 0x70, 0xE0, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x06, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70,
  0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x30, 0x03, 0x0E, 0x00, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0xFF, 0xC3, 0xFF, 0xEF, 0xFF, 0xBC, 0xC3, 0x79,
  0x80, 0xE3, 0x01, 0xC6, 0x03, 0xCC, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xFC,
  0x03, 0xFE, 0x01, 0xFE, 0x03, 0x7E, 0x06, 0x3C, 0x0C, 0x38, 0x18, 0x70,
  0x31, 0xF8, 0x67, 0xFF, 0xFF, 0x7F, 0xFC, 0x7F, 0xE0, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x38, 0x0F, 0xE0, 0x1C, 0x07,
  0xFC, 0x07, 0x01, 0xC7, 0x03, 0x80, 0x71, 0xC0, 0xE0, 0x1C, 0x38, 0x78,
  0x0F, 0x0E, 0x1C, 0x03, 0x83, 0x8F, 0x00, 0xE0, 0xE3, 0x80, 0x1C, 0x39,
  0xE0, 0x07, 0x0E, 0x71, 0xE1, 0xC7, 0x1C, 0xFC, 0x71, 0xCE, 0x7F, 0x8F,
  0xF3, 0xBC, 0xE3, 0xF9, 0xCE, 0x1C, 0x7C, 0x73, 0x87, 0x00, 0x38, 0xE1,
  0xC0, 0x0E, 0x38, 0x70, 0x07, 0x0E, 0x1C, 0x01, 0xC3, 0x87, 0x00, 0xE0,
  0xE1, 0xC0, 0x38, 0x38, 0x70, 0x1C, 0x0E, 0x1C, 0x07, 0x01, 0xCE, 0x03,
  0x80, 0x7F, 0x80, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x1E, 0x00, 0x70, 0x78, 0x01, 0xC1,
  0xE0, 0x07, 0x07, 0x00, 0x1E, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x81, 0xE3, 0xEF, 0x07, 0x9F,
  0x3E, 0x1E, 0x78, 0x7C, 0xF1, 0xE0, 0xFB, 0xCF, 0x01, 0xFE, 0x3C, 0x03,
  0xF8, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x07, 0xC1, 0xFE, 0x0F, 0xFF, 0xBC,
  0x3F, 0xFC, 0xF8, 0x3F, 0xC1, 0xF0, 0xFF, 0xFF, 0xF7, 0x77, 0x76, 0x07,
  0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0x70, 0xF0, 0xF0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0x70, 0x70,
  0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0xE0, 0x70, 0x78, 0x38, 0x3C,
  0x1C, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x1E, 0x1C, 0x3C, 0x38,
  0x78, 0x70, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0x61,
  0x86, 0x7D, 0xBE, 0xFF, 0xFE, 0x7F, 0xFF, 0x07, 0xC0, 0x07, 0xE0, 0x0E,
  0x70, 0x1E, 0x78, 0x3C, 0x3C, 0x1C, 0x38, 0x04, 0x20, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x3C, 0xF3, 0x9E, 0x79, 0xC7,
  0x1C, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x33, 0xFF, 0xF7, 0x80, 0x00, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3,
  0xC7, 0x83, 0xDE, 0x03, 0xBC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xCF, 0x07, 0x9E, 0x1F,
  0x1F, 0xFC, 0x1F, 0xF0, 0x1F, 0xC0, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F,
  0xFE, 0xFF, 0x3D, 0x8F, 0x43, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x07, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x7C, 0x3E, 0x30,
  0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F,
  0xFC, 0x78, 0x3E, 0x20, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x7C, 0x0F, 0xF8, 0x0F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0xE0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0x78, 0x07, 0x3C, 0x03, 0x9E, 0x03, 0x8F, 0x03, 0xC7,
  0x81, 0xC3, 0xC1, 0xC1, 0xE1, 0xE0, 0xF0, 0xE0, 0x78, 0xF0, 0x3C, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF,
  0xE3, 0xFF, 0xC7, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0x84, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0xB0, 0x1F, 0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0x80, 0x01, 0xFC, 0x0F, 0xF8,
  0x7F, 0xF1, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x9F, 0xC7, 0x7F, 0xCF, 0xFF, 0xDF, 0x07, 0xFC, 0x07,
  0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xEF,
  0x03, 0xDF, 0x0F, 0x1F, 0xFE, 0x1F, 0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x3C, 0x1E, 0x78, 0x0E, 0x78,
  0x0F, 0x78, 0x0F, 0x78, 0x0E, 0x38, 0x1E, 0x3C, 0x1E, 0x1F, 0x7C, 0x0F,
  0xF8, 0x07, 0xE0, 0x0F, 0xF8, 0x1E, 0x7C, 0x3C, 0x3E, 0x78, 0x1F, 0x70,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x78, 0x0F, 0x78, 0x1F, 0x3F,
  0xFE, 0x3F, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C,
  0x3C, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x70, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x3E, 0x7F, 0x3F, 0xFF, 0x1F,
  0xEF, 0x03, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x3F, 0xF8, 0x3F, 0xF0, 0x3F, 0xC0, 0x77, 0xFF, 0xF7,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x7F, 0xFE, 0xF0, 0x39, 0xF7,
  0xDF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xF7,
  0x9E, 0x79, 0xC7, 0x38, 0xE0, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x3F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00,
  0x1F, 0xC3, 0xFF, 0xC7, 0xFF, 0x9C, 0x1E, 0x40, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0x1E, 0x07, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x7E, 0x0E,
  0x70, 0x7F, 0xC3, 0x9C, 0x3F, 0xF0, 0xEE, 0x0E, 0x1C, 0x3B, 0x87, 0x07,
  0x06, 0xE1, 0xC1, 0xC1, 0xF8, 0x70, 0x70, 0x7E, 0x3C, 0x1C, 0x1B, 0x8F,
  0x07, 0x06, 0xE3, 0xC1, 0xC3, 0xB8, 0x70, 0x70, 0xEE, 0x1C, 0x3C, 0x33,
  0x87, 0xFF, 0xFC, 0xE0, 0xFE, 0x7E, 0x1C, 0x1F, 0x0F, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x08, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xC0, 0x00, 0xEE,
  0x00, 0x0F, 0x78, 0x00, 0x79, 0xC0, 0x03, 0x8E, 0x00, 0x3C, 0x78, 0x01,
  0xE3, 0xC0, 0x0E, 0x0E, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3C, 0x0E,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x78,
  0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF,
  0x9E, 0x1F, 0xCF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0,
  0x0F, 0x78, 0x07, 0x3C, 0x0F, 0x9F, 0xFF, 0x8F, 0xFF, 0x07, 0xFF, 0xE3,
  0xC0, 0xF9, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F,
  0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xF0, 0xF3, 0xE0,
  0x09, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xFC, 0x06, 0x3F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80,
  0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x01, 0xF1, 0xE0, 0x1F,
  0x3C, 0x01, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x00, 0xF9,
  0xE0, 0x3E, 0x3C, 0x1F, 0xC7, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x8F, 0xE1, 0xE3,
  0xF0, 0x04, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xFF, 0xE0, 0x3F, 0xFC,
  0x07, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1D, 0xE0, 0x03, 0xBC,
  0x00, 0x77, 0xC0, 0x0E, 0x7C, 0x01, 0xC7, 0xC0, 0x38, 0xFF, 0xFF, 0x07,
  0xFF, 0xE0, 0x7F, 0xF8, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE1, 0xFE, 0xFF, 0xFF, 0xF0,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF4, 0xFB, 0xFD, 0xFC,
  0xF8, 0x00, 0xF0, 0x07, 0xBC, 0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF0,
  0x3C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xC0, 0xF1, 0xE0, 0x3C, 0xF0,
  0x0F, 0x3C, 0x03, 0xDE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03,
  0xE7, 0x80, 0xF1, 0xF0, 0x3C, 0x3C, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xF0,
  0x3C, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x0F, 0xBC, 0x01,
  0xF0, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0x70, 0x03, 0xFF, 0xB8, 0x01, 0xDF, 0xDE, 0x00, 0xEF, 0xF7, 0x00, 0xF7,
  0xFB, 0x80, 0x73, 0xFD, 0xE0, 0x39, 0xFE, 0x70, 0x3C, 0xFF, 0x38, 0x1C,
  0x7F, 0x9E, 0x0E, 0x3F, 0xC7, 0x0F, 0x1F, 0xE3, 0x87, 0x0F, 0xF1, 0xE3,
  0x87, 0xF8, 0x73, 0xC3, 0xFC, 0x39, 0xC1, 0xFE, 0x1E, 0xE0, 0xFF, 0x07,
  0xF0, 0x7F, 0x83, 0xF0, 0x3F, 0xC1, 0xF8, 0x1F, 0xE0, 0x7C, 0x0F, 0xF0,
  0x3C, 0x07, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01, 0xFB, 0xC0, 0x3F, 0x3C,
  0x07, 0xE7, 0x80, 0xFE, 0x78, 0x1F, 0xCF, 0x03, 0xF8, 0xF0, 0x7F, 0x1E,
  0x0F, 0xE1, 0xE1, 0xFC, 0x3E, 0x3F, 0x83, 0xC7, 0xF0, 0x3C, 0xFE, 0x07,
  0x9F, 0xC0, 0x7B, 0xF8, 0x0F, 0x7F, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x0F, 0xC3, 0xE0, 0x1E, 0x3E, 0x00, 0xF9,
  0xE0, 0x03, 0xCF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01,
  0xE7, 0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0xFC, 0x1F, 0x83, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x01, 0xFF, 0xE3, 0xFF, 0xE7, 0xFF,
  0xEF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x81, 0xFF, 0x07, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF0, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0x0F, 0xC3, 0xE0, 0x1E, 0x3E, 0x00, 0xF9, 0xE0, 0x03,
  0xCF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0xC0,
  0x0F, 0x1E, 0x00, 0xF8, 0xFC, 0x1F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0xFF, 0x80, 0x7F, 0xF8, 0x3F, 0xFF,
  0x1F, 0xFF, 0x8F, 0x03, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x1C, 0xF0,
  0x0E, 0x78, 0x0F, 0x3C, 0x07, 0x9E, 0x07, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3,
  0xFF, 0x81, 0xFF, 0xC0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x07,
  0x8F, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x03, 0xC0, 0x0F, 0xF0, 0x7F, 0xF9, 0xFF, 0xF3, 0xF3, 0xCF, 0x00, 0x9E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xD0, 0x07, 0xB8, 0x1F, 0x7F, 0xFC, 0xFF,
  0xF0, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xDE, 0x01, 0xE7, 0xC0, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF,
  0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xE7, 0x80, 0x1E, 0x78,
  0x01, 0xE3, 0x80, 0x1C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x1C, 0x03, 0xC1,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x03, 0x9C,
  0x00, 0x39, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF0, 0x03, 0x80, 0x1F, 0xE0, 0x0F,
  0x80, 0x3D, 0xE0, 0x1F, 0x00, 0x73, 0xC0, 0x3E, 0x01, 0xE7, 0x80, 0x7C,
  0x03, 0xCF, 0x01, 0xDC, 0x07, 0x8E, 0x03, 0xB8, 0x0E, 0x1E, 0x07, 0x70,
  0x3C, 0x3C, 0x0E, 0xE0, 0x78, 0x78, 0x3D, 0xE0, 0xF0, 0x70, 0x71, 0xC1,
  0xC0, 0xF0, 0xE3, 0x87, 0x81, 0xE1, 0xC7, 0x0F, 0x03, 0xC7, 0x8F, 0x1E,
  0x03, 0x8E, 0x0E, 0x38, 0x07, 0x1C, 0x1C, 0x70, 0x0F, 0x38, 0x39, 0xE0,
  0x1E, 0xF0, 0x7B, 0xC0, 0x1D, 0xC0, 0x77, 0x00, 0x3B, 0x80, 0xEE, 0x00,
  0x77, 0x01, 0xDC, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x01,
  0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xEF, 0x00, 0x78, 0xF0, 0x0F, 0x1F, 0x03, 0xC1, 0xE0, 0x78, 0x1E,
  0x1E, 0x03, 0xC3, 0x80, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x07, 0xBC, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x07, 0x87, 0x81, 0xE0,
  0xF0, 0x3C, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x78, 0x03, 0xFE, 0x00,
  0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x1C, 0x03, 0xC3, 0xC0,
  0x78, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x70, 0x0F, 0x1E, 0x01, 0xE3,
  0x80, 0x1E, 0xF0, 0x03, 0xDC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3B, 0x80, 0x39, 0xE0, 0x1C, 0x70, 0x1E,
  0x3C, 0x0E, 0x0E, 0x0F, 0x07, 0x87, 0x01, 0xC3, 0x80, 0xF3, 0x80, 0x39,
  0xC0, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x78,
  0x3C, 0x1E, 0x0E, 0x07, 0x01, 0xE0, 0x3F, 0xF0, 0xFF, 0xF0, 0xE1, 0xF1,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x03, 0xFE, 0x3F, 0xFC, 0xFF,
  0xFB, 0xE0, 0xF7, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x78, 0x3E,
  0xFF, 0xFC, 0xFF, 0xB8, 0xFE, 0x70, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE1, 0xE0, 0xE7, 0xF0,
  0xEF, 0xFC, 0xFC, 0xFC, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x3C, 0xFF, 0xFC, 0xEF, 0xF8, 0xE7, 0xF0,
  0x03, 0xE0, 0xFF, 0xCF, 0xFE, 0xFC, 0xE7, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x7C, 0x09, 0xFF, 0xCF, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x07,
  0x0F, 0x1F, 0xEF, 0x3F, 0xFF, 0x7E, 0xFF, 0x78, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78, 0x3F, 0x7F, 0xFF, 0x3F,
  0xEF, 0x1F, 0xC7, 0x03, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3, 0xE7, 0x83,
  0xDE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x04, 0x7F,
  0xF8, 0x7F, 0xF0, 0x7F, 0xC0, 0x00, 0xC0, 0x3F, 0xC1, 0xFE, 0x1F, 0xE0,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x03, 0xFF, 0x3F, 0xF8, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0x07, 0x80, 0x1F, 0xEF, 0x3F, 0xFF, 0x7E, 0x7F, 0x78,
  0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x78,
  0x3F, 0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x40, 0x1E, 0x7E, 0xFC, 0x7F, 0xFC, 0x7F, 0xF0, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0xF0, 0xE7, 0xF9, 0xDF, 0xFB, 0xF9, 0xF7, 0xC1, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x78, 0x73, 0xFE, 0xE2, 0x00, 0x00, 0x73, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0x0E, 0x0E, 0x1F,
  0x0E, 0x04, 0x00, 0x00, 0x00, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0xBE, 0xFE, 0xFC, 0x60, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xE0, 0x3D, 0xC0, 0xF3, 0x83, 0xC7, 0x0F, 0x0E, 0x1E, 0x1C, 0x78, 0x39,
  0xE0, 0x77, 0x80, 0xEF, 0x81, 0xFF, 0x03, 0xEF, 0x07, 0x9E, 0x0E, 0x1E,
  0x1C, 0x1E, 0x38, 0x3C, 0x70, 0x3C, 0xE0, 0x7D, 0xC0, 0x7B, 0x80, 0x78,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xE0, 0x78, 0x73, 0xF8, 0xFF, 0x3B, 0xFE, 0xFF, 0xDF, 0x9F, 0xFB, 0xFF,
  0x83, 0xF0, 0x7F, 0x81, 0xF0, 0x3F, 0xC0, 0x78, 0x1F, 0xE0, 0x38, 0x07,
  0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03, 0x80,
  0x7E, 0x01, 0xC0, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38,
  0x07, 0xE0, 0x1C, 0x03, 0xF0, 0x0E, 0x01, 0xF8, 0x07, 0x00, 0xFC, 0x03,
  0x80, 0x70, 0x01, 0xC1, 0xCF, 0xF3, 0xBF, 0xF7, 0xF3, 0xEF, 0x83, 0xFE,
  0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7C,
  0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E,
  0x78, 0x1E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0xE0, 0xE7, 0xF8,
  0xEF, 0xFC, 0xFC, 0x7C, 0xF8, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0E,
  0xF0, 0x1E, 0xF0, 0x1E, 0xF8, 0x3C, 0xFF, 0xFC, 0xEF, 0xF8, 0xE7, 0xF0,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x1F, 0xEF, 0x3F, 0xFF,
  0x7E, 0x7F, 0x78, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0x78, 0x3F, 0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x01, 0xF9, 0xFE, 0xFF, 0xBF, 0xFC, 0x3E, 0x0F,
  0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0x0E, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0x80, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x7E, 0x01,
  0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xEF, 0xF8, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0xC1, 0xFF, 0xBF, 0xF1, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xC7, 0xF8, 0x7F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xFC, 0x0F,
  0xF8, 0x3F, 0xFF, 0xFE, 0xFF, 0x9C, 0xFE, 0x38, 0xF0, 0x07, 0xB8, 0x03,
  0xDE, 0x03, 0xCF, 0x01, 0xE3, 0x80, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x38,
  0x38, 0x1E, 0x1C, 0x0F, 0x1E, 0x03, 0x8E, 0x01, 0xE7, 0x00, 0xF7, 0x80,
  0x3B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF0, 0x1F, 0x03, 0xDE, 0x07, 0xC0, 0xF7, 0x81, 0xF0, 0x3D, 0xE0,
  0xFC, 0x0E, 0x38, 0x3B, 0x87, 0x8E, 0x0E, 0xE1, 0xE3, 0xC7, 0xB8, 0x78,
  0xF1, 0xCE, 0x1C, 0x1C, 0x71, 0xCF, 0x07, 0x1C, 0x73, 0xC1, 0xEF, 0x1C,
  0xE0, 0x7B, 0x87, 0x38, 0x0E, 0xE0, 0xEE, 0x03, 0xB8, 0x3F, 0x80, 0xEE,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x00,
  0x7C, 0x07, 0x80, 0x78, 0x0F, 0x9E, 0x07, 0x87, 0x87, 0x83, 0xC7, 0x80,
  0xF3, 0xC0, 0x7B, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xF7, 0x80, 0x79, 0xE0, 0x78, 0xF0, 0x3C,
  0x3C, 0x3C, 0x0F, 0x3C, 0x07, 0xBE, 0x01, 0xE0, 0xF0, 0x07, 0xBC, 0x03,
  0xDE, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0xF1, 0xE0, 0xF0, 0x70, 0x78, 0x3C,
  0x3C, 0x1E, 0x1C, 0x07, 0x1E, 0x03, 0x8F, 0x01, 0xE7, 0x00, 0x77, 0x80,
  0x3B, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x5F,
  0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0E, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFE, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x60, 0x7C, 0x1F, 0x87, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x3F, 0x87,
  0xC0, 0xF8, 0x1F, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x03, 0xF0, 0x1F, 0x01, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E,
  0x01, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x03, 0xE1, 0xF8, 0x3E, 0x07,
  0x00, 0x3F, 0x01, 0x7F, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x3C,
};

const GFXglyph NotoSans_SemiCondensed_Medium36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 26, 9, 2, -26 },
  { 18, 11, 10, 15, 2, -26 },
  { 32, 19, 26, 21, 1, -26 },
  { 94, 15, 29, 19, 2, -27 },
  { 149, 26, 26, 29, 1, -26 },
  { 234, 22, 26, 23, 1, -26 },
  { 306, 4, 10, 8, 2, -26 },
  { 311, 8, 32, 11, 2, -26 },
  { 343, 8, 32, 11, 1, -26 },
  { 375, 16, 15, 18, 1, -27 },
  { 405, 16, 17, 19, 1, -21 },
  { 439, 6, 9, 9, 1, -4 },
  { 446, 9, 3, 11, 1, -11 },
  { 450, 5, 5, 9, 2, -5 },
  { 454, 13, 26, 14, 0, -26 },
  { 497, 15, 26, 19, 2, -26 },
  { 546, 10, 26, 19, 3, -26 },
  { 579, 16, 26, 19, 1, -26 },
  { 631, 16, 26, 19, 1, -26 },
  { 683, 17, 26, 19, 1, -26 },
  { 739, 15, 26, 19, 2, -26 },
  { 788, 15, 26, 19, 2, -26 },
  { 837, 16, 26, 19, 1, -26 },
  { 889, 16, 26, 19, 1, -26 },
  { 941, 16, 26, 19, 1, -26 },
  { 993, 5, 20, 9, 2, -20 },
  { 1006, 6, 25, 9, 1, -20 },
  { 1025, 16, 18, 19, 1, -22 },
  { 1061, 15, 10, 19, 2, -18 },
  { 1080, 16, 18, 19, 1, -22 },
  { 1116, 14, 26, 15, 0, -26 },
  { 1162, 26, 29, 29, 2, -26 },
  { 1257, 21, 26, 21, 0, -26 },
  { 1326, 17, 26, 21, 3, -26 },
  { 1382, 17, 26, 21, 2, -26 },
  { 1438, 19, 26, 24, 3, -26 },
  { 1500, 13, 26, 18, 3, -26 },
  { 1543, 13, 26, 17, 3, -26 },
  { 1586, 19, 26, 24, 2, -26 },
  { 1648, 18, 26, 24, 3, -26 },
  { 1707, 10, 26, 12, 1, -26 },
  { 1740, 9, 33, 10, -2, -26 },
  { 1778, 18, 26, 21, 3, -26 },
  { 1837, 13, 26, 17, 3, -26 },
  { 1880, 25, 26, 31, 3, -26 },
  { 1962, 19, 26, 25, 3, -26 },
  { 2024, 21, 26, 25, 2, -26 },
  { 2093, 15, 26, 20, 3, -26 },
  { 2142, 21, 32, 25, 2, -26 },
  { 2226, 17, 26, 21, 3, -26 },
  { 2282, 15, 26, 18, 2, -26 },
  { 2331, 18, 26, 18, 0, -26 },
  { 2390, 18, 26, 24, 3, -26 },
  { 2449, 20, 26, 20, 0, -26 },
  { 2514, 31, 26, 31, 0, -26 },
  { 2615, 19, 26, 19, 0, -26 },
  { 2677, 19, 26, 19, 0, -26 },
  { 2739, 16, 26, 18, 1, -26 },
  { 2791, 8, 32, 12, 3, -26 },
  { 2823, 13, 26, 14, 0, -26 },
  { 2866, 8, 32, 12, 1, -26 },
  { 2898, 17, 16, 19, 1, -26 },
  { 2932, 16, 3, 16, 0, 3 },
  { 2938, 8, 6, 11, 1, -28 },
  { 2944, 15, 20, 19, 1, -20 },
  { 2982, 16, 27, 20, 3, -27 },
  { 3036, 13, 20, 16, 2, -20 },
  { 3069, 16, 27, 20, 2, -27 },
  { 3123, 15, 20, 19, 2, -20 },
  { 3161, 13, 28, 12, 0, -28 },
  { 3207, 16, 29, 20, 2, -20 },
  { 3265, 15, 27, 20, 3, -27 },
  { 3316, 5, 27, 9, 2, -27 },
  { 3333, 8, 36, 9, -1, -27 },
  { 3369, 15, 27, 18, 3, -27 },
  { 3420, 3, 27, 9, 3, -27 },
  { 3431, 25, 20, 31, 3, -20 },
  { 3494, 15, 20, 20, 3, -20 },
  { 3532, 16, 20, 20, 2, -20 },
  { 3572, 16, 29, 20, 3, -20 },
  { 3630, 16, 29, 20, 2, -20 },
  { 3688, 10, 20, 14, 3, -20 },
  { 3713, 12, 20, 16, 2, -20 },
  { 3743, 11, 24, 12, 1, -24 },
  { 3776, 15, 19, 20, 3, -19 },
  { 3812, 17, 19, 17, 0, -19 },
  { 3853, 26, 19, 27, 0, -19 },
  { 3915, 17, 19, 18, 0, -19 },
  { 3956, 17, 28, 17, 0, -19 },
  { 4016, 13, 19, 15, 1, -19 },
  { 4047, 11, 32, 13, 1, -26 },
  { 4091, 4, 36, 18, 7, -27 },
  { 4109, 11, 32, 13, 1, -26 },
  { 4153, 16, 5, 19, 1, -15 },
};

const GFXfont NotoSans_SemiCondensed_Medium36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium36pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM36PT7B_H_
