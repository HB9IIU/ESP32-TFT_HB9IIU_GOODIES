#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM50PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium50pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFD, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x8F, 0x1E, 0x3C, 0x70,
  0x00, 0x00, 0x02, 0x1F, 0x7F, 0xFF, 0xFF, 0xFB, 0xE1, 0x00, 0xF8, 0x7F,
  0xF0, 0xFF, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xBE, 0x0F, 0x3C,
  0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x83, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0,
  0x1F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x78,
  0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xF8, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x0F,
  0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x1F, 0xE0, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE7, 0xE3, 0x83, 0x3E, 0x1C, 0x01, 0xF0, 0xE0, 0x0F, 0x07, 0x00, 0x7C,
  0x38, 0x03, 0xE1, 0xC0, 0x1F, 0x8E, 0x00, 0xFF, 0x70, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x0E, 0xFE, 0x00, 0x71, 0xF0, 0x03, 0x87, 0xC0, 0x1C, 0x3E,
  0x00, 0xE1, 0xF0, 0x07, 0x0F, 0xC0, 0x38, 0xFB, 0x81, 0xCF, 0xDF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0x3F, 0xF0,
  0x01, 0xF0, 0x07, 0xEF, 0x80, 0x1E, 0x00, 0x78, 0x78, 0x03, 0xE0, 0x07,
  0x83, 0xC0, 0x3C, 0x00, 0xF8, 0x3C, 0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x78,
  0x00, 0xF0, 0x3C, 0x0F, 0x80, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C,
  0x1F, 0x00, 0x0F, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x3C, 0x3E, 0x00, 0x0F,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x3C, 0x7C, 0x3E, 0x0F, 0x83, 0xC7, 0x8F,
  0xF8, 0x78, 0x3C, 0xF9, 0xFF, 0x87, 0x87, 0x8F, 0x1F, 0xFC, 0x7F, 0xF8,
  0xF3, 0xE3, 0xE3, 0xFF, 0x1E, 0x3C, 0x1E, 0x1F, 0xF1, 0xE3, 0xC1, 0xE0,
  0xFC, 0x3C, 0x3C, 0x1E, 0x00, 0x03, 0xC7, 0xC1, 0xF0, 0x00, 0x78, 0x7C,
  0x1F, 0x00, 0x07, 0x87, 0xC1, 0xF0, 0x00, 0xF0, 0x7C, 0x1F, 0x00, 0x0F,
  0x07, 0xC1, 0xF0, 0x01, 0xE0, 0x7C, 0x1F, 0x00, 0x1E, 0x03, 0xC1, 0xE0,
  0x03, 0xC0, 0x3C, 0x1E, 0x00, 0x3C, 0x03, 0xC1, 0xE0, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x80, 0x1F, 0xFC, 0x00, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0xFB, 0xF8,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x07, 0xE0, 0xFF, 0xF8, 0x0F,
  0x83, 0xF3, 0xF8, 0x1F, 0x0F, 0xC3, 0xF8, 0x3E, 0x1F, 0x03, 0xF0, 0xFC,
  0x7E, 0x03, 0xF1, 0xF0, 0xFC, 0x03, 0xF7, 0xE1, 0xF0, 0x03, 0xFF, 0x83,
  0xE0, 0x03, 0xFF, 0x07, 0xC0, 0x03, 0xFC, 0x0F, 0xC0, 0x07, 0xF8, 0x1F,
  0x80, 0x0F, 0xF0, 0x1F, 0x80, 0x3F, 0xF0, 0x3F, 0x81, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE7, 0xE0, 0x3F, 0xFF, 0x07, 0xE0, 0x3F,
  0xF8, 0x07, 0xF0, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0x7B, 0xDE, 0xF7, 0x80, 0x01, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x1F, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03,
  0xE0, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x03, 0x01, 0xC0, 0x5F, 0x8E,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0xF3, 0xE0, 0x0F, 0x8F,
  0x80, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x1E, 0x0F, 0x00, 0x20, 0x20, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x7C,
  0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x18, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F, 0xCF, 0xE0, 0xFC, 0x0F, 0xC3,
  0xE0, 0x1F, 0x1F, 0x80, 0x7E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0x7C, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E,
  0x7E, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xF0, 0x3F, 0x07, 0xE1, 0xFC, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x30,
  0x00, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3,
  0xF7, 0xDF, 0xBF, 0xFC, 0xFF, 0xE3, 0xF7, 0x0F, 0xC8, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x03, 0xFE, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0xFF, 0x0F, 0xF1, 0xF0, 0x0F, 0xC3, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0x7F, 0xFE,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7E, 0x0F, 0xF0, 0xE0, 0x0F, 0xC2,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE8, 0x00, 0x3F, 0xBC, 0x01, 0xFC, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3D,
  0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xF1,
  0xF0, 0x01, 0xE1, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xC1, 0xF0, 0x07, 0xC1,
  0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE,
  0x0E, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xFA, 0x00, 0x1F, 0x9E, 0x03,
  0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x01,
  0xFF, 0xFC, 0x0F, 0xF0, 0x10, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x70, 0x07, 0x8F, 0xF8, 0x1E, 0x7F, 0xF8, 0xFB,
  0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xF0, 0x1F, 0xBF, 0x80, 0x3E, 0xFC, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0x7C, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7E, 0x00, 0xFC, 0xF8,
  0x03, 0xE3, 0xF0, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x7F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0x03, 0xF1, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00,
  0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x7E, 0x3F, 0x01, 0xF0,
  0x7E, 0x0F, 0x81, 0xFC, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x3F, 0x8F, 0xE0, 0xFC, 0x0F,
  0xC7, 0xE0, 0x1F, 0x9F, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xF7, 0xC0,
  0x0F, 0x9F, 0x80, 0x7E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x01,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x8F, 0xE1, 0xF8, 0x0F, 0xC7, 0xC0,
  0x1F, 0x1F, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x3F, 0x7C, 0x01, 0xFD, 0xF8, 0x0F, 0xF7, 0xF8, 0x7F, 0xCF, 0xFF,
  0xDF, 0x1F, 0xFE, 0x7C, 0x3F, 0xF1, 0xE0, 0x3F, 0x8F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xFF,
  0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x02, 0x00, 0x00,
  0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x8E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x0F, 0xBF, 0xFF, 0xFF, 0xFD, 0xF1,
  0x80, 0x3E, 0x7F, 0x7F, 0x7F, 0x7F, 0x3E, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E,
  0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0xE0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7,
  0xE1, 0xFC, 0x60, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00,
  0x00, 0xF8, 0xF0, 0x0F, 0xFC, 0x0F, 0x3E, 0x03, 0xFF, 0xC1, 0xE7, 0x80,
  0xFF, 0xF8, 0x1E, 0xF0, 0x3E, 0x0F, 0x03, 0xFE, 0x0F, 0x81, 0xE0, 0x7F,
  0x81, 0xE0, 0x3C, 0x0F, 0xF0, 0x7C, 0x07, 0x81, 0xFE, 0x0F, 0x00, 0xF0,
  0x3F, 0xC1, 0xE0, 0x1E, 0x07, 0xF8, 0x3C, 0x03, 0xC0, 0xFF, 0x07, 0x80,
  0x78, 0x1F, 0xE0, 0xF0, 0x0F, 0x03, 0xFC, 0x1E, 0x03, 0xE0, 0x7F, 0x83,
  0xC0, 0x7C, 0x0F, 0xF0, 0x78, 0x0F, 0x83, 0xDE, 0x0F, 0x83, 0xF0, 0x7B,
  0xC0, 0xF8, 0xFF, 0x1E, 0x78, 0x1F, 0xFC, 0xFF, 0xCF, 0x81, 0xFF, 0x9F,
  0xF0, 0xF0, 0x1F, 0xC1, 0xFC, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07,
  0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF0,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0x80, 0x3F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0xFC,
  0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0,
  0x0F, 0xDF, 0x80, 0x1F, 0x3F, 0x00, 0x7E, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xC0, 0x1F,
  0xDF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x3F, 0x7E, 0x07, 0xFE, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFC, 0x7E, 0x1F,
  0xE0, 0x06, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x02, 0x1F, 0xF0, 0x1E, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0xFF, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x01,
  0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0,
  0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x3F,
  0x8F, 0xC0, 0x1F, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xE1, 0xF8, 0x1F, 0xC0, 0x03, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0x7F,
  0x80, 0x7F, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x00, 0x30, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x7F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x07,
  0xFF, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xC0, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x8F, 0xC0, 0x1F, 0x87,
  0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0,
  0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x0F, 0xC7, 0xE0,
  0x07, 0xE3, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xF7,
  0xE0, 0x07, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F,
  0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xF0, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFB, 0xC0, 0x00, 0xFF, 0xFE, 0xF8, 0x00, 0x3D, 0xFF, 0xBE, 0x00,
  0x1F, 0x7F, 0xE7, 0x80, 0x07, 0x9F, 0xF9, 0xF0, 0x01, 0xE7, 0xFE, 0x7C,
  0x00, 0xF9, 0xFF, 0x8F, 0x00, 0x3C, 0x7F, 0xE3, 0xE0, 0x0F, 0x1F, 0xF8,
  0xF8, 0x07, 0xC7, 0xFE, 0x1E, 0x01, 0xE1, 0xFF, 0x87, 0xC0, 0x78, 0x7F,
  0xE1, 0xF0, 0x3E, 0x1F, 0xF8, 0x3C, 0x0F, 0x07, 0xFE, 0x0F, 0x83, 0xC1,
  0xFF, 0x83, 0xE1, 0xF0, 0x7F, 0xE0, 0x78, 0x78, 0x1F, 0xF8, 0x1F, 0x1E,
  0x07, 0xFE, 0x07, 0xCF, 0x81, 0xFF, 0x80, 0xF3, 0xC0, 0x7F, 0xE0, 0x3E,
  0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFE,
  0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xE0, 0x07, 0x80, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xFB, 0xE0, 0x03, 0xFF, 0x7E, 0x00, 0x7F, 0xE7, 0xC0,
  0x0F, 0xFC, 0xFC, 0x01, 0xFF, 0x8F, 0x80, 0x3F, 0xF1, 0xF8, 0x07, 0xFE,
  0x1F, 0x80, 0xFF, 0xC3, 0xF0, 0x1F, 0xF8, 0x3F, 0x03, 0xFF, 0x07, 0xE0,
  0x7F, 0xE0, 0x7E, 0x0F, 0xFC, 0x07, 0xC1, 0xFF, 0x80, 0xFC, 0x3F, 0xF0,
  0x0F, 0x87, 0xFE, 0x01, 0xF8, 0xFF, 0xC0, 0x1F, 0x9F, 0xF8, 0x03, 0xF3,
  0xFF, 0x00, 0x3F, 0x7F, 0xE0, 0x07, 0xEF, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0x8F, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x1F,
  0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF0, 0x1F, 0xCF, 0xC0, 0x1F,
  0xBF, 0x00, 0x7E, 0xFC, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00,
  0x7E, 0xFC, 0x03, 0xFB, 0xF0, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF,
  0x8F, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x3F,
  0x03, 0xFE, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00,
  0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFC, 0x1F,
  0x80, 0xFC, 0x0F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0xFC, 0x07,
  0xE0, 0xFC, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x87, 0xFF, 0xFC,
  0x7F, 0xFF, 0xE3, 0xFE, 0xFE, 0x3F, 0x80, 0x31, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00,
  0x0F, 0xDF, 0x81, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xF0, 0x01, 0xF9,
  0xFC, 0x01, 0xFC, 0x7F, 0x81, 0xFC, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F,
  0x81, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x07,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xEF, 0x80, 0x03,
  0xE0, 0x00, 0xFD, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0xC0,
  0x03, 0xE7, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x8F, 0x80, 0x1F, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xDE, 0x00, 0x7C, 0x3E,
  0x00, 0x7B, 0xC0, 0x0F, 0x87, 0xE0, 0x0F, 0x78, 0x03, 0xF0, 0x7C, 0x03,
  0xEF, 0x80, 0x7C, 0x0F, 0x80, 0x7D, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x3E,
  0x01, 0xF0, 0x3F, 0x01, 0xE3, 0xC0, 0x3E, 0x03, 0xE0, 0x7C, 0x7C, 0x0F,
  0x80, 0x7C, 0x0F, 0x8F, 0x81, 0xF0, 0x0F, 0x81, 0xE0, 0xF0, 0x3E, 0x01,
  0xF0, 0x3C, 0x1E, 0x07, 0xC0, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x03, 0xE1,
  0xF0, 0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x07, 0x87, 0xC0, 0x0F, 0x87, 0x80,
  0xF0, 0xF8, 0x00, 0xF9, 0xF0, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x03, 0xE7,
  0xC0, 0x03, 0xE7, 0x80, 0x3C, 0xF8, 0x00, 0x7C, 0xF0, 0x07, 0x9F, 0x00,
  0x07, 0x9E, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC7, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0xFC,
  0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x0F,
  0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0x9F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x07,
  0xE0, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x01,
  0xF1, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xDF,
  0x00, 0x03, 0xF7, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x03,
  0xE1, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0xC0, 0x03, 0xC3, 0xC0, 0x03,
  0xC3, 0xE0, 0x07, 0xC1, 0xE0, 0x07, 0x81, 0xF0, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF8, 0x1F, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x3E, 0x00, 0x3C, 0x3C,
  0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x07, 0xFF, 0x01,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0C, 0x03, 0xF0, 0x80, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0x81, 0xF7, 0xE0,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xF7, 0xFF, 0xEF, 0x7F, 0xFE, 0xF3,
  0xFF, 0xCF, 0x1F, 0xF0, 0x70, 0x10, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x3F, 0xC0, 0xF9, 0xFF, 0xC3, 0xEF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x3F, 0xC0, 0xFC, 0xFE, 0x01, 0xFB, 0xF0, 0x07, 0xEF, 0xC0, 0x0F, 0xBE,
  0x00, 0x3E, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x7E, 0xFE,
  0x01, 0xFB, 0xFC, 0x0F, 0xCF, 0xFF, 0xFF, 0x3D, 0xFF, 0xF8, 0xF3, 0xFF,
  0xC3, 0xC3, 0xFC, 0x00, 0x00, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF8, 0x1C, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x4F,
  0xE0, 0x30, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0x08, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0xE3,
  0xF0, 0x7F, 0xF3, 0xE1, 0xFF, 0xF7, 0xC7, 0xFF, 0xFF, 0x9F, 0xC1, 0xFF,
  0x3F, 0x00, 0xFE, 0xFC, 0x01, 0xFD, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xF7,
  0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0,
  0x07, 0xEF, 0x80, 0x0F, 0xDF, 0x00, 0x1F, 0xBF, 0x00, 0x7F, 0x3F, 0x00,
  0xFE, 0x7F, 0x03, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFD, 0xF0, 0xFF, 0xF3,
  0xE0, 0x7F, 0x87, 0xC0, 0x18, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x03, 0xF0, 0xF8, 0x07, 0xE3,
  0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x21, 0xF8, 0x03, 0x87, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0x01, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0xE0, 0xFC, 0x10, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x07,
  0xFF, 0xCF, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x3E,
  0x0F, 0xFE, 0x7C, 0x3F, 0xFE, 0xF8, 0xFF, 0xFF, 0xF3, 0xF8, 0x3F, 0xE7,
  0xE0, 0x1F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8,
  0x00, 0xFD, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0xF8, 0x00,
  0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xE7, 0xE0, 0x1F,
  0xCF, 0xE0, 0x7F, 0x8F, 0xFF, 0xDF, 0x1F, 0xFF, 0xBE, 0x1F, 0xFE, 0x7C,
  0x0F, 0xF1, 0xF8, 0x03, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x60, 0x03, 0xF0, 0xFC,
  0x3F, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF1, 0xFF, 0x0F, 0x9F, 0xFC,
  0x7D, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xE0, 0x7E, 0xFE, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7C, 0x79, 0xFF, 0xFF, 0x7C, 0xE0, 0x00,
  0x00, 0x07, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7C, 0x03, 0xC0,
  0x7C, 0x1F, 0x83, 0xF0, 0x3E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF8, 0xFD,
  0xFF, 0xBF, 0xE7, 0xF8, 0xFE, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x03, 0xFF, 0x80, 0x3E, 0x7C, 0x03, 0xF3, 0xE0, 0x3F, 0x1F, 0x03, 0xF0,
  0xF8, 0x3F, 0x07, 0xC1, 0xF0, 0x3E, 0x1F, 0x01, 0xF1, 0xF8, 0x0F, 0x9F,
  0x80, 0x7D, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x3F, 0xBF, 0x01, 0xF8, 0xFC, 0x0F, 0x83, 0xE0, 0x7C, 0x1F,
  0x83, 0xE0, 0x7C, 0x1F, 0x03, 0xF0, 0xF8, 0x0F, 0xC7, 0xC0, 0x3E, 0x3E,
  0x01, 0xF9, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x7C, 0x00, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xFF,
  0x01, 0xFE, 0x1E, 0x7F, 0xF8, 0xFF, 0xF3, 0xDF, 0xFF, 0xBF, 0xFF, 0x7B,
  0xFF, 0xF7, 0xFF, 0xEF, 0xF0, 0x7F, 0xE0, 0xFF, 0xFC, 0x07, 0xF8, 0x0F,
  0xFF, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x01, 0xF0,
  0x03, 0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0xFC, 0x00,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xFE,
  0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x03,
  0xFF, 0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x00,
  0x7C, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x03, 0xFF,
  0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0xFF, 0x87,
  0x8F, 0xFE, 0x3C, 0xFF, 0xF9, 0xEF, 0xFF, 0xEF, 0xF0, 0x3F, 0x7F, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0x01, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x1F, 0x87, 0xE0,
  0x1F, 0x9F, 0x80, 0x1F, 0x3F, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF0, 0x01, 0xFB, 0xF0, 0x03, 0xF3, 0xE0, 0x07, 0xC7, 0xE0, 0x1F, 0x87,
  0xE0, 0x7E, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x00, 0x80, 0x00, 0xF0, 0xFF, 0x03, 0xC7, 0xFF, 0x0F, 0x3F,
  0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0x03, 0xF3, 0xF8, 0x07, 0xEF, 0xC0, 0x1F,
  0xBF, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xBF, 0x00, 0x3E,
  0xFC, 0x01, 0xFB, 0xF8, 0x07, 0xEF, 0xF0, 0x3F, 0x3F, 0xFF, 0xFC, 0xFB,
  0xFF, 0xE3, 0xE7, 0xFF, 0x0F, 0x8F, 0xF0, 0x3E, 0x02, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x3E, 0x0F, 0xFE, 0x7C, 0x3F,
  0xFE, 0xF8, 0xFF, 0xFD, 0xF3, 0xF8, 0x3F, 0xE7, 0xE0, 0x1F, 0xDF, 0x80,
  0x3F, 0xBF, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB,
  0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xE7, 0xE0, 0x1F, 0xCF, 0xE0, 0x7F, 0x8F,
  0xFF, 0xDF, 0x1F, 0xFF, 0xBE, 0x1F, 0xFE, 0x7C, 0x0F, 0xF1, 0xF8, 0x03,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xF0, 0xFF,
  0xE3, 0xFB, 0xCF, 0xF7, 0xBF, 0xEF, 0x7E, 0xDF, 0xE0, 0x3F, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x0F, 0xFE, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFE, 0xFC, 0x03,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x03,
  0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xE0, 0x03, 0xFE, 0x01, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x83,
  0xFF, 0xC0, 0x06, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFF,
  0xC3, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x00, 0x40, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x3F, 0xEF, 0xFF, 0xFF, 0x7F,
  0xFE, 0xF9, 0xFF, 0xE7, 0xC3, 0xFE, 0x1E, 0x01, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81,
  0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC7,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xEF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFB,
  0xE0, 0x0F, 0xE0, 0x0F, 0x9F, 0x00, 0x7F, 0x00, 0x7C, 0xF8, 0x03, 0xF8,
  0x03, 0xE3, 0xE0, 0x1F, 0xE0, 0x3E, 0x1F, 0x01, 0xEF, 0x01, 0xF0, 0xF8,
  0x0F, 0x78, 0x0F, 0x87, 0xC0, 0x7B, 0xC0, 0x7C, 0x1F, 0x07, 0xDF, 0x07,
  0xC0, 0xF8, 0x3C, 0x78, 0x3E, 0x07, 0xC1, 0xE3, 0xC1, 0xF0, 0x3E, 0x0F,
  0x1E, 0x0F, 0x80, 0xF8, 0xF8, 0xF8, 0xF8, 0x07, 0xC7, 0xC7, 0xC7, 0xC0,
  0x3E, 0x3C, 0x1E, 0x3E, 0x01, 0xF1, 0xE0, 0xF1, 0xF0, 0x07, 0xDF, 0x07,
  0xCF, 0x00, 0x3E, 0xF8, 0x3E, 0xF8, 0x01, 0xF7, 0x80, 0xF7, 0xC0, 0x0F,
  0xBC, 0x07, 0xBE, 0x00, 0x3D, 0xE0, 0x3D, 0xE0, 0x01, 0xEE, 0x01, 0xEF,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF0, 0xF8, 0x07, 0xE1, 0xF8, 0x0F, 0x81,
  0xF0, 0x3F, 0x03, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x03, 0xE7, 0xE0, 0x07,
  0xEF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x0F, 0xDF, 0x00, 0x1F, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7E,
  0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x1F, 0x00, 0xFC, 0x7E, 0x00, 0xF8,
  0xF8, 0x01, 0xFB, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0xFC, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0,
  0x01, 0xE7, 0xC0, 0x01, 0xF7, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x47, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x07, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x03,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xE0, 0x01, 0xF8, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xF8, 0x01, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0xFF, 0x03, 0xF8,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0x80, 0x00,
  0x1F, 0x80, 0x05, 0xFF, 0xC0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x00, 0x7F, 0xE8, 0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Medium50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 37, 13, 3, -36 },
  { 34, 15, 13, 21, 3, -36 },
  { 59, 27, 36, 29, 1, -36 },
  { 181, 21, 41, 26, 3, -38 },
  { 289, 36, 36, 40, 2, -36 },
  { 451, 31, 37, 33, 2, -36 },
  { 595, 5, 13, 11, 3, -36 },
  { 604, 12, 44, 15, 2, -36 },
  { 670, 12, 44, 15, 1, -36 },
  { 736, 21, 21, 25, 2, -38 },
  { 792, 22, 24, 26, 2, -30 },
  { 858, 8, 13, 13, 2, -6 },
  { 871, 12, 5, 15, 2, -16 },
  { 879, 7, 8, 13, 3, -7 },
  { 886, 18, 36, 19, 1, -36 },
  { 967, 22, 37, 26, 2, -36 },
  { 1069, 14, 36, 26, 4, -36 },
  { 1132, 22, 36, 26, 2, -36 },
  { 1231, 22, 37, 26, 2, -36 },
  { 1333, 24, 36, 26, 1, -36 },
  { 1441, 21, 37, 26, 3, -36 },
  { 1539, 22, 37, 26, 2, -36 },
  { 1641, 22, 36, 26, 2, -36 },
  { 1740, 22, 37, 26, 2, -36 },
  { 1842, 22, 37, 26, 2, -36 },
  { 1944, 7, 28, 13, 3, -27 },
  { 1969, 8, 34, 13, 2, -27 },
  { 2003, 22, 24, 26, 2, -30 },
  { 2069, 22, 14, 26, 2, -25 },
  { 2108, 22, 24, 26, 2, -30 },
  { 2174, 19, 37, 20, 0, -36 },
  { 2262, 35, 40, 41, 3, -36 },
  { 2437, 29, 36, 29, 0, -36 },
  { 2568, 23, 36, 30, 4, -36 },
  { 2672, 24, 37, 29, 3, -36 },
  { 2783, 26, 36, 33, 4, -36 },
  { 2900, 18, 36, 25, 4, -36 },
  { 2981, 18, 36, 24, 4, -36 },
  { 3062, 27, 37, 33, 3, -36 },
  { 3187, 25, 36, 34, 4, -36 },
  { 3300, 13, 36, 17, 2, -36 },
  { 3359, 12, 46, 14, -3, -36 },
  { 3428, 25, 36, 29, 4, -36 },
  { 3541, 19, 36, 24, 4, -36 },
  { 3627, 34, 36, 43, 4, -36 },
  { 3780, 27, 36, 35, 4, -36 },
  { 3902, 29, 37, 35, 3, -36 },
  { 4037, 22, 36, 28, 4, -36 },
  { 4136, 29, 45, 35, 3, -36 },
  { 4300, 24, 36, 29, 4, -36 },
  { 4408, 21, 37, 25, 2, -36 },
  { 4506, 23, 36, 25, 1, -36 },
  { 4610, 25, 37, 33, 4, -36 },
  { 4726, 28, 36, 28, 0, -36 },
  { 4852, 43, 36, 43, 0, -36 },
  { 5046, 27, 36, 27, 0, -36 },
  { 5168, 26, 36, 26, 0, -36 },
  { 5285, 23, 36, 25, 1, -36 },
  { 5389, 11, 44, 16, 4, -36 },
  { 5450, 18, 36, 19, 1, -36 },
  { 5531, 12, 44, 16, 1, -36 },
  { 5597, 24, 22, 27, 1, -36 },
  { 5663, 22, 4, 22, 0, 4 },
  { 5674, 11, 8, 15, 2, -38 },
  { 5685, 20, 28, 26, 2, -27 },
  { 5755, 22, 39, 28, 4, -38 },
  { 5863, 19, 28, 22, 2, -27 },
  { 5930, 23, 39, 28, 2, -38 },
  { 6043, 22, 28, 26, 2, -27 },
  { 6120, 17, 38, 16, 1, -38 },
  { 6201, 23, 39, 28, 2, -27 },
  { 6314, 21, 38, 28, 4, -38 },
  { 6414, 6, 37, 13, 3, -37 },
  { 6442, 11, 49, 13, -2, -37 },
  { 6510, 21, 38, 26, 4, -38 },
  { 6610, 5, 38, 13, 4, -38 },
  { 6634, 35, 27, 43, 4, -27 },
  { 6753, 21, 27, 28, 4, -27 },
  { 6824, 23, 28, 28, 2, -27 },
  { 6905, 22, 39, 28, 4, -27 },
  { 7013, 23, 39, 28, 2, -27 },
  { 7126, 15, 27, 19, 4, -27 },
  { 7177, 18, 28, 22, 2, -27 },
  { 7240, 15, 34, 17, 1, -33 },
  { 7304, 21, 28, 28, 4, -27 },
  { 7378, 24, 27, 24, 0, -27 },
  { 7459, 37, 27, 37, 0, -27 },
  { 7584, 23, 27, 24, 1, -27 },
  { 7662, 24, 39, 24, 0, -27 },
  { 7779, 17, 27, 21, 2, -27 },
  { 7837, 16, 44, 19, 1, -36 },
  { 7925, 5, 50, 25, 10, -38 },
  { 7957, 15, 44, 19, 2, -36 },
  { 8040, 22, 7, 26, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_Medium50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium50pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM50PT7B_H_
