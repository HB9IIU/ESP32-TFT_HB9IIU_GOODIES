#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM21PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium21pt7bBitmaps[] PROGMEM = {
  0x00, 0xED, 0xB6, 0xDB, 0x6D, 0x87, 0xF8, 0xEF, 0x9B, 0x32, 0x64, 0x40,
  0x0C, 0x40, 0xCC, 0x0C, 0xC0, 0xCC, 0x7F, 0xF7, 0xFF, 0x19, 0x81, 0x98,
  0x19, 0x8F, 0xFE, 0xFF, 0xE1, 0x10, 0x33, 0x03, 0x30, 0x33, 0x00, 0x08,
  0x04, 0x0F, 0xEF, 0xEC, 0x86, 0x43, 0xA0, 0xF0, 0x3E, 0x07, 0x82, 0x61,
  0x38, 0x9F, 0xF9, 0xF8, 0x10, 0x08, 0x00, 0x78, 0x31, 0xB0, 0xC3, 0x31,
  0x86, 0x66, 0x0C, 0xCC, 0x19, 0xB0, 0x33, 0x6F, 0x6D, 0xB6, 0x7B, 0x66,
  0x0C, 0xCC, 0x19, 0x98, 0x23, 0x30, 0xC6, 0x61, 0x0D, 0x86, 0x0F, 0x00,
  0x3E, 0x03, 0xF8, 0x18, 0xC0, 0xC6, 0x07, 0x30, 0x1B, 0x00, 0xF0, 0x07,
  0x86, 0x6E, 0x76, 0x3B, 0x30, 0xF9, 0x83, 0x8E, 0x1C, 0x3F, 0xF0, 0xF9,
  0xE0, 0xFB, 0x24, 0x19, 0x98, 0xC6, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x71,
  0x8C, 0x31, 0xC0, 0xC3, 0x18, 0xE3, 0x18, 0xC6, 0x39, 0xCC, 0x63, 0x18,
  0xCC, 0x66, 0x00, 0x18, 0x0C, 0x06, 0x1D, 0xFF, 0xF8, 0xE0, 0xD8, 0xCE,
  0x24, 0x00, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xF8, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x00, 0x7F, 0x68, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0x06, 0x06, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x3E,
  0x3F, 0x98, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x76, 0x33, 0xF8, 0xF8, 0x19, 0xDF, 0xB9, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x60, 0x7E, 0x7F, 0x90, 0xC0, 0x70, 0x38, 0x18, 0x0C, 0x0C, 0x0E,
  0x0E, 0x0E, 0x0E, 0x06, 0x07, 0xFF, 0xFE, 0x7E, 0x7F, 0x90, 0xC0, 0x70,
  0x30, 0x18, 0xF8, 0x7C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x3F, 0xFB, 0xF8,
  0x03, 0x80, 0x70, 0x1E, 0x06, 0xC0, 0xD8, 0x33, 0x04, 0x61, 0x8C, 0x61,
  0x8C, 0x33, 0xFF, 0xFF, 0xF0, 0x18, 0x03, 0x00, 0x60, 0x7F, 0x3F, 0x98,
  0x0C, 0x06, 0x03, 0x03, 0xF8, 0xFE, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x37,
  0xFB, 0xF8, 0x1F, 0x1F, 0x9C, 0x0C, 0x0C, 0x06, 0x23, 0x7D, 0xE7, 0xC1,
  0xE0, 0xF0, 0x78, 0x36, 0x3B, 0xF8, 0xF8, 0xFF, 0xFF, 0xC0, 0x60, 0x60,
  0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06, 0x07, 0x03, 0x03, 0x81, 0x81, 0xC0,
  0x3E, 0x3F, 0xB8, 0xF8, 0x3E, 0x3B, 0x18, 0xF8, 0x7C, 0x77, 0x61, 0xF0,
  0x78, 0x3C, 0x1F, 0xF8, 0xF8, 0x3E, 0x3F, 0xB8, 0xD8, 0x3C, 0x1E, 0x0F,
  0x0F, 0xCF, 0x7D, 0x88, 0xC0, 0x60, 0x60, 0x73, 0xF1, 0xF0, 0x5F, 0x80,
  0x00, 0x0F, 0xF0, 0x5F, 0x80, 0x00, 0x01, 0xFD, 0xA0, 0x00, 0x80, 0xC1,
  0xE3, 0x87, 0x06, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xC0, 0x20, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x80, 0x60, 0x3C, 0x07, 0x80, 0x70, 0x0C,
  0x1E, 0x78, 0xF0, 0x60, 0x20, 0x00, 0x7E, 0xFF, 0x83, 0x03, 0x03, 0x07,
  0x0E, 0x1C, 0x18, 0x10, 0x10, 0x00, 0x10, 0x38, 0x38, 0x07, 0xE0, 0x3C,
  0xF0, 0xE0, 0x71, 0x00, 0x66, 0x3E, 0x68, 0xCC, 0xF3, 0x19, 0xE6, 0x33,
  0xCC, 0x67, 0x98, 0xCF, 0x33, 0x9E, 0x3D, 0xE4, 0x31, 0x8C, 0x00, 0x0C,
  0x04, 0x0F, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xD8, 0x1D,
  0x81, 0x98, 0x19, 0xC3, 0x8C, 0x30, 0xC3, 0xFE, 0x7F, 0xE6, 0x06, 0x60,
  0x7E, 0x03, 0xC0, 0x30, 0xFE, 0x7F, 0xB0, 0xF8, 0x3C, 0x1E, 0x1F, 0xFD,
  0xFE, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x3F, 0xFF, 0xF8, 0x0F, 0xCF, 0xF7,
  0x05, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0x80,
  0x70, 0x0F, 0xF1, 0xFC, 0xFE, 0x1F, 0xE3, 0x0E, 0x60, 0xEC, 0x0D, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1B, 0x03, 0x60, 0xEC, 0x39, 0xFE, 0x3F,
  0x80, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xC1, 0x83, 0x06, 0x0C,
  0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFF, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x00, 0x0F, 0xE7, 0xFC, 0xE0, 0xB8, 0x06, 0x01,
  0xC0, 0x38, 0x06, 0x0F, 0xE1, 0xFC, 0x0D, 0x81, 0xB0, 0x37, 0x06, 0x7F,
  0xC7, 0xF8, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xFF, 0x9C, 0xE7,
  0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x3B, 0xE0, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x3F, 0xB8, 0xC1, 0xF0, 0xEC, 0x33, 0x18,
  0xCC, 0x37, 0x0D, 0x83, 0xE0, 0xEC, 0x33, 0x8C, 0x63, 0x1C, 0xC3, 0xB0,
  0x6C, 0x1C, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0xFF, 0x03, 0xFC, 0x0F,
  0xF0, 0x6F, 0x61, 0xBD, 0x86, 0xF6, 0x33, 0xCC, 0xCF, 0x33, 0x3C, 0xD8,
  0xF1, 0xE3, 0xC7, 0x8F, 0x1C, 0x3C, 0x30, 0xC0, 0xE0, 0x7C, 0x0F, 0xC1,
  0xF8, 0x3D, 0x87, 0xB8, 0xF3, 0x1E, 0x73, 0xC6, 0x78, 0xEF, 0x0D, 0xE1,
  0xFC, 0x1F, 0x81, 0xF0, 0x38, 0x1F, 0x81, 0xFF, 0x1C, 0x18, 0xC0, 0x6E,
  0x03, 0x70, 0x1B, 0x80, 0xF8, 0x07, 0xE0, 0x3F, 0x01, 0x98, 0x0C, 0xC0,
  0xE7, 0x06, 0x1F, 0xF0, 0x7E, 0x00, 0xFC, 0x7F, 0xB0, 0xD8, 0x7C, 0x3E,
  0x1F, 0x0D, 0xFE, 0xFE, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x1F,
  0x81, 0xFF, 0x1C, 0x18, 0xC0, 0x6E, 0x03, 0x70, 0x1B, 0x80, 0xF8, 0x07,
  0xE0, 0x3F, 0x01, 0x98, 0x0C, 0xC0, 0xE7, 0x06, 0x1F, 0xF0, 0x7E, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0xFE, 0x3F, 0xCC, 0x33, 0x0E, 0xC3,
  0xB0, 0xEC, 0x33, 0xF8, 0xFC, 0x33, 0x8C, 0x63, 0x1C, 0xC3, 0x30, 0x6C,
  0x1C, 0x3F, 0x3F, 0xB8, 0x58, 0x0C, 0x07, 0x01, 0xE0, 0x7C, 0x0F, 0x01,
  0x80, 0xE0, 0x78, 0x37, 0xFB, 0xF8, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xE1, 0xDF, 0xE3, 0xF0, 0xC0, 0x7E, 0x06, 0x60,
  0x66, 0x0E, 0x70, 0xC3, 0x0C, 0x30, 0xC3, 0x18, 0x19, 0x81, 0x98, 0x1B,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0xC0, 0xC0, 0xF8, 0x30, 0x76,
  0x1E, 0x19, 0x87, 0x86, 0x61, 0xE1, 0x9C, 0x68, 0x63, 0x33, 0x30, 0xCC,
  0xCC, 0x33, 0x33, 0x0C, 0xC6, 0xC1, 0xE1, 0xE0, 0x78, 0x78, 0x1E, 0x1E,
  0x07, 0x83, 0x80, 0xC0, 0xE0, 0xE0, 0xEE, 0x18, 0xC7, 0x1C, 0xC1, 0xB0,
  0x3E, 0x03, 0x80, 0x70, 0x0F, 0x03, 0x60, 0x6E, 0x18, 0xC7, 0x0C, 0xC1,
  0xB8, 0x18, 0xE0, 0xEC, 0x19, 0x87, 0x18, 0xC3, 0x18, 0x36, 0x06, 0xC0,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xFF,
  0xFF, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x1C, 0x0C,
  0x0C, 0x07, 0xFF, 0xFE, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCF, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x0C,
  0x0E, 0x06, 0x06, 0x03, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x3F, 0x08, 0x07, 0x01, 0x40, 0xD8, 0x22, 0x18, 0xC6, 0x33, 0x06, 0xC1,
  0xC0, 0xFF, 0x80, 0xE6, 0x30, 0x08, 0x7F, 0x63, 0x03, 0x03, 0x3F, 0x7F,
  0xC3, 0xC3, 0xC3, 0xEF, 0x79, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x87, 0xF3,
  0x9D, 0x87, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x3E, 0x1B, 0xFD, 0x3C, 0x08,
  0x3F, 0x72, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x7F, 0x3F, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x99, 0xFD, 0xCF, 0xC3, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1F, 0x0D, 0xFE, 0x79, 0x08, 0x1F, 0x98, 0xDC, 0x3C, 0x1F, 0xFF,
  0xFF, 0x80, 0xC0, 0x30, 0x1F, 0xC7, 0xE0, 0x1F, 0x3E, 0x30, 0x30, 0x30,
  0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x08,
  0x1F, 0xDC, 0xFC, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xDF, 0xE7,
  0xB0, 0x18, 0x0E, 0x0E, 0xFE, 0x7E, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0xC8,
  0xFF, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x5D,
  0x80, 0xDB, 0x6D, 0xB6, 0xDB, 0x11, 0xC6, 0x00, 0x0C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xCF, 0xEF, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x3B, 0x39, 0x98, 0xD8, 0x78, 0x3E, 0x1B, 0x8C, 0xC6, 0x33, 0x1D,
  0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0x08, 0x22, 0xFB, 0xFE, 0x79, 0xF0, 0xC3,
  0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30,
  0xF0, 0xC3, 0x08, 0xBF, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x08, 0x0F, 0xC7, 0x3B, 0x86, 0xC1, 0xB0, 0x7C, 0x1F, 0x07,
  0xC1, 0x98, 0x67, 0xF0, 0xF8, 0x08, 0x5F, 0x39, 0xD8, 0x7C, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0xE1, 0xBF, 0xDB, 0xCC, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x00, 0x08, 0x1F, 0xDC, 0xFC, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0,
  0xDF, 0xE7, 0xB0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x0A, 0xFF, 0xF8,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x10, 0xFF, 0x0E, 0x0E, 0x0F, 0x0F,
  0x07, 0x06, 0x0F, 0xFF, 0xE0, 0x30, 0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0xE3, 0xC0, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0x61, 0xBF, 0xCF, 0x20, 0xE1, 0xD8, 0x66, 0x19, 0x86,
  0x33, 0x0C, 0xC3, 0x30, 0x78, 0x1E, 0x07, 0x80, 0xC0, 0xE3, 0x86, 0xC7,
  0x0D, 0x8F, 0x1B, 0x16, 0x67, 0x6C, 0xC6, 0xC9, 0x8D, 0x9B, 0x1A, 0x3C,
  0x3C, 0x78, 0x38, 0x70, 0x70, 0xE0, 0xE1, 0xCC, 0xE3, 0x30, 0x78, 0x1E,
  0x03, 0x81, 0xE0, 0xEC, 0x33, 0x18, 0x6E, 0x1C, 0xE0, 0xD8, 0x66, 0x19,
  0xC6, 0x33, 0x0C, 0xC3, 0xB0, 0x78, 0x1E, 0x03, 0x80, 0xC0, 0x30, 0x0C,
  0x06, 0x0F, 0x83, 0xC0, 0xFE, 0x0C, 0x30, 0xE1, 0x86, 0x0C, 0x30, 0xE1,
  0xFF, 0xF8, 0x1C, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0xE3, 0x87, 0x0C, 0x30,
  0xC3, 0x0C, 0x38, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC3, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x1C, 0x73, 0x0C, 0x30, 0xC3, 0x0C, 0x73, 0x80,
  0x70, 0xFF, 0xE3, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Medium21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 15, 5, 1, -15 },
  { 7, 7, 5, 9, 1, -15 },
  { 12, 12, 15, 12, 0, -15 },
  { 35, 9, 17, 11, 1, -16 },
  { 55, 15, 15, 17, 1, -15 },
  { 84, 13, 15, 14, 1, -15 },
  { 109, 3, 5, 5, 1, -15 },
  { 111, 5, 18, 6, 1, -15 },
  { 123, 5, 18, 6, 1, -15 },
  { 135, 9, 9, 10, 1, -16 },
  { 146, 9, 10, 11, 1, -12 },
  { 158, 3, 5, 5, 1, -2 },
  { 160, 5, 2, 6, 1, -7 },
  { 162, 3, 3, 5, 1, -3 },
  { 164, 8, 15, 8, 0, -15 },
  { 179, 9, 15, 11, 1, -15 },
  { 196, 5, 15, 11, 2, -15 },
  { 206, 9, 15, 11, 1, -15 },
  { 223, 9, 15, 11, 1, -15 },
  { 240, 11, 15, 11, 0, -15 },
  { 261, 9, 15, 11, 1, -15 },
  { 278, 9, 15, 11, 1, -15 },
  { 295, 9, 15, 11, 1, -15 },
  { 312, 9, 15, 11, 1, -15 },
  { 329, 9, 15, 11, 1, -15 },
  { 346, 3, 12, 5, 1, -12 },
  { 351, 3, 15, 5, 1, -12 },
  { 357, 9, 11, 11, 1, -13 },
  { 370, 9, 6, 11, 1, -10 },
  { 377, 9, 11, 11, 1, -13 },
  { 390, 8, 15, 9, 0, -15 },
  { 405, 15, 17, 17, 1, -15 },
  { 437, 12, 15, 12, 0, -15 },
  { 460, 9, 15, 13, 2, -15 },
  { 477, 10, 15, 12, 1, -15 },
  { 496, 11, 15, 14, 2, -15 },
  { 517, 7, 15, 11, 2, -15 },
  { 531, 7, 15, 10, 2, -15 },
  { 545, 11, 15, 14, 1, -15 },
  { 566, 10, 15, 14, 2, -15 },
  { 585, 5, 15, 7, 1, -15 },
  { 595, 5, 19, 6, -1, -15 },
  { 607, 10, 15, 12, 2, -15 },
  { 626, 8, 15, 10, 2, -15 },
  { 641, 14, 15, 18, 2, -15 },
  { 668, 11, 15, 15, 2, -15 },
  { 689, 13, 15, 15, 1, -15 },
  { 714, 9, 15, 12, 2, -15 },
  { 731, 13, 19, 15, 1, -15 },
  { 762, 10, 15, 12, 2, -15 },
  { 781, 9, 15, 11, 1, -15 },
  { 798, 10, 15, 11, 0, -15 },
  { 817, 10, 15, 14, 2, -15 },
  { 836, 12, 15, 12, 0, -15 },
  { 859, 18, 15, 18, 0, -15 },
  { 893, 11, 15, 11, 0, -15 },
  { 914, 11, 15, 11, 0, -15 },
  { 935, 9, 15, 11, 1, -15 },
  { 952, 4, 18, 7, 2, -15 },
  { 961, 8, 15, 8, 0, -15 },
  { 976, 4, 18, 7, 1, -15 },
  { 985, 10, 9, 11, 1, -15 },
  { 997, 9, 1, 9, 0, 2 },
  { 999, 4, 3, 6, 1, -16 },
  { 1001, 8, 12, 11, 1, -12 },
  { 1013, 9, 16, 12, 2, -16 },
  { 1031, 8, 12, 9, 1, -12 },
  { 1043, 9, 16, 12, 1, -16 },
  { 1061, 9, 12, 11, 1, -12 },
  { 1075, 8, 16, 7, 0, -16 },
  { 1091, 9, 17, 12, 1, -12 },
  { 1111, 8, 16, 12, 2, -16 },
  { 1127, 3, 16, 5, 1, -16 },
  { 1133, 5, 21, 5, -1, -16 },
  { 1147, 9, 16, 11, 2, -16 },
  { 1165, 2, 16, 5, 2, -16 },
  { 1169, 14, 12, 18, 2, -12 },
  { 1190, 8, 12, 12, 2, -12 },
  { 1202, 10, 12, 12, 1, -12 },
  { 1217, 9, 17, 12, 2, -12 },
  { 1237, 9, 17, 12, 1, -12 },
  { 1257, 6, 12, 8, 2, -12 },
  { 1266, 7, 12, 9, 1, -12 },
  { 1277, 7, 14, 7, 0, -14 },
  { 1290, 9, 11, 12, 1, -11 },
  { 1303, 10, 11, 10, 0, -11 },
  { 1317, 15, 11, 16, 0, -11 },
  { 1338, 10, 11, 10, 0, -11 },
  { 1352, 10, 16, 10, 0, -11 },
  { 1372, 7, 11, 9, 1, -11 },
  { 1382, 6, 18, 8, 1, -15 },
  { 1396, 2, 21, 11, 4, -16 },
  { 1402, 6, 18, 8, 1, -15 },
  { 1416, 9, 3, 11, 1, -9 },
};

const GFXfont NotoSans_SemiCondensed_Medium21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium21pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM21PT7B_H_
