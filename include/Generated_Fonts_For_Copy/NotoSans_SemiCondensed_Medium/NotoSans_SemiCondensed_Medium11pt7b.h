#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM11PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xB6, 0x80, 0x28, 0xA7, 0xCA, 0x2B, 0xF5, 0x14, 0x4F, 0xCC,
  0x35, 0xB4, 0x40, 0x62, 0x94, 0x94, 0x9B, 0x6D, 0x15, 0x15, 0x23, 0x30,
  0x91, 0x21, 0x85, 0x39, 0x93, 0x3F, 0xE0, 0x29, 0x2D, 0x92, 0x44, 0xC9,
  0x92, 0x4B, 0x50, 0x27, 0xCC, 0xB0, 0x21, 0x09, 0xF2, 0x10, 0x70, 0xE0,
  0x80, 0x11, 0x22, 0x44, 0x48, 0x72, 0x53, 0x9C, 0xA5, 0x2E, 0x7E, 0x92,
  0x49, 0xF2, 0x42, 0x31, 0x11, 0x1F, 0xF2, 0x42, 0x61, 0x84, 0x3E, 0x18,
  0x63, 0x96, 0x5B, 0xF1, 0x86, 0xF8, 0x8E, 0x11, 0x1E, 0x3A, 0x10, 0xFC,
  0xA5, 0x2F, 0xF8, 0x42, 0x21, 0x10, 0x8C, 0x72, 0x52, 0xE7, 0xE7, 0x2F,
  0x72, 0x72, 0x97, 0x84, 0x6E, 0xC4, 0x50, 0x1C, 0x08, 0xD9, 0xC1, 0x84,
  0xF8, 0x3E, 0x83, 0x06, 0x36, 0x40, 0xF1, 0x13, 0x24, 0x06, 0x3C, 0x86,
  0x6D, 0x5A, 0xB5, 0x6D, 0xC0, 0x7C, 0x30, 0xC2, 0x9A, 0x49, 0xFC, 0x61,
  0xF4, 0xE3, 0xE9, 0xC6, 0x3E, 0x7E, 0x21, 0x08, 0x43, 0x0F, 0xF2, 0x68,
  0xA3, 0x8E, 0x28, 0xBC, 0xF8, 0x8F, 0x88, 0x8F, 0xF8, 0x88, 0xF8, 0x88,
  0x7B, 0x08, 0x20, 0x9E, 0x3C, 0xDF, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xE9,
  0x24, 0x97, 0x24, 0x92, 0x49, 0x3C, 0x8C, 0xA9, 0xCE, 0x5A, 0x51, 0x88,
  0x88, 0x88, 0x8F, 0xC3, 0x8F, 0x1D, 0x3A, 0xB5, 0x66, 0xC9, 0xC7, 0x1E,
  0x69, 0xB6, 0x58, 0xE3, 0x7B, 0x38, 0x61, 0x86, 0x18, 0xDE, 0xF4, 0xA7,
  0x2F, 0x42, 0x10, 0x7B, 0x38, 0x61, 0x86, 0x18, 0xDE, 0x18, 0x30, 0xF4,
  0xE7, 0x2E, 0x4A, 0x51, 0x7A, 0x10, 0xC1, 0x84, 0x3E, 0xF9, 0x08, 0x42,
  0x10, 0x84, 0x8C, 0x63, 0x18, 0xC6, 0x2F, 0x87, 0x14, 0x92, 0x48, 0xC3,
  0x0C, 0x88, 0xE6, 0x53, 0x2A, 0xB5, 0x52, 0x98, 0xCC, 0x46, 0xCD, 0x23,
  0x0C, 0x31, 0xE4, 0xB3, 0x8D, 0x25, 0x8C, 0x30, 0x82, 0x08, 0xF8, 0x44,
  0x62, 0x31, 0x1F, 0xEA, 0xAA, 0xB0, 0x84, 0x44, 0x22, 0x31, 0xE4, 0x92,
  0x49, 0x3C, 0x20, 0xC5, 0x12, 0x8C, 0xF8, 0xE0, 0x70, 0x4E, 0x9C, 0xBC,
  0x84, 0x3D, 0x38, 0xC6, 0x7E, 0xF8, 0x88, 0x8E, 0x11, 0xF9, 0x99, 0x9F,
  0xE9, 0xF8, 0x8F, 0x74, 0xE4, 0x44, 0x44, 0xF9, 0x99, 0x9F, 0x19, 0x60,
  0x88, 0xF9, 0x99, 0x99, 0xBF, 0x45, 0x55, 0x58, 0x84, 0x25, 0x4C, 0x52,
  0xD3, 0xFF, 0xFE, 0x9B, 0x91, 0x91, 0x91, 0x91, 0xF9, 0x99, 0x99, 0xF4,
  0xA7, 0x39, 0x78, 0xF4, 0xE3, 0x19, 0xFA, 0x10, 0x80, 0xF9, 0x99, 0x9F,
  0x11, 0x10, 0xF2, 0x49, 0x00, 0x7C, 0x63, 0x1F, 0x4F, 0x44, 0x44, 0x70,
  0x99, 0x99, 0x9F, 0x8E, 0x54, 0xA7, 0x10, 0x99, 0xD9, 0x5A, 0x56, 0x66,
  0x66, 0xCA, 0x8C, 0x65, 0x64, 0x8A, 0x54, 0xA3, 0x10, 0x8C, 0xC0, 0xF1,
  0x26, 0x4F, 0x32, 0x22, 0xC4, 0x22, 0x23, 0xFF, 0xE0, 0xC6, 0x66, 0x32,
  0x66, 0x6C, 0x6C, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Medium11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 3, 3, 5, 1, -8 },
  { 4, 6, 8, 6, 0, -8 },
  { 10, 4, 9, 6, 1, -8 },
  { 15, 8, 8, 9, 0, -8 },
  { 23, 7, 8, 7, 0, -8 },
  { 30, 1, 3, 3, 1, -8 },
  { 31, 3, 10, 3, 0, -8 },
  { 35, 3, 10, 3, 0, -8 },
  { 39, 5, 4, 5, 0, -8 },
  { 42, 5, 6, 6, 0, -7 },
  { 46, 2, 2, 3, 0, -1 },
  { 47, 3, 1, 3, 0, -3 },
  { 48, 1, 1, 3, 1, -1 },
  { 49, 4, 8, 4, 0, -8 },
  { 53, 5, 8, 6, 0, -8 },
  { 58, 3, 8, 6, 1, -8 },
  { 61, 5, 8, 6, 0, -8 },
  { 66, 5, 8, 6, 0, -8 },
  { 71, 6, 8, 6, 0, -8 },
  { 77, 4, 8, 6, 1, -8 },
  { 81, 5, 8, 6, 0, -8 },
  { 86, 5, 8, 6, 0, -8 },
  { 91, 5, 8, 6, 0, -8 },
  { 96, 5, 8, 6, 0, -8 },
  { 101, 1, 6, 3, 1, -6 },
  { 102, 2, 7, 3, 0, -6 },
  { 104, 5, 6, 6, 0, -7 },
  { 108, 5, 3, 6, 0, -5 },
  { 110, 5, 6, 6, 0, -7 },
  { 114, 4, 8, 4, 0, -8 },
  { 118, 7, 9, 9, 1, -8 },
  { 126, 6, 8, 6, 0, -8 },
  { 132, 5, 8, 7, 1, -8 },
  { 137, 5, 8, 6, 1, -8 },
  { 142, 6, 8, 7, 1, -8 },
  { 148, 4, 8, 6, 1, -8 },
  { 152, 4, 8, 5, 1, -8 },
  { 156, 6, 8, 7, 1, -8 },
  { 162, 5, 8, 7, 1, -8 },
  { 167, 3, 8, 4, 0, -8 },
  { 170, 3, 10, 3, -1, -8 },
  { 174, 5, 8, 6, 1, -8 },
  { 179, 4, 8, 5, 1, -8 },
  { 183, 7, 8, 9, 1, -8 },
  { 190, 6, 8, 8, 1, -8 },
  { 196, 6, 8, 8, 1, -8 },
  { 202, 5, 8, 6, 1, -8 },
  { 207, 6, 10, 8, 1, -8 },
  { 215, 5, 8, 6, 1, -8 },
  { 220, 5, 8, 6, 0, -8 },
  { 225, 5, 8, 6, 0, -8 },
  { 230, 5, 8, 7, 1, -8 },
  { 235, 6, 8, 6, 0, -8 },
  { 241, 9, 8, 9, 0, -8 },
  { 250, 6, 8, 6, 0, -8 },
  { 256, 6, 8, 6, 0, -8 },
  { 262, 5, 8, 6, 0, -8 },
  { 267, 2, 10, 4, 1, -8 },
  { 270, 4, 8, 4, 0, -8 },
  { 274, 3, 10, 4, 0, -8 },
  { 278, 6, 5, 6, 0, -8 },
  { 282, 5, 1, 5, 0, 1 },
  { 283, 3, 1, 3, 0, -8 },
  { 284, 5, 6, 6, 0, -6 },
  { 288, 5, 8, 6, 1, -8 },
  { 293, 4, 6, 5, 1, -6 },
  { 296, 4, 8, 6, 1, -8 },
  { 300, 4, 6, 6, 1, -6 },
  { 303, 4, 8, 4, 0, -8 },
  { 307, 4, 9, 6, 1, -6 },
  { 312, 4, 8, 6, 1, -8 },
  { 316, 1, 8, 3, 1, -8 },
  { 317, 2, 11, 3, 0, -8 },
  { 320, 5, 8, 6, 1, -8 },
  { 325, 1, 8, 3, 1, -8 },
  { 326, 8, 6, 9, 1, -6 },
  { 332, 4, 6, 6, 1, -6 },
  { 335, 5, 6, 6, 1, -6 },
  { 339, 5, 9, 6, 1, -6 },
  { 345, 4, 9, 6, 1, -6 },
  { 350, 3, 6, 4, 1, -6 },
  { 353, 4, 6, 5, 0, -6 },
  { 356, 4, 7, 4, 0, -7 },
  { 360, 4, 6, 6, 1, -6 },
  { 363, 5, 6, 5, 0, -6 },
  { 367, 8, 6, 8, 0, -6 },
  { 373, 5, 6, 5, 0, -6 },
  { 377, 5, 9, 5, 0, -6 },
  { 383, 4, 6, 5, 0, -6 },
  { 386, 4, 10, 4, 0, -8 },
  { 391, 1, 11, 6, 2, -8 },
  { 393, 4, 10, 4, 0, -8 },
  { 398, 5, 2, 6, 0, -5 },
};

const GFXfont NotoSans_SemiCondensed_Medium11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium11pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM11PT7B_H_
