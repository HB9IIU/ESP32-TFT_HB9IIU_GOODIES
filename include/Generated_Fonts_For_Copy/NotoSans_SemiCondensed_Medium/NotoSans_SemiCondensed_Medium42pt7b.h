#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM42PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium42pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x80, 0xF1, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0E, 0xF0, 0xEE, 0x0E,
  0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x0F,
  0x07, 0x00, 0x1E, 0x1E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0,
  0xE0, 0x01, 0xC1, 0xC0, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF0, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x03, 0xC1, 0xC0,
  0x07, 0x87, 0x80, 0x0E, 0x0F, 0x03, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x81, 0xE0, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0xF0, 0xF0, 0x01, 0xE1,
  0xE0, 0x03, 0x83, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x0F, 0xFF, 0x0F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFB, 0x3C, 0xF8,
  0xC1, 0x3C, 0x30, 0x0F, 0x0C, 0x03, 0xC3, 0x00, 0xF8, 0xC0, 0x1F, 0x30,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x03, 0x7E, 0x00, 0xC7, 0xC0, 0x30, 0xF0, 0x0C, 0x3C, 0x03, 0x0F, 0x80,
  0xC7, 0xF8, 0x31, 0xEF, 0xFF, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x07, 0xFC,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x1F, 0x80,
  0x0F, 0x00, 0xFF, 0x00, 0x78, 0x07, 0xFC, 0x01, 0xC0, 0x3C, 0x78, 0x0F,
  0x00, 0xF0, 0xE0, 0x3C, 0x03, 0x83, 0x81, 0xE0, 0x0E, 0x0F, 0x07, 0x80,
  0x38, 0x3C, 0x3C, 0x00, 0xE0, 0xF0, 0xF0, 0x03, 0x83, 0xC3, 0x80, 0x0E,
  0x0F, 0x1E, 0x00, 0x38, 0x3C, 0x70, 0x00, 0xE0, 0xE3, 0xCF, 0xE3, 0xC3,
  0x8E, 0x7F, 0xC7, 0x1E, 0x79, 0xFF, 0x1F, 0xF1, 0xCF, 0x1E, 0x3F, 0xCF,
  0x3C, 0x38, 0x7E, 0x38, 0xE0, 0xE0, 0x01, 0xE3, 0x83, 0xC0, 0x07, 0x0E,
  0x0F, 0x00, 0x3C, 0x38, 0x3C, 0x00, 0xE0, 0xE0, 0xF0, 0x07, 0x83, 0x83,
  0xC0, 0x1C, 0x0E, 0x0F, 0x00, 0xF0, 0x38, 0x38, 0x03, 0x80, 0xF0, 0xE0,
  0x1E, 0x03, 0xC7, 0x80, 0x70, 0x07, 0xFC, 0x03, 0xC0, 0x0F, 0xF0, 0x0E,
  0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xE3, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xCF,
  0x80, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xE0, 0x3E, 0x3E, 0xF8, 0x1E, 0x3E, 0x3E, 0x0F, 0x3E,
  0x0F, 0x87, 0x9F, 0x03, 0xE7, 0xCF, 0x01, 0xFB, 0xC7, 0x80, 0x7F, 0xE3,
  0xC0, 0x1F, 0xE1, 0xE0, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0x7E, 0x03, 0xFC,
  0x1F, 0xCF, 0xFF, 0x0F, 0xFF, 0xF7, 0xC3, 0xFF, 0xE1, 0xF0, 0x7F, 0xC0,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0, 0x07, 0xC1, 0xE0, 0xF0, 0x7C,
  0x1E, 0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x1E,
  0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x0F,
  0x03, 0xC1, 0xE0, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x18, 0x38, 0x37, 0xCE, 0x7D, 0xFF, 0xFF, 0x7F,
  0xFF, 0xE3, 0xFF, 0x00, 0x3F, 0x00, 0x0E, 0xE0, 0x07, 0xBC, 0x03, 0xCF,
  0x81, 0xF1, 0xE0, 0x78, 0x7C, 0x0E, 0x0E, 0x00, 0x82, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x7D, 0xF7, 0xDE, 0x79, 0xEF,
  0x3C, 0xF3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x90, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0x07, 0xF8, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0xFC, 0xFC, 0x7C, 0x0F,
  0x1F, 0x03, 0xE7, 0x80, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFE, 0x01, 0xF7, 0x80, 0x79, 0xE0, 0x1E, 0x7C, 0x0F, 0x9F, 0x03, 0xC3,
  0xF3, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0x3F,
  0x07, 0xF0, 0xFF, 0x1F, 0xF3, 0xFF, 0xFD, 0xF7, 0x9F, 0x71, 0xF2, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0xF8, 0x0F, 0xFF, 0x87, 0xFF,
  0xF3, 0xF9, 0xFC, 0x70, 0x0F, 0x88, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0xF3, 0xF0, 0xFC, 0x60,
  0x0F, 0x90, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xA0, 0x03,
  0xEF, 0x87, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0xFF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x3C, 0xF8, 0x03,
  0x8F, 0x80, 0x78, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0xF8, 0x1E, 0x0F, 0x81,
  0xC0, 0xF8, 0x3C, 0x0F, 0x87, 0x80, 0xF8, 0x78, 0x0F, 0x8F, 0x00, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE7, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0x87, 0xFF, 0xF0, 0xC0,
  0xFE, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0xB0, 0x07, 0xEF,
  0x87, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0x04, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC7, 0xE0,
  0xF3, 0xFE, 0x3D, 0xFF, 0xCF, 0xFB, 0xFB, 0xF0, 0x3E, 0xF8, 0x07, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x3D, 0xE0, 0x0F, 0x7C, 0x07, 0xCF, 0x03, 0xE3, 0xF3, 0xF8, 0x7F, 0xFC,
  0x0F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1,
  0xF8, 0x7E, 0x7C, 0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0x9E, 0x01, 0xE7, 0xC0, 0xF0, 0xFC, 0xFC, 0x1F, 0xFE, 0x03, 0xFE,
  0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3F, 0x7F, 0x1F, 0x07, 0xE7, 0x80, 0xFB,
  0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFE, 0x01, 0xF7, 0xC1, 0xF9, 0xFF, 0xFC, 0x3F, 0xFE, 0x03, 0xFF,
  0x00, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xFC, 0xFC, 0x7C, 0x0F,
  0x3E, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xF7, 0xC0, 0xFD, 0xFD,
  0xFF, 0x3F, 0xFB, 0xC7, 0xFC, 0xF0, 0xFE, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x84,
  0x0F, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x77, 0xFF, 0xFF,
  0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE4,
  0x1C, 0x7C, 0xF9, 0xF3, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF9, 0xF3, 0xE7, 0x8F, 0x3E, 0x78, 0xF1, 0xC7,
  0x80, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x38, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xF8,
  0xFF, 0xFC, 0x7F, 0xFE, 0x7E, 0x7E, 0x20, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x01, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x3C, 0x07, 0xF8, 0x38, 0xE0, 0x7F,
  0xF0, 0xE7, 0x83, 0xFF, 0xC3, 0xDC, 0x1F, 0x0F, 0x0F, 0x70, 0x78, 0x3C,
  0x1D, 0xC3, 0xC0, 0xF0, 0x7F, 0x0F, 0x03, 0xC1, 0xFC, 0x3C, 0x0F, 0x07,
  0xF0, 0xE0, 0x3C, 0x1F, 0xC3, 0x80, 0xF0, 0x7F, 0x0E, 0x03, 0x83, 0xFC,
  0x3C, 0x0E, 0x0F, 0xF0, 0xF0, 0x78, 0x3B, 0xC3, 0xC1, 0xF1, 0xE7, 0x07,
  0xFF, 0xFF, 0x1C, 0x0F, 0xF3, 0xF8, 0x78, 0x1F, 0x87, 0xC1, 0xE0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x18, 0x00, 0x7F, 0xCF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3C, 0x1E,
  0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x01, 0xE0, 0x0F, 0x80,
  0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x3C,
  0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7C, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x7F, 0xFF, 0xCF, 0x00, 0xFD, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x07, 0xCF, 0x07,
  0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0xF0, 0x1F, 0x9E, 0x00,
  0xFB, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xDE, 0x01, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF,
  0xCF, 0xFF, 0xE1, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x1F, 0xE7, 0xE1, 0xF8, 0x02, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x83, 0xFE, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF0, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0x00, 0xFC, 0x78, 0x03, 0xF3, 0xC0, 0x0F, 0xDE, 0x00, 0x3E, 0xF0, 0x00,
  0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xC0,
  0x07, 0xDE, 0x00, 0x7C, 0xF0, 0x07, 0xE7, 0x80, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFE, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFD, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F,
  0xEF, 0xE1, 0xFC, 0x00, 0x83, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFD, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7,
  0xC0, 0x01, 0xEF, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9F, 0x00, 0x0F, 0x3F,
  0x00, 0x1E, 0x3F, 0x00, 0x3C, 0x3F, 0xE7, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7C,
  0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0xFB, 0xFF, 0x7F, 0xCF, 0xF9, 0xFC, 0x00, 0xF0,
  0x03, 0xFF, 0x00, 0x3E, 0xF0, 0x07, 0xCF, 0x00, 0xF8, 0xF0, 0x1F, 0x0F,
  0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x80,
  0xF1, 0xF0, 0x0F, 0x3E, 0x00, 0xF3, 0xC0, 0x0F, 0x7C, 0x00, 0xFF, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0x9F, 0x00, 0xF0, 0xF8, 0x0F, 0x07,
  0xC0, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0xF0,
  0x0F, 0x8F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x03, 0xEF,
  0x00, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFE, 0xF0, 0x00, 0xFF, 0xEF, 0x00, 0x0E, 0xFF,
  0xF0, 0x01, 0xEF, 0xF7, 0x80, 0x1E, 0xFF, 0x78, 0x01, 0xCF, 0xF7, 0x80,
  0x3C, 0xFF, 0x3C, 0x03, 0xCF, 0xF3, 0xC0, 0x38, 0xFF, 0x3C, 0x07, 0x8F,
  0xF1, 0xE0, 0x78, 0xFF, 0x1E, 0x07, 0x0F, 0xF1, 0xE0, 0xF0, 0xFF, 0x0F,
  0x0F, 0x0F, 0xF0, 0xF0, 0xE0, 0xFF, 0x0F, 0x1E, 0x0F, 0xF0, 0x79, 0xE0,
  0xFF, 0x07, 0x9C, 0x0F, 0xF0, 0x7B, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0,
  0x3F, 0x80, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0xFF, 0x01, 0xF0,
  0x0F, 0xF0, 0x1F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFE, 0xF8, 0x03, 0xFB, 0xE0, 0x0F, 0xF7, 0xC0, 0x3F, 0xDF, 0x00, 0xFF,
  0x3E, 0x03, 0xFC, 0x78, 0x0F, 0xF1, 0xF0, 0x3F, 0xC3, 0xC0, 0xFF, 0x0F,
  0x83, 0xFC, 0x1F, 0x0F, 0xF0, 0x7C, 0x3F, 0xC0, 0xF8, 0xFF, 0x03, 0xE3,
  0xFC, 0x07, 0xCF, 0xF0, 0x1F, 0x3F, 0xC0, 0x3E, 0xFF, 0x00, 0x7B, 0xFC,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFE, 0x7F, 0x81, 0xF8, 0x07, 0xE1, 0xF8,
  0x01, 0xF0, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x3E,
  0x00, 0x07, 0xDE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3F, 0x00,
  0x3E, 0x0F, 0xC0, 0x3F, 0x03, 0xFD, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3,
  0xFF, 0xFC, 0xF0, 0x1F, 0xBC, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0,
  0x07, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0xBC, 0x07,
  0xEF, 0x07, 0xF3, 0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x0F, 0xF8, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFE,
  0x7F, 0x81, 0xF8, 0x07, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03,
  0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x79, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x3F, 0x03, 0xFD,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF0, 0x1F, 0x8F, 0x00, 0xF8,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x07,
  0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x01, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x8F,
  0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x00, 0x3F,
  0x07, 0xFE, 0x0F, 0xFF, 0xCF, 0xFF, 0xCF, 0xFF, 0xE7, 0xC0, 0x37, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xBF, 0xDF, 0xFF, 0xCF,
  0xFF, 0xC3, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xE7,
  0x80, 0x07, 0x9E, 0x00, 0x3E, 0x7C, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xFC,
  0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xE7, 0xC0, 0x03,
  0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0xF8,
  0x3C, 0x01, 0xE0, 0x7C, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xE0, 0x3C, 0x03, 0xE0, 0x78, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F,
  0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3C,
  0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0x80, 0x1F, 0x78, 0x01,
  0xF8, 0x01, 0xE7, 0x80, 0x1F, 0x80, 0x1E, 0x7C, 0x01, 0xF8, 0x01, 0xE3,
  0xC0, 0x1F, 0xC0, 0x3E, 0x3C, 0x03, 0xFC, 0x03, 0xC3, 0xC0, 0x3F, 0xC0,
  0x3C, 0x3E, 0x03, 0xDC, 0x03, 0xC3, 0xE0, 0x39, 0xE0, 0x7C, 0x1E, 0x07,
  0x9E, 0x07, 0x81, 0xE0, 0x79, 0xE0, 0x78, 0x1F, 0x07, 0x9E, 0x07, 0x81,
  0xF0, 0xF0, 0xF0, 0xF8, 0x0F, 0x0F, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0xF0,
  0xF0, 0x0F, 0x0F, 0x0F, 0x0F, 0x00, 0xF9, 0xE0, 0x78, 0xF0, 0x07, 0x9E,
  0x07, 0x9F, 0x00, 0x79, 0xE0, 0x79, 0xE0, 0x07, 0x9E, 0x03, 0x9E, 0x00,
  0x79, 0xC0, 0x3D, 0xE0, 0x03, 0xFC, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x7C, 0x78, 0x01, 0xF0, 0xF8, 0x03,
  0xE0, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF0,
  0x03, 0xE3, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0xDF, 0x00, 0x07, 0xBC, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x1F,
  0x7C, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF8, 0x03, 0xE0, 0xF0, 0x07, 0x81,
  0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xE0, 0x07,
  0xC7, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7D, 0xE0, 0x01,
  0xE7, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x3E, 0x01, 0xF0, 0x78, 0x07, 0x81,
  0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x1E, 0x00, 0x78,
  0xF8, 0x01, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0x9C, 0x00, 0x79, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xF0,
  0x0E, 0x07, 0x01, 0xE0, 0x78, 0x1C, 0x03, 0x83, 0xC0, 0x3C, 0x3C, 0x01,
  0xC7, 0x80, 0x1E, 0x78, 0x00, 0xEF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0xF8, 0x1F,
  0xFF, 0x0F, 0xFF, 0xC3, 0xE7, 0xE1, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0xF0,
  0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC,
  0x07, 0xFF, 0x07, 0xF7, 0xFF, 0x7B, 0xFF, 0x3C, 0xFF, 0x0E, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x1F, 0x83, 0xCF, 0xF8,
  0x7B, 0xFF, 0x8F, 0xFF, 0xF9, 0xF8, 0x1F, 0x3F, 0x01, 0xF7, 0xC0, 0x1E,
  0xF8, 0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xDF, 0x00, 0x7B,
  0xE0, 0x1F, 0x7E, 0x03, 0xEF, 0xF1, 0xF9, 0xEF, 0xFF, 0x3C, 0xFF, 0xC7,
  0x8F, 0xE0, 0x03, 0xFC, 0x1F, 0xFC, 0x7F, 0xF9, 0xFF, 0xF3, 0xE0, 0x2F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01,
  0xF0, 0x09, 0xF8, 0x71, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x7C, 0x3F, 0xEF,
  0x8F, 0xFE, 0xF3, 0xFF, 0xFE, 0xFC, 0x1F, 0xDF, 0x01, 0xFB, 0xC0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7D,
  0xF0, 0x0F, 0xBE, 0x03, 0xF3, 0xF1, 0xFE, 0x7F, 0xFB, 0xC7, 0xFE, 0x78,
  0x7F, 0x8F, 0x03, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0xF0, 0xFC, 0x7C, 0x3C,
  0x0F, 0x9E, 0x01, 0xE7, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x08, 0xFC, 0x0E, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x7F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0xC3,
  0xF6, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xFF, 0xCF,
  0xFF, 0x3F, 0xFC, 0xFF, 0xF0, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x07, 0xE1, 0xE1, 0xFF, 0x3C, 0x7F, 0xF7, 0x9F, 0xFF, 0xF7,
  0xE0, 0xFE, 0xF8, 0x0F, 0xDE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x00, 0x7D, 0xF0, 0x1F, 0x9F,
  0x8F, 0xF3, 0xFF, 0xFE, 0x3F, 0xF7, 0xC3, 0xFC, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE6, 0x00, 0xFC, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x3F, 0x0F, 0x3F, 0xF3, 0xDF, 0xFC,
  0xFF, 0xFF, 0xBF, 0x83, 0xEF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF7, 0xFF, 0xF7,
  0x00, 0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xC0, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0xBF, 0xEF, 0xF3, 0xFC, 0xFC, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0xFB, 0xC0, 0x7C,
  0xF0, 0x3E, 0x3C, 0x1F, 0x0F, 0x07, 0x83, 0xC3, 0xE0, 0xF1, 0xF0, 0x3C,
  0xF8, 0x0F, 0x7C, 0x03, 0xDF, 0x00, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xDF,
  0x03, 0xE3, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F, 0x03, 0xE3, 0xC0, 0xF8,
  0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x00, 0xFB, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFC, 0x0F, 0xC3, 0xCF, 0xF8, 0xFF, 0xCF, 0x7F, 0xF7, 0xFF,
  0xBF, 0xFF, 0xDF, 0xFE, 0xFC, 0x0F, 0xE0, 0xFF, 0xF0, 0x3F, 0x01, 0xFF,
  0x80, 0x7C, 0x07, 0xFE, 0x01, 0xF0, 0x0F, 0xF8, 0x07, 0x80, 0x3F, 0xE0,
  0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07,
  0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0,
  0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03,
  0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF,
  0x00, 0x78, 0x03, 0xC0, 0xF0, 0xFC, 0x3C, 0xFF, 0xCF, 0x7F, 0xFB, 0xFF,
  0xFE, 0xFE, 0x0F, 0xBF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xE0, 0x7C, 0xF8, 0x07, 0x9E, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0x78, 0x03,
  0xEF, 0x80, 0x79, 0xF0, 0x1F, 0x1F, 0x87, 0xC1, 0xFF, 0xF8, 0x1F, 0xFE,
  0x01, 0xFF, 0x00, 0xF0, 0xFC, 0x1E, 0x7F, 0xC3, 0xDF, 0xFC, 0x7F, 0xFF,
  0xCF, 0xC0, 0xF9, 0xF8, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0xFB, 0xF0, 0x1F,
  0x7F, 0x8F, 0xCF, 0x7F, 0xF1, 0xE7, 0xFE, 0x3C, 0x7F, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xE1,
  0xE1, 0xFF, 0x3C, 0x7F, 0xF7, 0x9F, 0xFF, 0xF7, 0xE0, 0xFE, 0xF8, 0x0F,
  0xDE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F,
  0xF8, 0x03, 0xEF, 0x00, 0x7D, 0xF0, 0x1F, 0x9F, 0x8F, 0xF3, 0xFF, 0xFE,
  0x3F, 0xF7, 0xC3, 0xFC, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0xF0, 0xFF, 0x9F, 0xBD, 0xFD, 0xEF, 0xEF,
  0xF0, 0x7F, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0xF9, 0xFF,
  0xF7, 0xE3, 0xEF, 0x00, 0x9E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xF7, 0x03, 0xEF, 0xFF, 0xDF, 0xFF,
  0x1F, 0xF8, 0x00, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1F,
  0xFB, 0xFF, 0xDF, 0xFE, 0xFF, 0xF1, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x08, 0xFF, 0xC3, 0xFE, 0x0F,
  0xF0, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0x80, 0xFD, 0xF8, 0xFF, 0x7F, 0xFB,
  0xCF, 0xFC, 0xF1, 0xFE, 0x3C, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01,
  0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC3, 0xE0,
  0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF9, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0xF0, 0x0F, 0x80, 0x79, 0xE0,
  0x1F, 0x80, 0xF3, 0xE0, 0x7F, 0x01, 0xE7, 0xC0, 0xFE, 0x07, 0xC7, 0x81,
  0xDC, 0x0F, 0x0F, 0x03, 0xBC, 0x1E, 0x1E, 0x0F, 0x78, 0x3C, 0x3E, 0x1E,
  0xF0, 0xF8, 0x3C, 0x38, 0xE1, 0xE0, 0x78, 0x71, 0xE3, 0xC0, 0xF1, 0xE3,
  0xC7, 0x80, 0xF3, 0xC7, 0x9F, 0x01, 0xE7, 0x07, 0x3C, 0x03, 0xCE, 0x0F,
  0x78, 0x07, 0xBC, 0x1E, 0xF0, 0x07, 0x78, 0x3D, 0xE0, 0x0F, 0xE0, 0x3F,
  0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x03, 0xEF,
  0x00, 0xF9, 0xF0, 0x1E, 0x1E, 0x07, 0xC3, 0xE1, 0xF0, 0x3E, 0x3C, 0x03,
  0xCF, 0x80, 0x7D, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7D, 0xE0, 0x1F,
  0x3E, 0x03, 0xC3, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0xC7, 0xC0, 0x79, 0xF0,
  0x0F, 0xBE, 0x00, 0xF8, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xE7,
  0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x3E, 0x03, 0xC1, 0xE0, 0x7C,
  0x1E, 0x07, 0x81, 0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x8F,
  0x00, 0x79, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x3F,
  0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x78, 0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x7F, 0x07, 0xF0, 0x3E, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0xC0, 0xFE, 0x01, 0xF0, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x01, 0xF0,
  0x0F, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x3E, 0x0F,
  0xF0, 0xFC, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x3E, 0x07, 0xF0, 0x3F,
  0x01, 0xF0, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x5F, 0xE0, 0x1F, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Medium42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 5, 31, 11, 3, -30 },
  { 21, 12, 11, 18, 3, -30 },
  { 38, 23, 30, 24, 1, -30 },
  { 125, 18, 34, 22, 2, -32 },
  { 202, 30, 30, 33, 2, -30 },
  { 315, 25, 30, 27, 2, -30 },
  { 409, 4, 11, 10, 3, -30 },
  { 415, 10, 37, 13, 2, -30 },
  { 462, 10, 37, 13, 1, -30 },
  { 509, 18, 18, 21, 1, -32 },
  { 550, 18, 20, 22, 2, -25 },
  { 595, 6, 10, 11, 2, -5 },
  { 603, 11, 4, 13, 1, -13 },
  { 609, 5, 6, 11, 3, -5 },
  { 613, 16, 30, 16, 0, -30 },
  { 673, 18, 30, 22, 2, -30 },
  { 741, 12, 30, 22, 3, -30 },
  { 786, 18, 30, 22, 2, -30 },
  { 854, 18, 30, 22, 2, -30 },
  { 922, 20, 30, 22, 1, -30 },
  { 997, 18, 30, 22, 2, -30 },
  { 1065, 18, 30, 22, 2, -30 },
  { 1133, 19, 30, 22, 1, -30 },
  { 1205, 18, 30, 22, 2, -30 },
  { 1273, 18, 30, 22, 2, -30 },
  { 1341, 5, 24, 11, 3, -23 },
  { 1356, 7, 28, 11, 1, -23 },
  { 1381, 18, 20, 22, 2, -25 },
  { 1426, 18, 12, 22, 2, -21 },
  { 1453, 18, 20, 22, 2, -25 },
  { 1498, 16, 31, 17, 0, -30 },
  { 1560, 30, 34, 34, 2, -30 },
  { 1688, 25, 30, 25, 0, -30 },
  { 1782, 19, 30, 25, 4, -30 },
  { 1854, 21, 30, 24, 2, -30 },
  { 1933, 21, 30, 28, 4, -30 },
  { 2012, 15, 30, 21, 4, -30 },
  { 2069, 15, 30, 20, 4, -30 },
  { 2126, 23, 30, 28, 2, -30 },
  { 2213, 21, 30, 28, 4, -30 },
  { 2292, 11, 30, 14, 1, -30 },
  { 2334, 11, 38, 11, -3, -30 },
  { 2387, 20, 30, 24, 4, -30 },
  { 2462, 15, 30, 20, 4, -30 },
  { 2519, 28, 30, 36, 4, -30 },
  { 2624, 22, 30, 30, 4, -30 },
  { 2707, 25, 30, 30, 2, -30 },
  { 2801, 18, 30, 23, 4, -30 },
  { 2869, 25, 37, 30, 2, -30 },
  { 2985, 20, 30, 24, 4, -30 },
  { 3060, 17, 30, 21, 2, -30 },
  { 3124, 21, 30, 21, 0, -30 },
  { 3203, 22, 30, 28, 3, -30 },
  { 3286, 23, 30, 23, 0, -30 },
  { 3373, 36, 30, 36, 0, -30 },
  { 3508, 23, 30, 23, 0, -30 },
  { 3595, 22, 30, 22, 0, -30 },
  { 3678, 19, 30, 21, 1, -30 },
  { 3750, 9, 37, 14, 3, -30 },
  { 3792, 16, 30, 16, 0, -30 },
  { 3852, 10, 37, 14, 1, -30 },
  { 3899, 20, 18, 22, 1, -30 },
  { 3944, 18, 2, 18, 0, 4 },
  { 3949, 9, 7, 12, 2, -32 },
  { 3957, 17, 23, 22, 2, -23 },
  { 4006, 19, 32, 24, 3, -32 },
  { 4082, 15, 23, 19, 2, -23 },
  { 4126, 19, 32, 24, 2, -32 },
  { 4202, 18, 23, 22, 2, -23 },
  { 4254, 14, 32, 14, 1, -32 },
  { 4310, 19, 33, 24, 2, -23 },
  { 4389, 18, 32, 24, 3, -32 },
  { 4461, 5, 31, 11, 3, -31 },
  { 4481, 10, 41, 11, -2, -31 },
  { 4533, 18, 32, 21, 3, -32 },
  { 4605, 4, 32, 11, 3, -32 },
  { 4621, 30, 23, 36, 3, -23 },
  { 4708, 18, 23, 24, 3, -23 },
  { 4760, 19, 23, 23, 2, -23 },
  { 4815, 19, 33, 24, 3, -23 },
  { 4894, 19, 33, 24, 2, -23 },
  { 4973, 13, 23, 16, 3, -23 },
  { 5011, 15, 23, 18, 2, -23 },
  { 5055, 13, 28, 14, 1, -28 },
  { 5101, 18, 23, 24, 3, -23 },
  { 5153, 20, 23, 20, 0, -23 },
  { 5211, 31, 23, 31, 0, -23 },
  { 5301, 19, 23, 20, 1, -23 },
  { 5356, 20, 33, 20, 0, -23 },
  { 5439, 15, 23, 18, 1, -23 },
  { 5483, 13, 37, 16, 1, -30 },
  { 5544, 3, 42, 21, 9, -32 },
  { 5560, 13, 37, 16, 2, -30 },
  { 5621, 18, 6, 22, 2, -18 },
};

const GFXfont NotoSans_SemiCondensed_Medium42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium42pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM42PT7B_H_
