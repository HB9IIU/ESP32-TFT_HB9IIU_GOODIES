#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM19PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xE4, 0x92, 0x48, 0x0F, 0xC0, 0xCF, 0x3C, 0xF3, 0xC8, 0x0C,
  0x81, 0x10, 0x26, 0x04, 0xC7, 0xFE, 0xFF, 0xC6, 0x40, 0x88, 0x13, 0x1F,
  0xF8, 0xCC, 0x19, 0x03, 0x20, 0x4C, 0x00, 0x18, 0x3E, 0x7F, 0xD8, 0xD8,
  0xD8, 0x78, 0x1E, 0x1F, 0x1B, 0x1B, 0xFF, 0xFC, 0x18, 0x18, 0x70, 0x67,
  0xC2, 0x36, 0x31, 0x11, 0x08, 0x98, 0x44, 0x83, 0x6D, 0xDF, 0x5B, 0x76,
  0xC8, 0x24, 0x43, 0x22, 0x11, 0x91, 0x8D, 0x98, 0x38, 0x1C, 0x0F, 0xC1,
  0x98, 0x33, 0x06, 0x60, 0x78, 0x0E, 0x03, 0xE3, 0xEC, 0xD8, 0xDB, 0x0F,
  0x61, 0xCF, 0xFC, 0xFD, 0xC0, 0xFF, 0xC0, 0x33, 0x66, 0xCC, 0xCC, 0xCC,
  0xCC, 0xC4, 0x62, 0x30, 0x8C, 0x66, 0x23, 0x33, 0x33, 0x33, 0x36, 0x6C,
  0xC0, 0x18, 0x10, 0xD7, 0xFF, 0x38, 0x6C, 0x66, 0x24, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x7B, 0x60, 0xFF, 0xFC, 0x06, 0x0C,
  0x30, 0x60, 0xC3, 0x06, 0x08, 0x30, 0x60, 0x83, 0x06, 0x18, 0x00, 0x38,
  0x7E, 0x66, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0x7E,
  0x3C, 0x0C, 0x73, 0xFB, 0x4C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0x38, 0xFE, 0xC6, 0x03, 0x03, 0x06, 0x06, 0x0C, 0x18, 0x38, 0x30, 0x60,
  0xFF, 0xFF, 0x38, 0xFE, 0x86, 0x03, 0x03, 0x06, 0x3C, 0x3E, 0x07, 0x03,
  0x03, 0x03, 0xEE, 0xFC, 0x03, 0x01, 0xC0, 0x70, 0x3C, 0x1B, 0x04, 0xC3,
  0x30, 0x8C, 0x63, 0x3F, 0xFF, 0xFC, 0x0C, 0x03, 0x00, 0xC0, 0x7E, 0x7E,
  0x40, 0x40, 0xC0, 0xC0, 0xFE, 0x47, 0x03, 0x03, 0x03, 0x03, 0xEE, 0xFC,
  0x0E, 0x3E, 0x60, 0x60, 0xC0, 0xCC, 0xFE, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x7E, 0x3C, 0xFF, 0xFF, 0x03, 0x02, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18,
  0x18, 0x30, 0x30, 0x60, 0x3C, 0x7E, 0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0x7C,
  0xE6, 0xC3, 0xC3, 0xC3, 0xE7, 0x7E, 0x38, 0x7E, 0xC6, 0xC3, 0xC3, 0xC3,
  0xC3, 0xFF, 0x7B, 0x03, 0x02, 0x06, 0x9C, 0x78, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0xFB, 0x40, 0x03, 0x0F, 0x3C, 0xE0, 0xC0, 0x78, 0x1E,
  0x07, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0x1E, 0x78, 0xE0, 0x80, 0x39, 0xFD, 0x18, 0x30, 0x60, 0xC3, 0x0C, 0x30,
  0x60, 0x00, 0x03, 0x06, 0x00, 0x03, 0x80, 0x7F, 0x83, 0x03, 0x18, 0x06,
  0x47, 0xCB, 0x33, 0x2C, 0x8C, 0xF2, 0x33, 0x98, 0xCB, 0x23, 0x2C, 0xD5,
  0xB1, 0xDC, 0x60, 0x01, 0xC0, 0x81, 0xFC, 0x01, 0xC0, 0x0E, 0x01, 0xC0,
  0x28, 0x0D, 0x81, 0xB0, 0x36, 0x0C, 0x61, 0x8C, 0x3F, 0x8F, 0xF9, 0x83,
  0x30, 0x6E, 0x07, 0x80, 0xC0, 0xF8, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xFE,
  0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFC, 0x0F, 0x1F, 0xDC, 0x2C, 0x0E,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0xF8, 0xFC, 0xF0,
  0x7F, 0x31, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x6F, 0xF7, 0xE0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x3F, 0x7E, 0xC1, 0x83,
  0x06, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x7E, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x00, 0x0F, 0x8F, 0xF7, 0x05, 0x80, 0xE0, 0x30,
  0x0C, 0x03, 0x0F, 0xC0, 0xF0, 0x36, 0x0D, 0xC3, 0x3F, 0xC7, 0xF0, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0C, 0xFF, 0xD8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x7C,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x66, 0xF7, 0x00,
  0xC3, 0xE1, 0xB1, 0x99, 0x8C, 0xC6, 0xC3, 0xC1, 0xF0, 0xDC, 0x66, 0x33,
  0x98, 0xCC, 0x36, 0x1C, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0F, 0xFF, 0xC0, 0xC0, 0x3F, 0x03, 0xF8, 0x1F, 0x40, 0xBB,
  0x0D, 0xD8, 0x6E, 0x42, 0x73, 0x33, 0x99, 0x9C, 0x48, 0xE3, 0xC7, 0x1E,
  0x38, 0x61, 0xC3, 0x0C, 0xC0, 0xF8, 0x3E, 0x0E, 0xC3, 0xB0, 0xE6, 0x39,
  0x8E, 0x33, 0x8E, 0xE1, 0xB8, 0x7E, 0x0F, 0x81, 0xE0, 0x70, 0x0F, 0x07,
  0xF1, 0xC3, 0x30, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0D,
  0x81, 0xB0, 0x63, 0xFC, 0x3F, 0x00, 0xF0, 0xFE, 0xC6, 0xC3, 0xC3, 0xC3,
  0xC6, 0xFE, 0xF8, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0F, 0x07, 0xF1, 0xC3,
  0x30, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0D, 0x81, 0xB0,
  0x63, 0xFC, 0x3F, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0xF0, 0x7F, 0x31, 0x98,
  0x6C, 0x36, 0x1B, 0x19, 0xF8, 0xCC, 0x66, 0x31, 0x98, 0xCC, 0x36, 0x1C,
  0x3C, 0x7F, 0xE2, 0xC0, 0xC0, 0xE0, 0x78, 0x3C, 0x0E, 0x03, 0x03, 0x07,
  0xFE, 0xFC, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0xF3, 0xF0, 0xC0, 0x78,
  0x19, 0x83, 0x30, 0x66, 0x18, 0x63, 0x0C, 0x61, 0x98, 0x13, 0x03, 0x60,
  0x68, 0x0F, 0x00, 0xE0, 0x1C, 0x00, 0xC1, 0x83, 0xC1, 0x83, 0x61, 0xC3,
  0x63, 0xC3, 0x63, 0xC6, 0x63, 0x46, 0x32, 0x66, 0x36, 0x66, 0x36, 0x6C,
  0x36, 0x2C, 0x14, 0x3C, 0x1C, 0x3C, 0x1C, 0x38, 0x1C, 0x18, 0xE0, 0xD8,
  0x63, 0x18, 0xCC, 0x1B, 0x07, 0x80, 0xE0, 0x38, 0x1E, 0x06, 0xC3, 0x31,
  0xC6, 0x61, 0xB0, 0x30, 0xC0, 0xD8, 0x66, 0x19, 0xCC, 0x33, 0x0C, 0xC1,
  0xE0, 0x78, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xFF,
  0x06, 0x06, 0x0C, 0x0C, 0x18, 0x38, 0x30, 0x60, 0x60, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xF8, 0xC0,
  0x81, 0x83, 0x03, 0x06, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x60, 0xC0,
  0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xF8, 0x18,
  0x0C, 0x0F, 0x07, 0x86, 0x63, 0x31, 0x0D, 0x86, 0x81, 0x80, 0xFF, 0xCE,
  0x70, 0x7E, 0x46, 0x03, 0x03, 0x7F, 0xE3, 0xC3, 0xC7, 0xEF, 0x7B, 0xC0,
  0x60, 0x30, 0x18, 0x0D, 0xE7, 0x1B, 0x8F, 0x83, 0xC1, 0xE0, 0xF0, 0x7C,
  0x6F, 0x76, 0xF0, 0x3E, 0xC7, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x76, 0x7C,
  0x03, 0x03, 0x03, 0x03, 0x7F, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x77, 0x3D, 0x7E, 0x66, 0xC3, 0xC3, 0xFF, 0xC0, 0xC0, 0xC0, 0x73, 0x3F,
  0x0C, 0x7C, 0xC1, 0x83, 0x1F, 0x8C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x00, 0x7D, 0x67, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x77, 0x3F,
  0x03, 0x03, 0x87, 0x7E, 0x18, 0xC0, 0xC0, 0xC0, 0xC0, 0xDF, 0xF3, 0xE3,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xDC, 0x0D, 0xB6, 0xDB, 0x6D,
  0x80, 0x31, 0xC0, 0x03, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x37,
  0x90, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x36, 0x33, 0x31, 0xB0, 0xF8, 0x76,
  0x33, 0x18, 0xCC, 0x76, 0x1C, 0xFF, 0xFF, 0xFF, 0xF0, 0xDE, 0xFB, 0x8E,
  0x7E, 0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3,
  0x0F, 0x0C, 0x30, 0xDF, 0xE3, 0xE3, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0x7E, 0x33, 0xB0, 0xD8, 0x3C, 0x1E, 0x0F, 0x0D, 0x86, 0x77, 0x1F,
  0x00, 0xDF, 0x71, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC6, 0xF7, 0x6F,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x7D, 0x67, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x77, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x03, 0xDF, 0xDE, 0x38,
  0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x7D, 0x8B, 0x07, 0x07, 0x83, 0x83, 0x03,
  0xCD, 0xF0, 0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0D, 0x3C,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0x77, 0x7D, 0xC1, 0xB1,
  0x98, 0xCC, 0x62, 0x21, 0xB0, 0xD8, 0x28, 0x1C, 0x0E, 0x00, 0xC3, 0x0D,
  0x8E, 0x26, 0x79, 0x99, 0xE6, 0x64, 0x98, 0xF3, 0x43, 0xCF, 0x0F, 0x3C,
  0x38, 0x70, 0x61, 0x80, 0xE3, 0xB9, 0x8D, 0x83, 0xC1, 0xC0, 0xE0, 0xD8,
  0x6C, 0x63, 0x70, 0xC0, 0xC1, 0xB1, 0x98, 0xCC, 0x63, 0x21, 0xB0, 0xD8,
  0x28, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x87, 0x81, 0x00, 0xFC, 0x31, 0x86,
  0x30, 0xC6, 0x30, 0xFF, 0xF0, 0x09, 0xCC, 0x63, 0x18, 0xCC, 0xC7, 0x0C,
  0x63, 0x18, 0xC7, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x83, 0x86, 0x08,
  0x20, 0x82, 0x0C, 0x1C, 0xF3, 0x08, 0x20, 0x86, 0x38, 0xC0, 0xF1, 0xFF,
  0x86,
};

const GFXglyph NotoSans_SemiCondensed_Medium19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 8, 1, -14 },
  { 11, 11, 14, 11, 0, -14 },
  { 31, 8, 15, 10, 1, -14 },
  { 46, 13, 14, 15, 1, -14 },
  { 69, 11, 14, 12, 1, -14 },
  { 89, 2, 5, 4, 1, -14 },
  { 91, 4, 17, 6, 1, -14 },
  { 100, 4, 17, 6, 1, -14 },
  { 109, 8, 8, 9, 1, -14 },
  { 117, 8, 9, 10, 1, -11 },
  { 126, 3, 4, 5, 1, -2 },
  { 128, 4, 2, 6, 1, -6 },
  { 129, 3, 2, 5, 1, -2 },
  { 130, 7, 14, 7, 0, -14 },
  { 143, 8, 14, 10, 1, -14 },
  { 157, 6, 14, 10, 1, -14 },
  { 168, 8, 14, 10, 1, -14 },
  { 182, 8, 14, 10, 1, -14 },
  { 196, 10, 14, 10, 0, -14 },
  { 214, 8, 14, 10, 1, -14 },
  { 228, 8, 14, 10, 1, -14 },
  { 242, 8, 14, 10, 1, -14 },
  { 256, 8, 14, 10, 1, -14 },
  { 270, 8, 14, 10, 1, -14 },
  { 284, 3, 10, 5, 1, -10 },
  { 288, 3, 12, 5, 1, -10 },
  { 293, 8, 9, 10, 1, -11 },
  { 302, 8, 5, 10, 1, -9 },
  { 307, 8, 9, 10, 1, -11 },
  { 316, 7, 14, 8, 0, -14 },
  { 329, 14, 16, 16, 1, -14 },
  { 357, 11, 14, 11, 0, -14 },
  { 377, 8, 14, 11, 2, -14 },
  { 391, 9, 14, 11, 1, -14 },
  { 407, 9, 14, 12, 2, -14 },
  { 423, 7, 14, 10, 2, -14 },
  { 436, 7, 14, 9, 2, -14 },
  { 449, 10, 14, 13, 1, -14 },
  { 467, 9, 14, 13, 2, -14 },
  { 483, 5, 14, 6, 1, -14 },
  { 492, 5, 18, 5, -1, -14 },
  { 504, 9, 14, 11, 2, -14 },
  { 520, 7, 14, 9, 2, -14 },
  { 533, 13, 14, 16, 2, -14 },
  { 556, 10, 14, 13, 2, -14 },
  { 574, 11, 14, 13, 1, -14 },
  { 594, 8, 14, 11, 2, -14 },
  { 608, 11, 17, 13, 1, -14 },
  { 632, 9, 14, 11, 2, -14 },
  { 648, 8, 14, 10, 1, -14 },
  { 662, 9, 14, 10, 0, -14 },
  { 678, 9, 14, 13, 2, -14 },
  { 694, 11, 14, 11, 0, -14 },
  { 714, 16, 14, 16, 0, -14 },
  { 742, 10, 14, 10, 0, -14 },
  { 760, 10, 14, 10, 0, -14 },
  { 778, 8, 14, 10, 1, -14 },
  { 792, 5, 17, 6, 1, -14 },
  { 803, 7, 14, 7, 0, -14 },
  { 816, 5, 17, 6, 0, -14 },
  { 827, 9, 9, 10, 1, -14 },
  { 838, 8, 1, 8, 0, 2 },
  { 839, 4, 3, 6, 1, -15 },
  { 841, 8, 10, 10, 1, -10 },
  { 851, 9, 14, 11, 1, -14 },
  { 867, 7, 10, 8, 1, -10 },
  { 876, 8, 14, 11, 1, -14 },
  { 890, 8, 10, 10, 1, -10 },
  { 900, 7, 15, 6, 0, -15 },
  { 914, 8, 15, 11, 1, -10 },
  { 929, 8, 14, 11, 1, -14 },
  { 943, 3, 14, 5, 1, -14 },
  { 949, 5, 19, 5, -1, -14 },
  { 961, 9, 14, 10, 1, -14 },
  { 977, 2, 14, 5, 1, -14 },
  { 981, 14, 10, 16, 1, -10 },
  { 999, 8, 10, 11, 1, -10 },
  { 1009, 9, 10, 11, 1, -10 },
  { 1021, 9, 15, 11, 1, -10 },
  { 1038, 8, 15, 11, 1, -10 },
  { 1053, 6, 10, 7, 1, -10 },
  { 1061, 7, 10, 8, 1, -10 },
  { 1070, 6, 13, 7, 0, -13 },
  { 1080, 8, 10, 11, 1, -10 },
  { 1090, 9, 10, 9, 0, -10 },
  { 1102, 14, 10, 14, 0, -10 },
  { 1120, 9, 10, 9, 0, -10 },
  { 1132, 9, 15, 9, 0, -10 },
  { 1149, 6, 10, 8, 1, -10 },
  { 1157, 5, 17, 7, 1, -14 },
  { 1168, 2, 18, 10, 4, -14 },
  { 1173, 6, 17, 7, 1, -14 },
  { 1186, 8, 3, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Medium19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium19pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM19PT7B_H_
