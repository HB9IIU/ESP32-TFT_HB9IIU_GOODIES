#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM53PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium53pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBE, 0x7C, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xF0, 0x00, 0x00, 0x00, 0x1E, 0x7E, 0xFF, 0xFF, 0xF7, 0xEF, 0xC6, 0x00,
  0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x3F, 0x7C, 0x3F, 0x7C, 0x1F,
  0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E,
  0x78, 0x1E, 0x78, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0x7C, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E,
  0x07, 0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x0F,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F,
  0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xF9,
  0xC1, 0xCF, 0xC7, 0x00, 0x3E, 0x1C, 0x00, 0xF8, 0x70, 0x03, 0xE1, 0xC0,
  0x0F, 0x87, 0x00, 0x3F, 0x1C, 0x00, 0xFE, 0x70, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x73, 0xF8, 0x01, 0xC3, 0xF0, 0x07, 0x07,
  0xC0, 0x1C, 0x1F, 0x00, 0x70, 0x7C, 0x01, 0xC1, 0xF0, 0x07, 0x07, 0xF0,
  0x1C, 0x3F, 0xFC, 0x73, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x3C, 0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0x80, 0x0F,
  0xBF, 0x00, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0xF8, 0x07,
  0xC0, 0x07, 0x83, 0xE0, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0xF8, 0x00, 0xF8,
  0x1E, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x1F, 0x00, 0x0F, 0x81, 0xE0, 0x78,
  0x00, 0x3E, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x1E, 0x0F, 0x00, 0x03, 0xE0,
  0x78, 0x7C, 0x00, 0x0F, 0x81, 0xE1, 0xE0, 0x00, 0x3E, 0x07, 0x8F, 0x87,
  0xF0, 0x78, 0x3E, 0x3C, 0x3F, 0xE1, 0xE0, 0xF8, 0xF1, 0xFF, 0xC7, 0xC3,
  0xC7, 0xCF, 0xFF, 0x0F, 0xBF, 0x1E, 0x3C, 0x3E, 0x3F, 0xF8, 0xF9, 0xF0,
  0x78, 0x7F, 0xC3, 0xC7, 0xC1, 0xE0, 0xFE, 0x1F, 0x1E, 0x07, 0xC0, 0x00,
  0x78, 0x78, 0x1F, 0x00, 0x03, 0xE1, 0xE0, 0x7C, 0x00, 0x0F, 0x07, 0x81,
  0xF0, 0x00, 0x7C, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x1F, 0x00, 0x0F,
  0x81, 0xE0, 0x7C, 0x00, 0x3C, 0x07, 0x81, 0xF0, 0x01, 0xF0, 0x1E, 0x07,
  0xC0, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x78, 0x00, 0xF0,
  0x03, 0xC3, 0xE0, 0x07, 0xC0, 0x0F, 0x9F, 0x80, 0x1E, 0x00, 0x1F, 0xFC,
  0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x7E, 0x1F, 0xFF, 0x80, 0x7C, 0x3F, 0x9F,
  0xC0, 0xFC, 0x3F, 0x0F, 0xE0, 0xFC, 0x7E, 0x07, 0xE0, 0xF8, 0x7E, 0x03,
  0xF1, 0xF8, 0xFC, 0x01, 0xF9, 0xF8, 0xFC, 0x01, 0xFF, 0xF0, 0xFC, 0x00,
  0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0x3F, 0xC0, 0xFC, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x7F, 0xE0, 0x7F, 0xC3,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFD, 0xF8, 0x1F, 0xFF, 0xF9, 0xFC, 0x0F, 0xFF,
  0xE0, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x7D, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xFC,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x04, 0x07, 0x80, 0xFF, 0x1E,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xF8,
  0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0xC0, 0x3E, 0x1F, 0x01, 0xF8, 0x7E, 0x07, 0xC0, 0xFC, 0x07, 0x03,
  0x80, 0x04, 0x04, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0x3F, 0x3F, 0x3F, 0x3E,
  0x3E, 0x7E, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0x8C,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xFE, 0x7F, 0x87, 0xF0, 0x3F,
  0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0xFC, 0x00, 0xF9,
  0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x01,
  0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x07, 0xEF, 0xC0, 0x0F, 0x8F, 0x80, 0x3F,
  0x1F, 0x80, 0x7E, 0x3F, 0x81, 0xF8, 0x3F, 0x8F, 0xF0, 0x3F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7,
  0xFF, 0xBF, 0xBF, 0xFE, 0x7F, 0xF8, 0xFD, 0xE1, 0xF9, 0x83, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F,
  0xF8, 0xFF, 0x87, 0x80, 0x3F, 0x0E, 0x00, 0x3F, 0x08, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xC7, 0xF8, 0x7F, 0x87, 0x00, 0x3F, 0x8C, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0xC0, 0x01,
  0xFD, 0xF8, 0x0F, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x07, 0xFF, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x03,
  0xE0, 0x78, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC2, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x0E, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xA0, 0x00, 0x7E, 0xC0, 0x03, 0xFB, 0xE0, 0x7F, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07,
  0xFC, 0x08, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x3F, 0x80, 0x7C, 0xFF, 0xE0, 0x7D,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0xF3, 0xFC, 0xFF, 0x80, 0xFC, 0xFF,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x1F,
  0x80, 0xFC, 0x1F, 0xC3, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0x83, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7E,
  0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xF8, 0x1F, 0xC3, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC7, 0xF8, 0x3F, 0x01, 0xFC, 0x7E,
  0x00, 0xFC, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7F, 0x01, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFC,
  0x7F, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0x7C, 0x00,
  0x7D, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x7C, 0x00, 0x7E,
  0xFC, 0x01, 0xFD, 0xFC, 0x07, 0xF9, 0xFE, 0x3F, 0xF3, 0xFF, 0xFB, 0xE3,
  0xFF, 0xF7, 0xC3, 0xFF, 0xCF, 0x81, 0xFE, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x40, 0x3F,
  0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x3F, 0xFF, 0xFF, 0xFB, 0xF7, 0xE3, 0x00, 0x1E, 0x3F, 0x7F, 0x7F, 0x7F,
  0x3F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF0, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x0F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xE3, 0xFC, 0xE0, 0x0F, 0xD0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x60, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x07, 0xC3,
  0xE0, 0x07, 0xF0, 0x0F, 0x0F, 0x80, 0xFF, 0xF8, 0x3C, 0x3C, 0x07, 0xFF,
  0xE0, 0xF9, 0xF0, 0x3F, 0xFF, 0x81, 0xE7, 0x81, 0xF8, 0x1E, 0x07, 0x9E,
  0x07, 0xC0, 0x78, 0x1E, 0xF8, 0x3E, 0x03, 0xE0, 0x7B, 0xC0, 0xF8, 0x0F,
  0x81, 0xEF, 0x03, 0xC0, 0x3E, 0x07, 0xFC, 0x0F, 0x00, 0xF8, 0x1F, 0xF0,
  0x3C, 0x03, 0xE0, 0x7B, 0xC1, 0xF0, 0x0F, 0x81, 0xEF, 0x07, 0xC0, 0x3E,
  0x07, 0xBC, 0x1F, 0x00, 0xF8, 0x1E, 0xF0, 0x3C, 0x03, 0xE0, 0x7B, 0xC0,
  0xF0, 0x1F, 0x83, 0xEF, 0x03, 0xE0, 0x7E, 0x0F, 0x3C, 0x0F, 0x83, 0xF8,
  0x7C, 0xF8, 0x1F, 0xFE, 0xFF, 0xE3, 0xE0, 0x7F, 0xF3, 0xFF, 0x07, 0x80,
  0xFF, 0xC7, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xC0,
  0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xDE, 0x00,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0xFC, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xC0, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xE0, 0x0F, 0xF3,
  0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F,
  0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03,
  0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x03, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE7, 0xE0,
  0x07, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0xFF,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0x7F, 0x83, 0xFC, 0x00, 0xC1,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x01, 0x03, 0xFF, 0x8F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x1F, 0xF0, 0xFC, 0x00, 0x7F, 0x8F,
  0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFE, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x8F,
  0xC0, 0x07, 0xF8, 0xFC, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFD, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBE,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xBF, 0xE0, 0xFF, 0x80, 0x0E, 0x1F,
  0xE0, 0x00, 0x21, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x1F, 0x7F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x3F,
  0x80, 0x01, 0xF1, 0xFC, 0x00, 0x1F, 0x1F, 0xF0, 0x01, 0xF0, 0xFF, 0xE0,
  0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x07, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xB9, 0xFE, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFE, 0x3F, 0xE0, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xBE, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x0F,
  0xC3, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x7C, 0x07,
  0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC3,
  0xF0, 0x03, 0xE3, 0xF0, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7D,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07,
  0xFB, 0xF0, 0x03, 0xF8, 0xFC, 0x01, 0xF0, 0x7F, 0x00, 0xF8, 0x1F, 0x80,
  0x7C, 0x0F, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x7F,
  0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x0F, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x00,
  0xFC, 0x7C, 0x00, 0x7F, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xEF, 0x80,
  0x03, 0xF7, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFD, 0xF0, 0x00, 0x1F, 0xFF, 0xBE,
  0x00, 0x03, 0xFF, 0xF7, 0xC0, 0x00, 0x7F, 0xFF, 0x7C, 0x00, 0x1F, 0x7F,
  0xEF, 0x80, 0x03, 0xEF, 0xFD, 0xF0, 0x00, 0x7D, 0xFF, 0x9F, 0x00, 0x1F,
  0x3F, 0xF3, 0xE0, 0x03, 0xE7, 0xFE, 0x7C, 0x00, 0x7C, 0xFF, 0xC7, 0x80,
  0x1F, 0x1F, 0xF8, 0xF8, 0x03, 0xE3, 0xFF, 0x1F, 0x00, 0x7C, 0x7F, 0xE1,
  0xE0, 0x1F, 0x0F, 0xFC, 0x3E, 0x03, 0xE1, 0xFF, 0x87, 0xC0, 0x7C, 0x3F,
  0xF0, 0xF8, 0x1F, 0x07, 0xFE, 0x0F, 0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7C,
  0x1F, 0xF8, 0x3E, 0x1F, 0x03, 0xFF, 0x03, 0xE3, 0xE0, 0x7F, 0xE0, 0x7C,
  0x7C, 0x0F, 0xFC, 0x0F, 0x9F, 0x01, 0xFF, 0x80, 0xFB, 0xE0, 0x3F, 0xF0,
  0x1F, 0x7C, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F,
  0xF8, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0x00, 0x3F, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xF7, 0xE0, 0x01, 0xFF, 0x7E,
  0x00, 0x1F, 0xF3, 0xF0, 0x01, 0xFF, 0x9F, 0x80, 0x1F, 0xF9, 0xF8, 0x01,
  0xFF, 0x8F, 0xC0, 0x1F, 0xF8, 0xFC, 0x01, 0xFF, 0x87, 0xE0, 0x1F, 0xF8,
  0x7E, 0x01, 0xFF, 0x83, 0xF0, 0x1F, 0xF8, 0x3F, 0x01, 0xFF, 0x81, 0xF8,
  0x1F, 0xF8, 0x0F, 0xC1, 0xFF, 0x80, 0xFC, 0x1F, 0xF8, 0x07, 0xE1, 0xFF,
  0x80, 0x7E, 0x1F, 0xF8, 0x03, 0xF1, 0xFF, 0x80, 0x3F, 0x1F, 0xF8, 0x01,
  0xF9, 0xFF, 0x80, 0x1F, 0x9F, 0xF8, 0x00, 0xFD, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xEF, 0xFE, 0x03,
  0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F,
  0x8F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0,
  0x1F, 0xFC, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x40, 0x00, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xBF, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFD, 0xF8, 0x03, 0xFB, 0xF0, 0x1F, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x7F, 0xF8, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xEF, 0xFE, 0x03, 0xFC, 0x01,
  0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xFC,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x5F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0xFF,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xFC,
  0x3F, 0x00, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF0,
  0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFC,
  0x01, 0xC7, 0xE0, 0x01, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xF0, 0x01, 0xFB, 0xFC, 0x3F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x0F, 0x9F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x3F, 0x87,
  0xFE, 0x1F, 0xF0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x03,
  0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7E,
  0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF7, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xC7, 0xE0,
  0x07, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0xF0, 0x03, 0xE0, 0xF8, 0x01,
  0xEF, 0x80, 0x1F, 0x07, 0xC0, 0x1F, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0xF9,
  0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xCF, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x7C,
  0x03, 0xE0, 0x3E, 0x03, 0xE3, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0xF8, 0x7C, 0x0F, 0xC0, 0x7E, 0x07, 0xC3, 0xE0, 0x7C,
  0x01, 0xF0, 0x7C, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0xF8, 0x3F, 0x00,
  0x7E, 0x1F, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0xF8, 0x1F, 0x0F, 0x80, 0x0F,
  0x8F, 0x80, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x03, 0xC7, 0xE0, 0x03, 0xE3,
  0xE0, 0x1F, 0x3F, 0x00, 0x1F, 0x9F, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF0,
  0x07, 0xCF, 0x80, 0x03, 0xEF, 0x80, 0x1E, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0xF7, 0xE0, 0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xDE, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0xFC,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xE0, 0x7E,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0x80, 0x00,
  0xFD, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x81, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1,
  0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F,
  0x9F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xDF, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x07,
  0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x07,
  0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0x87, 0xF8, 0x30, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFC, 0x3F, 0x7F, 0x00, 0xFD, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFF, 0x7E, 0x07, 0xFD, 0xFF, 0xFD, 0xF3,
  0xFF, 0xE7, 0xC7, 0xFF, 0x9F, 0x0F, 0xF8, 0x3C, 0x02, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC1, 0xFC, 0x0F, 0x8F, 0xFC,
  0x1F, 0x3F, 0xFE, 0x3E, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0x01, 0xFD,
  0xFC, 0x01, 0xFB, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x01,
  0xFB, 0xFC, 0x03, 0xF7, 0xFC, 0x1F, 0xCF, 0xFF, 0xFF, 0x9F, 0x7F, 0xFE,
  0x3E, 0x7F, 0xF8, 0x78, 0x3F, 0xE0, 0x00, 0x04, 0x00, 0x00, 0xFF, 0x80,
  0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7E, 0x01, 0x9F,
  0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x01, 0x3F, 0xC1, 0xE7, 0xFF, 0xFC, 0x7F,
  0xFF, 0x87, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0xC1, 0xF0, 0x7F, 0xE3, 0xE3, 0xFF,
  0xE7, 0xCF, 0xFF, 0xEF, 0x9F, 0xFF, 0xFF, 0x7F, 0x01, 0xFE, 0xFC, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC, 0x01, 0xFD, 0xF8,
  0x03, 0xF9, 0xFC, 0x1F, 0xF3, 0xFF, 0xFF, 0xE3, 0xFF, 0xF7, 0xC3, 0xFF,
  0xCF, 0x83, 0xFE, 0x0F, 0x00, 0x40, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xF0, 0xFC, 0x07, 0xE7,
  0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x02, 0x3F, 0xC0, 0x78, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00, 0x08, 0x00, 0x3F, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFE, 0x07, 0xFF, 0x81, 0xF8, 0x20, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x1F,
  0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF8, 0x1E, 0x0F, 0xFC, 0x7C, 0x7F, 0xFC, 0xF8,
  0xFF, 0xFD, 0xF3, 0xFF, 0xFF, 0xEF, 0xE0, 0x3F, 0xDF, 0x80, 0x3F, 0xBE,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x7F,
  0x7F, 0x83, 0xFE, 0x7F, 0xFF, 0x7C, 0x7F, 0xFE, 0xF8, 0x7F, 0xF9, 0xF0,
  0x7F, 0xC3, 0xE0, 0x08, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF2, 0x00, 0x07, 0xE7, 0x80,
  0x3F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x0F,
  0xE0, 0xF8, 0xFF, 0xE3, 0xE7, 0xFF, 0xCF, 0xBF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFB, 0xFF, 0xFF, 0xF9, 0xE0, 0x00,
  0x00, 0x0F, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0x80,
  0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xEF, 0xFE,
  0xFF, 0xCF, 0xF8, 0xFF, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x07, 0xEF, 0x80, 0x1F, 0x9F, 0x00, 0x7E, 0x3E, 0x00,
  0xFC, 0x7C, 0x03, 0xF0, 0xF8, 0x0F, 0xC1, 0xF0, 0x3F, 0x03, 0xE0, 0xFC,
  0x07, 0xC3, 0xF0, 0x0F, 0x87, 0xE0, 0x1F, 0x1F, 0x80, 0x3E, 0x7E, 0x00,
  0x7D, 0xF8, 0x00, 0xFB, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x07,
  0xFB, 0xF0, 0x0F, 0xE7, 0xE0, 0x1F, 0x87, 0xE0, 0x3E, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xC0,
  0x1F, 0x8F, 0x80, 0x3F, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7C, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0x80, 0x7F, 0x83, 0xC3, 0xFF, 0x07, 0xFF, 0x8F,
  0xBF, 0xFE, 0x3F, 0xFF, 0x3E, 0xFF, 0xFD, 0xFF, 0xFC, 0xFF, 0xEF, 0xFF,
  0xEF, 0xFB, 0xFC, 0x0F, 0xFC, 0x07, 0xEF, 0xE0, 0x1F, 0xE0, 0x1F, 0xBF,
  0x00, 0x3F, 0x80, 0x3E, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xF8,
  0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xC0,
  0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0x00,
  0x3F, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x80,
  0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00,
  0xFF, 0xE0, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xFE, 0x00,
  0x3F, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0xF0, 0x3F, 0x83, 0xC3,
  0xFF, 0x8F, 0x9F, 0xFF, 0x3E, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFC, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xEF, 0xF8, 0x3F, 0x01, 0xFC, 0x7E, 0x00,
  0xFC, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7E, 0x00,
  0x7C, 0x7F, 0x00, 0xFC, 0x3F, 0x83, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x38, 0x00, 0xF0, 0x3F,
  0x81, 0xF1, 0xFF, 0xC3, 0xE7, 0xFF, 0xC7, 0xDF, 0xFF, 0xCF, 0xFE, 0x7F,
  0x9F, 0xE0, 0x3F, 0xBF, 0x80, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0x3F, 0x7F, 0x80, 0xFE, 0xFF, 0x83, 0xF9, 0xFF, 0xFF,
  0xF3, 0xEF, 0xFF, 0xC7, 0xCF, 0xFF, 0x0F, 0x87, 0xF8, 0x1F, 0x00, 0x80,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x1E, 0x0F, 0xFC, 0x7C, 0x7F, 0xFC, 0xF9, 0xFF, 0xFD, 0xF3, 0xFC,
  0xFF, 0xEF, 0xE0, 0x3F, 0xDF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xDF, 0x80, 0x3F, 0xBF, 0x00, 0x7F, 0x7F, 0x83, 0xFE, 0x7F,
  0xFF, 0x7C, 0x7F, 0xFE, 0xF8, 0x7F, 0xF9, 0xF0, 0x7F, 0xC3, 0xE0, 0x0C,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0xF0, 0x3F, 0xF0, 0xFF, 0xF9, 0xFE, 0xFB, 0xFE, 0xFB, 0xFE, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFE,
  0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0xBF, 0xFF, 0xE7, 0xF0, 0x7D, 0xF8, 0x01,
  0x3F, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x0F, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x7F, 0xFF, 0x83, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC1,
  0x0F, 0xFF, 0x07, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x20, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0xFF, 0x7F, 0x07, 0xFD, 0xFF, 0xFF, 0xF3, 0xFF, 0xF7,
  0xC7, 0xFF, 0x8F, 0x0F, 0xFC, 0x3C, 0x02, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xE7, 0xE0, 0x03,
  0xF1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x00,
  0x7E, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x07,
  0xE1, 0xF0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0xC0, 0x0F, 0xBF, 0x00, 0x7F, 0x00, 0x3E, 0x7C,
  0x01, 0xFE, 0x01, 0xF9, 0xF0, 0x0F, 0xF8, 0x07, 0xC7, 0xC0, 0x3D, 0xE0,
  0x1F, 0x1F, 0x80, 0xF7, 0xC0, 0x7C, 0x3E, 0x03, 0xDF, 0x03, 0xF0, 0xF8,
  0x1F, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0xF0, 0x3E, 0x0F, 0xC1, 0xE3, 0xE0,
  0xF8, 0x1F, 0x0F, 0x8F, 0x87, 0xE0, 0x7C, 0x3E, 0x3E, 0x1F, 0x01, 0xF0,
  0xF8, 0x78, 0x7C, 0x07, 0xE3, 0xC1, 0xF1, 0xF0, 0x0F, 0x9F, 0x07, 0xCF,
  0xC0, 0x3E, 0x7C, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x3C, 0xF8, 0x03, 0xE7,
  0x80, 0xF3, 0xE0, 0x07, 0xDE, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0x81,
  0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xE0, 0x07, 0xE7,
  0xE0, 0x03, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xE7, 0xC0, 0x07, 0xE7,
  0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x01,
  0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0xC0,
  0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x3E,
  0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xE0,
  0x0F, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xFC, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0xFF,
  0x03, 0xFE, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0x7F, 0xF8, 0x07,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0xC0, 0x1F, 0xFC,
  0x80, 0x03, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Medium53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 7, 39, 14, 3, -38 },
  { 36, 16, 14, 22, 3, -38 },
  { 64, 29, 38, 31, 1, -38 },
  { 202, 22, 43, 28, 3, -40 },
  { 321, 38, 38, 42, 2, -38 },
  { 502, 32, 39, 34, 2, -38 },
  { 658, 6, 14, 12, 3, -38 },
  { 669, 13, 46, 16, 2, -38 },
  { 744, 13, 46, 16, 1, -38 },
  { 819, 22, 22, 26, 2, -40 },
  { 880, 24, 25, 28, 2, -31 },
  { 955, 8, 13, 14, 2, -6 },
  { 968, 13, 5, 16, 2, -17 },
  { 977, 7, 8, 14, 3, -7 },
  { 984, 19, 38, 20, 1, -38 },
  { 1075, 23, 39, 28, 2, -38 },
  { 1188, 15, 38, 28, 4, -38 },
  { 1260, 23, 38, 28, 2, -38 },
  { 1370, 23, 39, 28, 2, -38 },
  { 1483, 26, 38, 28, 1, -38 },
  { 1607, 22, 39, 28, 3, -38 },
  { 1715, 24, 39, 28, 2, -38 },
  { 1832, 24, 38, 28, 2, -38 },
  { 1946, 24, 39, 28, 2, -38 },
  { 2063, 23, 39, 28, 2, -38 },
  { 2176, 7, 30, 14, 3, -29 },
  { 2203, 8, 36, 14, 2, -29 },
  { 2239, 24, 26, 28, 2, -32 },
  { 2317, 23, 15, 28, 2, -26 },
  { 2361, 24, 26, 28, 2, -32 },
  { 2439, 19, 39, 21, 1, -38 },
  { 2532, 38, 43, 43, 3, -38 },
  { 2737, 31, 38, 31, 0, -38 },
  { 2885, 25, 38, 32, 4, -38 },
  { 3004, 26, 39, 30, 3, -38 },
  { 3131, 28, 38, 35, 4, -38 },
  { 3264, 19, 38, 27, 5, -38 },
  { 3355, 19, 38, 25, 5, -38 },
  { 3446, 28, 39, 35, 3, -38 },
  { 3583, 26, 38, 36, 5, -38 },
  { 3707, 14, 38, 18, 2, -38 },
  { 3774, 14, 48, 14, -4, -38 },
  { 3858, 25, 38, 30, 5, -38 },
  { 3977, 20, 38, 25, 4, -38 },
  { 4072, 35, 38, 45, 5, -38 },
  { 4239, 28, 38, 37, 5, -38 },
  { 4372, 31, 39, 37, 3, -38 },
  { 4524, 23, 38, 29, 4, -38 },
  { 4634, 31, 47, 37, 3, -38 },
  { 4817, 26, 38, 30, 4, -38 },
  { 4941, 22, 39, 27, 2, -38 },
  { 5049, 25, 38, 27, 1, -38 },
  { 5168, 27, 39, 35, 4, -38 },
  { 5300, 30, 38, 30, 0, -38 },
  { 5443, 45, 38, 46, 0, -38 },
  { 5657, 28, 38, 29, 0, -38 },
  { 5790, 28, 38, 28, 0, -38 },
  { 5923, 23, 38, 27, 2, -38 },
  { 6033, 12, 46, 17, 4, -38 },
  { 6102, 19, 38, 20, 1, -38 },
  { 6193, 12, 46, 17, 1, -38 },
  { 6262, 26, 23, 28, 1, -38 },
  { 6337, 23, 3, 23, 0, 5 },
  { 6346, 12, 9, 16, 2, -41 },
  { 6360, 22, 30, 28, 2, -29 },
  { 6443, 23, 41, 30, 4, -40 },
  { 6561, 19, 30, 24, 3, -29 },
  { 6633, 23, 41, 30, 3, -40 },
  { 6751, 22, 30, 28, 3, -29 },
  { 6834, 18, 41, 17, 1, -41 },
  { 6927, 23, 42, 30, 3, -29 },
  { 7048, 22, 40, 30, 4, -40 },
  { 7158, 6, 39, 13, 4, -39 },
  { 7188, 12, 52, 13, -2, -39 },
  { 7266, 23, 40, 27, 4, -40 },
  { 7381, 5, 40, 13, 4, -40 },
  { 7406, 38, 29, 45, 4, -29 },
  { 7544, 22, 29, 30, 4, -29 },
  { 7624, 24, 30, 29, 3, -29 },
  { 7714, 23, 42, 30, 4, -29 },
  { 7835, 23, 42, 30, 3, -29 },
  { 7956, 16, 29, 20, 4, -29 },
  { 8014, 19, 30, 23, 2, -29 },
  { 8086, 16, 36, 18, 1, -35 },
  { 8158, 22, 30, 30, 4, -29 },
  { 8241, 25, 29, 25, 0, -29 },
  { 8332, 38, 29, 39, 1, -29 },
  { 8470, 24, 29, 26, 1, -29 },
  { 8557, 25, 42, 25, 0, -29 },
  { 8689, 19, 29, 22, 2, -29 },
  { 8758, 17, 46, 20, 1, -38 },
  { 8856, 5, 53, 27, 11, -40 },
  { 8890, 16, 46, 20, 2, -38 },
  { 8982, 24, 7, 28, 2, -22 },
};

const GFXfont NotoSans_SemiCondensed_Medium53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium53pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM53PT7B_H_
