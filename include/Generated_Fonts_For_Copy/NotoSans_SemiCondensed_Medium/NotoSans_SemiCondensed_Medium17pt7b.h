#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM17PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM17PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0x0F, 0xDE, 0xF7, 0x90, 0x09, 0x06, 0x41, 0x91, 0xFF,
  0x7F, 0xC4, 0x81, 0x23, 0xFE, 0x36, 0x09, 0x82, 0x40, 0x90, 0x10, 0x21,
  0xFE, 0x9D, 0x1A, 0x1E, 0x0E, 0x16, 0x2E, 0x5F, 0xE1, 0x02, 0x00, 0xF0,
  0x89, 0x18, 0x99, 0x09, 0xB0, 0x9A, 0x09, 0x6E, 0xF5, 0xB0, 0xD3, 0x09,
  0x31, 0x93, 0x11, 0xA3, 0x0E, 0x7C, 0x19, 0x04, 0x41, 0xB0, 0x7C, 0x0C,
  0x07, 0x8B, 0x36, 0xC7, 0xB0, 0xCE, 0xF9, 0xF7, 0xFF, 0x36, 0x4C, 0xCC,
  0x88, 0x8C, 0xCC, 0x46, 0x30, 0xE6, 0x33, 0x11, 0x11, 0x11, 0x33, 0x26,
  0xC0, 0x30, 0x62, 0x5F, 0xF3, 0x8D, 0x33, 0x00, 0x10, 0x20, 0x47, 0xFF,
  0xE2, 0x04, 0x08, 0xFE, 0xF0, 0xF0, 0x0C, 0x30, 0x86, 0x18, 0x43, 0x0C,
  0x21, 0x84, 0x30, 0x7D, 0xDB, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8D,
  0xB3, 0xE0, 0x19, 0xFE, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x30, 0x7D, 0x98,
  0x18, 0x30, 0x41, 0x86, 0x18, 0x30, 0xC3, 0xFF, 0xF0, 0xFD, 0x9C, 0x18,
  0x30, 0xCF, 0x07, 0x03, 0x06, 0x0E, 0x3F, 0xE0, 0x06, 0x07, 0x03, 0x83,
  0xC3, 0x61, 0x31, 0x98, 0x8C, 0xFF, 0x83, 0x01, 0x80, 0xC0, 0x7D, 0x83,
  0x06, 0x0D, 0x1F, 0x81, 0x83, 0x06, 0x0E, 0x37, 0xC0, 0x3C, 0xC3, 0x06,
  0x0D, 0x97, 0xB1, 0xE3, 0xC7, 0x8D, 0xB9, 0xE0, 0xFE, 0x0C, 0x18, 0x60,
  0xC1, 0x06, 0x0C, 0x30, 0x60, 0x83, 0x00, 0x7D, 0x8F, 0x1E, 0x36, 0xC7,
  0x1F, 0x63, 0x87, 0x0F, 0x1B, 0xE0, 0x7D, 0x9B, 0x1C, 0x38, 0x78, 0xFF,
  0x9B, 0x06, 0x08, 0x77, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xF8, 0x02,
  0x1C, 0xE7, 0x0E, 0x07, 0x03, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x81, 0xC0,
  0xE0, 0x70, 0xE7, 0x38, 0x40, 0xFC, 0x98, 0x18, 0x20, 0xC3, 0x0C, 0x18,
  0x00, 0x00, 0xC1, 0x80, 0x1F, 0x83, 0x0C, 0x60, 0x24, 0x7B, 0xC9, 0x99,
  0x99, 0x91, 0x99, 0x11, 0x99, 0xBC, 0xEE, 0x40, 0x06, 0x00, 0x3F, 0x80,
  0x0C, 0x07, 0x81, 0xE0, 0x58, 0x33, 0x0C, 0xC3, 0x31, 0xFC, 0x7F, 0x98,
  0x6C, 0x0B, 0x03, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xFC, 0xC7, 0xC3, 0xC3,
  0xC3, 0xFF, 0xFE, 0x3F, 0x71, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x60, 0x73, 0x3F, 0xFE, 0x63, 0xB0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE1, 0xBF, 0xDF, 0x80, 0xFF, 0x83, 0x06, 0x0C, 0x1F, 0xB0, 0x60,
  0xC1, 0x83, 0xFF, 0xF0, 0xFF, 0x83, 0x06, 0x0C, 0x1F, 0xBF, 0x60, 0xC1,
  0x83, 0x06, 0x00, 0x3F, 0xB8, 0xD8, 0x18, 0x0C, 0x06, 0x3F, 0x1F, 0x83,
  0xC1, 0xB0, 0xDC, 0x67, 0xF0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0xF6, 0x66, 0x66, 0x66, 0x66,
  0x6F, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xE0, 0xC3, 0xE3, 0x31,
  0x99, 0x8D, 0x87, 0xC3, 0xE1, 0x98, 0xC6, 0x63, 0x30, 0xD8, 0x70, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xF0, 0xE0, 0x7F,
  0x07, 0xF0, 0x7D, 0x0F, 0xD8, 0xBD, 0x8B, 0xC9, 0xBC, 0x93, 0xCD, 0x3C,
  0x73, 0xC6, 0x3C, 0x63, 0xE0, 0xFC, 0x3F, 0x0F, 0x63, 0xD8, 0xF3, 0x3C,
  0xCF, 0x1B, 0xC6, 0xF0, 0xFC, 0x1F, 0x07, 0x3F, 0x1C, 0xE6, 0x1B, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD8, 0x67, 0x38, 0xFC, 0xFC, 0xCE,
  0xC3, 0xC3, 0xC3, 0xC6, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3F, 0x1C,
  0xE6, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xD8, 0x67, 0x38,
  0xFC, 0x03, 0x00, 0xC0, 0x1C, 0xFC, 0x63, 0x30, 0xD8, 0x6C, 0x36, 0x73,
  0xF1, 0x98, 0xC6, 0x63, 0x30, 0xD8, 0x70, 0x7F, 0x8B, 0x06, 0x0E, 0x0F,
  0x07, 0x07, 0x06, 0x0F, 0x37, 0xC0, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xA0, 0xDC, 0xC7, 0xC0, 0xC1, 0xA0, 0xD8, 0x6C,
  0x26, 0x31, 0x18, 0xC8, 0x6C, 0x16, 0x0E, 0x07, 0x01, 0x80, 0xC3, 0x07,
  0x87, 0x19, 0x0E, 0x33, 0x14, 0x66, 0x68, 0x8C, 0xDB, 0x09, 0x36, 0x1A,
  0x2C, 0x3C, 0x50, 0x78, 0xE0, 0x61, 0xC0, 0xC1, 0x80, 0xE1, 0xB1, 0x8C,
  0x86, 0xC1, 0xC0, 0xE0, 0x70, 0x2C, 0x36, 0x31, 0x98, 0xD8, 0x30, 0xC1,
  0xB1, 0x98, 0xC6, 0xC3, 0x60, 0xE0, 0x70, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0xFE, 0x0C, 0x30, 0x61, 0x86, 0x0C, 0x30, 0x61, 0x83, 0xFF, 0xF0,
  0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC1, 0x06, 0x08, 0x30,
  0xC1, 0x06, 0x18, 0x20, 0xC1, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F,
  0xF0, 0x08, 0x0E, 0x05, 0x06, 0xC2, 0x23, 0x1B, 0x06, 0xFF, 0xFC, 0xCC,
  0x80, 0x7C, 0x88, 0x18, 0xFF, 0xF8, 0xE1, 0xE7, 0xF6, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFE, 0xE6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE6, 0xDC, 0x7F, 0x9C,
  0x30, 0xC3, 0x0C, 0x39, 0x7C, 0x02, 0x04, 0x08, 0x17, 0xB8, 0xF1, 0xE1,
  0xC3, 0x87, 0x1F, 0x37, 0xA0, 0x7D, 0x8F, 0x1F, 0xFF, 0xF8, 0x30, 0x31,
  0x3E, 0x1C, 0xD2, 0x08, 0xF8, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x7B,
  0x8F, 0x1E, 0x1C, 0x38, 0x71, 0xF3, 0x7A, 0x04, 0x1E, 0x7F, 0xC0, 0xC1,
  0x83, 0x06, 0x0F, 0xFC, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x20, 0x70,
  0xFF, 0xFF, 0xC0, 0x13, 0x00, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3B, 0xE0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC6, 0xCC, 0xD8, 0xF0, 0xF8, 0xD8, 0xCC, 0xC6,
  0xC7, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x73, 0xC6, 0x1C, 0x61, 0xC6,
  0x1C, 0x61, 0xC6, 0x1C, 0x61, 0xC6, 0x10, 0xFF, 0xCF, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC2, 0x7C, 0xC6, 0xC2, 0xC3, 0xC3, 0xC3, 0xC2, 0x66, 0x3C,
  0xFE, 0xE6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE6, 0xDC, 0xC0, 0xC0, 0xC0,
  0xC0, 0x7B, 0x8F, 0x1E, 0x1C, 0x38, 0x71, 0xF3, 0x7A, 0x04, 0x08, 0x10,
  0x20, 0xDF, 0x31, 0x8C, 0x63, 0x18, 0xC0, 0xFF, 0x28, 0x38, 0x78, 0x70,
  0xE3, 0xF8, 0x21, 0x3E, 0xC6, 0x31, 0x8C, 0x61, 0xCE, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x71, 0xF3, 0x7A, 0xC3, 0x43, 0x66, 0x66, 0x26, 0x34, 0x3C,
  0x1C, 0x18, 0xC6, 0x14, 0x73, 0x65, 0x36, 0xD2, 0x6D, 0x22, 0x9E, 0x29,
  0xE3, 0x8C, 0x38, 0xC0, 0xE3, 0x66, 0x3C, 0x1C, 0x18, 0x3C, 0x36, 0x66,
  0xC3, 0xC3, 0x43, 0x66, 0x66, 0x26, 0x34, 0x3C, 0x1C, 0x18, 0x18, 0x18,
  0x30, 0xE0, 0xF8, 0x61, 0x8C, 0x21, 0x8C, 0x30, 0xFC, 0x1C, 0x63, 0x0C,
  0x30, 0xC7, 0x38, 0x30, 0xC3, 0x0C, 0x30, 0x70, 0xC0, 0xFF, 0xFF, 0x80,
  0xC3, 0x18, 0xC6, 0x30, 0xC7, 0x63, 0x18, 0xC6, 0x72, 0x00, 0xF3, 0x3C,
};

const GFXglyph NotoSans_SemiCondensed_Medium17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 12, 4, 1, -12 },
  { 4, 5, 4, 7, 1, -12 },
  { 7, 10, 12, 10, 0, -12 },
  { 22, 7, 14, 9, 1, -13 },
  { 35, 12, 12, 14, 1, -12 },
  { 53, 10, 12, 11, 1, -12 },
  { 68, 2, 4, 4, 1, -12 },
  { 69, 4, 15, 5, 1, -12 },
  { 77, 4, 15, 5, 0, -12 },
  { 85, 7, 7, 8, 1, -13 },
  { 92, 7, 8, 9, 1, -10 },
  { 99, 2, 4, 4, 1, -2 },
  { 100, 4, 1, 5, 1, -5 },
  { 101, 2, 2, 4, 1, -2 },
  { 102, 6, 12, 7, 0, -12 },
  { 111, 7, 12, 9, 1, -12 },
  { 122, 5, 12, 9, 1, -12 },
  { 130, 7, 12, 9, 1, -12 },
  { 141, 7, 12, 9, 1, -12 },
  { 152, 9, 12, 9, 0, -12 },
  { 166, 7, 12, 9, 1, -12 },
  { 177, 7, 12, 9, 1, -12 },
  { 188, 7, 12, 9, 1, -12 },
  { 199, 7, 12, 9, 1, -12 },
  { 210, 7, 12, 9, 1, -12 },
  { 221, 2, 9, 4, 1, -9 },
  { 224, 2, 11, 4, 1, -9 },
  { 227, 7, 8, 9, 1, -10 },
  { 234, 7, 4, 9, 1, -8 },
  { 238, 7, 8, 9, 1, -10 },
  { 245, 7, 12, 7, 0, -12 },
  { 256, 12, 13, 14, 1, -12 },
  { 276, 10, 12, 10, 0, -12 },
  { 291, 8, 12, 10, 1, -12 },
  { 303, 8, 12, 10, 1, -12 },
  { 315, 9, 12, 11, 1, -12 },
  { 329, 7, 12, 9, 1, -12 },
  { 340, 7, 12, 8, 1, -12 },
  { 351, 9, 12, 11, 1, -12 },
  { 365, 9, 12, 11, 1, -12 },
  { 379, 4, 12, 6, 1, -12 },
  { 385, 4, 15, 5, -1, -12 },
  { 393, 9, 12, 10, 1, -12 },
  { 407, 7, 12, 8, 1, -12 },
  { 418, 12, 12, 14, 1, -12 },
  { 436, 10, 12, 12, 1, -12 },
  { 451, 10, 12, 12, 1, -12 },
  { 466, 8, 12, 9, 1, -12 },
  { 478, 10, 15, 12, 1, -12 },
  { 497, 9, 12, 10, 1, -12 },
  { 511, 7, 12, 9, 1, -12 },
  { 522, 8, 12, 9, 0, -12 },
  { 534, 9, 12, 11, 1, -12 },
  { 548, 9, 12, 9, 0, -12 },
  { 562, 15, 12, 15, 0, -12 },
  { 585, 9, 12, 9, 0, -12 },
  { 599, 9, 12, 9, 0, -12 },
  { 613, 7, 12, 9, 1, -12 },
  { 624, 4, 15, 5, 1, -12 },
  { 632, 6, 12, 7, 0, -12 },
  { 641, 4, 15, 5, 0, -12 },
  { 649, 9, 7, 9, 0, -12 },
  { 657, 7, 2, 7, 0, 1 },
  { 659, 3, 3, 5, 1, -13 },
  { 661, 7, 9, 9, 1, -9 },
  { 669, 8, 13, 10, 1, -13 },
  { 682, 6, 9, 8, 1, -9 },
  { 689, 7, 13, 10, 1, -13 },
  { 701, 7, 9, 9, 1, -9 },
  { 709, 6, 13, 6, 0, -13 },
  { 719, 7, 13, 10, 1, -9 },
  { 731, 7, 13, 10, 1, -13 },
  { 743, 2, 13, 4, 1, -13 },
  { 747, 4, 17, 4, -1, -13 },
  { 756, 8, 13, 9, 1, -13 },
  { 769, 2, 13, 4, 1, -13 },
  { 773, 12, 9, 15, 1, -9 },
  { 787, 7, 9, 10, 1, -9 },
  { 795, 8, 9, 9, 1, -9 },
  { 804, 8, 13, 10, 1, -9 },
  { 817, 7, 13, 10, 1, -9 },
  { 829, 5, 9, 7, 1, -9 },
  { 835, 6, 9, 7, 1, -9 },
  { 842, 5, 11, 6, 0, -11 },
  { 849, 7, 9, 10, 1, -9 },
  { 857, 8, 9, 8, 0, -9 },
  { 866, 12, 9, 13, 0, -9 },
  { 880, 8, 9, 8, 0, -9 },
  { 889, 8, 13, 8, 0, -9 },
  { 902, 6, 9, 7, 1, -9 },
  { 909, 6, 15, 6, 0, -12 },
  { 921, 1, 17, 9, 4, -13 },
  { 924, 5, 15, 6, 1, -12 },
  { 934, 7, 2, 9, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_Medium17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium17pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM17PT7B_H_
