#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/NotoSans_SemiCondensed_Medium
// Headers: 67

#include "NotoSans_SemiCondensed_Medium6pt7b.h"
#include "NotoSans_SemiCondensed_Medium7pt7b.h"
#include "NotoSans_SemiCondensed_Medium8pt7b.h"
#include "NotoSans_SemiCondensed_Medium9pt7b.h"
#include "NotoSans_SemiCondensed_Medium10pt7b.h"
#include "NotoSans_SemiCondensed_Medium11pt7b.h"
#include "NotoSans_SemiCondensed_Medium12pt7b.h"
#include "NotoSans_SemiCondensed_Medium13pt7b.h"
#include "NotoSans_SemiCondensed_Medium14pt7b.h"
#include "NotoSans_SemiCondensed_Medium15pt7b.h"
#include "NotoSans_SemiCondensed_Medium16pt7b.h"
#include "NotoSans_SemiCondensed_Medium17pt7b.h"
#include "NotoSans_SemiCondensed_Medium18pt7b.h"
#include "NotoSans_SemiCondensed_Medium19pt7b.h"
#include "NotoSans_SemiCondensed_Medium20pt7b.h"
#include "NotoSans_SemiCondensed_Medium21pt7b.h"
#include "NotoSans_SemiCondensed_Medium22pt7b.h"
#include "NotoSans_SemiCondensed_Medium23pt7b.h"
#include "NotoSans_SemiCondensed_Medium24pt7b.h"
#include "NotoSans_SemiCondensed_Medium25pt7b.h"
#include "NotoSans_SemiCondensed_Medium26pt7b.h"
#include "NotoSans_SemiCondensed_Medium27pt7b.h"
#include "NotoSans_SemiCondensed_Medium28pt7b.h"
#include "NotoSans_SemiCondensed_Medium29pt7b.h"
#include "NotoSans_SemiCondensed_Medium30pt7b.h"
#include "NotoSans_SemiCondensed_Medium31pt7b.h"
#include "NotoSans_SemiCondensed_Medium32pt7b.h"
#include "NotoSans_SemiCondensed_Medium33pt7b.h"
#include "NotoSans_SemiCondensed_Medium34pt7b.h"
#include "NotoSans_SemiCondensed_Medium35pt7b.h"
#include "NotoSans_SemiCondensed_Medium36pt7b.h"
#include "NotoSans_SemiCondensed_Medium37pt7b.h"
#include "NotoSans_SemiCondensed_Medium38pt7b.h"
#include "NotoSans_SemiCondensed_Medium39pt7b.h"
#include "NotoSans_SemiCondensed_Medium40pt7b.h"
#include "NotoSans_SemiCondensed_Medium41pt7b.h"
#include "NotoSans_SemiCondensed_Medium42pt7b.h"
#include "NotoSans_SemiCondensed_Medium43pt7b.h"
#include "NotoSans_SemiCondensed_Medium44pt7b.h"
#include "NotoSans_SemiCondensed_Medium45pt7b.h"
#include "NotoSans_SemiCondensed_Medium46pt7b.h"
#include "NotoSans_SemiCondensed_Medium47pt7b.h"
#include "NotoSans_SemiCondensed_Medium48pt7b.h"
#include "NotoSans_SemiCondensed_Medium49pt7b.h"
#include "NotoSans_SemiCondensed_Medium50pt7b.h"
#include "NotoSans_SemiCondensed_Medium51pt7b.h"
#include "NotoSans_SemiCondensed_Medium52pt7b.h"
#include "NotoSans_SemiCondensed_Medium53pt7b.h"
#include "NotoSans_SemiCondensed_Medium54pt7b.h"
#include "NotoSans_SemiCondensed_Medium55pt7b.h"
#include "NotoSans_SemiCondensed_Medium56pt7b.h"
#include "NotoSans_SemiCondensed_Medium57pt7b.h"
#include "NotoSans_SemiCondensed_Medium58pt7b.h"
#include "NotoSans_SemiCondensed_Medium59pt7b.h"
#include "NotoSans_SemiCondensed_Medium60pt7b.h"
#include "NotoSans_SemiCondensed_Medium61pt7b.h"
#include "NotoSans_SemiCondensed_Medium62pt7b.h"
#include "NotoSans_SemiCondensed_Medium63pt7b.h"
#include "NotoSans_SemiCondensed_Medium64pt7b.h"
#include "NotoSans_SemiCondensed_Medium65pt7b.h"
#include "NotoSans_SemiCondensed_Medium66pt7b.h"
#include "NotoSans_SemiCondensed_Medium67pt7b.h"
#include "NotoSans_SemiCondensed_Medium68pt7b.h"
#include "NotoSans_SemiCondensed_Medium69pt7b.h"
#include "NotoSans_SemiCondensed_Medium70pt7b.h"
#include "NotoSans_SemiCondensed_Medium71pt7b.h"
#include "NotoSans_SemiCondensed_Medium72pt7b.h"
