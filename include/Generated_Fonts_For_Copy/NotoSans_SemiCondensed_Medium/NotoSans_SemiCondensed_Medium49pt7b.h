#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM49PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium49pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x1E, 0x1C, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0xBF, 0x7F, 0xFF, 0xF9, 0xF1, 0x80, 0xF8, 0x7F, 0xF0,
  0xFB, 0xE1, 0xF7, 0xC3, 0xEF, 0x87, 0xDF, 0x07, 0xBE, 0x0F, 0x3C, 0x1E,
  0x78, 0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x03, 0xC0, 0x00, 0x78,
  0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0xF0, 0x00,
  0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x38, 0x00, 0x3C, 0x1E, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x1E, 0x07, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x3C, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x3F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x81, 0xE0, 0x78, 0x00, 0x78,
  0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xC0, 0xF0, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFE, 0x7F, 0x71, 0xE3, 0xE3, 0x81, 0x1F, 0x1C, 0x01, 0xF0, 0xE0, 0x0F,
  0x87, 0x00, 0x3E, 0x38, 0x01, 0xF1, 0xC0, 0x0F, 0xEE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xDF, 0xC0, 0x0E, 0x3F, 0x00, 0x70, 0xF8, 0x03, 0x87,
  0xC0, 0x1C, 0x1E, 0x00, 0xE1, 0xF8, 0x07, 0x0F, 0xF8, 0x38, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC1, 0xFF, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x1F, 0xC0, 0x00, 0xF0, 0x07, 0xFE, 0x00, 0x3C, 0x00, 0xFF, 0xC0,
  0x07, 0x80, 0x3E, 0x7C, 0x01, 0xE0, 0x07, 0x87, 0x80, 0x3C, 0x01, 0xF0,
  0xF8, 0x0F, 0x00, 0x3C, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x78, 0x00,
  0xF0, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x78,
  0x00, 0x78, 0x1E, 0x1E, 0x00, 0x0F, 0x03, 0xC3, 0xC0, 0x01, 0xE0, 0x78,
  0xF0, 0x20, 0x3C, 0x0F, 0x1E, 0x3F, 0x83, 0xC3, 0xE7, 0x8F, 0xF8, 0x78,
  0x78, 0xF1, 0xFF, 0x8F, 0x9F, 0x3E, 0x7C, 0xF8, 0xFF, 0xC7, 0x8F, 0x0F,
  0x1F, 0xF9, 0xF3, 0xC1, 0xE0, 0xFC, 0x3C, 0x78, 0x1E, 0x00, 0x0F, 0x8F,
  0x03, 0xC0, 0x01, 0xE1, 0xE0, 0x78, 0x00, 0x7C, 0x3C, 0x0F, 0x00, 0x0F,
  0x07, 0x81, 0xE0, 0x03, 0xE0, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x07, 0x80,
  0x0F, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xC0, 0x1F, 0x3E, 0x00, 0xF0, 0x01,
  0xFF, 0x80, 0x1E, 0x00, 0x3F, 0xE0, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x1E,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xC1, 0xFF, 0xE0, 0x1F, 0x0F, 0xEF,
  0xC0, 0x7C, 0x7E, 0x1F, 0x83, 0xE1, 0xF8, 0x3F, 0x0F, 0x8F, 0xC0, 0xFE,
  0x3E, 0x3F, 0x01, 0xF9, 0xF0, 0xF8, 0x03, 0xFF, 0xC3, 0xE0, 0x07, 0xFE,
  0x0F, 0x80, 0x0F, 0xF8, 0x3E, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x01,
  0xF8, 0x03, 0xFE, 0x07, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE7, 0xF0, 0x7F, 0xFF, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0x00, 0x01, 0xF0, 0x3E, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03,
  0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC3, 0xC1,
  0xDF, 0xDE, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x03,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x1E, 0x7C, 0x01, 0xF3, 0xE0,
  0x1F, 0x0F, 0x81, 0xF8, 0x7E, 0x03, 0x81, 0xE0, 0x0C, 0x0C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78,
  0xF8, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7D, 0xFB, 0xFF,
  0xFF, 0xCF, 0x84, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0xFC, 0x1F, 0x83,
  0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x7C, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x3E, 0xFC, 0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E,
  0x7C, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0xE1, 0xF8, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xF8,
  0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x9F, 0xFD, 0xFB, 0xFF, 0x9F, 0xF8,
  0xFB, 0x87, 0xC8, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x07, 0xFE, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xE0, 0x7E, 0x1C, 0x01, 0xF8, 0xC0,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xC7, 0xC0, 0x7F, 0x18, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFB, 0xC0, 0x1F,
  0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x3D, 0xE0, 0x00,
  0x79, 0xE0, 0x00, 0xF9, 0xE0, 0x00, 0xF3, 0xE0, 0x01, 0xF3, 0xE0, 0x01,
  0xE3, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0x83, 0xE0, 0x0F,
  0x83, 0xE0, 0x0F, 0x03, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x7F, 0xFF, 0xC7, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x9F, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE8, 0x00, 0x7E, 0xE0,
  0x1F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE1, 0xFC, 0x07, 0x9F, 0xFC, 0x3E, 0xFF, 0xF8, 0xFB, 0xFF, 0xF3, 0xFE,
  0x0F, 0xCF, 0xE0, 0x1F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xE0, 0x03,
  0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0xFC, 0x07, 0xE1, 0xF8,
  0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x9F, 0x00, 0x3E,
  0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x3F,
  0x03, 0xE0, 0x7E, 0x3F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xE7, 0xF8, 0x3F, 0x07, 0xF1,
  0xF8, 0x0F, 0xC7, 0xC0, 0x1F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFB, 0xF0, 0x03,
  0xE7, 0xE0, 0x1F, 0x9F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x83, 0xF0, 0x7E, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3E,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0x7C, 0x03, 0xFB,
  0xF8, 0x3F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFD, 0xF0, 0xFF, 0xCF, 0x83, 0xFC,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x38,
  0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xBF, 0x7F, 0xFF, 0xF9, 0xF0, 0x80,
  0x1C, 0x3E, 0x7E, 0x7F, 0x7F, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E,
  0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0x00, 0x00, 0x04,
  0x00, 0x00, 0x30, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0xFC,
  0x07, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0x80, 0xFC, 0x40, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x40, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x7F, 0xC3, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xC0,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x07, 0xC3, 0xC0, 0x0F, 0x80, 0x78, 0x78, 0x0F, 0xFF, 0x0F,
  0x1E, 0x03, 0xFF, 0xE0, 0xF3, 0xC0, 0xFF, 0xFC, 0x1E, 0xF8, 0x3E, 0x07,
  0x83, 0xDE, 0x07, 0x80, 0xF0, 0x7B, 0xC1, 0xF0, 0x1E, 0x07, 0x78, 0x3C,
  0x07, 0xC0, 0xEF, 0x07, 0x80, 0xF8, 0x1D, 0xE0, 0xF0, 0x1F, 0x03, 0xB8,
  0x1E, 0x03, 0xC0, 0x7F, 0x03, 0xC0, 0x78, 0x1F, 0xE0, 0x78, 0x0F, 0x03,
  0xDC, 0x0F, 0x01, 0xE0, 0x7B, 0xC1, 0xE0, 0x3C, 0x0F, 0x78, 0x3C, 0x0F,
  0xC3, 0xCF, 0x07, 0xC3, 0xB8, 0xF9, 0xE0, 0x7F, 0xF7, 0xFE, 0x3C, 0x07,
  0xFC, 0x7F, 0x83, 0xC0, 0x7F, 0x0F, 0xE0, 0x78, 0x01, 0x00, 0x20, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0x80, 0x01, 0xFF, 0x87,
  0xF0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80,
  0x0F, 0x80, 0x3E, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xF8, 0x00,
  0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E,
  0x1F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0x7C,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7E, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x80, 0xFF,
  0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F,
  0x00, 0x3F, 0x3E, 0x03, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xC0, 0x1F, 0xCF, 0x80, 0x0F, 0xDF, 0x00,
  0x0F, 0xBE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xDF, 0x00, 0x3F,
  0xBE, 0x03, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0x83,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0x3C, 0x1F, 0xC0, 0x04, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x1C,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0xF8, 0x3F, 0xF8, 0x3E, 0x00, 0x7F, 0x0F, 0x80, 0x0F, 0xE3, 0xE0,
  0x01, 0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xFB,
  0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x0F,
  0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0xFE, 0x3E, 0x00,
  0xFF, 0x0F, 0x83, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xF8, 0x0F,
  0x87, 0xF0, 0x00, 0x43, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7C,
  0xFC, 0x00, 0x1F, 0x3F, 0x80, 0x07, 0xC7, 0xF0, 0x01, 0xF1, 0xFF, 0x00,
  0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFE, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x83, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x7E, 0xFF, 0xEF, 0xFC,
  0xFF, 0xCF, 0xF0, 0x38, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8,
  0x07, 0xE0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0xF8,
  0x3F, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF9,
  0xF8, 0x00, 0xFB, 0xF0, 0x00, 0xFB, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0x7E, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8,
  0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xF8,
  0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xDF, 0xFF, 0x80, 0x01, 0xEF, 0xFB, 0xC0, 0x01, 0xF7, 0xFD, 0xF0,
  0x00, 0xF3, 0xFE, 0xF8, 0x00, 0x79, 0xFF, 0x3C, 0x00, 0x7C, 0xFF, 0x9F,
  0x00, 0x3C, 0xFF, 0xCF, 0x80, 0x1E, 0x7F, 0xE3, 0xC0, 0x1F, 0x3F, 0xF1,
  0xF0, 0x0F, 0x1F, 0xF8, 0xF8, 0x07, 0x8F, 0xFC, 0x3C, 0x07, 0xC7, 0xFE,
  0x1F, 0x03, 0xC3, 0xFF, 0x0F, 0x81, 0xE1, 0xFF, 0x83, 0xC1, 0xF0, 0xFF,
  0xC1, 0xF0, 0xF0, 0x7F, 0xE0, 0xF8, 0x78, 0x3F, 0xF0, 0x3C, 0x7C, 0x1F,
  0xF8, 0x1F, 0x3C, 0x0F, 0xFC, 0x0F, 0x9E, 0x07, 0xFE, 0x03, 0xDF, 0x03,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xC0,
  0x7F, 0xE0, 0x1F, 0xC0, 0x3F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF8, 0x03, 0xF0,
  0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFB, 0xE0, 0x03, 0xFE, 0xFC, 0x00, 0xFF, 0x9F, 0x00, 0x3F, 0xE7, 0xE0,
  0x0F, 0xF8, 0xF8, 0x03, 0xFE, 0x3F, 0x00, 0xFF, 0x87, 0xC0, 0x3F, 0xE1,
  0xF8, 0x0F, 0xF8, 0x3F, 0x03, 0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF8, 0x3F,
  0xE0, 0x3E, 0x0F, 0xF8, 0x0F, 0xC3, 0xFE, 0x01, 0xF0, 0xFF, 0x80, 0x7E,
  0x3F, 0xE0, 0x0F, 0x8F, 0xF8, 0x03, 0xF3, 0xFE, 0x00, 0x7E, 0xFF, 0x80,
  0x1F, 0xBF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xF0,
  0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xCF, 0x87, 0xFF, 0x7C, 0x03, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7E, 0xF8, 0x07, 0xF7,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE, 0x00, 0x7F,
  0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xF8, 0x1F, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8,
  0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0,
  0xF8, 0x03, 0xF0, 0xF8, 0x3F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0,
  0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F,
  0x03, 0xFF, 0x80, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0x83,
  0xE7, 0xE0, 0x06, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03,
  0xE7, 0xC0, 0x03, 0xF3, 0xF0, 0x03, 0xF0, 0xFE, 0x03, 0xF8, 0x7F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE1, 0xF0,
  0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C,
  0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80,
  0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF9, 0xF0, 0x00,
  0x1F, 0x3C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xDF, 0x00, 0x0F, 0xC0, 0x03, 0xF7, 0xC0, 0x03, 0xF0,
  0x00, 0xF9, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x7F, 0x80, 0x0F,
  0x8F, 0x80, 0x1F, 0xE0, 0x03, 0xE3, 0xE0, 0x07, 0xF8, 0x01, 0xF0, 0xF8,
  0x01, 0xFE, 0x00, 0x7C, 0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x07, 0xC0, 0x3E,
  0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x3C, 0x03, 0xE0, 0x7C, 0x03, 0xCF, 0x00,
  0xF8, 0x1F, 0x01, 0xF3, 0xE0, 0x3E, 0x07, 0xE0, 0x7C, 0xF8, 0x0F, 0x80,
  0xF8, 0x1E, 0x1E, 0x07, 0xE0, 0x3E, 0x07, 0x87, 0xC1, 0xF0, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x03, 0xE0, 0xF8, 0x7C, 0x1F, 0x00, 0x7C, 0x3C, 0x0F,
  0x07, 0xC0, 0x1F, 0x0F, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0xF8, 0xF8,
  0x01, 0xF1, 0xF0, 0x3E, 0x3E, 0x00, 0x3E, 0x78, 0x07, 0x8F, 0x80, 0x0F,
  0x9E, 0x01, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x00, 0xFB, 0xE0,
  0x1F, 0x7C, 0x00, 0x1E, 0xF0, 0x03, 0xDF, 0x00, 0x07, 0xBC, 0x00, 0xF7,
  0x80, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x07,
  0xC0, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x01,
  0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7E,
  0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xDF,
  0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x3E,
  0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0xFC, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x03,
  0xE3, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xEF, 0x00, 0x01, 0xE7, 0x80, 0x03, 0xC7, 0x80, 0x03, 0xC3, 0xC0,
  0x07, 0xC3, 0xC0, 0x07, 0x81, 0xE0, 0x0F, 0x81, 0xE0, 0x0F, 0x00, 0xF0,
  0x1F, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xFE, 0x00, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0x07, 0xE0, 0x80, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x1F,
  0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0xE1, 0xF7, 0xE0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF,
  0x80, 0x3F, 0xFC, 0x0F, 0xF7, 0xFF, 0xFF, 0x7F, 0xFC, 0xF3, 0xFF, 0x8F,
  0x1F, 0xF0, 0xF0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x81, 0xF3, 0xFF, 0x0F, 0xBF,
  0xFC, 0x7B, 0xFF, 0xF3, 0xFE, 0x3F, 0x9F, 0xC0, 0x7E, 0xFC, 0x01, 0xF7,
  0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x07,
  0xDF, 0x80, 0x7E, 0xFE, 0x07, 0xF7, 0xFF, 0xFF, 0x3D, 0xFF, 0xF1, 0xE7,
  0xFF, 0x0F, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F, 0xFC,
  0x7F, 0xFF, 0x1F, 0xE7, 0x8F, 0xC0, 0x23, 0xE0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x0C, 0x7F, 0xFF, 0x0F,
  0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x87,
  0xC1, 0xFF, 0x9F, 0x0F, 0xFF, 0x7C, 0x7F, 0xFF, 0xF3, 0xFC, 0x7F, 0xCF,
  0xC0, 0x7F, 0x7E, 0x00, 0xFD, 0xF8, 0x03, 0xF7, 0xC0, 0x07, 0xDF, 0x00,
  0x1F, 0x7C, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C,
  0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x3F, 0x03,
  0xFC, 0x7F, 0xFF, 0xF1, 0xFF, 0xF3, 0xC3, 0xFF, 0x8F, 0x03, 0xFC, 0x3C,
  0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xF8,
  0x7E, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x01,
  0xFF, 0x81, 0xFF, 0x81, 0xFF, 0xC1, 0xFF, 0xE0, 0xFC, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0xFF,
  0x8F, 0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0xF0,
  0xFF, 0xF3, 0xC7, 0xFF, 0xFF, 0x3F, 0xCF, 0xFC, 0xFC, 0x07, 0xF7, 0xE0,
  0x0F, 0xDF, 0x80, 0x3F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00,
  0x1F, 0x7E, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xF0, 0x3F, 0xC7, 0xFF, 0xFF,
  0x1F, 0xFF, 0x7C, 0x3F, 0xF9, 0xF0, 0x3F, 0xC7, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0xC0, 0x07, 0xE3, 0xFD, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x7E, 0x0F, 0x9F, 0xF8,
  0xFB, 0xFF, 0xCF, 0x7F, 0xFE, 0xFF, 0xCF, 0xFF, 0xE0, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xF0, 0x11, 0xEF, 0xFF, 0xFD, 0xF1, 0x00, 0x00, 0x00, 0x1F,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7C, 0x00, 0x80, 0x78, 0x1F, 0x83,
  0xF0, 0x7E, 0x07, 0x80, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xED, 0xFD, 0xFF, 0xBF, 0xE7,
  0xF8, 0x7C, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x05, 0xF0, 0x07, 0xCF, 0x80,
  0x7E, 0x7C, 0x07, 0xE3, 0xE0, 0x7E, 0x1F, 0x03, 0xE0, 0xF8, 0x3E, 0x07,
  0xC3, 0xE0, 0x3E, 0x3F, 0x01, 0xF3, 0xF0, 0x0F, 0xBF, 0x00, 0x7D, 0xF0,
  0x03, 0xDF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x07, 0xF7, 0xC0, 0x3F,
  0x1F, 0x01, 0xF0, 0xFC, 0x0F, 0x83, 0xE0, 0x7C, 0x1F, 0x83, 0xE0, 0x7E,
  0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0xC7, 0xC0, 0x3F, 0x3E, 0x01, 0xF9, 0xF0,
  0x07, 0xEF, 0x80, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0xF8, 0x3C, 0x7F, 0xE1,
  0xFF, 0xCF, 0x3F, 0xFC, 0xFF, 0xFB, 0xDF, 0xFF, 0x3F, 0xFE, 0xFF, 0x8F,
  0xFF, 0x3F, 0xFF, 0x81, 0xFF, 0x03, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xF0,
  0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0x7C, 0x01, 0xFF,
  0x80, 0x1F, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0x07,
  0xFE, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x7F, 0xE0, 0x07, 0xC0,
  0x1F, 0xF8, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x1F,
  0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x1F, 0xF8, 0x01, 0xF0, 0x07, 0xFE, 0x00,
  0x7C, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x1F, 0xF8,
  0x01, 0xF0, 0x07, 0xFE, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x1F, 0x00, 0x7C,
  0x00, 0x7E, 0x0F, 0x1F, 0xF8, 0xF3, 0xFF, 0xCF, 0x7F, 0xFE, 0xFF, 0x8F,
  0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFC, 0x7F, 0x07, 0xE0,
  0x3F, 0x0F, 0x80, 0x3F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xF9, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xFD,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x0F,
  0xE0, 0x7E, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x00, 0x7E, 0x07, 0x8F, 0xFC, 0x3C, 0xFF, 0xF1, 0xEF, 0xFF,
  0xCF, 0xF8, 0xFE, 0x7F, 0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0x7E, 0x01, 0xFB,
  0xFC, 0x1F, 0xDF, 0xFF, 0xFC, 0xF7, 0xFF, 0xC7, 0xDF, 0xFC, 0x3E, 0x3F,
  0xC1, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xF8, 0xF0, 0xFF, 0xF3, 0xC7, 0xFF, 0xFF, 0x3F, 0xC7, 0xFC, 0xFC,
  0x07, 0xF7, 0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x7C, 0x00, 0x7D, 0xF0, 0x01,
  0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0,
  0x07, 0xDF, 0x00, 0x1F, 0x7E, 0x00, 0xFC, 0xF8, 0x03, 0xF3, 0xF0, 0x3F,
  0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0x7C, 0x3F, 0xF9, 0xF0, 0x3F, 0xC7, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xC7,
  0xFF, 0x3F, 0xFC, 0xFF, 0xF7, 0xFF, 0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x0F,
  0xFF, 0x8F, 0xFF, 0xEF, 0xFF, 0xE7, 0xE0, 0xF7, 0xC0, 0x0B, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0x1F, 0xFE, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00,
  0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x03, 0xF7,
  0xC0, 0x3F, 0xBF, 0x03, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xEF, 0x1F, 0xFE,
  0x78, 0x7F, 0xC3, 0xC0, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x01,
  0xF3, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x03,
  0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0xBE, 0x00, 0x0F,
  0x7C, 0x00, 0x1E, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF7,
  0xC0, 0x1F, 0x80, 0x3E, 0x7C, 0x01, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0xC0,
  0x3E, 0x3E, 0x03, 0xFC, 0x03, 0xE3, 0xE0, 0x3F, 0xC0, 0x7C, 0x3E, 0x03,
  0xDE, 0x07, 0xC3, 0xE0, 0x79, 0xE0, 0x7C, 0x1F, 0x07, 0x9E, 0x07, 0xC1,
  0xF0, 0x79, 0xF0, 0xF8, 0x1F, 0x07, 0x9F, 0x0F, 0x80, 0xF0, 0xF8, 0xF0,
  0xF8, 0x0F, 0x8F, 0x0F, 0x0F, 0x00, 0xF8, 0xF0, 0xF9, 0xF0, 0x0F, 0x9F,
  0x0F, 0x9F, 0x00, 0x79, 0xE0, 0x79, 0xF0, 0x07, 0x9E, 0x07, 0x9E, 0x00,
  0x7D, 0xE0, 0x79, 0xE0, 0x07, 0xDE, 0x07, 0xFE, 0x00, 0x3D, 0xC0, 0x3F,
  0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFD, 0xF8, 0x07, 0xE3, 0xE0, 0x1F,
  0x0F, 0xC0, 0xF8, 0x1F, 0x07, 0xE0, 0x3E, 0x1F, 0x00, 0xFC, 0xFC, 0x01,
  0xF3, 0xE0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1F, 0x3E, 0x00, 0xF8, 0xFC, 0x03, 0xE1, 0xF0, 0x1F,
  0x07, 0xE0, 0xFC, 0x0F, 0x83, 0xE0, 0x1F, 0x1F, 0x80, 0x7E, 0x7C, 0x00,
  0xFB, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0xFD, 0xF0, 0x01,
  0xF3, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x07, 0xC0, 0x3E,
  0x0F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x7C, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF0, 0x01,
  0xE3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x00, 0x07, 0xBE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0xDF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xF8,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0xF0, 0x1F, 0xE0, 0x07, 0xC0, 0x7F,
  0x81, 0xFE, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0xFF, 0x01, 0xF8, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x04, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0xFF, 0xE8, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Medium49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 7, 36, 13, 3, -35 },
  { 33, 15, 13, 20, 3, -35 },
  { 58, 26, 35, 29, 1, -35 },
  { 172, 21, 40, 26, 2, -37 },
  { 277, 35, 35, 39, 2, -35 },
  { 431, 30, 35, 32, 2, -35 },
  { 563, 5, 13, 11, 3, -35 },
  { 572, 12, 43, 15, 2, -35 },
  { 637, 12, 43, 15, 1, -35 },
  { 702, 21, 20, 24, 2, -37 },
  { 755, 22, 23, 26, 2, -29 },
  { 819, 8, 12, 13, 2, -6 },
  { 831, 11, 4, 15, 2, -15 },
  { 837, 7, 7, 13, 3, -6 },
  { 844, 17, 35, 19, 1, -35 },
  { 919, 22, 36, 26, 2, -36 },
  { 1018, 13, 35, 26, 4, -35 },
  { 1075, 21, 35, 26, 2, -35 },
  { 1167, 21, 35, 26, 2, -35 },
  { 1259, 24, 35, 26, 1, -35 },
  { 1364, 20, 35, 26, 3, -35 },
  { 1452, 22, 35, 26, 2, -35 },
  { 1549, 22, 35, 26, 2, -35 },
  { 1646, 22, 35, 26, 2, -35 },
  { 1743, 21, 35, 26, 2, -35 },
  { 1835, 7, 28, 13, 3, -27 },
  { 1860, 8, 33, 13, 2, -27 },
  { 1893, 22, 24, 26, 2, -30 },
  { 1959, 21, 14, 26, 2, -24 },
  { 1996, 22, 24, 26, 2, -30 },
  { 2062, 19, 36, 20, 0, -35 },
  { 2148, 35, 39, 40, 2, -35 },
  { 2319, 29, 35, 29, 0, -35 },
  { 2446, 23, 35, 29, 4, -35 },
  { 2547, 24, 35, 28, 3, -35 },
  { 2652, 26, 35, 32, 4, -35 },
  { 2766, 18, 35, 25, 4, -35 },
  { 2845, 18, 35, 23, 4, -35 },
  { 2924, 26, 35, 32, 3, -35 },
  { 3038, 25, 35, 33, 4, -35 },
  { 3148, 12, 35, 16, 2, -35 },
  { 3201, 12, 45, 13, -3, -35 },
  { 3269, 24, 35, 28, 4, -35 },
  { 3374, 18, 35, 23, 4, -35 },
  { 3453, 33, 35, 42, 4, -35 },
  { 3598, 26, 35, 35, 4, -35 },
  { 3712, 29, 36, 34, 3, -36 },
  { 3843, 21, 35, 27, 4, -35 },
  { 3935, 29, 44, 34, 3, -36 },
  { 4095, 24, 35, 28, 4, -35 },
  { 4200, 20, 35, 25, 2, -35 },
  { 4288, 23, 35, 25, 1, -35 },
  { 4389, 25, 35, 33, 4, -35 },
  { 4499, 27, 35, 27, 0, -35 },
  { 4618, 42, 35, 42, 0, -35 },
  { 4802, 26, 35, 27, 0, -35 },
  { 4916, 26, 35, 26, 0, -35 },
  { 5030, 22, 35, 25, 1, -35 },
  { 5127, 11, 43, 16, 4, -35 },
  { 5187, 17, 35, 19, 1, -35 },
  { 5262, 11, 43, 16, 1, -35 },
  { 5322, 24, 21, 26, 1, -35 },
  { 5385, 21, 4, 21, 0, 4 },
  { 5396, 11, 8, 15, 2, -38 },
  { 5407, 20, 27, 25, 2, -27 },
  { 5475, 21, 37, 28, 4, -37 },
  { 5573, 18, 27, 22, 2, -27 },
  { 5634, 22, 37, 28, 2, -37 },
  { 5736, 21, 27, 26, 2, -27 },
  { 5807, 17, 37, 16, 1, -37 },
  { 5886, 22, 39, 28, 2, -27 },
  { 5994, 20, 37, 28, 4, -37 },
  { 6087, 6, 37, 12, 3, -37 },
  { 6115, 11, 49, 12, -2, -37 },
  { 6183, 21, 37, 25, 4, -37 },
  { 6281, 5, 37, 12, 4, -37 },
  { 6305, 34, 27, 42, 4, -27 },
  { 6420, 20, 27, 28, 4, -27 },
  { 6488, 23, 27, 27, 2, -27 },
  { 6566, 21, 39, 28, 4, -27 },
  { 6669, 22, 39, 28, 2, -27 },
  { 6777, 14, 27, 19, 4, -27 },
  { 6825, 17, 27, 21, 2, -27 },
  { 6883, 15, 32, 17, 1, -32 },
  { 6943, 21, 26, 28, 3, -26 },
  { 7012, 23, 26, 23, 0, -26 },
  { 7087, 36, 26, 36, 0, -26 },
  { 7204, 22, 26, 24, 1, -26 },
  { 7276, 23, 38, 23, 0, -26 },
  { 7386, 17, 26, 21, 2, -26 },
  { 7442, 16, 43, 18, 1, -35 },
  { 7528, 4, 49, 25, 10, -37 },
  { 7553, 15, 43, 18, 2, -35 },
  { 7634, 22, 7, 26, 2, -21 },
};

const GFXfont NotoSans_SemiCondensed_Medium49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium49pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM49PT7B_H_
