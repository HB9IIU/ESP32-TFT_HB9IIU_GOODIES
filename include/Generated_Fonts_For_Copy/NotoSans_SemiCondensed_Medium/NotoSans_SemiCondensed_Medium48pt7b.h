#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM48PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium48pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x00, 0x7B, 0xFF,
  0xFF, 0xFD, 0xF1, 0x00, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x0F, 0x78, 0x3D, 0xC0, 0xE7, 0x03, 0x9C,
  0x0E, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01,
  0xE0, 0xF0, 0x00, 0x70, 0x3C, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x03, 0x80,
  0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x03, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC0, 0x78, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xF0, 0x00, 0xF0, 0x38, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x07, 0x83, 0xC0, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x03,
  0xC0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0x81, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x7E, 0x70, 0xE3, 0xE3, 0x80, 0x3E, 0x1C, 0x01, 0xF0, 0xE0, 0x0F,
  0x87, 0x00, 0x3E, 0x38, 0x01, 0xF9, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0xF8, 0x01, 0xCF, 0xC0, 0x0E, 0x1F, 0x00, 0x70, 0xF8, 0x03, 0x87,
  0xC0, 0x1C, 0x3F, 0x00, 0xE1, 0xFE, 0x07, 0x1F, 0x7F, 0xBF, 0xFB, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x78, 0x03, 0xFF, 0x00, 0x3C, 0x01,
  0xFF, 0xC0, 0x0F, 0x00, 0x78, 0xF8, 0x07, 0xC0, 0x1E, 0x1E, 0x01, 0xE0,
  0x0F, 0x07, 0x80, 0xF8, 0x03, 0xC1, 0xE0, 0x3C, 0x00, 0xF0, 0x3C, 0x0F,
  0x00, 0x3C, 0x0F, 0x07, 0x80, 0x0F, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF0,
  0xF0, 0x00, 0xF0, 0x3C, 0x3C, 0x00, 0x3C, 0x0F, 0x1E, 0x00, 0x0F, 0x07,
  0x87, 0x8F, 0xC3, 0xC1, 0xE3, 0xC7, 0xF8, 0x78, 0x78, 0xF3, 0xFF, 0x1E,
  0x3E, 0x78, 0xFB, 0xE7, 0xFF, 0x1E, 0x78, 0x78, 0xFF, 0xCF, 0x1E, 0x0F,
  0x1F, 0xE3, 0xC7, 0x83, 0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0x00, 0x78, 0xF0,
  0x3C, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x0F, 0x0F, 0x03, 0xC0, 0x07, 0x83,
  0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x3C, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x3C,
  0x07, 0x83, 0xC0, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0x78, 0x78, 0x03,
  0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0x03, 0xFF, 0x80, 0x7C, 0x00, 0x7F, 0xC0,
  0x1E, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF8, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x87, 0xFF, 0x00,
  0xF8, 0x7F, 0xFC, 0x07, 0xC7, 0xF3, 0xF0, 0x3E, 0x3F, 0x0F, 0xC1, 0xF3,
  0xF0, 0x3F, 0x1F, 0x1F, 0x00, 0xFC, 0xF8, 0xF8, 0x03, 0xFF, 0x87, 0xC0,
  0x0F, 0xFC, 0x3E, 0x00, 0x7F, 0xC1, 0xF0, 0x01, 0xFE, 0x0F, 0xC0, 0x07,
  0xE0, 0x7E, 0x00, 0x7F, 0x81, 0xFC, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE7, 0xE0, 0xFF, 0xFC, 0x1F, 0x81, 0xFF, 0x80, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7B, 0x9C, 0xE0, 0x03, 0xE0, 0x78, 0x1F, 0x07,
  0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0xF8,
  0x1F, 0x01, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0xF8, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F,
  0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x1F,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x08, 0x0F, 0x01, 0xF8,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7B, 0xE0, 0x0F, 0x9F, 0x01, 0xF1, 0xF0,
  0x1F, 0x0F, 0x83, 0xE0, 0xFC, 0x06, 0x06, 0x00, 0x20, 0x40, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x7C, 0xF9, 0xF7, 0xCF, 0x9F, 0x3C, 0x79, 0xF3, 0xC7, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0xFD, 0xF1, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFD, 0xFC,
  0x1F, 0x83, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x3E, 0x7C, 0x01, 0xF3, 0xE0,
  0x0F, 0x9F, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0x78, 0x00, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0xE0, 0x3F, 0x1F, 0x01, 0xF0, 0xFC, 0x1F, 0x83, 0xFF, 0xF8, 0x0F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x3F,
  0xC1, 0xFF, 0x0F, 0xFC, 0x7F, 0xF3, 0xF7, 0xFF, 0x9F, 0x7C, 0x7C, 0xC1,
  0xF1, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0xF8,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3E, 0x03, 0xF0, 0xC0,
  0x0F, 0xC4, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x87, 0xFB, 0xFE, 0x3C, 0x03, 0xF0, 0x80, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x40, 0x01, 0xFB, 0x80, 0x1F,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3D, 0xF0, 0x00, 0x7B,
  0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x1F, 0x00, 0x3C, 0x3E,
  0x00, 0xF8, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x03, 0xE0,
  0x3C, 0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F,
  0x00, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC2, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x80,
  0x07, 0xEE, 0x01, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF8, 0x0F, 0xFF,
  0xC0, 0xFF, 0xC6, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x1F, 0x01, 0xE3, 0xFE, 0x1F, 0x7F, 0xF8, 0xFB, 0xFF, 0xE7, 0xFC,
  0x7F, 0xBF, 0x80, 0xFD, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDF, 0x00,
  0x3E, 0xF8, 0x01, 0xF7, 0xE0, 0x1F, 0x1F, 0x00, 0xF8, 0xFC, 0x0F, 0xC3,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xF8, 0x7E, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE3,
  0xE0, 0x3E, 0x1F, 0x83, 0xE0, 0x7F, 0x7F, 0x01, 0xFF, 0xE0, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xBF, 0x83, 0xF0, 0xFE, 0x3F,
  0x01, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFD, 0xF8,
  0x0F, 0xCF, 0xFB, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xC0,
  0x00, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF,
  0xFC, 0x3F, 0x03, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0xF8, 0x01, 0xF7,
  0xC0, 0x0F, 0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0x7C, 0x03, 0xFB, 0xF0, 0x3F, 0xCF,
  0xFF, 0xFE, 0x7F, 0xFD, 0xF1, 0xFF, 0xCF, 0x83, 0xFC, 0x78, 0x02, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xFF, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFD,
  0xF1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B,
  0xFF, 0xFF, 0xFD, 0xF1, 0x00, 0x3E, 0xFD, 0xFB, 0xF7, 0xE7, 0xC2, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE7,
  0xCF, 0xBF, 0x7C, 0xF9, 0xF3, 0xCF, 0x9E, 0x3C, 0x78, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0x8C,
  0x03, 0xF2, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x07,
  0x83, 0xC0, 0x3F, 0xE0, 0xF8, 0xF0, 0x1F, 0xFE, 0x0F, 0x1E, 0x07, 0xFF,
  0xC1, 0xE3, 0xC1, 0xF0, 0x78, 0x3C, 0xF0, 0x3C, 0x0F, 0x03, 0x9E, 0x0F,
  0x01, 0xE0, 0x7B, 0xC1, 0xE0, 0x3C, 0x0F, 0x78, 0x3C, 0x07, 0x81, 0xEE,
  0x0F, 0x00, 0xF0, 0x3F, 0xC1, 0xE0, 0x1E, 0x07, 0xF8, 0x3C, 0x03, 0xC0,
  0xFF, 0x07, 0x80, 0x78, 0x1D, 0xE0, 0xF0, 0x1F, 0x07, 0x9C, 0x0F, 0x03,
  0xE0, 0xF3, 0x81, 0xE0, 0x7C, 0x1E, 0x78, 0x3E, 0x1F, 0x87, 0x8F, 0x03,
  0xFF, 0xFF, 0xF1, 0xE0, 0x7F, 0xE7, 0xFC, 0x3E, 0x07, 0xF8, 0x7F, 0x03,
  0xC0, 0x38, 0x03, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x18, 0x00, 0x0F, 0xFC, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x03, 0xE0, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xF8, 0x07, 0xFB, 0xE0, 0x07, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80,
  0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xE0, 0x1F, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x8F, 0x80, 0x7F, 0x3E,
  0x00, 0x7E, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x01, 0xFB, 0xE0, 0x1F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFC, 0x03, 0x8F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x07, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x80,
  0x7F, 0x87, 0xC0, 0x0F, 0xE3, 0xE0, 0x03, 0xF9, 0xF0, 0x00, 0xFC, 0xF8,
  0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x9F, 0x00,
  0x1F, 0x8F, 0x80, 0x3F, 0xC7, 0xC0, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07,
  0xF8, 0x01, 0xC1, 0xFC, 0x00, 0x10, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF8,
  0x00, 0x1F, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xFE, 0x00, 0xFC,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3,
  0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x07, 0xEF, 0xFE, 0xFF, 0xCF,
  0xF8, 0xFF, 0x00, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8,
  0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF9, 0xF8, 0x00, 0xF9, 0xF0, 0x00,
  0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0xFE, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0,
  0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xBC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xDF, 0xFB,
  0xC0, 0x01, 0xEF, 0xFD, 0xE0, 0x01, 0xF7, 0xFE, 0xF8, 0x00, 0xF3, 0xFF,
  0x3C, 0x00, 0x79, 0xFF, 0x9E, 0x00, 0x7C, 0xFF, 0xCF, 0x80, 0x3C, 0x7F,
  0xE3, 0xC0, 0x1E, 0x3F, 0xF1, 0xE0, 0x1F, 0x1F, 0xF8, 0xF8, 0x0F, 0x0F,
  0xFC, 0x3C, 0x07, 0x87, 0xFE, 0x1E, 0x07, 0xC3, 0xFF, 0x0F, 0x83, 0xC1,
  0xFF, 0x83, 0xC1, 0xE0, 0xFF, 0xC1, 0xE1, 0xF0, 0x7F, 0xE0, 0xF8, 0xF0,
  0x3F, 0xF0, 0x3C, 0x78, 0x1F, 0xF8, 0x1E, 0x7C, 0x0F, 0xFC, 0x0F, 0xBC,
  0x07, 0xFE, 0x03, 0xDE, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x7F, 0xE0, 0x1F, 0xC0, 0x3F, 0xF0, 0x0F,
  0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xDF, 0x00,
  0x1F, 0xFB, 0xE0, 0x07, 0xFE, 0xFC, 0x01, 0xFF, 0x9F, 0x00, 0x7F, 0xE7,
  0xE0, 0x1F, 0xF8, 0xF8, 0x07, 0xFE, 0x3F, 0x01, 0xFF, 0x87, 0xC0, 0x7F,
  0xE1, 0xF8, 0x1F, 0xF8, 0x3F, 0x07, 0xFE, 0x07, 0xC1, 0xFF, 0x81, 0xF8,
  0x7F, 0xE0, 0x3E, 0x1F, 0xF8, 0x0F, 0xC7, 0xFE, 0x01, 0xF1, 0xFF, 0x80,
  0x7E, 0x7F, 0xE0, 0x0F, 0x9F, 0xF8, 0x03, 0xF7, 0xFE, 0x00, 0x7D, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x3F,
  0x00, 0x1F, 0xC3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x1F,
  0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0x80, 0xFE, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x03,
  0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0xDF, 0x00, 0xFC, 0xF8,
  0x3F, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0x80,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC3,
  0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7C, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xF8, 0x1F, 0xE0, 0x7F, 0x80,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x80, 0xFF, 0x1F, 0x00, 0x7E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF9, 0xF0, 0x03, 0xF3, 0xE0,
  0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x3E, 0x00,
  0xF8, 0x7C, 0x07, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0x83, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x3F, 0x1F, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x7E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0xFC, 0x0F, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xF0, 0x1C, 0x7C,
  0x00, 0x47, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x3E, 0xF8,
  0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00,
  0x7E, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0,
  0x7C, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F,
  0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x80, 0x07, 0xDF, 0x00, 0x0F,
  0xC0, 0x07, 0xCF, 0x80, 0x0F, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xF0, 0x01,
  0xF1, 0xF0, 0x03, 0xFC, 0x00, 0xF8, 0xF8, 0x03, 0xFE, 0x00, 0xFC, 0x7C,
  0x01, 0xEF, 0x00, 0x7C, 0x3E, 0x00, 0xF7, 0x80, 0x3E, 0x0F, 0x80, 0x7B,
  0xE0, 0x1F, 0x07, 0xC0, 0x7D, 0xF0, 0x0F, 0x83, 0xE0, 0x3E, 0x78, 0x0F,
  0x81, 0xF0, 0x1E, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x1F, 0x03, 0xE0, 0x3E,
  0x0F, 0x8F, 0x81, 0xF0, 0x1F, 0x07, 0xC3, 0xC1, 0xF0, 0x0F, 0x83, 0xC1,
  0xE0, 0xF8, 0x03, 0xC1, 0xE0, 0xF8, 0x7C, 0x01, 0xF1, 0xF0, 0x7C, 0x3E,
  0x00, 0xF8, 0xF8, 0x1E, 0x1E, 0x00, 0x7C, 0x78, 0x0F, 0x1F, 0x00, 0x3E,
  0x3C, 0x07, 0xCF, 0x80, 0x0F, 0x3E, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x00,
  0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x7B, 0xE0, 0x01, 0xF7, 0x80, 0x3D, 0xF0,
  0x00, 0x7B, 0xC0, 0x1F, 0xF8, 0x00, 0x3D, 0xE0, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x07,
  0xC3, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x00,
  0xFC, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0xBE, 0x00, 0x0F, 0x9F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xF0, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x0F, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78,
  0x00, 0x79, 0xE0, 0x00, 0xF7, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x07, 0xFF, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x1C, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF,
  0xDF, 0x7E, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xFF, 0x7F, 0x7F, 0xF7,
  0xFF, 0xDF, 0x3F, 0xF8, 0xF1, 0xFF, 0x0F, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x3F, 0x81,
  0xE7, 0xFF, 0x0F, 0x7F, 0xFC, 0x7B, 0xFF, 0xF3, 0xF8, 0x1F, 0x9F, 0x80,
  0x7E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7E,
  0x00, 0xFB, 0xF0, 0x0F, 0xDF, 0xC0, 0xFC, 0xFF, 0xFF, 0xE7, 0xBF, 0xFE,
  0x3C, 0xFF, 0xE1, 0xC3, 0xFE, 0x00, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFF,
  0xF8, 0x7F, 0xFE, 0x3F, 0x81, 0x8F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x21, 0xFF, 0xF8, 0x7F, 0xFE,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x3F, 0xC7, 0xC3,
  0xFF, 0x9F, 0x1F, 0xFF, 0x7C, 0x7F, 0xFF, 0xF3, 0xF0, 0x3F, 0xDF, 0x80,
  0x7F, 0x7E, 0x00, 0xFD, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x3F, 0x7C, 0x00,
  0xFD, 0xF0, 0x03, 0xF7, 0xE0, 0x1F, 0xCF, 0xC0, 0xFF, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFD, 0xF0, 0xFF, 0xE7, 0xC0, 0xFF, 0x0F, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF0, 0x3E, 0x1F, 0x00, 0xF9,
  0xF0, 0x07, 0xCF, 0x80, 0x1E, 0x7C, 0x00, 0xFB, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x18, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0x07, 0xFF, 0x07,
  0xFF, 0x0F, 0xE6, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x3F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x7C, 0x3F, 0xF9,
  0xF1, 0xFF, 0xF7, 0xC7, 0xFF, 0xFF, 0x3F, 0x03, 0xFC, 0xF8, 0x07, 0xF7,
  0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xF7, 0xC0, 0x0F, 0xDF,
  0x00, 0x3F, 0x7E, 0x01, 0xFC, 0xFC, 0x0F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF,
  0xDF, 0x0F, 0xFE, 0x7C, 0x0F, 0xF1, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x90, 0x00, 0x7E, 0x30,
  0x03, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x00, 0x00, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0xFF, 0x0F, 0x3F, 0xF8, 0xF7, 0xFF,
  0xCF, 0x7F, 0xFE, 0xFF, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x31, 0xEF,
  0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x07, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7,
  0xDF, 0x01, 0x80, 0x78, 0x1F, 0x83, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x1F,
  0x7F, 0xEF, 0xF9, 0xFF, 0x3F, 0xC0, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xFF, 0x80,
  0x7E, 0xF8, 0x0F, 0xCF, 0x81, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8,
  0x7C, 0x0F, 0x8F, 0x80, 0xF1, 0xF8, 0x0F, 0x1F, 0x00, 0xF3, 0xE0, 0x0F,
  0x7E, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFE, 0xF8, 0x0F, 0xCF, 0xC0,
  0xF8, 0x7C, 0x0F, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0xF8, 0x1F,
  0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF1, 0xFE, 0x03, 0xFC, 0x3C, 0xFF, 0xE3, 0xFF, 0x8F, 0x7F, 0xFD, 0xFF,
  0xF3, 0xFF, 0xFF, 0x7F, 0xFE, 0xFE, 0x0F, 0xFC, 0x1F, 0xBF, 0x01, 0xFE,
  0x03, 0xEF, 0xC0, 0x3F, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03,
  0xE0, 0x07, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0xE0,
  0x0F, 0x80, 0x1F, 0xF8, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0x3E, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x1F, 0xF8, 0x03, 0xE0, 0x07,
  0xFE, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0x7F, 0xE0, 0x0F, 0x80,
  0x1F, 0xF8, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E,
  0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x1F, 0xF8, 0x03, 0xE0, 0x07, 0xFE, 0x00,
  0xF8, 0x01, 0xF0, 0xF0, 0xFF, 0x0F, 0x3F, 0xF8, 0xF7, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFE, 0x07, 0xEF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x01, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0x03, 0xF0, 0xF8, 0x07,
  0xE7, 0xE0, 0x0F, 0x9F, 0x00, 0x3F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07,
  0xDF, 0x00, 0x3E, 0x3E, 0x01, 0xF8, 0xFC, 0x07, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0xF0, 0xFE, 0x07, 0x9F,
  0xFC, 0x3D, 0xFF, 0xF1, 0xEF, 0xFF, 0xCF, 0xE0, 0x7E, 0x7E, 0x01, 0xFB,
  0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF8, 0x03,
  0xEF, 0xC0, 0x3F, 0x7F, 0x03, 0xF3, 0xFF, 0xFF, 0x9E, 0xFF, 0xF8, 0xF3,
  0xFF, 0x87, 0x8F, 0xF8, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xFC, 0x7C, 0x3F, 0xF9, 0xF1, 0xFF, 0xF7, 0xC7, 0xFF, 0xFF, 0x3F,
  0x03, 0xFC, 0xF8, 0x07, 0xF7, 0xE0, 0x0F, 0xDF, 0x00, 0x3F, 0x7C, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xF0,
  0x03, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x3F, 0x7E, 0x01, 0xFC, 0xFC, 0x0F,
  0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xDF, 0x0F, 0xFE, 0x7C, 0x0F, 0xF1, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0xF0, 0xFF, 0xC7,
  0xFF, 0x3F, 0xFD, 0xFE, 0xFF, 0xCB, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x1F, 0xFF, 0xDF,
  0xFF, 0xCF, 0xFF, 0xEF, 0xC0, 0x67, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0xFF, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFE,
  0x3F, 0xFC, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xE0, 0x0F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xC1,
  0xFF, 0x81, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x7E, 0xF8, 0x03, 0xF7, 0xC0, 0x3F, 0xBF, 0x03,
  0xFD, 0xFF, 0xFF, 0xE7, 0xFF, 0xDF, 0x1F, 0xFC, 0x78, 0x7F, 0xC3, 0xC0,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE3,
  0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0xF8, 0x1F,
  0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0xF8,
  0x3E, 0x00, 0xF0, 0x78, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xC7,
  0x80, 0x07, 0x9F, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x00, 0x7D,
  0xF0, 0x0F, 0xE0, 0x0F, 0x3E, 0x01, 0xFC, 0x03, 0xE3, 0xC0, 0x3F, 0xC0,
  0x7C, 0x7C, 0x07, 0xF8, 0x0F, 0x8F, 0x81, 0xEF, 0x01, 0xE1, 0xF0, 0x3D,
  0xE0, 0x7C, 0x1E, 0x07, 0x9E, 0x0F, 0x83, 0xE0, 0xF3, 0xC1, 0xF0, 0x7C,
  0x3C, 0x78, 0x3C, 0x0F, 0x87, 0x8F, 0x0F, 0x80, 0xF0, 0xF0, 0xF1, 0xF0,
  0x1F, 0x1E, 0x1E, 0x3E, 0x03, 0xE7, 0xC3, 0xC7, 0x80, 0x7C, 0xF0, 0x78,
  0xF0, 0x07, 0x9E, 0x0F, 0xBE, 0x00, 0xF3, 0xC0, 0xF7, 0xC0, 0x1F, 0x70,
  0x1E, 0xF0, 0x03, 0xFE, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x7B, 0xC0, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xF9,
  0xF0, 0x07, 0xE7, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0xE0, 0x7E,
  0x1F, 0x00, 0xF8, 0xFC, 0x03, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0x7E, 0x00, 0xF8,
  0xF8, 0x03, 0xE1, 0xF0, 0x1F, 0x07, 0xC0, 0xFC, 0x0F, 0x83, 0xE0, 0x3F,
  0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xFB, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x3E, 0x07, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x78, 0x01, 0xF1, 0xF0, 0x01, 0xE3, 0xE0, 0x03, 0xE7, 0x80, 0x07, 0xDF,
  0x00, 0x07, 0xBE, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x01, 0xFC, 0x07,
  0xF8, 0x1F, 0xF0, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0xFE, 0x07, 0xF8, 0x0F, 0xC0, 0x1F, 0xE0,
  0x3F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xF0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0x80, 0x00, 0x3F, 0xC0, 0x0B,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F,
  0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Medium48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 35, 13, 3, -34 },
  { 28, 14, 12, 20, 3, -34 },
  { 49, 26, 34, 28, 1, -34 },
  { 160, 21, 39, 25, 2, -36 },
  { 263, 34, 35, 38, 2, -35 },
  { 412, 29, 35, 31, 2, -35 },
  { 539, 5, 12, 11, 3, -34 },
  { 547, 11, 42, 15, 2, -34 },
  { 605, 12, 42, 15, 1, -34 },
  { 668, 20, 20, 24, 2, -36 },
  { 718, 21, 23, 25, 2, -28 },
  { 779, 7, 12, 12, 2, -6 },
  { 790, 11, 4, 15, 2, -15 },
  { 796, 6, 7, 12, 3, -6 },
  { 802, 17, 34, 18, 1, -34 },
  { 875, 21, 35, 25, 2, -35 },
  { 967, 14, 34, 25, 3, -34 },
  { 1027, 21, 35, 25, 2, -35 },
  { 1119, 21, 35, 25, 2, -35 },
  { 1211, 23, 34, 25, 1, -34 },
  { 1309, 20, 34, 25, 3, -34 },
  { 1394, 21, 35, 25, 2, -35 },
  { 1486, 21, 34, 25, 2, -34 },
  { 1576, 21, 35, 25, 2, -35 },
  { 1668, 21, 35, 25, 2, -35 },
  { 1760, 6, 27, 12, 3, -26 },
  { 1781, 7, 32, 12, 2, -26 },
  { 1809, 21, 23, 25, 2, -29 },
  { 1870, 21, 14, 25, 2, -24 },
  { 1907, 21, 23, 25, 2, -29 },
  { 1968, 18, 36, 19, 0, -35 },
  { 2049, 35, 38, 39, 2, -34 },
  { 2216, 28, 34, 28, 0, -34 },
  { 2335, 22, 34, 29, 4, -34 },
  { 2429, 23, 35, 27, 3, -35 },
  { 2530, 25, 34, 32, 4, -34 },
  { 2637, 18, 34, 24, 4, -34 },
  { 2714, 18, 34, 23, 4, -34 },
  { 2791, 26, 35, 32, 3, -35 },
  { 2905, 24, 34, 32, 4, -34 },
  { 3007, 12, 34, 16, 2, -34 },
  { 3058, 12, 43, 13, -3, -34 },
  { 3123, 24, 34, 27, 4, -34 },
  { 3225, 18, 34, 23, 4, -34 },
  { 3302, 33, 34, 41, 4, -34 },
  { 3443, 26, 34, 34, 4, -34 },
  { 3554, 28, 35, 34, 3, -35 },
  { 3677, 21, 34, 27, 4, -34 },
  { 3767, 28, 43, 34, 3, -35 },
  { 3918, 23, 34, 28, 4, -34 },
  { 4016, 20, 35, 24, 2, -35 },
  { 4104, 22, 34, 24, 1, -34 },
  { 4198, 24, 34, 32, 4, -34 },
  { 4300, 27, 34, 27, 0, -34 },
  { 4415, 41, 34, 41, 0, -34 },
  { 4590, 26, 34, 26, 0, -34 },
  { 4701, 25, 34, 25, 0, -34 },
  { 4808, 22, 34, 24, 1, -34 },
  { 4902, 10, 42, 16, 4, -34 },
  { 4955, 17, 34, 18, 1, -34 },
  { 5028, 11, 42, 16, 1, -34 },
  { 5086, 23, 20, 26, 1, -34 },
  { 5144, 21, 3, 21, 0, 4 },
  { 5152, 10, 8, 14, 2, -37 },
  { 5162, 20, 26, 25, 2, -26 },
  { 5227, 21, 36, 27, 4, -36 },
  { 5322, 18, 26, 21, 2, -26 },
  { 5381, 22, 36, 27, 2, -36 },
  { 5480, 21, 26, 25, 2, -26 },
  { 5549, 16, 37, 16, 1, -37 },
  { 5623, 22, 38, 27, 2, -26 },
  { 5728, 20, 36, 27, 4, -36 },
  { 5818, 6, 36, 12, 3, -36 },
  { 5845, 11, 48, 12, -2, -36 },
  { 5911, 20, 36, 24, 4, -36 },
  { 6001, 5, 36, 12, 4, -36 },
  { 6024, 34, 26, 41, 4, -26 },
  { 6135, 20, 26, 27, 4, -26 },
  { 6200, 22, 26, 27, 2, -26 },
  { 6272, 21, 38, 27, 4, -26 },
  { 6372, 22, 38, 27, 2, -26 },
  { 6477, 14, 26, 18, 4, -26 },
  { 6523, 17, 26, 21, 2, -26 },
  { 6579, 15, 32, 17, 1, -32 },
  { 6639, 21, 26, 27, 3, -26 },
  { 6708, 23, 26, 23, 0, -26 },
  { 6783, 35, 26, 36, 0, -26 },
  { 6897, 22, 26, 23, 1, -26 },
  { 6969, 23, 38, 23, 0, -26 },
  { 7079, 17, 26, 20, 2, -26 },
  { 7135, 15, 42, 18, 1, -34 },
  { 7214, 4, 48, 24, 10, -37 },
  { 7238, 15, 42, 18, 2, -34 },
  { 7317, 21, 6, 25, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_Medium48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium48pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM48PT7B_H_
