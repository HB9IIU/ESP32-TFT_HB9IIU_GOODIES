#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM23PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium23pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x06, 0xF6, 0xE6, 0xCD, 0x9B,
  0x36, 0x68, 0xC0, 0x0C, 0xC0, 0x8C, 0x18, 0xC1, 0x8C, 0xFF, 0xFF, 0xFF,
  0x19, 0x81, 0x18, 0x31, 0x8F, 0xFE, 0xFF, 0xE3, 0x30, 0x33, 0x02, 0x30,
  0x63, 0x06, 0x30, 0x0C, 0x03, 0x87, 0xFD, 0xFE, 0xEC, 0x33, 0x0E, 0xC1,
  0xF0, 0x3E, 0x03, 0xE0, 0xDC, 0x33, 0x0C, 0xF3, 0x7F, 0xF9, 0xF8, 0x0C,
  0x03, 0x00, 0x30, 0x00, 0x7C, 0x18, 0xCC, 0x30, 0xCC, 0x30, 0xC6, 0x60,
  0xC6, 0x60, 0xC6, 0xC0, 0xCC, 0xDE, 0xCD, 0xBF, 0x7D, 0xB3, 0x33, 0x33,
  0x03, 0x33, 0x06, 0x33, 0x06, 0x33, 0x0C, 0x33, 0x0C, 0x3F, 0x18, 0x1E,
  0x0E, 0x00, 0xFC, 0x03, 0x38, 0x1C, 0x60, 0x71, 0x80, 0xCE, 0x03, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xF8, 0x6E, 0x73, 0xB8, 0xEC, 0xC1, 0xF3, 0x83,
  0x8E, 0x1F, 0x1F, 0xEE, 0x3F, 0x1C, 0xED, 0xB6, 0x80, 0x19, 0x9C, 0xC6,
  0x73, 0x98, 0xC6, 0x31, 0x8C, 0x71, 0x8C, 0x71, 0x8E, 0x30, 0xC3, 0x1C,
  0x63, 0x1C, 0x63, 0x18, 0xC6, 0x31, 0x9C, 0xC6, 0x73, 0x39, 0x80, 0x0C,
  0x03, 0x08, 0xCB, 0xFE, 0xFF, 0xC7, 0x83, 0x61, 0xCC, 0x23, 0x00, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x6D, 0xFD, 0x80, 0xFF, 0xC0, 0x7D, 0x80, 0x03, 0x81, 0x81, 0xC0,
  0xC0, 0x60, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x03, 0x01,
  0x81, 0xC0, 0x0C, 0x0F, 0xC7, 0x39, 0x86, 0xE1, 0xF8, 0x7C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE1, 0xD8, 0x66, 0x19, 0xFE, 0x3F, 0x00,
  0x1C, 0xF6, 0xF3, 0x8C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x1C, 0x1F, 0xCF, 0x39, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x01,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x06, 0x03, 0xFF, 0xFF, 0xC0, 0x1C, 0x1F,
  0xCE, 0x39, 0x06, 0x01, 0x80, 0x60, 0x38, 0x3C, 0x3E, 0x0F, 0xE0, 0x1C,
  0x07, 0x01, 0xC0, 0x78, 0x1B, 0xFE, 0xFF, 0x00, 0x01, 0xC0, 0x3C, 0x07,
  0xC0, 0x7C, 0x0D, 0xC0, 0xDC, 0x19, 0xC3, 0x1C, 0x31, 0xC6, 0x1C, 0xFF,
  0xFF, 0xFF, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x7F, 0x9F, 0xE6, 0x01,
  0x80, 0x60, 0x18, 0x07, 0xF1, 0xFE, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01,
  0xE0, 0xEF, 0xFB, 0xF8, 0x07, 0x87, 0xE3, 0xC9, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x7C, 0xFF, 0xB8, 0x7E, 0x0F, 0x03, 0xE0, 0xD8, 0x77, 0x1C, 0xFE,
  0x1F, 0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C,
  0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x0C, 0x0F,
  0xC7, 0x3B, 0x87, 0xE1, 0xD8, 0x67, 0x38, 0xFC, 0x1E, 0x1F, 0xC6, 0x1B,
  0x07, 0xC0, 0xF0, 0x3E, 0x1D, 0xFE, 0x3F, 0x00, 0x0C, 0x0F, 0xC7, 0x3B,
  0x86, 0xC1, 0xF0, 0x3C, 0x0F, 0x87, 0xE1, 0xDF, 0xB3, 0xCC, 0x07, 0x01,
  0x80, 0x60, 0x31, 0xFC, 0x7C, 0x00, 0x6E, 0xF6, 0x00, 0x00, 0x00, 0x6F,
  0x60, 0x7F, 0xB0, 0x00, 0x01, 0xB7, 0xF6, 0x00, 0x40, 0x70, 0x78, 0x78,
  0x78, 0x38, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0C, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x3C, 0x3C, 0x3C, 0x3C, 0x0C, 0x00, 0x1C, 0x7F, 0x99, 0xC0, 0x70,
  0x18, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60,
  0x70, 0x18, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x07, 0x87, 0x07, 0x00, 0xC3,
  0x00, 0x33, 0x0F, 0x99, 0x9D, 0xC5, 0x8C, 0x63, 0xC6, 0x31, 0xE6, 0x18,
  0xF3, 0x0C, 0x58, 0x86, 0x6C, 0x67, 0x32, 0x3E, 0xF1, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x08, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0x00, 0x1E, 0x00,
  0xF8, 0x03, 0x60, 0x0D, 0xC0, 0x73, 0x01, 0x8C, 0x06, 0x38, 0x38, 0x60,
  0xFF, 0x83, 0xFF, 0x1C, 0x0C, 0x70, 0x31, 0x80, 0xEE, 0x03, 0xB8, 0x07,
  0xFF, 0x9F, 0xFB, 0x07, 0x60, 0x6C, 0x0D, 0x83, 0xBF, 0xE7, 0xF8, 0xC3,
  0xD8, 0x1B, 0x03, 0xE0, 0x7C, 0x0D, 0x83, 0xBF, 0xE7, 0xF8, 0x03, 0x83,
  0xFC, 0xFB, 0x9C, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x30, 0x06, 0x00, 0xE0, 0x0E, 0x09, 0xFF, 0x0F, 0xE0, 0xFF, 0x0F,
  0xFC, 0xC1, 0xEC, 0x0E, 0xC0, 0x6C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x06, 0xC0, 0xEC, 0x3C, 0xFF, 0x8F, 0xE0, 0xFF, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x03, 0xC0, 0x7F, 0xCF, 0x9C, 0x70,
  0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE1, 0xFF, 0x0F, 0xF8, 0x0E,
  0xC0, 0x76, 0x03, 0xB8, 0x1C, 0xE0, 0xE3, 0xFF, 0x0F, 0xF0, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xFD, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0xBF, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F,
  0xFE, 0x20, 0xC0, 0xF8, 0x3B, 0x0E, 0x63, 0x8C, 0x61, 0x9C, 0x37, 0x07,
  0xE0, 0xFE, 0x1D, 0xC3, 0x1C, 0x61, 0x8C, 0x39, 0x83, 0xB0, 0x36, 0x07,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xD8, 0x1F,
  0xD8, 0x1F, 0xD8, 0x37, 0xCC, 0x37, 0xCC, 0x37, 0xCC, 0x67, 0xCE, 0x67,
  0xC6, 0x67, 0xC6, 0xC7, 0xC7, 0xC7, 0xC3, 0xC7, 0xC3, 0x87, 0xC3, 0x87,
  0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xDC, 0x3C, 0xC3, 0xCE, 0x3C, 0x63,
  0xC7, 0x3C, 0x33, 0xC3, 0xBC, 0x1B, 0xC1, 0xFC, 0x0F, 0xC0, 0x7C, 0x07,
  0x07, 0x80, 0x7F, 0x83, 0xCF, 0x1C, 0x0E, 0x70, 0x19, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xD8, 0x07, 0x60, 0x19, 0xC0,
  0xE3, 0x87, 0x0F, 0xFC, 0x0F, 0xC0, 0xFF, 0x3F, 0xEC, 0x1B, 0x07, 0xC1,
  0xF0, 0x7C, 0x1B, 0x1E, 0xFF, 0x3F, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x07, 0x80, 0x7F, 0x83, 0xCF, 0x1C, 0x0E, 0x70, 0x19, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xD8, 0x07, 0x60,
  0x19, 0xC0, 0xE3, 0x87, 0x8F, 0xFC, 0x0F, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0xFF, 0x1F, 0xF3, 0x07, 0x60, 0xEC, 0x1D, 0x83, 0xB0,
  0x67, 0xFC, 0xFE, 0x18, 0xC3, 0x1C, 0x61, 0x8C, 0x39, 0x83, 0xB0, 0x76,
  0x07, 0x0E, 0x0F, 0xE7, 0xFB, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x68, 0x3B, 0xFE, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3E, 0x07, 0xC1, 0xDF, 0xF1, 0xFC, 0xE0, 0x3B, 0x01, 0x98, 0x1C,
  0xE0, 0xE3, 0x06, 0x18, 0x30, 0xE3, 0x87, 0x18, 0x18, 0xC0, 0xCE, 0x07,
  0x60, 0x1B, 0x00, 0xD8, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0xE0, 0xE0, 0x76,
  0x0F, 0x06, 0x60, 0xF0, 0x66, 0x0F, 0x0E, 0x71, 0xF0, 0xE3, 0x1B, 0x8C,
  0x31, 0x98, 0xC3, 0x19, 0x9C, 0x3B, 0x99, 0xC1, 0xB1, 0xD8, 0x1B, 0x0D,
  0x81, 0xB0, 0xD8, 0x1B, 0x0F, 0x81, 0xE0, 0xF0, 0x0E, 0x07, 0x00, 0xE0,
  0x70, 0xF0, 0x73, 0x0E, 0x38, 0xC1, 0x9C, 0x1D, 0x80, 0xF8, 0x0F, 0x00,
  0x70, 0x0F, 0x00, 0xF8, 0x1D, 0x81, 0x9C, 0x38, 0xC7, 0x0E, 0x60, 0x7E,
  0x07, 0xE0, 0x76, 0x06, 0x70, 0xE3, 0x0C, 0x39, 0xC1, 0x98, 0x1F, 0x80,
  0xF0, 0x0F, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xFF, 0xFF, 0xF0, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0F, 0xFF, 0xFF, 0xFE, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xF0, 0xE0, 0x30,
  0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xC0,
  0x60, 0x38, 0x0C, 0x07, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xFF, 0xF0, 0x0C, 0x03, 0xC0, 0x78, 0x19, 0x83, 0x30,
  0x43, 0x18, 0x63, 0x06, 0xC0, 0xE0, 0xFF, 0xFF, 0xF0, 0xE3, 0x0C, 0x30,
  0x0E, 0x3F, 0x88, 0xE0, 0x30, 0x18, 0x3D, 0xFF, 0xC3, 0xC1, 0xE0, 0xF8,
  0xFF, 0xF7, 0xD8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCC, 0x37, 0xCF, 0x3B,
  0x86, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1B, 0xFE, 0xDF,
  0x00, 0x0E, 0x1F, 0xDE, 0xCC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x1C, 0x2F, 0xE3, 0xF0, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0C, 0xCF, 0xB7,
  0x3D, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x36, 0x1D, 0xFF,
  0x3E, 0xC0, 0x0C, 0x0F, 0xC7, 0x39, 0x87, 0xE0, 0xF8, 0x3F, 0xFF, 0x80,
  0xE0, 0x38, 0x07, 0x04, 0xFE, 0x1F, 0x80, 0x06, 0x1F, 0x39, 0x38, 0x38,
  0x38, 0xFE, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x0C, 0x0F, 0xB7, 0x3D, 0x87, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x36, 0x1D, 0xFF, 0x3E, 0xC0, 0x30, 0x0C, 0x07, 0x73, 0xDF, 0xE0,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0xE6, 0xFB, 0xCF, 0xC3, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0x80, 0xFC, 0x3F, 0xFF,
  0xFF, 0xC0, 0x18, 0xC6, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x3B, 0xF9, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0xEC, 0x73, 0x38, 0xCC, 0x36, 0x0F, 0x83, 0xB0, 0xCE, 0x31, 0x8C, 0x73,
  0x0E, 0xC1, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x18, 0xDF, 0x7E,
  0xF3, 0xE7, 0xE3, 0xC7, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83,
  0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0x0E, 0x6F,
  0xBC, 0xFC, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x18, 0x0E, 0x07, 0xF1, 0xCF, 0x30, 0x6E, 0x0D, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x19, 0x87, 0x1F, 0xC1, 0xF0, 0x0E, 0x37, 0xCF, 0x3B, 0x86,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1B, 0xFE, 0xDF, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x0C, 0x0F, 0xB7, 0x3D, 0x87,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x36, 0x1D, 0xFF, 0x3E, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x0D, 0xBB, 0xF7, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x00, 0x1C, 0x7F, 0xE2, 0xC0, 0xE0,
  0xF0, 0x7C, 0x1E, 0x07, 0x03, 0x83, 0xFF, 0xFE, 0x10, 0x60, 0xC7, 0xF3,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xC7, 0x80, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF1, 0xFF, 0xEF, 0xB0,
  0xE0, 0xEC, 0x19, 0x83, 0x38, 0xE3, 0x18, 0x63, 0x0E, 0xE0, 0xD8, 0x1B,
  0x03, 0x60, 0x38, 0x07, 0x00, 0xE1, 0xC3, 0xB0, 0xE1, 0x98, 0xD8, 0xCE,
  0x6C, 0x67, 0x36, 0x71, 0x9B, 0x30, 0xD8, 0xD8, 0x6C, 0x6C, 0x3E, 0x3E,
  0x0F, 0x1E, 0x07, 0x07, 0x03, 0x83, 0x80, 0xF0, 0xE6, 0x38, 0xEE, 0x0D,
  0x81, 0xF0, 0x1C, 0x03, 0xC0, 0xD8, 0x3B, 0x86, 0x31, 0xC7, 0x70, 0x70,
  0xE0, 0xEC, 0x19, 0x83, 0x38, 0xE3, 0x18, 0x63, 0x0E, 0xE0, 0xD8, 0x1B,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x05, 0xC0, 0xF8, 0x08,
  0x00, 0xFF, 0x07, 0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x60, 0xE0, 0xFF,
  0xFF, 0x1E, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x71, 0x83, 0xC1, 0x83,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0x78, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE0, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x1C, 0x1C, 0x79, 0xC3,
  0x06, 0x0C, 0x18, 0x30, 0xE3, 0xC6, 0x00, 0x70, 0x7F, 0xB8, 0xFE, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Medium23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 4, 16, 6, 1, -16 },
  { 9, 7, 6, 10, 1, -16 },
  { 15, 12, 16, 13, 1, -16 },
  { 39, 10, 18, 12, 1, -17 },
  { 62, 16, 17, 18, 1, -17 },
  { 96, 14, 17, 15, 1, -17 },
  { 126, 3, 6, 5, 1, -16 },
  { 129, 5, 20, 7, 1, -16 },
  { 142, 5, 20, 7, 1, -16 },
  { 155, 10, 9, 11, 1, -17 },
  { 167, 10, 11, 12, 1, -14 },
  { 181, 3, 6, 6, 1, -3 },
  { 184, 5, 2, 7, 1, -7 },
  { 186, 3, 3, 6, 1, -3 },
  { 188, 9, 16, 9, 0, -16 },
  { 206, 10, 17, 12, 1, -17 },
  { 228, 6, 16, 12, 2, -16 },
  { 240, 10, 17, 12, 1, -17 },
  { 262, 10, 17, 12, 1, -17 },
  { 284, 12, 16, 12, 0, -16 },
  { 308, 10, 16, 12, 1, -16 },
  { 328, 10, 17, 12, 1, -17 },
  { 350, 10, 16, 12, 1, -16 },
  { 370, 10, 17, 12, 1, -17 },
  { 392, 10, 17, 12, 1, -17 },
  { 414, 4, 13, 6, 1, -13 },
  { 421, 3, 16, 6, 1, -13 },
  { 427, 10, 11, 12, 1, -14 },
  { 441, 10, 6, 12, 1, -11 },
  { 449, 10, 11, 12, 1, -14 },
  { 463, 9, 17, 9, 0, -17 },
  { 483, 17, 19, 19, 1, -17 },
  { 524, 14, 16, 14, 0, -16 },
  { 552, 11, 16, 14, 2, -16 },
  { 574, 11, 17, 13, 1, -17 },
  { 598, 12, 16, 15, 2, -16 },
  { 622, 8, 16, 12, 2, -16 },
  { 638, 8, 16, 11, 2, -16 },
  { 654, 13, 17, 15, 1, -17 },
  { 682, 12, 16, 16, 2, -16 },
  { 706, 6, 16, 8, 1, -16 },
  { 718, 6, 21, 6, -2, -16 },
  { 734, 11, 16, 13, 2, -16 },
  { 756, 8, 16, 11, 2, -16 },
  { 772, 16, 16, 20, 2, -16 },
  { 804, 12, 16, 16, 2, -16 },
  { 828, 14, 17, 16, 1, -17 },
  { 858, 10, 16, 13, 2, -16 },
  { 878, 14, 21, 16, 1, -17 },
  { 915, 11, 16, 13, 2, -16 },
  { 937, 10, 17, 12, 1, -17 },
  { 959, 11, 16, 12, 0, -16 },
  { 981, 11, 16, 15, 2, -16 },
  { 1003, 13, 16, 13, 0, -16 },
  { 1029, 20, 16, 20, 0, -16 },
  { 1069, 12, 16, 12, 0, -16 },
  { 1093, 12, 16, 12, 0, -16 },
  { 1117, 10, 16, 12, 1, -16 },
  { 1137, 5, 20, 7, 2, -16 },
  { 1150, 9, 16, 9, 0, -16 },
  { 1168, 5, 20, 7, 1, -16 },
  { 1181, 11, 9, 12, 1, -16 },
  { 1194, 10, 2, 10, 0, 2 },
  { 1197, 5, 4, 7, 1, -18 },
  { 1200, 9, 13, 12, 1, -13 },
  { 1215, 10, 17, 13, 2, -17 },
  { 1237, 9, 13, 10, 1, -13 },
  { 1252, 10, 17, 13, 1, -17 },
  { 1274, 10, 13, 12, 1, -13 },
  { 1291, 8, 18, 7, 0, -18 },
  { 1309, 10, 19, 13, 1, -13 },
  { 1333, 9, 17, 13, 2, -17 },
  { 1353, 2, 17, 6, 2, -17 },
  { 1358, 5, 23, 6, -1, -17 },
  { 1373, 10, 17, 12, 2, -17 },
  { 1395, 2, 17, 6, 2, -17 },
  { 1400, 16, 13, 20, 2, -13 },
  { 1426, 9, 13, 13, 2, -13 },
  { 1441, 11, 13, 13, 1, -13 },
  { 1459, 10, 19, 13, 2, -13 },
  { 1483, 10, 19, 13, 1, -13 },
  { 1507, 7, 13, 9, 2, -13 },
  { 1519, 8, 13, 10, 1, -13 },
  { 1532, 7, 15, 8, 0, -15 },
  { 1546, 9, 12, 13, 2, -12 },
  { 1560, 11, 12, 11, 0, -12 },
  { 1577, 17, 12, 17, 0, -12 },
  { 1603, 11, 12, 11, 0, -12 },
  { 1620, 11, 18, 11, 0, -12 },
  { 1645, 8, 12, 10, 1, -12 },
  { 1657, 7, 20, 9, 1, -16 },
  { 1675, 2, 23, 12, 5, -18 },
  { 1681, 7, 20, 9, 1, -16 },
  { 1699, 10, 4, 12, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Medium23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium23pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM23PT7B_H_
