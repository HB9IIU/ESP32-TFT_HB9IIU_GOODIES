#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM62PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium62pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0xFC, 0x1F,
  0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xE7, 0xC0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0,
  0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF0, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFB, 0xFC, 0x3F, 0x8F, 0x03, 0x8F, 0xE1, 0xE0,
  0x01, 0xFC, 0x3C, 0x00, 0x3F, 0x07, 0x80, 0x07, 0xE0, 0xF0, 0x00, 0xFC,
  0x1E, 0x00, 0x1F, 0xC3, 0xC0, 0x01, 0xF8, 0x78, 0x00, 0x3F, 0xCF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xEF, 0xF8, 0x00, 0x3C, 0x7F, 0x80, 0x07,
  0x87, 0xF0, 0x00, 0xF0, 0x7E, 0x00, 0x1E, 0x0F, 0xC0, 0x03, 0xC1, 0xFC,
  0x00, 0x78, 0x3F, 0x00, 0x0F, 0x07, 0xE8, 0x01, 0xE1, 0xFD, 0xE0, 0x3C,
  0x7F, 0xBF, 0xC7, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x0F,
  0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x00,
  0x0F, 0x81, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x00, 0x0F,
  0x80, 0xF8, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8,
  0x1F, 0x80, 0x00, 0xF8, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x1F,
  0x00, 0x00, 0xF8, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x3E, 0x00,
  0x00, 0xF8, 0x0F, 0x87, 0xC1, 0xFC, 0x0F, 0x80, 0xF8, 0x7C, 0x3F, 0xF0,
  0xF8, 0x1F, 0x8F, 0x87, 0xFF, 0x87, 0xC1, 0xF0, 0xF8, 0xFF, 0xF8, 0x7C,
  0x3F, 0x1F, 0x0F, 0xCF, 0xC7, 0xFF, 0xF1, 0xF1, 0xF8, 0x7C, 0x3F, 0xFE,
  0x3E, 0x1F, 0x03, 0xE1, 0xFF, 0xC3, 0xE1, 0xF0, 0x3E, 0x0F, 0xF8, 0x7C,
  0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC3, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x3E,
  0x03, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x01,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x03, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x00,
  0x7C, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x3E, 0x03, 0xE0, 0x00, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0xFC, 0x1F, 0xFF, 0xE0, 0x0F, 0xE1, 0xFE, 0x7F, 0x80, 0x7F, 0x1F,
  0xE1, 0xFE, 0x03, 0xF0, 0xFE, 0x07, 0xF8, 0x3F, 0x8F, 0xE0, 0x1F, 0xC1,
  0xFC, 0x7F, 0x00, 0x7F, 0x0F, 0xC3, 0xF8, 0x03, 0xFC, 0xFE, 0x1F, 0x80,
  0x0F, 0xF7, 0xE0, 0xFC, 0x00, 0x3F, 0xFF, 0x07, 0xE0, 0x00, 0xFF, 0xF0,
  0x3F, 0x00, 0x03, 0xFF, 0x81, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00,
  0x7F, 0xC0, 0x7F, 0x00, 0x07, 0xFF, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF9,
  0xFE, 0x07, 0xFF, 0xFF, 0x87, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F,
  0xFE, 0x00, 0x7F, 0x80, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0,
  0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x02, 0x00, 0xF8, 0x02, 0x78, 0x1F, 0x03,
  0xCF, 0xF3, 0xE7, 0xF9, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0x3E, 0x03, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0x10, 0x04, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xE3,
  0xF0, 0xFC, 0x3F, 0x0F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFC, 0x03, 0xF8,
  0x3F, 0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0xE7, 0xE0, 0x01, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x0F,
  0xCF, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xC7, 0xF0,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC0, 0xFF, 0x07, 0xF8,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF,
  0xFC, 0x7F, 0xBF, 0x3F, 0xDF, 0xFF, 0xE7, 0xF7, 0xF1, 0xFC, 0xF8, 0x7F,
  0x18, 0x1F, 0xC4, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x1F, 0xC0, 0x3F, 0xC1,
  0xE0, 0x03, 0xFC, 0x38, 0x00, 0x3F, 0x82, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xC7, 0xE0, 0x0F, 0xF0, 0xE0, 0x01, 0xFE, 0x20, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFB, 0xE0, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF7, 0xE0, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80,
  0xFC, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7C,
  0x00, 0x1F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x1F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x04, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC1, 0x80,
  0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x80, 0x00, 0x3F, 0xB8,
  0x00, 0x1F, 0xEF, 0xC0, 0x1F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xF4,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0x9E, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x83, 0xFC, 0x03, 0xF1, 0xFF, 0xE0, 0x7E, 0x7F, 0xFF, 0x0F, 0xDF, 0xFF,
  0xF1, 0xFB, 0xFF, 0xFE, 0x3F, 0xF8, 0x3F, 0xE7, 0xFC, 0x01, 0xFE, 0xFF,
  0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xF0,
  0x0F, 0xE0, 0xFF, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F,
  0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0xFC, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x80,
  0xFF, 0x07, 0xF0, 0x07, 0xFD, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x83, 0xF8,
  0x03, 0xFC, 0x3F, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7E, 0x7F, 0x00, 0x0F, 0xE3, 0xFC, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xE0, 0x3F, 0xC3, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x9F,
  0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC,
  0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFE, 0xFE, 0x00, 0x7F, 0xDF, 0xE0, 0x1F, 0xF3, 0xFF,
  0x1F, 0xFE, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFD, 0xF8, 0x3F, 0xFF, 0x3F,
  0x03, 0xFF, 0xC7, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x3F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7E, 0x3C, 0x0F, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3,
  0xFC, 0x7E, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF1,
  0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0x9F, 0x00, 0xFF, 0x10, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0x80, 0x07, 0xE1, 0xF0,
  0x03, 0xFF, 0xE0, 0x3E, 0x1F, 0x00, 0x7F, 0xFF, 0x03, 0xE3, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0x3E, 0x01, 0xFF, 0xFF, 0x01, 0xF7, 0xE0, 0x3F, 0x01,
  0xF0, 0x1F, 0x7C, 0x07, 0xE0, 0x1F, 0x01, 0xF7, 0xC0, 0x7C, 0x01, 0xF0,
  0x1F, 0x7C, 0x0F, 0xC0, 0x1F, 0x01, 0xF7, 0xC0, 0xFC, 0x01, 0xF0, 0x1F,
  0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xFF, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0xF8,
  0x0F, 0x80, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0xF8, 0x0F,
  0x80, 0x3F, 0x01, 0xFF, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0xF8, 0x0F, 0x80,
  0x3F, 0x01, 0xFF, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0x3F,
  0x03, 0xEF, 0xC0, 0xFC, 0x07, 0xF0, 0x3E, 0x7C, 0x07, 0xC0, 0xFF, 0x07,
  0xC7, 0xC0, 0x7F, 0x1F, 0xF8, 0xFC, 0x7C, 0x03, 0xFF, 0xE7, 0xFF, 0x87,
  0xC0, 0x3F, 0xFC, 0x7F, 0xF0, 0x7E, 0x01, 0xFF, 0x83, 0xFE, 0x03, 0xE0,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x04,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFC, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F,
  0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xE0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0x00,
  0x7F, 0xF3, 0xF8, 0x00, 0x7F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0x9F, 0xC0,
  0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x3F, 0xE7, 0xF0,
  0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xFB, 0xF8, 0x07,
  0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x3E, 0x03,
  0xFE, 0x00, 0x0C, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x02, 0x03, 0xFF, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFE, 0x03, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0xF0, 0xFE,
  0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE,
  0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xF0, 0xFE,
  0x00, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xF0, 0x1F,
  0xF0, 0x00, 0x1C, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xDF, 0x80, 0x07, 0xFF, 0xF7, 0xE0, 0x01, 0xFF, 0xFD,
  0xFC, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x80,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0xC0, 0x01, 0xFC, 0x1F, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x1F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x01,
  0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0x80, 0xFE, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFE, 0x1F, 0xC0, 0x07, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xDF,
  0xE0, 0x01, 0xFF, 0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0x3F,
  0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x3F, 0x80, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE,
  0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFD, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x7E,
  0x00, 0x00, 0xFB, 0xFF, 0xDF, 0x80, 0x00, 0x3E, 0xFF, 0xF3, 0xE0, 0x00,
  0x1F, 0xBF, 0xFC, 0xFC, 0x00, 0x07, 0xCF, 0xFF, 0x3F, 0x00, 0x01, 0xF3,
  0xFF, 0xC7, 0xC0, 0x00, 0xFC, 0xFF, 0xF1, 0xF8, 0x00, 0x3E, 0x3F, 0xFC,
  0x7E, 0x00, 0x0F, 0x8F, 0xFF, 0x0F, 0x80, 0x07, 0xE3, 0xFF, 0xC3, 0xF0,
  0x01, 0xF0, 0xFF, 0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0xFC, 0x1F, 0x00, 0x3F,
  0x0F, 0xFF, 0x07, 0xE0, 0x0F, 0x83, 0xFF, 0xC1, 0xF8, 0x03, 0xE0, 0xFF,
  0xF0, 0x3E, 0x01, 0xF8, 0x3F, 0xFC, 0x0F, 0xC0, 0x7C, 0x0F, 0xFF, 0x03,
  0xF0, 0x1F, 0x03, 0xFF, 0xC0, 0x7C, 0x0F, 0xC0, 0xFF, 0xF0, 0x1F, 0x83,
  0xE0, 0x3F, 0xFC, 0x07, 0xE0, 0xF8, 0x0F, 0xFF, 0x00, 0xF8, 0x7E, 0x03,
  0xFF, 0xC0, 0x3F, 0x1F, 0x00, 0xFF, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F, 0xFC,
  0x03, 0xF3, 0xF0, 0x0F, 0xFF, 0x00, 0x7E, 0xF8, 0x03, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFE, 0xFE, 0x00, 0x0F, 0xFF, 0x7F, 0x00, 0x07, 0xFF,
  0x9F, 0xC0, 0x03, 0xFF, 0xCF, 0xE0, 0x01, 0xFF, 0xE3, 0xF8, 0x00, 0xFF,
  0xF1, 0xFC, 0x00, 0x7F, 0xF8, 0x7F, 0x00, 0x3F, 0xFC, 0x3F, 0x80, 0x1F,
  0xFE, 0x0F, 0xE0, 0x0F, 0xFF, 0x03, 0xF8, 0x07, 0xFF, 0x81, 0xFC, 0x03,
  0xFF, 0xC0, 0x7F, 0x01, 0xFF, 0xE0, 0x3F, 0x80, 0xFF, 0xF0, 0x0F, 0xE0,
  0x7F, 0xF8, 0x07, 0xF0, 0x3F, 0xFC, 0x01, 0xFC, 0x1F, 0xFE, 0x00, 0xFE,
  0x0F, 0xFF, 0x00, 0x3F, 0x87, 0xFF, 0x80, 0x1F, 0xE1, 0xFF, 0xC0, 0x07,
  0xF0, 0xFF, 0xE0, 0x01, 0xFC, 0x7F, 0xF0, 0x00, 0xFE, 0x3F, 0xF8, 0x00,
  0x3F, 0x9F, 0xFC, 0x00, 0x1F, 0xCF, 0xFE, 0x00, 0x07, 0xF7, 0xFF, 0x00,
  0x03, 0xFB, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFC, 0x0F, 0xFF, 0x3F, 0x80, 0x1F,
  0xE7, 0xF0, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xDF, 0xC0,
  0x03, 0xFB, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0x0F, 0xF9,
  0xFC, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF0,
  0x07, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFE, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x83, 0xF8, 0x0F, 0xFE, 0x0F,
  0xE0, 0x07, 0xFC, 0x3F, 0x80, 0x0F, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00,
  0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03,
  0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xFC,
  0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8,
  0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF9, 0xFF, 0x00, 0xF8, 0xFE, 0x00, 0x0C, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFD,
  0xFC, 0x07, 0xFE, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xA0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0xFF, 0x0F, 0xFC, 0x07, 0xFE, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x3E, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF7, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFC,
  0x07, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x3E, 0x3F, 0x00,
  0x7F, 0x01, 0xF8, 0x01, 0xF1, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x8F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x3E, 0x01, 0xFC, 0x01, 0xF8, 0x07,
  0xC1, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x00, 0x7F,
  0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x80,
  0x0F, 0xC0, 0xF8, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x7E, 0x0F,
  0xC0, 0x03, 0xF8, 0x7E, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x0F,
  0x83, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF0, 0xF8,
  0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0x8F, 0xC0, 0x00, 0xFE,
  0x7E, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xF3, 0xE0, 0x03, 0xE3, 0xF0, 0x00,
  0x1F, 0x9F, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x3F, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7E,
  0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00,
  0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0xE0, 0x60, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF3, 0xFF, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xDF, 0xC0,
  0x07, 0xF7, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xDF,
  0x80, 0x07, 0xF7, 0xE0, 0x03, 0xFD, 0xFC, 0x01, 0xFF, 0x7F, 0x80, 0xFF,
  0xDF, 0xF9, 0xFF, 0xF3, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0x1F, 0x0F, 0xFF,
  0x87, 0xC1, 0xFF, 0xC1, 0xF0, 0x07, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x3F, 0x1F, 0xFE, 0x07, 0xE7,
  0xFF, 0xE0, 0xFD, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xC7, 0xFE,
  0x7F, 0xC0, 0x3F, 0xCF, 0xF0, 0x03, 0xFD, 0xFC, 0x00, 0x3F, 0xBF, 0x80,
  0x07, 0xF7, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xF7, 0xF8, 0x00, 0xFE, 0xFF,
  0x80, 0x3F, 0x9F, 0xF8, 0x0F, 0xF3, 0xFF, 0xFF, 0xFC, 0x7D, 0xFF, 0xFF,
  0x8F, 0x9F, 0xFF, 0xE1, 0xF1, 0xFF, 0xF8, 0x3E, 0x0F, 0xFC, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0x3F, 0x0F, 0xF0, 0x02, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x23, 0xFE,
  0x01, 0xC3, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x03, 0xFF, 0xC7, 0xF0,
  0x7F, 0xFE, 0x7F, 0x0F, 0xFF, 0xF7, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xF1,
  0xFF, 0xF3, 0xFC, 0x03, 0xFF, 0x3F, 0x80, 0x1F, 0xF7, 0xF0, 0x00, 0xFF,
  0x7F, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xF3, 0xFC, 0x07, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF, 0xF3, 0xF0, 0x7F, 0xFE, 0x3F,
  0x01, 0xFF, 0x83, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00,
  0x1F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x41, 0xFE, 0x00, 0x78, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0,
  0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x08, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xFC, 0x3F, 0x07, 0xFF, 0xE3, 0xF0, 0xFF, 0xFF, 0x3F,
  0x1F, 0xFF, 0xFB, 0xF1, 0xFF, 0x1F, 0xFF, 0x3F, 0xC0, 0x3F, 0xF3, 0xF8,
  0x01, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7E, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x01, 0xFF,
  0x3F, 0xC0, 0x3F, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0x7F, 0x07, 0xFF, 0xE7, 0xF0, 0x1F, 0xF8, 0x7F, 0x00, 0x18, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE2, 0x00, 0x01,
  0xFC, 0x3C, 0x00, 0x3F, 0xC3, 0xFF, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x0F,
  0xC7, 0xFF, 0x83, 0xF3, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0x9F, 0xFB, 0xFE, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xBF, 0xC0,
  0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x3C,
  0xFF, 0xFF, 0xFF, 0xEF, 0xDF, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD,
  0xFB, 0xF7, 0xEF, 0xC0, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01,
  0xFC, 0x07, 0xF0, 0x3F, 0xFB, 0xFE, 0xFF, 0xFB, 0xFF, 0xCF, 0xFE, 0x3F,
  0xF0, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x03, 0xFB, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0xFE, 0x3F, 0x00,
  0x7F, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0x3F,
  0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x1F, 0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF,
  0xBF, 0x80, 0x3F, 0xC7, 0xF0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0x3F, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x83, 0xF0, 0x0F,
  0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0,
  0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0x87, 0xFF, 0x80, 0xFF, 0xF0, 0xF8,
  0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0x9F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFB, 0xFF,
  0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0x1F, 0xFF, 0xC7, 0xFE, 0xFF, 0x80, 0x7F,
  0xF0, 0x1F, 0xEF, 0xF0, 0x07, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xEF, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x3E, 0x1F,
  0xFE, 0x0F, 0x8F, 0xFF, 0xE3, 0xE7, 0xFF, 0xFC, 0xFB, 0xFF, 0xFF, 0x3F,
  0xFC, 0x7F, 0xEF, 0xF8, 0x07, 0xFB, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x3F, 0xC3, 0xF8,
  0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE3, 0xF8, 0x01, 0xFC,
  0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x1F, 0x0F, 0xFF, 0x03, 0xE3, 0xFF, 0xF0, 0x7C,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xC3, 0xFF, 0x3F, 0xE0, 0x1F,
  0xE7, 0xF8, 0x01, 0xFE, 0xFE, 0x00, 0x1F, 0xDF, 0xC0, 0x03, 0xFB, 0xF8,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xDF, 0xC0, 0x03, 0xFB, 0xFC, 0x00, 0x7F, 0x7F, 0xC0, 0x1F, 0xCF,
  0xFC, 0x07, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xEF, 0xFF,
  0xF0, 0xFC, 0xFF, 0xFC, 0x1F, 0x87, 0xFE, 0x03, 0xF0, 0x1E, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0xFC, 0x3F, 0x07, 0xFF, 0xE3, 0xF0, 0xFF, 0xFF,
  0x3F, 0x1F, 0xFF, 0xFB, 0xF1, 0xFF, 0x0F, 0xFF, 0x3F, 0xC0, 0x3F, 0xF3,
  0xF8, 0x01, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7E, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7E,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF3, 0xF8, 0x01,
  0xFF, 0x3F, 0xC0, 0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF7, 0xF0,
  0xFF, 0xFF, 0x7F, 0x07, 0xFF, 0xE7, 0xF0, 0x1F, 0xF8, 0x7F, 0x00, 0x18,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF,
  0xF9, 0xFF, 0xFE, 0xFF, 0xEF, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x3F,
  0xFF, 0x81, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xFC, 0x07,
  0xCF, 0xE0, 0x02, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xA0, 0x00,
  0x7E, 0xF0, 0x03, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x01,
  0x80, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x7E, 0x00,
  0x1F, 0xEF, 0xE0, 0x07, 0xFD, 0xFC, 0x00, 0xFF, 0xBF, 0xC0, 0x7F, 0xF3,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xEF, 0xC7, 0xFF, 0xF9, 0xF8, 0x7F, 0xFE,
  0x3F, 0x03, 0xFF, 0x03, 0xE0, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x00, 0xFC, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E,
  0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01,
  0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF7, 0xE0, 0x07, 0xFE, 0x00, 0x7E, 0x7E, 0x00,
  0x7F, 0xE0, 0x07, 0xE7, 0xE0, 0x07, 0xFE, 0x00, 0x7E, 0x7F, 0x00, 0x7F,
  0xE0, 0x0F, 0xE3, 0xF0, 0x0F, 0xBF, 0x00, 0xFC, 0x3F, 0x00, 0xF9, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0x9F, 0x00, 0xFC, 0x3F, 0x80, 0xF9, 0xF0, 0x1F,
  0x81, 0xF8, 0x1F, 0x9F, 0x81, 0xF8, 0x1F, 0x81, 0xF1, 0xF8, 0x1F, 0x81,
  0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0x1F, 0xC1, 0xF0, 0xF8, 0x3F, 0x00, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xE0, 0xFC, 0x3F, 0x00, 0xFC, 0x3E,
  0x07, 0xC3, 0xF0, 0x0F, 0xC3, 0xE0, 0x7C, 0x7E, 0x00, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0x07, 0xE7, 0xC0, 0x7E, 0x7E, 0x00, 0x7E, 0x7C, 0x03, 0xE7,
  0xE0, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x03, 0xEF, 0xC0,
  0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x1F,
  0xC1, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x07,
  0xE0, 0x7F, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x9F,
  0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF9, 0xFC, 0x00, 0x3F,
  0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xE0, 0x3F,
  0x01, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E,
  0x07, 0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F,
  0x80, 0x7E, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x7F, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x0F,
  0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01,
  0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x13,
  0xFF, 0xE0, 0x03, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xEC, 0x00, 0x0F, 0xF8,
  0x80, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Medium62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 8, 45, 16, 4, -44 },
  { 46, 18, 16, 26, 4, -44 },
  { 82, 34, 44, 36, 1, -44 },
  { 269, 27, 51, 32, 3, -47 },
  { 442, 44, 46, 49, 3, -45 },
  { 695, 37, 46, 40, 3, -45 },
  { 908, 6, 16, 14, 4, -44 },
  { 920, 14, 54, 19, 3, -44 },
  { 1015, 14, 54, 19, 2, -44 },
  { 1110, 27, 26, 31, 2, -47 },
  { 1198, 27, 30, 32, 3, -37 },
  { 1300, 10, 15, 16, 2, -7 },
  { 1319, 15, 6, 19, 2, -20 },
  { 1331, 8, 9, 16, 4, -8 },
  { 1340, 22, 44, 24, 1, -44 },
  { 1461, 27, 46, 32, 3, -45 },
  { 1617, 18, 44, 32, 4, -44 },
  { 1716, 27, 45, 32, 3, -45 },
  { 1868, 26, 46, 32, 3, -45 },
  { 2018, 30, 44, 32, 1, -44 },
  { 2183, 26, 45, 32, 3, -44 },
  { 2330, 27, 46, 32, 3, -45 },
  { 2486, 28, 44, 32, 2, -44 },
  { 2640, 28, 46, 32, 2, -45 },
  { 2801, 27, 46, 32, 3, -45 },
  { 2957, 8, 35, 16, 4, -34 },
  { 2992, 10, 42, 16, 2, -34 },
  { 3045, 27, 30, 32, 3, -37 },
  { 3147, 27, 18, 32, 3, -31 },
  { 3208, 27, 30, 32, 3, -37 },
  { 3310, 23, 46, 25, 1, -45 },
  { 3443, 44, 50, 51, 3, -45 },
  { 3718, 36, 44, 36, 0, -44 },
  { 3916, 29, 44, 37, 5, -44 },
  { 4076, 31, 46, 35, 3, -45 },
  { 4255, 32, 44, 41, 5, -44 },
  { 4431, 23, 44, 31, 5, -44 },
  { 4558, 23, 44, 30, 5, -44 },
  { 4685, 34, 46, 41, 3, -45 },
  { 4881, 32, 44, 42, 5, -44 },
  { 5057, 16, 44, 21, 2, -44 },
  { 5145, 16, 56, 17, -4, -44 },
  { 5257, 31, 44, 35, 5, -44 },
  { 5428, 23, 44, 30, 5, -44 },
  { 5555, 42, 44, 53, 5, -44 },
  { 5786, 33, 44, 44, 5, -44 },
  { 5968, 37, 46, 44, 3, -45 },
  { 6181, 27, 44, 34, 5, -44 },
  { 6330, 37, 56, 44, 3, -45 },
  { 6589, 30, 44, 36, 5, -44 },
  { 6754, 25, 46, 31, 3, -45 },
  { 6898, 29, 44, 31, 1, -44 },
  { 7058, 31, 45, 41, 5, -44 },
  { 7233, 35, 44, 35, 0, -44 },
  { 7426, 53, 44, 53, 0, -44 },
  { 7718, 33, 44, 34, 0, -44 },
  { 7900, 32, 44, 32, 0, -44 },
  { 8076, 27, 44, 31, 2, -44 },
  { 8225, 13, 54, 20, 5, -44 },
  { 8313, 22, 44, 24, 1, -44 },
  { 8434, 14, 54, 20, 2, -44 },
  { 8529, 29, 26, 33, 2, -44 },
  { 8624, 27, 4, 27, 0, 5 },
  { 8638, 14, 9, 18, 2, -47 },
  { 8654, 26, 35, 32, 2, -34 },
  { 8768, 27, 48, 35, 5, -47 },
  { 8930, 23, 35, 28, 3, -34 },
  { 9031, 28, 48, 35, 3, -47 },
  { 9199, 27, 35, 32, 3, -34 },
  { 9318, 21, 47, 20, 1, -47 },
  { 9442, 28, 49, 35, 3, -34 },
  { 9614, 26, 47, 35, 5, -47 },
  { 9767, 7, 46, 16, 4, -46 },
  { 9808, 14, 61, 16, -3, -46 },
  { 9915, 26, 47, 32, 5, -47 },
  { 10068, 6, 47, 16, 5, -47 },
  { 10104, 44, 34, 53, 5, -34 },
  { 10291, 26, 34, 35, 5, -34 },
  { 10402, 28, 35, 34, 3, -34 },
  { 10525, 27, 49, 35, 5, -34 },
  { 10691, 28, 49, 35, 3, -34 },
  { 10863, 18, 34, 24, 5, -34 },
  { 10940, 22, 35, 27, 3, -34 },
  { 11037, 19, 42, 21, 1, -41 },
  { 11137, 27, 34, 35, 4, -33 },
  { 11252, 30, 33, 30, 0, -33 },
  { 11376, 44, 33, 46, 1, -33 },
  { 11558, 28, 33, 30, 1, -33 },
  { 11674, 30, 48, 30, 0, -33 },
  { 11854, 22, 33, 26, 2, -33 },
  { 11945, 19, 54, 23, 2, -44 },
  { 12074, 5, 62, 31, 13, -47 },
  { 12113, 20, 54, 23, 2, -44 },
  { 12248, 28, 9, 32, 2, -26 },
};

const GFXfont NotoSans_SemiCondensed_Medium62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium62pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM62PT7B_H_
