#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM54PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM54PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium54pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7E,
  0xFF, 0xFF, 0x7E, 0x7E, 0x18, 0xFC, 0x3F, 0xFC, 0x3F, 0xFC, 0x1F, 0xFC,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C,
  0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00,
  0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07,
  0xC0, 0x00, 0xF0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x3E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x1F, 0x03,
  0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x0F, 0x80,
  0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFE, 0x73, 0xF3,
  0xF0, 0xE0, 0x47, 0xC1, 0xC0, 0x0F, 0x83, 0x80, 0x1F, 0x07, 0x00, 0x3E,
  0x0E, 0x00, 0x7E, 0x1C, 0x00, 0xFC, 0x38, 0x00, 0xFE, 0x70, 0x01, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x73, 0xF8, 0x00, 0xE3,
  0xF0, 0x01, 0xC3, 0xF0, 0x03, 0x87, 0xE0, 0x07, 0x0F, 0xC0, 0x0E, 0x1F,
  0xC0, 0x1C, 0x3E, 0xE0, 0x38, 0xFD, 0xF8, 0x7F, 0xFB, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00,
  0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xE0, 0x07, 0xC3, 0xC0,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x1F, 0x00, 0x1E, 0x07, 0x80, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0xF8, 0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x01, 0xF0, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x3E, 0x00,
  0x0F, 0x81, 0xF0, 0x78, 0x00, 0x1F, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x07,
  0xC3, 0xC0, 0x00, 0x7C, 0x0F, 0x0F, 0x83, 0xC0, 0x78, 0x1E, 0x1E, 0x1F,
  0xE0, 0xF0, 0x3C, 0x7C, 0x7F, 0xE1, 0xF0, 0xF8, 0xF1, 0xFF, 0xE3, 0xE1,
  0xE3, 0xE3, 0xE7, 0xC3, 0xFF, 0xC7, 0x8F, 0x87, 0xC3, 0xFF, 0x1F, 0x1E,
  0x0F, 0x87, 0xFC, 0x3C, 0x3C, 0x0F, 0x03, 0xF0, 0xF8, 0xF8, 0x1E, 0x00,
  0x01, 0xE1, 0xF0, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x7C, 0x00, 0x0F, 0x07,
  0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x1F, 0x03, 0xE0,
  0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0x0F, 0x80,
  0x78, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x01, 0xE0, 0xF8,
  0x00, 0xF8, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xC0,
  0x07, 0xFF, 0x80, 0x0F, 0x00, 0x07, 0xFE, 0x00, 0x3E, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x07, 0xE0, 0xFE, 0xFC, 0x03, 0xF0, 0xFE, 0x3F, 0x01, 0xF8,
  0xFE, 0x1F, 0xC0, 0xF8, 0x7E, 0x07, 0xF0, 0xFC, 0x3F, 0x01, 0xFC, 0x7E,
  0x3F, 0x00, 0x7F, 0x7E, 0x1F, 0x80, 0x1F, 0xFF, 0x0F, 0xC0, 0x07, 0xFF,
  0x07, 0xE0, 0x01, 0xFF, 0x83, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x3F, 0xF8, 0x1F, 0xF8, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xBF, 0x81, 0xFF, 0xFF, 0x8F, 0xE0, 0x7F, 0xFF,
  0x03, 0xF8, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x79, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x1F, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C,
  0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0,
  0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x20, 0x1E, 0x01, 0x38,
  0x3C, 0x1E, 0xFF, 0x39, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xF7,
  0xC0, 0x07, 0xCF, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0xF8, 0x3E, 0x00, 0x60, 0x30, 0x00, 0x40, 0x40, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8,
  0xF8, 0x7C, 0x3E, 0x1E, 0x1F, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x7E, 0x7E, 0xFF, 0xFE, 0x7E, 0x7E, 0x18,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x1F, 0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00, 0x7E,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E,
  0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x3F, 0x00, 0xFC,
  0x1F, 0x81, 0xFC, 0x1F, 0xE7, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00, 0x3E, 0x00,
  0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x7F, 0xE1, 0xFF, 0xC7, 0xFF, 0x9F, 0xFF,
  0x7F, 0x7F, 0xFC, 0xFD, 0xE1, 0xF9, 0x83, 0xF2, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x7E, 0x01, 0xFC, 0x3C, 0x00, 0xFC, 0x10, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x3C,
  0x01, 0xFC, 0x38, 0x00, 0xFC, 0x20, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x80, 0x00, 0xFE, 0xE0,
  0x01, 0xFC, 0xFC, 0x0F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1E,
  0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xCF, 0xC0, 0x01, 0xF3, 0xF0, 0x00,
  0xF8, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0x83, 0xF0,
  0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x3E, 0x03,
  0xF0, 0x0F, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0xC0, 0xF8,
  0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC1, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x80,
  0x01, 0xF9, 0x80, 0x07, 0xF3, 0xF0, 0x7F, 0xC7, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x06, 0x00, 0x7C, 0x3F, 0xE0, 0x7C, 0xFF,
  0xF0, 0x7D, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xC1, 0xFC, 0xFF, 0x00,
  0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x3F, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x3E, 0x3F, 0x00,
  0x7E, 0x1F, 0x80, 0xFE, 0x1F, 0xE3, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xE7, 0xFC, 0x3F, 0x00,
  0xFC, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x3E, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3F, 0x00,
  0xFC, 0x1F, 0x81, 0xF8, 0x0F, 0xE3, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xEF,
  0xF0, 0x1F, 0x83, 0xF8, 0x3F, 0x01, 0xFC, 0x7E, 0x00, 0xFE, 0x7C, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00,
  0x7E, 0x7F, 0x81, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x28, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x81,
  0xF8, 0x7F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x7C, 0x00,
  0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00,
  0x7F, 0x7E, 0x00, 0xFF, 0x7F, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xBF, 0x0F, 0xFF, 0xBE, 0x07, 0xFE, 0x3E, 0x01, 0xF8, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x10, 0x3F, 0xE0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x18, 0x7E, 0x7E, 0xFF, 0xFF,
  0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7E, 0xFF, 0xFF, 0x7E,
  0x7E, 0x18, 0x0C, 0x1F, 0x8F, 0xCF, 0xE7, 0xF9, 0xF8, 0xFC, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x8F, 0xC7, 0xC3, 0xE3, 0xF1,
  0xF0, 0xF8, 0x7C, 0x3C, 0x3E, 0x1F, 0x0F, 0x00, 0x00, 0x00, 0x01, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xE7, 0x80, 0xFE, 0x40, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0x0F, 0x8F, 0x80,
  0x3F, 0xF8, 0x3E, 0x3C, 0x03, 0xFF, 0xF0, 0x79, 0xF0, 0x1F, 0xFF, 0xC1,
  0xF7, 0xC0, 0xFE, 0x3F, 0x07, 0xDE, 0x07, 0xE0, 0x7C, 0x0F, 0x78, 0x1F,
  0x01, 0xF0, 0x3F, 0xE0, 0xF8, 0x07, 0x80, 0xFF, 0x83, 0xE0, 0x1E, 0x03,
  0xFC, 0x0F, 0x80, 0x78, 0x0F, 0xF0, 0x3C, 0x01, 0xE0, 0x3F, 0xC0, 0xF0,
  0x07, 0x80, 0xFF, 0x03, 0xC0, 0x1E, 0x03, 0xFC, 0x0F, 0x00, 0x78, 0x0F,
  0xF0, 0x3C, 0x03, 0xE0, 0x3F, 0xC0, 0xF0, 0x0F, 0x81, 0xFF, 0x03, 0xE0,
  0x3E, 0x07, 0xBC, 0x0F, 0x81, 0xF8, 0x3E, 0xF8, 0x1F, 0x07, 0xF0, 0xF3,
  0xE0, 0x7F, 0xFD, 0xFF, 0xC7, 0x80, 0xFF, 0xE7, 0xFE, 0x1E, 0x01, 0xFF,
  0x0F, 0xF0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x20, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x00,
  0xFF, 0x80, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xC0, 0x1F, 0xF3, 0xE0, 0x03, 0xF9, 0xF0, 0x00, 0xFC,
  0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07,
  0xCF, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x01,
  0xF8, 0xF8, 0x1F, 0xF8, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xC0, 0x1F, 0xE3, 0xE0, 0x03, 0xF9, 0xF0,
  0x00, 0xFE, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFD,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x7F, 0x7C, 0x00, 0xFF, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x01, 0xE1, 0xFE, 0x00, 0x10,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x60, 0xFF, 0xF7, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0x80, 0xFF, 0xE0, 0xF8, 0x00, 0xFF, 0x0F,
  0x80, 0x07, 0xF8, 0xF8, 0x00, 0x3F, 0x8F, 0x80, 0x01, 0xFC, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E,
  0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x7E, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xFC, 0xF8, 0x00, 0x3F, 0x8F,
  0x80, 0x07, 0xF8, 0xF8, 0x00, 0xFF, 0x0F, 0x80, 0x3F, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0xF0, 0x3F, 0xC0, 0x00, 0x83,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFE,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x80,
  0x0F, 0xC3, 0xFF, 0xC7, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0xC7, 0xFB, 0xFF, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC0, 0x70, 0x00,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xEF, 0x80, 0x03, 0xF3, 0xE0, 0x01,
  0xF8, 0xF8, 0x00, 0xFE, 0x3E, 0x00, 0x7F, 0x0F, 0x80, 0x1F, 0x83, 0xE0,
  0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF8, 0x0F, 0x80, 0xFC, 0x03,
  0xE0, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x1F, 0xC0, 0x0F, 0x87, 0xE0,
  0x03, 0xE3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xBF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xF7, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x07, 0xF0,
  0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x3F, 0x80, 0xF8, 0x07, 0xF0, 0x3E, 0x00,
  0xFC, 0x0F, 0x80, 0x3F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x3E,
  0x00, 0x3F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xFC, 0xF8, 0x00, 0x3F,
  0x3E, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFC, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3D, 0xFF, 0xBE, 0x00, 0x07, 0xDF, 0xFB, 0xE0, 0x00, 0x7D, 0xFF, 0xBE,
  0x00, 0x07, 0x9F, 0xF9, 0xF0, 0x00, 0xF9, 0xFF, 0x9F, 0x00, 0x0F, 0x9F,
  0xF9, 0xF0, 0x00, 0xF1, 0xFF, 0x8F, 0x80, 0x1F, 0x1F, 0xF8, 0xF8, 0x01,
  0xF1, 0xFF, 0x8F, 0x80, 0x1E, 0x1F, 0xF8, 0x7C, 0x03, 0xE1, 0xFF, 0x87,
  0xC0, 0x3E, 0x1F, 0xF8, 0x7C, 0x03, 0xC1, 0xFF, 0x83, 0xE0, 0x7C, 0x1F,
  0xF8, 0x3E, 0x07, 0xC1, 0xFF, 0x83, 0xE0, 0xF8, 0x1F, 0xF8, 0x1F, 0x0F,
  0x81, 0xFF, 0x81, 0xF0, 0xF8, 0x1F, 0xF8, 0x1F, 0x1F, 0x01, 0xFF, 0x81,
  0xF9, 0xF0, 0x1F, 0xF8, 0x0F, 0x9F, 0x01, 0xFF, 0x80, 0xFB, 0xE0, 0x1F,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0x80, 0x1F, 0xF8, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xF7, 0xE0, 0x01,
  0xFF, 0xFE, 0x00, 0x1F, 0xFB, 0xF0, 0x01, 0xFF, 0xBF, 0x80, 0x1F, 0xF9,
  0xF8, 0x01, 0xFF, 0x8F, 0xC0, 0x1F, 0xF8, 0xFC, 0x01, 0xFF, 0x87, 0xE0,
  0x1F, 0xF8, 0x7E, 0x01, 0xFF, 0x83, 0xF0, 0x1F, 0xF8, 0x3F, 0x01, 0xFF,
  0x81, 0xF8, 0x1F, 0xF8, 0x1F, 0xC1, 0xFF, 0x80, 0xFC, 0x1F, 0xF8, 0x07,
  0xE1, 0xFF, 0x80, 0x7E, 0x1F, 0xF8, 0x03, 0xF1, 0xFF, 0x80, 0x3F, 0x1F,
  0xF8, 0x01, 0xF9, 0xFF, 0x80, 0x1F, 0x9F, 0xF8, 0x00, 0xFD, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x7E, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0,
  0x07, 0xF0, 0x0F, 0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00,
  0x80, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x03, 0xFF, 0x3E, 0x00, 0xFF, 0x7C, 0x00,
  0xFE, 0xF8, 0x00, 0xFD, 0xF0, 0x01, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x7E,
  0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xFB, 0xE0, 0x0F, 0xE7, 0xC3, 0xFF, 0xCF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xFE, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3E,
  0x03, 0xFE, 0x0F, 0x80, 0x1F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC,
  0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0xF8,
  0x01, 0xFC, 0x3E, 0x00, 0xFE, 0x0F, 0x81, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xE0, 0x7E,
  0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xE0,
  0x1F, 0x80, 0xF8, 0x07, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x83,
  0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x07,
  0xE3, 0xE0, 0x01, 0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xEF, 0x80,
  0x01, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x87, 0xF0, 0x0F, 0x1F, 0xC0, 0x06, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x80, 0x00,
  0xFD, 0xE0, 0x03, 0xFB, 0xFE, 0x7F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3E, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0xF1,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x50, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0x7E, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00,
  0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x80, 0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0,
  0x3F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F,
  0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xFE,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0xF0,
  0x01, 0xF0, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xEF, 0x80,
  0x3F, 0x07, 0xE0, 0x0F, 0xBE, 0x00, 0xFC, 0x1F, 0x80, 0x7C, 0xF8, 0x03,
  0xE0, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xCF, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0xF8, 0x7C, 0x07, 0xC0,
  0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x83, 0xE0, 0xFC, 0x01,
  0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0x07, 0xE1, 0xF0, 0x3E, 0x0F, 0x80, 0x1F,
  0x87, 0xC0, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x7C, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0x0F, 0xCF,
  0x80, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8,
  0x03, 0xEF, 0xC0, 0x01, 0xF3, 0xC0, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7B, 0xE0, 0x00, 0x3F, 0xF0, 0x01,
  0xEF, 0x80, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x07, 0xE0,
  0x03, 0xE0, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03,
  0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x03,
  0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xEF, 0x00, 0x01,
  0xE7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0x78, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x8F, 0x80, 0x07,
  0xC7, 0xC0, 0x01, 0xF3, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x3E,
  0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3C, 0x07, 0xE0, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0xC0, 0x7D, 0xFC, 0x01, 0xF7,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x01, 0xFD, 0xFC, 0x1F, 0xF7, 0xFF, 0xFF,
  0xCF, 0xFF, 0xCF, 0x1F, 0xFE, 0x3C, 0x3F, 0xE0, 0xF0, 0x08, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x0E, 0x00,
  0xFC, 0x7F, 0xC0, 0xF9, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFB, 0xFF, 0xF8,
  0xFF, 0x83, 0xFC, 0xFF, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFF, 0x00, 0xFC,
  0xFF, 0xC3, 0xFC, 0xFB, 0xFF, 0xF8, 0xFB, 0xFF, 0xF0, 0xF9, 0xFF, 0xE0,
  0xF0, 0x7F, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x1A, 0x00, 0x3F, 0xF8, 0x1F,
  0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0x83, 0x9F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x27, 0xF8, 0x3C, 0x7F, 0xFF, 0x8F, 0xFF,
  0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x80, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xF0, 0x3F, 0x07, 0xFE, 0x3F, 0x0F,
  0xFF, 0x3F, 0x1F, 0xFF, 0xBF, 0x3F, 0xFF, 0xFF, 0x3F, 0x83, 0xFF, 0x7F,
  0x00, 0xFF, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F, 0x83, 0xFF, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0x9F, 0x0F, 0xFF, 0x1F, 0x03, 0xFE, 0x1F, 0x00,
  0x20, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F,
  0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xE0, 0x7F, 0x1F, 0x80, 0x3E, 0x3F, 0x00,
  0x7E, 0x7C, 0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x08, 0x7F, 0x80, 0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x02, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x3F,
  0xF8, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7F, 0x18, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x03, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x07, 0xFE, 0x1F, 0x0F, 0xFF, 0x1F, 0x1F, 0xFF, 0x9F, 0x3F, 0xFF,
  0xFF, 0x3F, 0x83, 0xFF, 0x7F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00,
  0xFF, 0x3F, 0x83, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF,
  0x3F, 0x03, 0xFE, 0x3F, 0x00, 0x20, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x40, 0x00,
  0xFE, 0x78, 0x01, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x78, 0x0F, 0xC7, 0xFE, 0x1F, 0x3F, 0xFE, 0x3E,
  0xFF, 0xFE, 0x7D, 0xFF, 0xFE, 0xFF, 0xC1, 0xFD, 0xFE, 0x01, 0xFB, 0xF8,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x7B, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0xFF,
  0xEF, 0xFC, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x3F,
  0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x1F, 0x83, 0xF0,
  0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x3F,
  0x00, 0x7C, 0xFC, 0x00, 0xFB, 0xF8, 0x01, 0xF7, 0xF0, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x0F, 0xF7, 0xE0, 0x1F, 0xC7, 0xE0, 0x3F, 0x0F, 0xE0,
  0x7E, 0x0F, 0xC0, 0xFC, 0x0F, 0xC1, 0xF8, 0x1F, 0xC3, 0xF0, 0x1F, 0x87,
  0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x7F, 0x7E,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0E, 0x00, 0x0E, 0x03, 0xE1, 0xFF, 0x01, 0xFF, 0x8F, 0x9F, 0xFE,
  0x1F, 0xFF, 0x3E, 0xFF, 0xFC, 0xFF, 0xFE, 0xFB, 0xFF, 0xFB, 0xFF, 0xFB,
  0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0xF0, 0x1F, 0xF0, 0x0F, 0xFF, 0x80, 0x3F,
  0x80, 0x3F, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x03, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x00, 0xFC,
  0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xFF,
  0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF0,
  0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xFC,
  0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xC0,
  0x07, 0xFF, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xF0,
  0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0x00,
  0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0x07, 0x01, 0xF0, 0xFF, 0xC3, 0xE7, 0xFF, 0xC7, 0xDF, 0xFF, 0xCF, 0xBF,
  0xFF, 0xDF, 0xF8, 0x3F, 0xBF, 0xC0, 0x3F, 0x7F, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xC0, 0x00, 0x18, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x7F, 0x00, 0xFE, 0x7E,
  0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00,
  0x0E, 0x00, 0xF8, 0x7F, 0xC0, 0xF9, 0xFF, 0xF0, 0xFB, 0xFF, 0xF8, 0xFB,
  0xFF, 0xF8, 0xFF, 0x81, 0xFC, 0xFF, 0x00, 0xFC, 0xFE, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFF,
  0x00, 0xFC, 0xFF, 0xC3, 0xFC, 0xFB, 0xFF, 0xF8, 0xFB, 0xFF, 0xF0, 0xF9,
  0xFF, 0xE0, 0xFC, 0x7F, 0xC0, 0xFC, 0x06, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xFE, 0x1F, 0x0F, 0xFF, 0x1F, 0x1F, 0xFF, 0x9F, 0x3F, 0xFF, 0xFF, 0x3F,
  0x83, 0xFF, 0x7F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x00, 0xFF, 0x3F,
  0x83, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xBF, 0x0F, 0xFF, 0x3F, 0x03,
  0xFE, 0x3F, 0x00, 0x40, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x0E, 0xF0, 0x7F, 0xF8, 0xFF, 0xF9,
  0xFF, 0xFB, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x7F, 0xFF,
  0x9F, 0xFF, 0xF7, 0xFF, 0xFC, 0xFC, 0x07, 0xBF, 0x00, 0x17, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x20, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE1, 0x0F,
  0xFF, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x18, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0x7F, 0x87, 0xFE, 0xFF, 0xFF, 0x7C,
  0xFF, 0xFC, 0xF8, 0xFF, 0xF1, 0xF0, 0xFF, 0xC3, 0xE0, 0x08, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xE0, 0x7C,
  0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F,
  0x80, 0x1F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3F,
  0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x7C, 0x01, 0xFE, 0x00, 0xF9, 0xF0,
  0x0F, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0xF0, 0x1F, 0x9F, 0x80, 0xF3, 0xC0,
  0x7C, 0x3E, 0x03, 0xCF, 0x01, 0xF0, 0xF8, 0x1F, 0x3E, 0x07, 0xC3, 0xF0,
  0x7C, 0xF8, 0x3F, 0x07, 0xC1, 0xF3, 0xE0, 0xF8, 0x1F, 0x07, 0x87, 0x83,
  0xE0, 0x7C, 0x3E, 0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x7C, 0x7E, 0x03, 0xE3,
  0xE1, 0xF1, 0xF0, 0x0F, 0x8F, 0x03, 0xC7, 0xC0, 0x3E, 0x7C, 0x0F, 0x9F,
  0x00, 0xF9, 0xF0, 0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0x07, 0xDE,
  0x01, 0xEF, 0x80, 0x1F, 0x78, 0x07, 0xBE, 0x00, 0x7D, 0xE0, 0x1E, 0xF8,
  0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x01, 0xFB, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0x7E, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xEF, 0xC0, 0x03, 0xF8,
  0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7C,
  0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x3F, 0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x1F,
  0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x1F,
  0x3F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xFF,
  0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0xFF, 0xC0, 0xFF, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07,
  0xF0, 0x1F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF0, 0x01, 0x00, 0x00,
  0x0F, 0x80, 0x01, 0x3F, 0xF0, 0x01, 0x7F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0xC0, 0x0F, 0xFC, 0x80, 0x01, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Medium54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 40, 14, 3, -39 },
  { 41, 16, 14, 23, 3, -39 },
  { 69, 29, 39, 31, 1, -39 },
  { 211, 23, 44, 28, 3, -41 },
  { 338, 39, 39, 43, 2, -39 },
  { 529, 33, 40, 35, 2, -39 },
  { 694, 6, 14, 12, 3, -39 },
  { 705, 13, 48, 17, 2, -39 },
  { 783, 12, 48, 17, 2, -39 },
  { 855, 23, 23, 27, 2, -41 },
  { 922, 24, 26, 28, 2, -32 },
  { 1000, 9, 13, 14, 2, -6 },
  { 1015, 13, 5, 17, 2, -17 },
  { 1024, 8, 8, 14, 3, -7 },
  { 1032, 19, 39, 21, 1, -39 },
  { 1125, 24, 40, 28, 2, -39 },
  { 1245, 15, 39, 28, 4, -39 },
  { 1319, 24, 39, 28, 2, -39 },
  { 1436, 24, 40, 28, 2, -39 },
  { 1556, 26, 39, 28, 1, -39 },
  { 1683, 23, 40, 28, 3, -39 },
  { 1798, 24, 40, 28, 2, -39 },
  { 1918, 24, 39, 28, 2, -39 },
  { 2035, 24, 40, 28, 2, -39 },
  { 2155, 24, 40, 28, 2, -39 },
  { 2275, 8, 31, 14, 3, -30 },
  { 2306, 9, 37, 14, 2, -30 },
  { 2348, 24, 27, 28, 2, -33 },
  { 2429, 24, 16, 28, 2, -27 },
  { 2477, 24, 27, 28, 2, -33 },
  { 2558, 20, 40, 22, 1, -39 },
  { 2658, 38, 44, 44, 3, -39 },
  { 2867, 32, 39, 32, 0, -39 },
  { 3023, 25, 39, 32, 5, -39 },
  { 3145, 26, 40, 31, 3, -39 },
  { 3275, 28, 39, 35, 5, -39 },
  { 3412, 19, 39, 27, 5, -39 },
  { 3505, 19, 39, 26, 5, -39 },
  { 3598, 29, 40, 36, 3, -39 },
  { 3743, 27, 39, 36, 5, -39 },
  { 3875, 14, 39, 18, 2, -39 },
  { 3944, 14, 50, 15, -4, -39 },
  { 4032, 26, 39, 31, 5, -39 },
  { 4159, 20, 39, 26, 5, -39 },
  { 4257, 36, 39, 46, 5, -39 },
  { 4433, 28, 39, 38, 5, -39 },
  { 4570, 32, 40, 38, 3, -39 },
  { 4730, 23, 39, 30, 5, -39 },
  { 4843, 32, 48, 38, 3, -39 },
  { 5035, 26, 39, 31, 5, -39 },
  { 5162, 23, 40, 27, 2, -39 },
  { 5277, 25, 39, 27, 1, -39 },
  { 5399, 28, 40, 36, 4, -39 },
  { 5539, 30, 39, 30, 0, -39 },
  { 5686, 46, 39, 47, 0, -39 },
  { 5911, 29, 39, 29, 0, -39 },
  { 6053, 28, 39, 28, 0, -39 },
  { 6190, 24, 39, 27, 2, -39 },
  { 6307, 12, 48, 17, 4, -39 },
  { 6379, 19, 39, 21, 1, -39 },
  { 6472, 13, 48, 17, 1, -39 },
  { 6550, 25, 24, 29, 2, -39 },
  { 6625, 23, 3, 23, 0, 5 },
  { 6634, 12, 8, 16, 2, -41 },
  { 6646, 22, 31, 28, 2, -30 },
  { 6732, 24, 42, 31, 4, -41 },
  { 6858, 19, 31, 24, 3, -30 },
  { 6932, 24, 42, 31, 3, -41 },
  { 7058, 23, 31, 28, 3, -30 },
  { 7148, 19, 41, 18, 1, -41 },
  { 7246, 24, 43, 31, 3, -30 },
  { 7375, 23, 41, 31, 4, -41 },
  { 7493, 6, 40, 14, 4, -40 },
  { 7523, 12, 53, 14, -2, -40 },
  { 7603, 23, 41, 28, 4, -41 },
  { 7721, 6, 41, 14, 4, -41 },
  { 7752, 38, 30, 46, 4, -30 },
  { 7895, 23, 30, 31, 4, -30 },
  { 7982, 24, 31, 30, 3, -30 },
  { 8075, 24, 43, 31, 4, -30 },
  { 8204, 24, 43, 31, 3, -30 },
  { 8333, 16, 30, 21, 4, -30 },
  { 8393, 19, 31, 24, 2, -30 },
  { 8467, 16, 37, 19, 1, -36 },
  { 8541, 23, 30, 31, 4, -29 },
  { 8628, 26, 29, 26, 0, -29 },
  { 8723, 38, 29, 40, 1, -29 },
  { 8861, 25, 29, 26, 1, -29 },
  { 8952, 26, 42, 26, 0, -29 },
  { 9089, 19, 29, 23, 2, -29 },
  { 9158, 17, 48, 20, 1, -39 },
  { 9260, 5, 54, 27, 11, -41 },
  { 9294, 17, 48, 20, 2, -39 },
  { 9396, 24, 8, 28, 2, -23 },
};

const GFXfont NotoSans_SemiCondensed_Medium54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium54pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM54PT7B_H_
