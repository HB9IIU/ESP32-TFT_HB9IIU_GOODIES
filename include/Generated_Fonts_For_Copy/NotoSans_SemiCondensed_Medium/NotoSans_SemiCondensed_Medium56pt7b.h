#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM56PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium56pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x30, 0xFC, 0x1F, 0xFE, 0x0F, 0xDF, 0x07, 0xEF, 0x83, 0xF7, 0xC1, 0xFB,
  0xE0, 0xFD, 0xF0, 0x7E, 0xF8, 0x3E, 0x7C, 0x0F, 0x3E, 0x07, 0x9F, 0x03,
  0xCF, 0x81, 0xE7, 0xC0, 0xF3, 0xE0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x78, 0x0F, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E,
  0x07, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x1E, 0x00, 0x03,
  0xE0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0xF0,
  0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x78, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0x38, 0x7C, 0xFC, 0x38,
  0x08, 0xFC, 0x38, 0x00, 0xF8, 0x38, 0x00, 0xF8, 0x38, 0x00, 0xF8, 0x38,
  0x00, 0xFC, 0x38, 0x00, 0xFE, 0x38, 0x00, 0x7F, 0x38, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3B, 0xFE, 0x00, 0x38,
  0xFE, 0x00, 0x38, 0x7E, 0x00, 0x38, 0x3F, 0x00, 0x38, 0x3F, 0x00, 0x38,
  0x3F, 0x00, 0x38, 0x3E, 0x80, 0x38, 0x7E, 0xF0, 0x38, 0xFE, 0xFF, 0xBF,
  0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0x80, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0xFC,
  0x00, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0xF8, 0x00, 0x78,
  0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x01,
  0xF0, 0x00, 0xF8, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x03, 0xE0, 0x00,
  0xF8, 0x0F, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x07, 0xC0, 0x00, 0xF8, 0x0F,
  0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x0F, 0x81, 0x80, 0x78, 0x1F, 0x0F, 0x0F,
  0xF0, 0x78, 0x1F, 0x1F, 0x1F, 0xF8, 0x7C, 0x1F, 0x1E, 0x3F, 0xFC, 0x7C,
  0x3E, 0x3E, 0x3F, 0xFE, 0x3F, 0xFE, 0x3C, 0x7C, 0x3E, 0x1F, 0xFC, 0x7C,
  0x7C, 0x1E, 0x1F, 0xF8, 0x78, 0x78, 0x1F, 0x0F, 0xF0, 0xF8, 0xF8, 0x1F,
  0x00, 0x80, 0xF0, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x1F, 0x00, 0x01,
  0xE0, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x1F, 0x00, 0x03, 0xC0, 0xF8,
  0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x07, 0x80, 0xF8, 0x1F, 0x00,
  0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x78, 0x1F, 0x00, 0x1F, 0x00,
  0x78, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x00, 0x3F, 0xFE, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x7C,
  0x00, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x83, 0xFF, 0xE0, 0x0F, 0xC1, 0xFF,
  0xFC, 0x03, 0xF0, 0xFF, 0x3F, 0x80, 0xFC, 0x3F, 0x87, 0xF0, 0x3F, 0x1F,
  0xC0, 0xFC, 0x1F, 0x87, 0xE0, 0x3F, 0x87, 0xE1, 0xF8, 0x07, 0xF1, 0xF8,
  0xFC, 0x00, 0xFE, 0xFC, 0x3F, 0x00, 0x1F, 0xFF, 0x0F, 0xC0, 0x03, 0xFF,
  0x83, 0xF0, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x03,
  0xFC, 0x07, 0xF0, 0x01, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xF7,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xBF, 0x81, 0xFF, 0xFF, 0xC7, 0xF0, 0x3F,
  0xFF, 0xC0, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xC0, 0x06, 0x00, 0x00, 0x00,
  0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00,
  0xFC, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E,
  0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x3C, 0x02, 0x7C, 0x3C, 0x3E,
  0xFF, 0xBD, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xEF, 0xC0,
  0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x1F, 0x83, 0xF8,
  0x0F, 0x81, 0xF0, 0x07, 0x81, 0xC0, 0x01, 0x00, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x9F,
  0xCF, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0xFC, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7D,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xBF, 0xE0, 0x7E, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7,
  0xE0, 0x03, 0xF3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3F,
  0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0xC0,
  0x03, 0xF7, 0xE0, 0x01, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x1F, 0x83,
  0xF0, 0x1F, 0x81, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF,
  0x3F, 0xBF, 0x7F, 0x3F, 0xFE, 0x3F, 0x7C, 0x3F, 0x38, 0x3F, 0x10, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x18, 0x00, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0x7F,
  0xE0, 0xF8, 0x03, 0xF8, 0x78, 0x00, 0xFC, 0x10, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFE, 0x3F, 0xE0, 0xF0, 0x03,
  0xF8, 0x60, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0xA0, 0x00, 0x1F, 0xDC, 0x00, 0x1F, 0xCF, 0xF0, 0xFF, 0xE7, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x7F, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xC1, 0x80, 0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFB, 0x80, 0x0F, 0xF7, 0xF8,
  0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFC, 0x18, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x7F, 0xC0, 0xF8, 0xFF, 0xF0, 0xF9, 0xFF, 0xF8, 0xFB, 0xFF,
  0xFC, 0xFF, 0xC3, 0xFC, 0xFF, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x80,
  0xFC, 0x1F, 0xE7, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0x7E, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0,
  0x07, 0xE3, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x3F,
  0x81, 0xF8, 0x0F, 0xE3, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x3F, 0x87, 0xF8, 0x3F, 0x81, 0xFE, 0x1F, 0x80, 0x3F, 0x9F, 0x80, 0x0F,
  0xCF, 0xC0, 0x07, 0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x80,
  0x0F, 0xCF, 0xE0, 0x0F, 0xE3, 0xFC, 0x0F, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x04, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x03, 0xFE, 0x7F, 0xC1, 0xFC, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xDF, 0x80, 0x1F, 0xEF,
  0xE0, 0x1F, 0xF3, 0xFC, 0x3F, 0xF8, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0x7C,
  0x1F, 0xFF, 0x3E, 0x03, 0xFE, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFE, 0x03, 0x07, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0x40, 0x00, 0x00, 0x39, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x18, 0x0E, 0x1F, 0x8F, 0xE7, 0xF3, 0xF9, 0xFC, 0xFC, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8,
  0xFC, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F, 0x87, 0x80, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x60, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE7, 0xFB, 0xFE, 0x70, 0x07, 0xF4, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0xFF, 0xF0, 0x3C, 0x3E, 0x01, 0xFF,
  0xF8, 0x3E, 0x3C, 0x03, 0xFF, 0xF8, 0x1E, 0x7C, 0x07, 0xF1, 0xF8, 0x1E,
  0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x78, 0x1F, 0x80, 0xF8, 0x1F, 0xF8, 0x1F,
  0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0xF8, 0x1E, 0x00, 0xF8,
  0x1F, 0xF8, 0x3E, 0x00, 0xF0, 0x1F, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0xF0,
  0x3E, 0x00, 0xF0, 0x1F, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0xF0, 0x3E, 0x01,
  0xF0, 0x1E, 0xF0, 0x3E, 0x01, 0xF0, 0x1E, 0xF0, 0x3E, 0x01, 0xF0, 0x1E,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0xF8, 0x1F, 0x03, 0xF8, 0x3C, 0xF8, 0x1F,
  0x87, 0xFC, 0xFC, 0xF8, 0x0F, 0xFF, 0x3F, 0xF8, 0x78, 0x07, 0xFE, 0x3F,
  0xF0, 0x7C, 0x03, 0xFC, 0x1F, 0xE0, 0x7C, 0x00, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x02, 0x00,
  0x07, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0x01, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x7E, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x7F, 0xCF, 0xC0,
  0x07, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xEF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x03, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x8F, 0xC0, 0x0F, 0xF3, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xEF, 0xC0, 0x0F, 0xF3, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x40, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFE, 0x00,
  0x70, 0x7F, 0x00, 0x02, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x60, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x10, 0x00, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7E, 0x01, 0xFF, 0x83, 0xF0, 0x01, 0xFE,
  0x1F, 0x80, 0x07, 0xF8, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x3F,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0xC7, 0xE0,
  0x07, 0xFC, 0x3F, 0x00, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x07, 0x03, 0xFC,
  0x00, 0x04, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0xFC,
  0x7F, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x0F, 0xC3, 0xFE, 0x00, 0x3F, 0x07,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0x0F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xD0, 0x7F, 0x3F,
  0xFE, 0x7F, 0xF8, 0xFF, 0xF1, 0xFF, 0x81, 0xFC, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x8F, 0xC0,
  0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x07, 0xE0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x07,
  0xE0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xCF, 0xC0, 0x07, 0xF1, 0xFC, 0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF8,
  0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8,
  0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE,
  0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF9, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFB, 0xE0, 0x00, 0x1F, 0xFF, 0xEF,
  0x80, 0x00, 0xFB, 0xFF, 0xBF, 0x00, 0x03, 0xEF, 0xFE, 0x7C, 0x00, 0x0F,
  0xBF, 0xF9, 0xF0, 0x00, 0x7C, 0xFF, 0xE7, 0xE0, 0x01, 0xF3, 0xFF, 0x8F,
  0x80, 0x07, 0xCF, 0xFE, 0x3E, 0x00, 0x3E, 0x3F, 0xF8, 0xFC, 0x00, 0xF8,
  0xFF, 0xE1, 0xF0, 0x03, 0xE3, 0xFF, 0x87, 0xC0, 0x1F, 0x0F, 0xFE, 0x1F,
  0x80, 0x7C, 0x3F, 0xF8, 0x3E, 0x01, 0xF0, 0xFF, 0xE0, 0xF8, 0x0F, 0x83,
  0xFF, 0x83, 0xF0, 0x3E, 0x0F, 0xFE, 0x07, 0xC0, 0xF8, 0x3F, 0xF8, 0x1F,
  0x07, 0xC0, 0xFF, 0xE0, 0x7E, 0x1F, 0x03, 0xFF, 0x80, 0xF8, 0x7C, 0x0F,
  0xFE, 0x03, 0xE3, 0xE0, 0x3F, 0xF8, 0x0F, 0x8F, 0x80, 0xFF, 0xE0, 0x1F,
  0x3E, 0x03, 0xFF, 0x80, 0x7D, 0xF0, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xC0, 0x0F, 0xFE, 0x00, 0x3E,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xEF, 0xC0, 0x03, 0xFF, 0xBF, 0x80, 0x0F, 0xFE, 0x7E, 0x00, 0x3F, 0xF9,
  0xFC, 0x00, 0xFF, 0xE3, 0xF0, 0x03, 0xFF, 0x87, 0xE0, 0x0F, 0xFE, 0x1F,
  0x80, 0x3F, 0xF8, 0x3F, 0x00, 0xFF, 0xE0, 0xFE, 0x03, 0xFF, 0x81, 0xF8,
  0x0F, 0xFE, 0x07, 0xF0, 0x3F, 0xF8, 0x0F, 0xC0, 0xFF, 0xE0, 0x3F, 0x83,
  0xFF, 0x80, 0x7E, 0x0F, 0xFE, 0x00, 0xFC, 0x3F, 0xF8, 0x03, 0xF0, 0xFF,
  0xE0, 0x07, 0xE3, 0xFF, 0x80, 0x1F, 0xCF, 0xFE, 0x00, 0x3F, 0x3F, 0xF8,
  0x00, 0xFE, 0xFF, 0xE0, 0x01, 0xF9, 0xFF, 0x80, 0x07, 0xF7, 0xFE, 0x00,
  0x0F, 0xDF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9,
  0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x50,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x07, 0xFC, 0xFC, 0x01, 0xFE, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0xFC, 0x01, 0xFC, 0xFC,
  0x0F, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC1, 0xF8, 0x07, 0xF8, 0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xF0,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x1F,
  0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F,
  0x00, 0x1C, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x1F, 0xC0, 0x1E, 0x7F, 0x00, 0x04, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFA, 0x00, 0x07, 0xF7, 0x80, 0x1F, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x0A, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x1F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF0,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F,
  0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x3E,
  0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3E,
  0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x7C,
  0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7C, 0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0x7C,
  0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0xF8,
  0x1F, 0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0xF8,
  0x1F, 0x07, 0xE0, 0x03, 0xE0, 0xF8, 0x1F, 0x87, 0xE0, 0x03, 0xF1, 0xF0,
  0x0F, 0x87, 0xC0, 0x03, 0xF1, 0xF0, 0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0,
  0x0F, 0x8F, 0xC0, 0x01, 0xF1, 0xF0, 0x0F, 0xCF, 0xC0, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x07, 0xCF, 0x80, 0x01, 0xFB, 0xE0,
  0x07, 0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x80, 0x00, 0xFB, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0xFB, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0x1F, 0x80,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x01, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0xF8, 0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC0, 0xF0,
  0x01, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x1F, 0x00,
  0x3C, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xE0, 0x3F, 0x81, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x3F, 0xFE, 0x7E, 0xFF, 0x00, 0xFD, 0xFC, 0x01, 0xFB, 0xF0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC,
  0x00, 0xFE, 0xFC, 0x03, 0xFD, 0xFC, 0x1F, 0xFB, 0xFF, 0xFD, 0xF3, 0xFF,
  0xF3, 0xE3, 0xFF, 0xC3, 0xC3, 0xFF, 0x07, 0x80, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0xF8, 0x07, 0xE3, 0xFF, 0x03, 0xF3, 0xFF, 0xC1, 0xFB, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x7F, 0xE0, 0xFF, 0x3F, 0xC0, 0x1F, 0x9F, 0xE0, 0x0F,
  0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xDF,
  0xC0, 0x07, 0xEF, 0xF0, 0x07, 0xF7, 0xFC, 0x07, 0xF3, 0xFF, 0x87, 0xF9,
  0xF7, 0xFF, 0xF8, 0xF9, 0xFF, 0xF8, 0x7C, 0x7F, 0xF8, 0x3E, 0x1F, 0xF8,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFE, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFC, 0x1E, 0x3F, 0x80, 0x27, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x03, 0x3F, 0xE1, 0xF1,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x1F, 0xF8, 0xFC, 0x3F, 0xFE, 0x7E, 0x3F,
  0xFF, 0xBF, 0x3F, 0xFF, 0xFF, 0x9F, 0xE0, 0xFF, 0xDF, 0xC0, 0x3F, 0xEF,
  0xC0, 0x0F, 0xF7, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x07, 0xFB, 0xF8, 0x07, 0xFC, 0xFF,
  0x0F, 0xFE, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0x87, 0xFF, 0xC7, 0xC0,
  0xFF, 0x83, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC,
  0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x04,
  0x3F, 0xE0, 0x7C, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x07,
  0xFF, 0x81, 0xFF, 0xE0, 0x7F, 0xFC, 0x0F, 0xE0, 0x81, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x81, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x87, 0xC3, 0xFF, 0xE3, 0xE3, 0xFF,
  0xFB, 0xF1, 0xFF, 0xFF, 0xF9, 0xFE, 0x1F, 0xFD, 0xFC, 0x03, 0xFE, 0xFC,
  0x00, 0xFF, 0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xBF, 0x80, 0x7F, 0xCF, 0xF0,
  0xFF, 0xE3, 0xFF, 0xFB, 0xF1, 0xFF, 0xFD, 0xF8, 0x7F, 0xFC, 0xFC, 0x0F,
  0xF8, 0x7E, 0x00, 0x40, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF2, 0x00, 0x03, 0xF8,
  0xC0, 0x03, 0xF8, 0x7F, 0x1F, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0xFC, 0x7F,
  0xF0, 0xFC, 0xFF, 0xF8, 0xFD, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xC1,
  0xFE, 0xFF, 0x80, 0x7E, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0x33, 0xFF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xC0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x7F, 0xDF, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0xFC, 0xFC, 0x01, 0xF8, 0xFC,
  0x03, 0xF8, 0xFC, 0x07, 0xF0, 0xFC, 0x07, 0xE0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x1F, 0x80, 0xFC, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0xFE, 0x00, 0xFC,
  0xFC, 0x00, 0xFD, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0xFC,
  0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0xFC, 0x07, 0xF0, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF8, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0xFE, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xF8, 0x7F,
  0xE0, 0x3F, 0xF0, 0xF8, 0xFF, 0xF0, 0xFF, 0xF8, 0xF9, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xC3, 0xFF, 0xE1, 0xFE, 0xFF,
  0x00, 0xFF, 0x80, 0x7E, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0xF8, 0x7F, 0xF0, 0xF8, 0xFF,
  0xF8, 0xF9, 0xFF, 0xFC, 0xFB, 0xFF, 0xFE, 0xFF, 0xC1, 0xFE, 0xFF, 0x00,
  0x7E, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xF0, 0xFC, 0x01, 0xF8, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x7C, 0xFC, 0x00, 0x7E, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x3F, 0x07, 0xF0,
  0x7F, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x3F, 0xF0, 0x3E,
  0x3F, 0xFE, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFE, 0x0F, 0xF3,
  0xFC, 0x01, 0xF9, 0xFE, 0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x01, 0xFB, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFF, 0x00, 0x7F, 0x7F,
  0xC0, 0x7F, 0x3F, 0xF8, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0x87,
  0xE7, 0xFF, 0x83, 0xF1, 0xFF, 0x81, 0xF8, 0x0C, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xFF, 0x87, 0xC3, 0xFF, 0xE7, 0xE3, 0xFF, 0xFB, 0xF3,
  0xFF, 0xFF, 0xF9, 0xFE, 0x0F, 0xFD, 0xFC, 0x03, 0xFE, 0xFC, 0x00, 0xFF,
  0x7E, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFE, 0xFC,
  0x00, 0x7F, 0x7E, 0x00, 0x7F, 0xBF, 0x80, 0x7F, 0xCF, 0xF0, 0xFF, 0xE3,
  0xFF, 0xFB, 0xF1, 0xFF, 0xFD, 0xF8, 0x7F, 0xFC, 0xFC, 0x0F, 0xF8, 0x7E,
  0x00, 0x40, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x7C, 0x1F, 0xFE, 0x3F, 0xFF,
  0x3F, 0xEF, 0x9F, 0xF7, 0xDF, 0xFB, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xFC, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7,
  0xE0, 0x1C, 0x7C, 0x00, 0x4F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF,
  0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x04, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x83, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF0,
  0x1F, 0xF8, 0x00, 0x80, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0xFF, 0x7E, 0x01, 0xFF, 0x7F, 0xCF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0x9F, 0x1F, 0xFF, 0x1F, 0x07, 0xFE, 0x1F, 0x00, 0x40,
  0x00, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xC0, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0x81, 0xF8,
  0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x3F, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x3F, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x3E, 0x7C, 0x00,
  0xFF, 0x00, 0x7E, 0x7C, 0x01, 0xFF, 0x00, 0x7E, 0x7E, 0x01, 0xFF, 0x00,
  0x7C, 0x7E, 0x01, 0xEF, 0x80, 0x7C, 0x3E, 0x01, 0xEF, 0x80, 0xFC, 0x3E,
  0x03, 0xEF, 0x80, 0xFC, 0x3F, 0x03, 0xE7, 0x80, 0xF8, 0x3F, 0x03, 0xE7,
  0xC0, 0xF8, 0x1F, 0x03, 0xC7, 0xC1, 0xF8, 0x1F, 0x07, 0xC7, 0xC1, 0xF8,
  0x1F, 0x87, 0xC3, 0xC1, 0xF0, 0x1F, 0x87, 0xC3, 0xE1, 0xF0, 0x0F, 0x8F,
  0x83, 0xE3, 0xF0, 0x0F, 0x8F, 0x83, 0xE3, 0xF0, 0x0F, 0x8F, 0x81, 0xE3,
  0xE0, 0x0F, 0xCF, 0x81, 0xF3, 0xE0, 0x07, 0xCF, 0x01, 0xF3, 0xE0, 0x07,
  0xDF, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x00, 0xF7, 0xC0, 0x07, 0xDF, 0x00,
  0xF7, 0xC0, 0x03, 0xFE, 0x00, 0xF7, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xC0,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x3F, 0x9F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0xFE,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0xFC, 0x1F, 0x80,
  0x1F, 0x8F, 0xC0, 0x07, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0,
  0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0xBF,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x07,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0xF8,
  0x00, 0x7E, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F,
  0xBF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x11,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x3F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xFF, 0x01, 0xFE, 0x00, 0xFC,
  0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0x7F, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0x80, 0x3F, 0xE0, 0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x7F, 0xE0, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFE,
  0x01, 0xFC, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x9F, 0xF8, 0x00,
  0x5F, 0xFF, 0x00, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x00, 0x3F, 0xFD, 0x00, 0x03, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Medium56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 41, 15, 4, -40 },
  { 37, 17, 14, 23, 3, -40 },
  { 67, 30, 40, 33, 1, -40 },
  { 217, 24, 46, 29, 3, -43 },
  { 355, 40, 42, 45, 2, -41 },
  { 565, 34, 42, 36, 2, -41 },
  { 744, 6, 14, 13, 3, -40 },
  { 755, 14, 49, 17, 2, -40 },
  { 841, 13, 49, 17, 2, -40 },
  { 921, 24, 24, 28, 2, -43 },
  { 993, 25, 27, 29, 2, -33 },
  { 1078, 9, 13, 14, 2, -6 },
  { 1093, 13, 6, 17, 2, -18 },
  { 1103, 7, 8, 14, 4, -7 },
  { 1110, 20, 40, 21, 1, -40 },
  { 1210, 25, 42, 29, 2, -41 },
  { 1342, 16, 40, 29, 4, -40 },
  { 1422, 25, 41, 29, 2, -41 },
  { 1551, 25, 42, 29, 2, -41 },
  { 1683, 27, 40, 29, 1, -40 },
  { 1818, 23, 41, 29, 3, -40 },
  { 1936, 24, 41, 29, 3, -40 },
  { 2059, 25, 40, 29, 2, -40 },
  { 2184, 25, 42, 29, 2, -41 },
  { 2316, 25, 41, 29, 2, -40 },
  { 2445, 7, 32, 15, 4, -31 },
  { 2473, 9, 38, 15, 2, -31 },
  { 2516, 25, 27, 29, 2, -34 },
  { 2601, 25, 16, 29, 2, -28 },
  { 2651, 25, 27, 29, 2, -34 },
  { 2736, 20, 42, 23, 1, -41 },
  { 2841, 40, 45, 46, 3, -40 },
  { 3066, 33, 40, 33, 0, -40 },
  { 3231, 26, 40, 33, 5, -40 },
  { 3361, 27, 42, 32, 3, -41 },
  { 3503, 29, 40, 37, 5, -40 },
  { 3648, 20, 40, 28, 5, -40 },
  { 3748, 20, 40, 27, 5, -40 },
  { 3848, 30, 42, 37, 3, -41 },
  { 4006, 28, 40, 38, 5, -40 },
  { 4146, 15, 40, 19, 2, -40 },
  { 4221, 15, 51, 15, -4, -40 },
  { 4317, 27, 40, 32, 5, -40 },
  { 4452, 20, 40, 27, 5, -40 },
  { 4552, 38, 40, 48, 5, -40 },
  { 4742, 30, 40, 40, 5, -40 },
  { 4892, 33, 42, 39, 3, -41 },
  { 5066, 24, 40, 31, 5, -40 },
  { 5186, 33, 51, 39, 3, -41 },
  { 5397, 27, 40, 32, 5, -40 },
  { 5532, 23, 42, 28, 3, -41 },
  { 5653, 26, 40, 28, 1, -40 },
  { 5783, 29, 41, 37, 4, -40 },
  { 5932, 31, 40, 31, 0, -40 },
  { 6087, 48, 40, 48, 0, -40 },
  { 6327, 30, 40, 30, 0, -40 },
  { 6477, 29, 40, 29, 0, -40 },
  { 6622, 24, 40, 28, 2, -40 },
  { 6742, 13, 49, 18, 4, -40 },
  { 6822, 20, 40, 21, 1, -40 },
  { 6922, 13, 49, 18, 1, -40 },
  { 7002, 26, 24, 30, 2, -40 },
  { 7080, 24, 4, 24, 0, 5 },
  { 7092, 12, 9, 17, 2, -43 },
  { 7106, 23, 32, 29, 2, -31 },
  { 7198, 25, 44, 32, 4, -43 },
  { 7336, 20, 32, 25, 3, -31 },
  { 7416, 25, 44, 32, 3, -43 },
  { 7554, 24, 32, 29, 3, -31 },
  { 7650, 19, 43, 18, 1, -43 },
  { 7753, 25, 44, 32, 3, -31 },
  { 7891, 24, 43, 32, 4, -43 },
  { 8020, 6, 42, 14, 4, -42 },
  { 8052, 12, 55, 14, -2, -42 },
  { 8135, 24, 43, 29, 4, -43 },
  { 8264, 6, 43, 14, 4, -43 },
  { 8297, 40, 31, 48, 4, -31 },
  { 8452, 24, 31, 32, 4, -31 },
  { 8545, 25, 32, 31, 3, -31 },
  { 8645, 25, 44, 32, 4, -31 },
  { 8783, 25, 44, 32, 3, -31 },
  { 8921, 17, 31, 22, 4, -31 },
  { 8987, 20, 32, 24, 2, -31 },
  { 9067, 17, 38, 19, 1, -37 },
  { 9148, 24, 31, 32, 4, -30 },
  { 9241, 27, 30, 27, 0, -30 },
  { 9343, 40, 30, 42, 1, -30 },
  { 9493, 26, 30, 27, 1, -30 },
  { 9591, 27, 43, 27, 0, -30 },
  { 9737, 20, 30, 23, 2, -30 },
  { 9812, 17, 49, 21, 2, -40 },
  { 9917, 4, 56, 28, 12, -43 },
  { 9945, 17, 49, 21, 2, -40 },
  { 10050, 25, 8, 29, 2, -24 },
};

const GFXfont NotoSans_SemiCondensed_Medium56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium56pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM56PT7B_H_
