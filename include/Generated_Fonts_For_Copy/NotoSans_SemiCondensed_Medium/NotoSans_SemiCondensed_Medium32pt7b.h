#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM32PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium32pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x66, 0x00, 0x07, 0xFF,
  0xF0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0x03, 0x0E,
  0x01, 0x86, 0x01, 0xC3, 0x00, 0xE1, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x18,
  0x60, 0xFF, 0xFF, 0x7F, 0xFF, 0x87, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00,
  0xC3, 0x00, 0x61, 0x83, 0xFF, 0xFD, 0xFF, 0xFE, 0x1C, 0x70, 0x0C, 0x38,
  0x06, 0x18, 0x03, 0x0C, 0x01, 0x86, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x06,
  0x00, 0x30, 0x03, 0xE0, 0x7F, 0xF7, 0xFF, 0x7B, 0x1B, 0x98, 0x1C, 0xC0,
  0xE6, 0x07, 0xB0, 0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x1B, 0xE0,
  0xC7, 0x06, 0x38, 0x31, 0xE1, 0x8F, 0xCD, 0xFF, 0xFF, 0x7F, 0xE0, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0x1E, 0x00, 0xE0, 0x7E, 0x03, 0x81,
  0xCE, 0x06, 0x03, 0x1C, 0x1C, 0x0E, 0x18, 0x30, 0x1C, 0x30, 0xE0, 0x38,
  0x71, 0x80, 0x70, 0xC7, 0x00, 0xE1, 0x8E, 0x01, 0xC3, 0x39, 0xF1, 0x8E,
  0x77, 0xF3, 0x9D, 0xCE, 0xE3, 0xF3, 0xB8, 0xE3, 0xCE, 0x71, 0xC0, 0x1C,
  0xE3, 0x80, 0x71, 0xC7, 0x00, 0xE3, 0x8E, 0x03, 0x87, 0x1C, 0x07, 0x0E,
  0x38, 0x1C, 0x1C, 0x70, 0x38, 0x18, 0xC0, 0x60, 0x3F, 0x81, 0xC0, 0x3E,
  0x00, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x1E, 0xF8, 0x03, 0xC3, 0x80, 0x38,
  0x38, 0x03, 0x83, 0x80, 0x3C, 0x78, 0x01, 0xC7, 0x00, 0x1E, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x1E, 0x3F, 0xC1, 0xC7, 0x9E, 0x1C,
  0x70, 0xF1, 0xCF, 0x07, 0xBC, 0xF0, 0x3F, 0x8F, 0x01, 0xF0, 0xF0, 0x0F,
  0x07, 0x83, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xBC, 0x1F, 0xE1, 0xF0, 0xFF,
  0xFF, 0xFF, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70,
  0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x78,
  0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0xE0, 0xE1, 0xC1, 0xC3, 0x83, 0x87,
  0x0F, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x71,
  0xE3, 0x87, 0x1E, 0x38, 0xF1, 0xC7, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x30,
  0x00, 0xC0, 0xF3, 0x3B, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x0F, 0xC0, 0x73,
  0x81, 0xCE, 0x0E, 0x1C, 0x08, 0x40, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x39, 0xDE, 0xE7,
  0x39, 0x9C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x0E,
  0x1E, 0x78, 0x39, 0xC0, 0xF7, 0x01, 0xDC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xDC, 0x07, 0x70, 0x1D,
  0xC0, 0xF7, 0x83, 0x8E, 0x1E, 0x3F, 0xF8, 0x7F, 0xC0, 0xFE, 0x00, 0x03,
  0x83, 0xC3, 0xE3, 0xF7, 0xBF, 0x9D, 0x8E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x0F, 0xC0, 0xFF, 0xCF, 0xFF, 0x9C, 0x1E, 0x20, 0x38, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0xCF, 0xFF, 0x98,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x07, 0xC1,
  0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0xE0, 0x1F, 0xFF, 0xFB, 0xFF, 0xC7, 0xFE, 0x00, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x6E, 0x01, 0xDC,
  0x07, 0x38, 0x0E, 0x70, 0x38, 0xE0, 0x61, 0xC1, 0xC3, 0x87, 0x07, 0x0E,
  0x0E, 0x38, 0x1C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0xFE, 0x3F,
  0xF8, 0xFF, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1F, 0x01, 0xEF, 0xFF, 0x7F, 0xF3, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0xE1, 0xFF, 0x87, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x81, 0xDF, 0xC7, 0xFF, 0xBF, 0x1F, 0xF8, 0x3F, 0xC0, 0x77, 0x01, 0xDC,
  0x07, 0x70, 0x1D, 0xC0, 0x77, 0x81, 0xCE, 0x0F, 0x3F, 0xF8, 0x7F, 0xC0,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0xC3, 0xEF,
  0x9E, 0x0F, 0x70, 0x3D, 0xC0, 0x77, 0x03, 0xDE, 0x0E, 0x3C, 0x78, 0x7F,
  0xC0, 0xFE, 0x03, 0xF8, 0x3F, 0xF0, 0xE1, 0xE7, 0x03, 0xFC, 0x07, 0xF0,
  0x1F, 0x80, 0x7F, 0x01, 0xDC, 0x0F, 0x7C, 0x78, 0xFF, 0xE1, 0xFE, 0x00,
  0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0xC0, 0xFF, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x03, 0xDE, 0x1F, 0x3F, 0xFC, 0x7F,
  0x70, 0x61, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x27,
  0xE0, 0xFF, 0x03, 0xF8, 0x00, 0x2F, 0xFF, 0x70, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x13, 0xDE, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF,
  0x7B, 0x9C, 0xEE, 0x70, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7E, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x70, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0xC0,
  0x03, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x00, 0x7C, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xFC, 0x03, 0xC0, 0x0C,
  0x00, 0x00, 0x3F, 0x8F, 0xFE, 0x7F, 0xF6, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x1E, 0x01, 0xF0, 0x0E,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFC, 0x3E, 0x07, 0x80, 0x3C,
  0x3C, 0x00, 0x78, 0xE0, 0x00, 0xE7, 0x03, 0xE1, 0xD8, 0x3F, 0xC7, 0xE1,
  0xE7, 0x0F, 0x8E, 0x1C, 0x3E, 0x38, 0x70, 0xF0, 0xC1, 0xC3, 0xC3, 0x07,
  0x0F, 0x0C, 0x1C, 0x3C, 0x30, 0x70, 0xF0, 0xC1, 0xC7, 0xC3, 0x8F, 0x1F,
  0x8F, 0xFF, 0xEE, 0x1F, 0x9F, 0x18, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x08, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3B,
  0x80, 0x07, 0x70, 0x01, 0xEE, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01, 0xE3,
  0x80, 0x38, 0x78, 0x07, 0x07, 0x01, 0xE0, 0xE0, 0x3F, 0xFE, 0x07, 0xFF,
  0xC1, 0xFF, 0xF8, 0x3C, 0x07, 0x87, 0x00, 0xF1, 0xE0, 0x0E, 0x3C, 0x01,
  0xE7, 0x00, 0x3D, 0xE0, 0x03, 0xBC, 0x00, 0x78, 0xFF, 0x81, 0xFF, 0xE3,
  0xFF, 0xE7, 0x03, 0xEE, 0x03, 0xDC, 0x07, 0xB8, 0x0F, 0x70, 0x1E, 0xE0,
  0x39, 0xC1, 0xF3, 0xFF, 0x87, 0xFF, 0x8E, 0x1F, 0x9C, 0x07, 0xB8, 0x07,
  0x70, 0x0E, 0xE0, 0x1F, 0xC0, 0x3B, 0x80, 0xF7, 0x01, 0xEF, 0xFF, 0x9F,
  0xFE, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0x7F, 0xF9, 0xF0, 0x27,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x13, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0x00,
  0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x7C, 0xE0, 0x3E, 0xE0, 0x1E,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E,
  0xE0, 0x3E, 0xE0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xFF, 0xFF,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0xC7, 0xFF, 0xC7, 0xC0, 0x67, 0xC0,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x0F, 0xFE, 0x07, 0xFF, 0x03, 0xFF, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xBC, 0x01, 0xDE, 0x00, 0xE7, 0xC0, 0x71, 0xFF, 0xF8, 0x7F,
  0xFC, 0x1F, 0xFC, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xFF, 0xFF, 0x7E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x3E, 0xFF, 0xFF,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0F, 0x0F, 0xFE, 0xFE, 0xF8, 0xE0, 0x1F, 0xC0, 0x7B, 0x80, 0xE7, 0x03,
  0xCE, 0x0F, 0x1C, 0x3C, 0x38, 0x70, 0x71, 0xE0, 0xE7, 0x81, 0xDE, 0x03,
  0xBC, 0x07, 0xF8, 0x0F, 0xF8, 0x1E, 0x78, 0x38, 0xF0, 0x70, 0xF0, 0xE0,
  0xE1, 0xC1, 0xE3, 0x81, 0xE7, 0x03, 0xCE, 0x03, 0xDC, 0x03, 0xB8, 0x07,
  0x80, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0xFF, 0xB8, 0x06, 0xFD, 0xC0, 0x77, 0xEE, 0x03, 0xBF,
  0x38, 0x19, 0xF9, 0xC1, 0xCF, 0xCE, 0x0E, 0x7E, 0x38, 0x63, 0xF1, 0xC7,
  0x1F, 0x8E, 0x38, 0xFC, 0x39, 0x87, 0xE1, 0xDC, 0x3F, 0x0E, 0xE1, 0xF8,
  0x3E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0x83, 0xF0, 0x38, 0x1F, 0x81, 0xC0,
  0xE0, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xB8, 0x0F, 0xDE, 0x07, 0xE7, 0x03, 0xF3, 0xC1, 0xF8, 0xF0,
  0xFC, 0x78, 0x7E, 0x1E, 0x3F, 0x07, 0x1F, 0x83, 0xCF, 0xC0, 0xE7, 0xE0,
  0x7B, 0xF0, 0x1D, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F,
  0x80, 0x1E, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1E, 0x07, 0xC7,
  0x80, 0x78, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xDC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0E, 0xF0, 0x03, 0xCE, 0x00, 0x79, 0xE0, 0x1E, 0x1E,
  0x07, 0xC3, 0xFF, 0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x07, 0xFF,
  0x3F, 0xFD, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x03, 0xF8, 0x1F, 0xFF, 0xEF, 0xFE, 0x7F, 0xE3, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x07,
  0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1E, 0x07, 0xC7, 0x80, 0x78, 0xE0,
  0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xDC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0E, 0xF0, 0x03, 0xCE, 0x00, 0x79, 0xE0, 0x1E, 0x1E, 0x07, 0xC3, 0xFF,
  0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7,
  0x07, 0xCE, 0x07, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xE0, 0x39, 0xC0,
  0xF3, 0x83, 0xC7, 0xFF, 0x0F, 0xFC, 0x1F, 0xF8, 0x38, 0x70, 0x70, 0xF0,
  0xE0, 0xE1, 0xC1, 0xE3, 0x81, 0xE7, 0x03, 0xCE, 0x03, 0xDC, 0x07, 0xB8,
  0x07, 0x80, 0x0F, 0xF0, 0xFF, 0xE3, 0xFF, 0x9E, 0x06, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xB0,
  0x1E, 0xFF, 0xFB, 0xFF, 0xC7, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x0E, 0xF8, 0x1E, 0x7F, 0xFC, 0x3F,
  0xF8, 0x1F, 0xF0, 0xF0, 0x03, 0xFC, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1E,
  0x78, 0x07, 0x8E, 0x01, 0xC3, 0x80, 0x70, 0xF0, 0x3C, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xE1, 0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x8F, 0x00, 0xF3,
  0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0xFE, 0x01,
  0xE0, 0x1D, 0xC0, 0x3C, 0x07, 0xB8, 0x0F, 0x80, 0xF7, 0x81, 0xF0, 0x1C,
  0xF0, 0x3F, 0x03, 0x8E, 0x06, 0xE0, 0x71, 0xC1, 0xDC, 0x1E, 0x38, 0x39,
  0xC3, 0x87, 0x87, 0x38, 0x70, 0x71, 0xC7, 0x0E, 0x0E, 0x38, 0xE3, 0xC1,
  0xC7, 0x0E, 0x70, 0x3C, 0xE1, 0xCE, 0x03, 0x98, 0x39, 0xC0, 0x77, 0x07,
  0x78, 0x0E, 0xE0, 0x6F, 0x01, 0xDC, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x03,
  0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x78, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0xBC, 0x07, 0x8F, 0x03, 0x87, 0x83, 0xC1, 0xE1, 0xC0,
  0x71, 0xE0, 0x3C, 0xE0, 0x0E, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x1D, 0xC0, 0x1E, 0x70, 0x0E,
  0x3C, 0x0F, 0x0E, 0x07, 0x07, 0x87, 0x81, 0xC3, 0x80, 0xF3, 0xC0, 0x3B,
  0xC0, 0x1E, 0xF0, 0x07, 0xB8, 0x03, 0x9E, 0x03, 0xC7, 0x01, 0xC3, 0xC1,
  0xE0, 0xE0, 0xE0, 0x70, 0xF0, 0x3C, 0x70, 0x0E, 0x78, 0x07, 0xB8, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0xF0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x1E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0xFF,
  0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1F, 0xFF, 0xF0,
  0x03, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xEC, 0x01, 0xDC, 0x07,
  0x18, 0x0E, 0x38, 0x38, 0x30, 0x70, 0x71, 0xC0, 0x63, 0x80, 0xE6, 0x00,
  0xDC, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0,
  0xC0, 0x01, 0x00, 0xFF, 0x0F, 0xFC, 0x30, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0F, 0x1F, 0xF9, 0xFF, 0xDE, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC1, 0xEF, 0x3F, 0x7F, 0xD9, 0xF8, 0xC0, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x60, 0x7B, 0xF8, 0xFF, 0xF9,
  0xF8, 0xF3, 0xE0, 0xF7, 0x80, 0xEF, 0x01, 0xDE, 0x03, 0xBC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3B, 0xC0, 0x77, 0x80, 0xEF, 0x83, 0xDF, 0xDF,
  0x3B, 0xFE, 0x73, 0xF0, 0x03, 0x03, 0xFC, 0xFF, 0xBC, 0x3F, 0x01, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x3C,
  0x0B, 0xFF, 0x3F, 0xE3, 0xFC, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x43, 0xCF, 0xE7, 0x7F, 0xDD, 0xE3, 0xFF, 0x07,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x7D, 0xF7, 0xF3, 0xFD, 0xC7, 0xE7, 0x02,
  0x00, 0xFE, 0x0F, 0xF8, 0xF1, 0xEF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x2F,
  0xCE, 0x3F, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x1E, 0x21, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x07, 0xFC, 0xFF, 0xC1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x04, 0x00, 0xFE, 0x77, 0xFD, 0xDE, 0x3F,
  0xF0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xDF, 0x7F, 0x3F, 0xDC, 0x7E,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE6, 0x0F, 0x9F, 0xFC, 0x7F,
  0xE0, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x08, 0x3D, 0xFC, 0xFF, 0xFB, 0xF1, 0xEF, 0x83, 0xFC, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x6F, 0xF7, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x3C, 0x78,
  0x60, 0x00, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xDF, 0xBE,
  0x78, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x7C, 0x1E, 0xF0, 0x73, 0xC3, 0x8F, 0x1E, 0x3C, 0xF0, 0xF7, 0x83,
  0xDC, 0x0F, 0xF0, 0x3F, 0xE0, 0xFB, 0x83, 0xCF, 0x0F, 0x1E, 0x3C, 0x38,
  0xF0, 0xF3, 0xC1, 0xEF, 0x07, 0xBC, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x41, 0xCF, 0xE7,
  0xF3, 0xBF, 0xFF, 0xF7, 0xE7, 0xF9, 0xFF, 0x83, 0xC1, 0xFE, 0x07, 0x81,
  0xFC, 0x0F, 0x03, 0xF8, 0x1C, 0x07, 0xF0, 0x38, 0x0F, 0xE0, 0x70, 0x1F,
  0xC0, 0xE0, 0x3F, 0x81, 0xC0, 0x7F, 0x03, 0x80, 0xFE, 0x07, 0x01, 0xFC,
  0x0E, 0x03, 0xF8, 0x1C, 0x07, 0xF0, 0x38, 0x0F, 0xE0, 0x70, 0x1C, 0x00,
  0xC3, 0x9F, 0xCE, 0xFF, 0xBF, 0x1E, 0xF8, 0x3F, 0xC0, 0xFF, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x70, 0x02, 0x00, 0x7F, 0x83, 0xFF,
  0x1E, 0x3E, 0xF0, 0x3B, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0xF7, 0x03, 0x9F, 0x3E, 0x3F,
  0xF0, 0x7F, 0x00, 0x00, 0x81, 0xCF, 0xE3, 0xBF, 0xE7, 0xE3, 0xCF, 0x83,
  0xDE, 0x03, 0xBC, 0x07, 0x78, 0x0E, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xEF, 0x01, 0xDE, 0x07, 0xBE, 0x0F, 0x7F, 0x7C, 0xFF, 0xF9, 0xEF,
  0xC3, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x04, 0x00, 0xFE, 0x77, 0xFD, 0xDE, 0x3F, 0xF0,
  0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xDF, 0x7F, 0x3F, 0xDC, 0x7E, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x00, 0xB9, 0xFE, 0xFF, 0xBF, 0xF8, 0x3E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x00, 0x07, 0x03, 0xFE, 0x7F, 0xE7, 0x06, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0xC0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0xFF,
  0x9E, 0xFF, 0xE7, 0xF8, 0x18, 0x1C, 0x0E, 0x07, 0x0F, 0xFF, 0xFC, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0F, 0xA7, 0xF1, 0xF8, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFC,
  0x0F, 0xF0, 0x3D, 0xC1, 0xF7, 0xDF, 0xDF, 0xF7, 0x1F, 0x9C, 0xF0, 0x0E,
  0xE0, 0x3D, 0xC0, 0x73, 0xC0, 0xE3, 0x83, 0xC7, 0x07, 0x0F, 0x0E, 0x0E,
  0x3C, 0x1C, 0x70, 0x38, 0xE0, 0x39, 0xC0, 0x77, 0x00, 0xEE, 0x00, 0xDC,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0xE0, 0x78, 0x1D,
  0xC1, 0xF0, 0x7B, 0xC3, 0xF0, 0xE3, 0x86, 0xE1, 0xC7, 0x0D, 0xC3, 0x8E,
  0x39, 0x8F, 0x1C, 0x73, 0x9C, 0x1C, 0xE7, 0x38, 0x3B, 0x8E, 0x70, 0x77,
  0x0C, 0xE0, 0xEE, 0x1F, 0x80, 0xDC, 0x3F, 0x01, 0xF0, 0x7E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x70, 0x78, 0xF0,
  0xE0, 0xE3, 0xC0, 0xE7, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x03, 0xC0,
  0x0F, 0xC0, 0x3F, 0x80, 0x77, 0x81, 0xE7, 0x03, 0x8F, 0x0E, 0x0F, 0x3C,
  0x0E, 0xF0, 0x1E, 0xF0, 0x0E, 0xE0, 0x3D, 0xC0, 0x73, 0xC0, 0xE3, 0x83,
  0xC7, 0x07, 0x0F, 0x0E, 0x0E, 0x3C, 0x1C, 0x70, 0x3C, 0xE0, 0x39, 0xC0,
  0x77, 0x00, 0x6E, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x1F, 0x80, 0x3E, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0,
  0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xC1, 0xF0, 0xFC, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x70, 0x3C, 0x3E, 0x0F, 0x03, 0xF0, 0x1C, 0x07,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xF0, 0x7C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x0F,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78,
  0x0F, 0x01, 0xF0, 0x3C, 0x3F, 0x0E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x3F, 0x0F, 0x83, 0xC0, 0x10, 0x05, 0xFC, 0x1F,
  0xFF, 0xF0, 0xFF, 0x80, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Medium32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 23, 8, 2, -23 },
  { 13, 9, 8, 13, 2, -23 },
  { 22, 17, 23, 19, 1, -23 },
  { 71, 13, 26, 17, 2, -24 },
  { 114, 23, 23, 25, 1, -23 },
  { 181, 20, 23, 21, 1, -23 },
  { 239, 3, 8, 7, 2, -23 },
  { 242, 8, 28, 10, 1, -23 },
  { 270, 7, 28, 10, 1, -23 },
  { 295, 14, 13, 16, 1, -24 },
  { 318, 14, 15, 17, 1, -19 },
  { 345, 5, 8, 8, 1, -4 },
  { 350, 8, 3, 10, 1, -10 },
  { 353, 4, 4, 8, 2, -4 },
  { 355, 12, 23, 12, 0, -23 },
  { 390, 14, 23, 17, 1, -23 },
  { 431, 9, 23, 17, 2, -23 },
  { 457, 14, 23, 17, 1, -23 },
  { 498, 14, 23, 17, 1, -23 },
  { 539, 15, 23, 17, 1, -23 },
  { 583, 13, 23, 17, 2, -23 },
  { 621, 14, 23, 17, 1, -23 },
  { 662, 14, 23, 17, 1, -23 },
  { 703, 14, 23, 17, 1, -23 },
  { 744, 14, 23, 17, 1, -23 },
  { 785, 4, 18, 8, 2, -18 },
  { 794, 5, 22, 8, 1, -18 },
  { 808, 14, 15, 17, 1, -19 },
  { 835, 14, 9, 17, 1, -16 },
  { 851, 14, 15, 17, 1, -19 },
  { 878, 12, 23, 13, 0, -23 },
  { 913, 22, 26, 26, 2, -23 },
  { 985, 19, 23, 19, 0, -23 },
  { 1040, 15, 23, 19, 3, -23 },
  { 1084, 15, 23, 18, 2, -23 },
  { 1128, 16, 23, 21, 3, -23 },
  { 1174, 11, 23, 16, 3, -23 },
  { 1206, 11, 23, 15, 3, -23 },
  { 1238, 17, 23, 21, 2, -23 },
  { 1287, 16, 23, 22, 3, -23 },
  { 1333, 8, 23, 11, 1, -23 },
  { 1356, 8, 29, 9, -2, -23 },
  { 1385, 15, 23, 18, 3, -23 },
  { 1429, 12, 23, 15, 3, -23 },
  { 1464, 21, 23, 27, 3, -23 },
  { 1525, 17, 23, 23, 3, -23 },
  { 1574, 19, 23, 23, 2, -23 },
  { 1629, 13, 23, 18, 3, -23 },
  { 1667, 19, 28, 23, 2, -23 },
  { 1734, 15, 23, 18, 3, -23 },
  { 1778, 14, 23, 16, 1, -23 },
  { 1819, 16, 23, 16, 0, -23 },
  { 1865, 16, 23, 21, 3, -23 },
  { 1911, 18, 23, 18, 0, -23 },
  { 1963, 27, 23, 28, 0, -23 },
  { 2041, 17, 23, 17, 0, -23 },
  { 2090, 17, 23, 17, 0, -23 },
  { 2139, 14, 23, 16, 1, -23 },
  { 2180, 8, 28, 10, 2, -23 },
  { 2208, 12, 23, 12, 0, -23 },
  { 2243, 7, 28, 10, 1, -23 },
  { 2268, 15, 14, 17, 1, -23 },
  { 2295, 14, 2, 14, 0, 3 },
  { 2299, 7, 6, 9, 1, -25 },
  { 2305, 13, 18, 17, 1, -18 },
  { 2335, 15, 24, 18, 2, -24 },
  { 2380, 11, 18, 14, 2, -18 },
  { 2405, 14, 24, 18, 2, -24 },
  { 2447, 13, 18, 17, 2, -18 },
  { 2477, 12, 24, 10, 0, -24 },
  { 2513, 14, 26, 18, 2, -18 },
  { 2559, 14, 24, 18, 2, -24 },
  { 2601, 4, 24, 8, 2, -24 },
  { 2613, 7, 32, 8, -1, -24 },
  { 2641, 14, 24, 16, 2, -24 },
  { 2683, 4, 24, 8, 2, -24 },
  { 2695, 23, 18, 27, 2, -18 },
  { 2747, 14, 18, 18, 2, -18 },
  { 2779, 14, 18, 18, 2, -18 },
  { 2811, 15, 26, 18, 2, -18 },
  { 2860, 14, 26, 18, 2, -18 },
  { 2906, 10, 18, 12, 2, -18 },
  { 2929, 12, 18, 14, 1, -18 },
  { 2956, 9, 21, 11, 1, -21 },
  { 2980, 14, 17, 18, 2, -17 },
  { 3010, 15, 17, 15, 0, -17 },
  { 3042, 23, 17, 24, 0, -17 },
  { 3091, 15, 17, 16, 0, -17 },
  { 3123, 15, 25, 15, 0, -17 },
  { 3170, 11, 17, 13, 1, -17 },
  { 3194, 10, 28, 12, 1, -23 },
  { 3229, 2, 32, 16, 7, -24 },
  { 3237, 10, 28, 12, 1, -23 },
  { 3272, 14, 5, 17, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_Medium32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium32pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM32PT7B_H_
