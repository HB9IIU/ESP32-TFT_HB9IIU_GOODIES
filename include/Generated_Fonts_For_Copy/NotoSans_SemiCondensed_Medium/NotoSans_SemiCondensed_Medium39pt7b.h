#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM39PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium39pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x78, 0xE3, 0x8E, 0x00, 0x00, 0x1E, 0x7B, 0xF7, 0xDE, 0xF8, 0xFF,
  0x8F, 0x70, 0xF7, 0x0F, 0x70, 0xF7, 0x0F, 0x70, 0xE7, 0x0E, 0x70, 0xE7,
  0x0E, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x87, 0x00,
  0x1C, 0x38, 0x01, 0xE1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x07, 0x0E, 0x00, 0x70, 0x70, 0x03,
  0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x07, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x38,
  0x70, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x0F, 0x00,
  0x38, 0x70, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0xFF, 0xC1, 0xFF, 0xF9, 0xFF, 0xF9, 0xF3, 0x1C, 0xF1, 0x80, 0x78, 0xC0,
  0x3C, 0x60, 0x1E, 0x30, 0x0F, 0x98, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x6F, 0xC0, 0x31, 0xE0, 0x18, 0x78,
  0x0C, 0x3C, 0x06, 0x1D, 0x03, 0x1E, 0xF1, 0xBF, 0x7F, 0xFF, 0x3F, 0xFF,
  0x07, 0xFE, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x3F,
  0x00, 0x3C, 0x0F, 0xF0, 0x07, 0x01, 0xFF, 0x01, 0xE0, 0x78, 0xE0, 0x38,
  0x0E, 0x1C, 0x0F, 0x01, 0xC3, 0xC1, 0xC0, 0x38, 0x78, 0x78, 0x07, 0x0F,
  0x0E, 0x00, 0xE1, 0xE3, 0xC0, 0x1C, 0x3C, 0x70, 0x03, 0x87, 0x8E, 0x00,
  0x70, 0xF3, 0x8F, 0x8E, 0x1C, 0x73, 0xF9, 0xE3, 0x9C, 0xFF, 0x9F, 0xF3,
  0x9C, 0x7B, 0xFC, 0xE3, 0x87, 0x1F, 0x1C, 0xF0, 0xE0, 0x07, 0x1E, 0x1C,
  0x00, 0xE3, 0x83, 0x80, 0x38, 0x70, 0x70, 0x07, 0x0E, 0x0E, 0x01, 0xE1,
  0xE1, 0xC0, 0x38, 0x3C, 0x38, 0x0F, 0x03, 0x87, 0x01, 0xC0, 0x71, 0xE0,
  0x78, 0x0F, 0xF8, 0x0E, 0x00, 0xFF, 0x03, 0xC0, 0x0F, 0xC0, 0x07, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xC1, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0x3F, 0xF8, 0x1E, 0x78, 0xF8, 0x79, 0xF0,
  0xF8, 0xF3, 0xC0, 0xF9, 0xE7, 0x80, 0xFF, 0x8F, 0x00, 0xFF, 0x1E, 0x00,
  0xFC, 0x3C, 0x01, 0xF0, 0x7C, 0x07, 0xF0, 0xFC, 0x3F, 0xF0, 0xFF, 0xFD,
  0xF0, 0xFF, 0xF1, 0xF0, 0xFF, 0x81, 0xF0, 0xFF, 0xDC, 0xE7, 0x39, 0xCE,
  0x73, 0x80, 0x07, 0x87, 0x83, 0x83, 0xC3, 0xC1, 0xE0, 0xE0, 0xF0, 0x78,
  0x38, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0,
  0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xC0, 0xF0,
  0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1,
  0xC1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x78, 0x00, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x0E, 0x09, 0xF7, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x00, 0xFC, 0x00, 0xEF, 0x00, 0xF3, 0x80,
  0xF1, 0xE0, 0xF8, 0xF8, 0x18, 0x38, 0x04, 0x10, 0x00, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3E, 0x78, 0xF1, 0xE7, 0x8F, 0x1C, 0x38, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x79, 0xEF, 0xDF, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x07,
  0xF0, 0x0F, 0xFC, 0x0F, 0xFF, 0x07, 0xC7, 0xC7, 0xC1, 0xE3, 0xC0, 0xFB,
  0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x03, 0xDE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0x79, 0xE0, 0x7C,
  0xF0, 0x3C, 0x3C, 0x3E, 0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x01,
  0xE0, 0x7C, 0x1F, 0x8F, 0xF3, 0xFE, 0xFB, 0xFE, 0x7B, 0x8F, 0x61, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFF, 0x1F, 0x8F, 0xC7, 0x01,
  0xE2, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xF0, 0x7F, 0xFC, 0xFF, 0xFC, 0xF8, 0x7E, 0x60, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x1F, 0xE0, 0x7E, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0E, 0xF0, 0x03, 0x9E, 0x00, 0xF3, 0xC0, 0x1C, 0x78,
  0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x38, 0x3C, 0x0F, 0x07, 0x81, 0xC0, 0xF0,
  0x78, 0x1E, 0x1E, 0x03, 0xC3, 0x80, 0x78, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x3F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F,
  0xFE, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x7F, 0xFE, 0x20, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x1F, 0xE0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F,
  0xE0, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x83, 0xF0, 0x43, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x38,
  0x1E, 0x7F, 0x8F, 0x7F, 0xE7, 0xFF, 0xF3, 0xF0, 0x7D, 0xF0, 0x1E, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3D,
  0xE0, 0x3C, 0xF8, 0x1E, 0x3E, 0x3F, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x87,
  0xC7, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0x78, 0x0F, 0x3C,
  0x0F, 0x0F, 0x0F, 0x87, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0x00, 0x7F, 0xE0,
  0x7D, 0xF8, 0x7C, 0x3E, 0x7C, 0x0F, 0xBC, 0x03, 0xDE, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1E, 0xF8, 0x1F, 0x3F, 0xFF, 0x0F,
  0xFF, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0x8F,
  0xCF, 0x81, 0xE7, 0x80, 0xFB, 0xC0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78,
  0x03, 0xBC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0xFD, 0xFB, 0xFE,
  0xFF, 0xEE, 0x3F, 0xE7, 0x07, 0xC7, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xFC, 0x3F, 0xFC, 0x1F,
  0xF8, 0x0F, 0xF8, 0x00, 0x7B, 0xFF, 0xDE, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x79, 0xEF, 0xDF, 0x78, 0x3C, 0xFD, 0xF9, 0xE3,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0xF1, 0xE7, 0x8F, 0x1E, 0x38, 0x71, 0xE0, 0x00, 0x01, 0x80, 0x03, 0xC0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0, 0x00,
  0x78, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x60, 0x00,
  0x00, 0x1F, 0xE1, 0xFF, 0xF1, 0xFF, 0xF3, 0xE3, 0xE2, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0x81,
  0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x01, 0xC3, 0xC0, 0x30, 0x1E, 0x38, 0x1F,
  0xF0, 0xE7, 0x83, 0xFF, 0x0E, 0x70, 0x78, 0x70, 0xF7, 0x0F, 0x07, 0x07,
  0xF0, 0xE0, 0x70, 0x7E, 0x1E, 0x07, 0x07, 0xE1, 0xE0, 0x70, 0x7E, 0x1C,
  0x07, 0x07, 0xE1, 0xC0, 0xF0, 0x7E, 0x1C, 0x0F, 0x0E, 0xE1, 0xE0, 0xF0,
  0xEE, 0x0E, 0x0F, 0x0E, 0xE0, 0xF1, 0xB9, 0xCF, 0x0F, 0xFB, 0xFC, 0x70,
  0x7F, 0x1F, 0x87, 0x80, 0xC0, 0x60, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x01, 0x80, 0x07, 0xFB, 0xF8, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x3D, 0xC0,
  0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x8F, 0x00,
  0x0F, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x03,
  0xC0, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x83, 0xE0, 0x0F, 0x07, 0x80, 0x1F, 0x0F, 0x00,
  0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0x7B, 0xE0, 0x00,
  0xF7, 0x80, 0x01, 0xF0, 0xFF, 0xE0, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFE, 0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xBC, 0x01, 0xEF, 0x00, 0xFB, 0xC0, 0x7C, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F,
  0xFF, 0xF3, 0xC0, 0x7E, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x7F,
  0xBF, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x7F, 0xFC,
  0x3F, 0xFF, 0x8F, 0xF3, 0xE1, 0xF0, 0x04, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC1, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x00,
  0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0xF0, 0x0F, 0xCF, 0x00, 0x7E, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x07, 0xCF,
  0x00, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xFF,
  0xDF, 0xFF, 0xBF, 0xFF, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xE3, 0xE1, 0xF8, 0x01, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x07, 0xFF, 0xC0,
  0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x03, 0xDE, 0x00, 0x1E,
  0xF0, 0x00, 0xF7, 0xC0, 0x07, 0xBE, 0x00, 0x3C, 0xF8, 0x01, 0xE7, 0xE0,
  0x0F, 0x1F, 0xC0, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xC0,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x8F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x0F, 0xFB, 0xFF, 0xFF,
  0xF0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0xFF, 0xBF, 0xEF, 0xF0, 0xE0, 0xF0, 0x03,
  0xFE, 0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x01, 0xF1, 0xE0, 0x7C,
  0x3C, 0x0F, 0x07, 0x83, 0xE0, 0xF0, 0xF8, 0x1E, 0x1E, 0x03, 0xC7, 0x80,
  0x79, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x3F, 0xF8, 0x07, 0xFF, 0x80,
  0xFC, 0xF0, 0x1F, 0x1F, 0x03, 0xC1, 0xF0, 0x78, 0x3E, 0x0F, 0x03, 0xE1,
  0xE0, 0x3C, 0x3C, 0x07, 0xC7, 0x80, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xFB,
  0xC0, 0x0F, 0x78, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFD, 0xC0, 0x07, 0x7F, 0xBC, 0x00,
  0xEF, 0xF7, 0x80, 0x3D, 0xFE, 0x70, 0x07, 0x3F, 0xCF, 0x00, 0xE7, 0xF9,
  0xE0, 0x3C, 0xFF, 0x1C, 0x07, 0x1F, 0xE3, 0xC0, 0xE3, 0xFC, 0x78, 0x3C,
  0x7F, 0x87, 0x07, 0x0F, 0xF0, 0xF0, 0xE1, 0xFE, 0x1E, 0x3C, 0x3F, 0xC1,
  0xC7, 0x07, 0xF8, 0x38, 0xE0, 0xFF, 0x07, 0xBC, 0x1F, 0xE0, 0x77, 0x03,
  0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x01, 0xFE, 0x03,
  0xE0, 0x3F, 0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0x00, 0xF0, 0xF8, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x01, 0xFE, 0xF0, 0x0F, 0xF7, 0xC0, 0x7F, 0x9E, 0x03, 0xFC,
  0x78, 0x1F, 0xE3, 0xE0, 0xFF, 0x0F, 0x07, 0xF8, 0x7C, 0x3F, 0xC1, 0xE1,
  0xFE, 0x0F, 0x8F, 0xF0, 0x3C, 0x7F, 0x81, 0xF3, 0xFC, 0x07, 0x9F, 0xE0,
  0x1E, 0x7F, 0x00, 0xFB, 0xF8, 0x03, 0xDF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFE, 0x3F, 0x83, 0xF0,
  0x0F, 0x87, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x78, 0x00,
  0x3E, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xCF,
  0x80, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x80, 0x7C, 0x1F, 0xC3, 0xF0, 0x1F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x7F, 0xFE,
  0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x01, 0xF7, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xFF, 0x01, 0xF7,
  0x81, 0xFB, 0xFF, 0xF9, 0xFF, 0xF8, 0xFF, 0xF0, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFE, 0x3F, 0x83, 0xF0, 0x0F, 0x87, 0xC0,
  0x0F, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xCF, 0x80, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x80, 0x7C, 0x1F, 0xC3, 0xF0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x01,
  0xF1, 0xE0, 0x1F, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00,
  0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x8F, 0x01, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0xF8, 0x1E, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0xC7, 0x80, 0x7C, 0xF0, 0x07,
  0x9E, 0x00, 0xFB, 0xC0, 0x0F, 0x78, 0x01, 0xF0, 0x0F, 0xF8, 0x1F, 0xFF,
  0x3F, 0xFE, 0x7F, 0x7E, 0xF8, 0x04, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x1E, 0xF0, 0x7E, 0xFF, 0xFC,
  0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x3F,
  0x0F, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0xF0, 0x00, 0x7F,
  0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0xF0, 0xF0,
  0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07,
  0x81, 0xE0, 0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00,
  0xF0, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3C, 0x00, 0x3C,
  0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCE, 0x00, 0x07, 0x78, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xBC, 0x01, 0xF0, 0x03, 0xDE, 0x00,
  0xF8, 0x01, 0xEF, 0x00, 0x7E, 0x01, 0xF7, 0x80, 0x3F, 0x00, 0xF3, 0xE0,
  0x3F, 0x80, 0x78, 0xF0, 0x1F, 0xC0, 0x3C, 0x78, 0x0E, 0xF0, 0x1E, 0x3C,
  0x07, 0x78, 0x1E, 0x1E, 0x07, 0x9C, 0x0F, 0x07, 0x83, 0xCE, 0x07, 0x83,
  0xC1, 0xE7, 0x83, 0xC1, 0xE0, 0xE3, 0xC3, 0xC0, 0xF0, 0xF0, 0xE1, 0xE0,
  0x3C, 0x78, 0x70, 0xF0, 0x1E, 0x3C, 0x3C, 0x78, 0x0F, 0x1C, 0x1E, 0x3C,
  0x07, 0x9E, 0x07, 0x3C, 0x01, 0xCF, 0x03, 0x9E, 0x00, 0xF7, 0x81, 0xEF,
  0x00, 0x7B, 0x80, 0xF7, 0x80, 0x3D, 0xC0, 0x3B, 0x80, 0x0F, 0xE0, 0x1F,
  0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x3C, 0x07, 0xC1, 0xF0, 0x3C, 0x07,
  0x83, 0xC0, 0x3E, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0xCF, 0x00, 0x1E, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1E, 0xF0, 0x01, 0xF7, 0xC0,
  0x0F, 0x1E, 0x00, 0xF8, 0xF8, 0x07, 0x83, 0xC0, 0x78, 0x0F, 0x03, 0xC0,
  0x78, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xF0,
  0xF8, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x03,
  0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0x81, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF8,
  0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0x70, 0x01,
  0xCE, 0x00, 0x38, 0xE0, 0x0E, 0x1C, 0x01, 0xC1, 0xC0, 0x70, 0x38, 0x0E,
  0x03, 0x83, 0xC0, 0x70, 0x70, 0x07, 0x1E, 0x00, 0xE3, 0x80, 0x1E, 0xF0,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0xF8, 0x7C,
  0x3C, 0x1E, 0x0F, 0x1F, 0xF8, 0x3F, 0xFC, 0x3F, 0xFE, 0x38, 0x3E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x03, 0xFF, 0x1F, 0xFF, 0x7F,
  0xFF, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xFF, 0xEF, 0x7F, 0xEF, 0x3F, 0x8F, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x79, 0xFC, 0x3D, 0xFF, 0x1F, 0xFF, 0xCF, 0xC1,
  0xF7, 0xC0, 0x7B, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF8, 0x0F, 0xFC, 0x07, 0xBF, 0x07, 0xDF, 0xFF, 0xCE, 0x7F, 0xC7, 0x1F,
  0xC0, 0x07, 0xFC, 0x7F, 0xF3, 0xFF, 0xDF, 0x82, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x33, 0xFF, 0xC7, 0xFF,
  0x0F, 0xF8, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x87, 0xF3, 0xC7,
  0xFD, 0xE7, 0xFF, 0xF7, 0xC1, 0xFB, 0xC0, 0x7F, 0xE0, 0x3F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0xDF, 0x07, 0xE7,
  0xFF, 0xF1, 0xFF, 0x38, 0x7F, 0x1C, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x8F, 0x83, 0xC7, 0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x0E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0x8F, 0xFF, 0xC3, 0xFF,
  0xE0, 0x7F, 0xE0, 0x01, 0xF0, 0x3F, 0xC3, 0xFE, 0x3F, 0xE1, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x03, 0xFF, 0x3F, 0xF9, 0xFF, 0xC1, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x0F, 0xE3, 0x8F, 0xF9, 0xCF, 0xFF, 0xEF, 0x83,
  0xF7, 0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xF0, 0x0F, 0x78, 0x0F, 0xBE, 0x0F, 0xCF, 0xFF, 0xE3, 0xFE, 0xF0, 0xFE,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xA0, 0x07, 0x9C,
  0x07, 0xCF, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF3, 0xFC, 0xF7, 0xFE, 0xFF, 0xFE, 0xFC, 0x1F, 0xF8, 0x0F,
  0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x60, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0x03, 0xC1, 0xE0, 0xF0, 0x30, 0x00, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC3, 0xFF, 0xEF, 0xF7, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x0F, 0xBC, 0x0F, 0x9E, 0x07, 0x8F, 0x07, 0x87, 0x87, 0x83,
  0xC7, 0xC1, 0xE7, 0xC0, 0xF3, 0xC0, 0x7B, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x07, 0xCF, 0x03, 0xC7, 0xC1, 0xE1, 0xF0, 0xF0, 0x78, 0x78,
  0x3E, 0x3C, 0x0F, 0x1E, 0x03, 0xCF, 0x01, 0xF7, 0x80, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE3, 0xF8, 0x3F, 0x8E, 0x7F, 0xCF, 0xFC, 0xFF, 0xFE, 0xFF, 0xEF,
  0xC3, 0xFC, 0x3E, 0xF8, 0x1F, 0x81, 0xEF, 0x80, 0xF0, 0x1F, 0xF0, 0x0F,
  0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F,
  0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00,
  0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00,
  0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0,
  0x0F, 0x00, 0xF0, 0xE3, 0xFC, 0xE7, 0xFE, 0xFF, 0xFE, 0xFC, 0x1F, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x07, 0xF8, 0x07,
  0xFF, 0x03, 0xFF, 0xE1, 0xF0, 0x7C, 0x78, 0x0F, 0x9E, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x79, 0xE0, 0x1E, 0x78, 0x0F, 0x8F,
  0x87, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xE3, 0xF8, 0x73,
  0xFE, 0x3F, 0xFF, 0x9F, 0x83, 0xEF, 0x80, 0xF7, 0xC0, 0x7F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0x7E, 0x0F, 0xBF,
  0xFF, 0x9E, 0xFF, 0x8F, 0x3F, 0x87, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xE3, 0x8F, 0xF9, 0xCF, 0xFF, 0xEF, 0x83, 0xF7, 0x80, 0xFF,
  0xC0, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x0F, 0x78,
  0x0F, 0xBE, 0x0F, 0xCF, 0xFF, 0xE3, 0xFE, 0xF0, 0xFE, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0xE3, 0xFE, 0x7E, 0xEF, 0xEF, 0xFA, 0xFC,
  0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x00, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0xE0, 0x6F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0x7E, 0x01, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xEF, 0xFC, 0x00,
  0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x07, 0xFE, 0xFF, 0xEF, 0xFE,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x01, 0xFF,
  0x1F, 0xF0, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF8, 0x3F, 0x7F, 0xF7, 0x7F, 0xE7, 0x1F, 0xC7, 0xF0, 0x03, 0xEF,
  0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F,
  0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0x38, 0x78, 0x07,
  0x8F, 0x00, 0xF1, 0xC0, 0x0E, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0xFB, 0xC0, 0x7C, 0x07, 0x9E, 0x03, 0xE0, 0x3C, 0xF0, 0x3F,
  0x81, 0xE3, 0x81, 0xDC, 0x1E, 0x1E, 0x0E, 0xE0, 0xF0, 0xF0, 0x77, 0x07,
  0x87, 0x87, 0xBC, 0x3C, 0x1C, 0x39, 0xE3, 0xC0, 0xF1, 0xC7, 0x1E, 0x07,
  0x9E, 0x38, 0xF0, 0x3C, 0xF1, 0xE7, 0x80, 0xE7, 0x0F, 0x38, 0x07, 0xB8,
  0x3B, 0xC0, 0x3D, 0xC1, 0xDE, 0x01, 0xFE, 0x0E, 0xE0, 0x07, 0xE0, 0x7F,
  0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xCF, 0x01, 0xE3, 0xE0, 0xF8, 0x78,
  0x3C, 0x0F, 0x1E, 0x03, 0xC7, 0x80, 0x7B, 0xC0, 0x1F, 0xF0, 0x03, 0xF8,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xEF, 0x00,
  0xFB, 0xE0, 0x3C, 0x78, 0x1F, 0x1F, 0x07, 0x83, 0xC3, 0xC0, 0x79, 0xF0,
  0x1F, 0xF8, 0x03, 0xC0, 0xF0, 0x03, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x3C,
  0x03, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x1E,
  0x0F, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF1, 0xC0, 0x0F,
  0x78, 0x01, 0xEF, 0x00, 0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x3F, 0x07, 0xF0, 0x7E, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF0, 0x0F, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0xFE, 0x01, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x78, 0x07, 0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0,
  0x07, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xFE, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x1F, 0xC0, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xBF, 0x80, 0x7F,
  0xF8, 0xFF, 0xFF, 0xF8, 0x1F, 0xF4, 0x03, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Medium39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 6, 28, 10, 2, -28 },
  { 22, 12, 10, 16, 2, -28 },
  { 37, 21, 28, 23, 1, -28 },
  { 111, 17, 32, 20, 2, -30 },
  { 179, 27, 28, 31, 2, -28 },
  { 274, 23, 28, 25, 2, -28 },
  { 355, 5, 10, 9, 2, -28 },
  { 362, 9, 34, 12, 2, -28 },
  { 401, 9, 34, 12, 1, -28 },
  { 440, 17, 17, 19, 1, -30 },
  { 477, 17, 19, 20, 2, -23 },
  { 518, 7, 9, 10, 1, -4 },
  { 526, 10, 3, 12, 1, -12 },
  { 530, 6, 5, 10, 2, -5 },
  { 534, 15, 28, 15, 0, -28 },
  { 587, 17, 28, 20, 2, -28 },
  { 647, 11, 28, 20, 3, -28 },
  { 686, 17, 28, 20, 2, -28 },
  { 746, 16, 28, 20, 2, -28 },
  { 802, 19, 28, 20, 1, -28 },
  { 869, 16, 28, 20, 2, -28 },
  { 925, 17, 28, 20, 2, -28 },
  { 985, 18, 28, 20, 1, -28 },
  { 1048, 17, 28, 20, 2, -28 },
  { 1108, 17, 28, 20, 2, -28 },
  { 1168, 6, 21, 10, 2, -21 },
  { 1184, 7, 26, 10, 1, -21 },
  { 1207, 17, 18, 20, 2, -23 },
  { 1246, 17, 11, 20, 2, -19 },
  { 1270, 17, 18, 20, 2, -23 },
  { 1309, 15, 28, 16, 0, -28 },
  { 1362, 28, 31, 32, 2, -28 },
  { 1471, 23, 28, 23, 0, -28 },
  { 1552, 18, 28, 23, 3, -28 },
  { 1615, 19, 28, 22, 2, -28 },
  { 1682, 20, 28, 26, 3, -28 },
  { 1752, 15, 28, 20, 3, -28 },
  { 1805, 15, 28, 19, 3, -28 },
  { 1858, 21, 28, 26, 2, -28 },
  { 1932, 20, 28, 26, 3, -28 },
  { 2002, 11, 28, 13, 1, -28 },
  { 2041, 10, 36, 11, -3, -28 },
  { 2086, 19, 28, 22, 3, -28 },
  { 2153, 15, 28, 19, 3, -28 },
  { 2206, 27, 28, 33, 3, -28 },
  { 2301, 21, 28, 28, 3, -28 },
  { 2375, 23, 28, 27, 2, -28 },
  { 2456, 17, 28, 22, 3, -28 },
  { 2516, 23, 35, 27, 2, -28 },
  { 2617, 19, 28, 22, 3, -28 },
  { 2684, 16, 28, 20, 2, -28 },
  { 2740, 19, 28, 20, 0, -28 },
  { 2807, 20, 28, 26, 3, -28 },
  { 2877, 22, 28, 22, 0, -28 },
  { 2954, 33, 28, 34, 0, -28 },
  { 3070, 21, 28, 21, 0, -28 },
  { 3144, 20, 28, 20, 0, -28 },
  { 3214, 17, 28, 20, 1, -28 },
  { 3274, 9, 34, 13, 3, -28 },
  { 3313, 15, 28, 15, 0, -28 },
  { 3366, 9, 34, 13, 1, -28 },
  { 3405, 19, 17, 21, 1, -28 },
  { 3446, 17, 3, 17, 0, 3 },
  { 3453, 8, 6, 12, 2, -30 },
  { 3459, 16, 21, 20, 2, -21 },
  { 3501, 17, 30, 22, 3, -30 },
  { 3565, 14, 21, 17, 2, -21 },
  { 3602, 17, 30, 22, 2, -30 },
  { 3666, 17, 21, 20, 2, -21 },
  { 3711, 13, 30, 13, 1, -30 },
  { 3760, 17, 30, 22, 2, -21 },
  { 3824, 16, 30, 22, 3, -30 },
  { 3884, 4, 29, 10, 3, -29 },
  { 3899, 9, 38, 10, -2, -29 },
  { 3942, 17, 30, 20, 3, -30 },
  { 4006, 4, 30, 10, 3, -30 },
  { 4021, 28, 21, 33, 3, -21 },
  { 4095, 16, 21, 22, 3, -21 },
  { 4137, 18, 21, 22, 2, -21 },
  { 4185, 17, 30, 22, 3, -21 },
  { 4249, 17, 30, 22, 2, -21 },
  { 4313, 12, 21, 15, 3, -21 },
  { 4345, 13, 21, 17, 2, -21 },
  { 4380, 12, 26, 13, 1, -26 },
  { 4419, 16, 21, 22, 3, -21 },
  { 4461, 19, 21, 19, 0, -21 },
  { 4511, 29, 21, 29, 0, -21 },
  { 4588, 18, 21, 19, 0, -21 },
  { 4636, 19, 30, 19, 0, -21 },
  { 4708, 14, 21, 16, 1, -21 },
  { 4745, 12, 34, 15, 1, -28 },
  { 4796, 3, 39, 20, 8, -30 },
  { 4811, 13, 34, 15, 1, -28 },
  { 4867, 17, 6, 20, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_Medium39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium39pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM39PT7B_H_
