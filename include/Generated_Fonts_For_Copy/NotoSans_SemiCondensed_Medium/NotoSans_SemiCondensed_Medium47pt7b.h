#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM47PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium47pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x00, 0x00, 0x00, 0x7B, 0xFF,
  0xFF, 0xFD, 0xF1, 0x00, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1F, 0xF8,
  0x7F, 0xE1, 0xEF, 0x87, 0xBC, 0x1E, 0xF0, 0x79, 0xC1, 0xE7, 0x07, 0x9C,
  0x0E, 0x70, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1C, 0x0F,
  0x00, 0x0E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x0F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0x07,
  0x03, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x1C, 0x07, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0,
  0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x01, 0xFE, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3, 0xFF, 0xFE, 0x7F, 0x73,
  0xE7, 0xC7, 0x04, 0xF8, 0x70, 0x0F, 0x87, 0x00, 0xF8, 0x70, 0x0F, 0x87,
  0x00, 0x7C, 0x70, 0x07, 0xF7, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x77, 0xF0,
  0x07, 0x1F, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x1F,
  0xE0, 0x71, 0xFF, 0xC7, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x7F, 0xFF,
  0x00, 0x7F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x1F, 0xF0, 0x01, 0xE0,
  0x0F, 0xFC, 0x00, 0xF0, 0x0F, 0xBE, 0x00, 0xF0, 0x07, 0x8F, 0x80, 0x78,
  0x07, 0x83, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x3C, 0x01, 0xE0, 0xF0, 0x3C,
  0x00, 0xF0, 0x78, 0x1E, 0x00, 0x78, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x0F,
  0x00, 0x1E, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x87, 0x80, 0x07, 0x83, 0xC7,
  0x83, 0x83, 0xC1, 0xE3, 0xC7, 0xF1, 0xE0, 0xF3, 0xC7, 0xFC, 0x78, 0xF9,
  0xE7, 0xFF, 0x3E, 0xF9, 0xE3, 0xC7, 0x8F, 0xFC, 0xF1, 0xE1, 0xE3, 0xFC,
  0x79, 0xE0, 0xF0, 0xF8, 0x78, 0xF0, 0x78, 0x00, 0x3C, 0x78, 0x3C, 0x00,
  0x3C, 0x3C, 0x1E, 0x00, 0x1E, 0x1E, 0x0F, 0x00, 0x1E, 0x0F, 0x07, 0x80,
  0x0F, 0x07, 0x83, 0xC0, 0x0F, 0x03, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0xF0,
  0x07, 0x80, 0xF0, 0x78, 0x03, 0xC0, 0x3C, 0x3C, 0x03, 0xC0, 0x1E, 0x3C,
  0x01, 0xE0, 0x07, 0xFE, 0x01, 0xE0, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xF8, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0x0F, 0xFF, 0x80, 0xF8, 0x7E, 0x7E,
  0x0F, 0x87, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0xC3, 0xE3, 0xE0, 0x3F, 0x3E,
  0x1F, 0x00, 0xFD, 0xF0, 0xF8, 0x03, 0xFF, 0x07, 0xC0, 0x0F, 0xF8, 0x3E,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xF0, 0x3F, 0x01,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xF9, 0xF8, 0x1F, 0xFF, 0x87,
  0xE0, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF3, 0x9C,
  0xE7, 0x00, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x07, 0xC0,
  0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3E, 0x07,
  0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0xF8,
  0x0F, 0x00, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x3E, 0x07,
  0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xC0,
  0xE0, 0x6F, 0xCE, 0x7E, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x0F, 0xBE, 0x00, 0xF1, 0xF0,
  0x1F, 0x1F, 0x03, 0xE0, 0xF8, 0x0E, 0x0F, 0x00, 0x20, 0x40, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x7C, 0xFB, 0xE7, 0xCF, 0x9E, 0x3C, 0xF1, 0xE3, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7B, 0xFF, 0xFF, 0xFD, 0xF1, 0x00, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xF0, 0xFC,
  0x1F, 0x03, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x01, 0xF3, 0xE0,
  0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0x7B,
  0xE0, 0x03, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0xDF,
  0x00, 0x3E, 0x78, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x07,
  0xC3, 0xE0, 0x3E, 0x1F, 0x83, 0xE0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x07, 0xF0,
  0x7F, 0x8F, 0xFC, 0xFD, 0xEF, 0xCF, 0xFC, 0x79, 0xC3, 0xCC, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xFC, 0xFE,
  0x0F, 0xC7, 0x80, 0x7E, 0x20, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC,
  0x7C, 0x0F, 0xE7, 0x00, 0x7E, 0x20, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x80, 0x03, 0xFE, 0x00, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F,
  0x1F, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x7C, 0x01, 0xE0, 0xF8, 0x07, 0xC1,
  0xF0, 0x0F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xFF, 0xE0, 0x3F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF, 0xFF, 0x86, 0x0F, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF8,
  0x00, 0xFD, 0x80, 0x3F, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0xFE, 0x02, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x7F, 0x83, 0xE7, 0xFE, 0x1F, 0x7F, 0xF8, 0xFF, 0xFF, 0xE7, 0xF8,
  0x1F, 0xBF, 0x00, 0x7D, 0xF8, 0x03, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0x9F, 0x00,
  0x7C, 0xF8, 0x03, 0xE3, 0xE0, 0x3F, 0x1F, 0x83, 0xF0, 0x7F, 0xFF, 0x81,
  0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x83, 0xF0, 0x7E, 0x3E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x7C,
  0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x78, 0x7C, 0x07, 0xC3, 0xF0, 0x7C,
  0x0F, 0xC7, 0xE0, 0x3F, 0xFE, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x7F,
  0xF8, 0x07, 0xFF, 0xE0, 0x7E, 0x3F, 0x87, 0xE0, 0x7E, 0x3E, 0x01, 0xFB,
  0xE0, 0x07, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xEF, 0x80, 0x1F, 0x3E, 0x01, 0xF9, 0xFF, 0x7F, 0x87,
  0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0x0F, 0xC7, 0xE0, 0x7E, 0x7C,
  0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x3F,
  0x7C, 0x03, 0xF7, 0xF0, 0xFF, 0x3F, 0xFE, 0xF1, 0xFF, 0xCF, 0x0F, 0xF9,
  0xF0, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x3F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x3B, 0xFF, 0xFF,
  0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7B, 0xFF, 0xFF, 0xFD, 0xF1, 0x00, 0x1C, 0xFD, 0xFB, 0xF7, 0xEF, 0xCF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xDF, 0xBE, 0x7C, 0xF9, 0xE3, 0xCF, 0x9E, 0x3C, 0x70, 0x00, 0x00,
  0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0x60, 0x00, 0x02, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x0F,
  0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7C, 0x1F, 0x88, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xF0, 0x00, 0x10, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x1E, 0x01, 0xE3, 0xC0,
  0x7F, 0xF8, 0x78, 0xF0, 0x3F, 0xFE, 0x1E, 0x3C, 0x1F, 0xDF, 0x83, 0x9E,
  0x07, 0x81, 0xE0, 0xF7, 0x83, 0xC0, 0x78, 0x3D, 0xE0, 0xF0, 0x1E, 0x0F,
  0x70, 0x78, 0x07, 0x03, 0xDC, 0x1E, 0x03, 0xC0, 0xFF, 0x07, 0x80, 0xF0,
  0x3F, 0xC1, 0xE0, 0x3C, 0x0F, 0xF0, 0x78, 0x0F, 0x03, 0xFC, 0x1E, 0x03,
  0xC0, 0xFF, 0x07, 0x80, 0xF0, 0x39, 0xC1, 0xF0, 0x7C, 0x1E, 0x78, 0x3C,
  0x1F, 0x87, 0x1E, 0x0F, 0xDE, 0xF7, 0xC7, 0x81, 0xFF, 0xBF, 0xE1, 0xE0,
  0x3F, 0xC7, 0xF0, 0x3C, 0x03, 0xC0, 0x70, 0x0F, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x30, 0x00, 0x3F, 0xE1, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x1F, 0x0F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07,
  0xC0, 0x07, 0xC0, 0x3C, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xE0,
  0x0F, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x7E, 0xF8, 0x00, 0xFB, 0xE0, 0x03,
  0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x8F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x3E, 0x00, 0xFC, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x3E, 0xF8, 0x01, 0xFB, 0xE0, 0x1F, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xF0, 0xF8, 0x7F, 0x00, 0x23,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x60, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xF8, 0xF8,
  0x01, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x03, 0xF8, 0xF8, 0x1F, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0x83, 0xF0, 0xFE, 0x00, 0x30, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x80,
  0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xF8, 0x00, 0xF8, 0xFF, 0x00, 0x7C, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x3E, 0x87, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8,
  0xFE, 0x00, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xC0,
  0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7C, 0x07,
  0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0,
  0x0F, 0x8F, 0x80, 0x1F, 0x3F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF8, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xF7, 0xE0, 0x0F,
  0xC7, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8,
  0x1F, 0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x0F, 0x80,
  0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xFD, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF7, 0x80, 0x01, 0xFF, 0xF7, 0x80, 0x01,
  0xFF, 0xF7, 0xC0, 0x03, 0xDF, 0xF3, 0xC0, 0x03, 0xDF, 0xF3, 0xC0, 0x03,
  0xDF, 0xFB, 0xE0, 0x07, 0x9F, 0xF9, 0xE0, 0x07, 0x9F, 0xF9, 0xE0, 0x07,
  0x9F, 0xF9, 0xF0, 0x0F, 0x1F, 0xF8, 0xF0, 0x0F, 0x1F, 0xF8, 0xF0, 0x0F,
  0x1F, 0xF8, 0xF8, 0x1E, 0x1F, 0xF8, 0x78, 0x1E, 0x1F, 0xF8, 0x78, 0x1E,
  0x1F, 0xF8, 0x7C, 0x3C, 0x1F, 0xF8, 0x3C, 0x3C, 0x1F, 0xF8, 0x3C, 0x3C,
  0x1F, 0xF8, 0x3E, 0x78, 0x1F, 0xF8, 0x1E, 0x78, 0x1F, 0xF8, 0x1E, 0x78,
  0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x0F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x0F, 0xE0, 0x1F, 0xF8, 0x07, 0xE0,
  0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xF8, 0x07, 0xC0, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xEF, 0x80, 0x0F, 0xF7, 0xC0,
  0x07, 0xF9, 0xF0, 0x03, 0xFC, 0xFC, 0x01, 0xFE, 0x3E, 0x00, 0xFF, 0x9F,
  0x80, 0x7F, 0xC7, 0xC0, 0x3F, 0xE3, 0xF0, 0x1F, 0xF0, 0xF8, 0x0F, 0xF8,
  0x3E, 0x07, 0xFC, 0x1F, 0x03, 0xFE, 0x07, 0xC1, 0xFF, 0x03, 0xF0, 0xFF,
  0x80, 0xF8, 0x7F, 0xC0, 0x7E, 0x3F, 0xE0, 0x1F, 0x1F, 0xF0, 0x0F, 0xCF,
  0xF8, 0x03, 0xE7, 0xFC, 0x00, 0xFB, 0xFE, 0x00, 0x7D, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x0F,
  0xF0, 0x7F, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7C,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9,
  0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x80,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0x80, 0xFE, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x03, 0xEF, 0x80, 0x7E, 0xF8, 0x1F, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x0F, 0xF0, 0x7F, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x1F,
  0x00, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x7C, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x7C, 0x07, 0xF0,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F,
  0x83, 0xE0, 0x1F, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0xF8,
  0x0F, 0x81, 0xF0, 0x1F, 0x83, 0xE0, 0x1F, 0x07, 0xC0, 0x3F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xFD, 0xF0, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x7F, 0x8F, 0xC7, 0xE0, 0x0C, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x80, 0x07, 0xEF, 0x00, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xF7,
  0xE0, 0x07, 0xCF, 0xE0, 0x3F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x07, 0xC0,
  0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x3C, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0x00, 0x1F, 0x7C,
  0x00, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x7F, 0x00, 0x3E, 0x7C, 0x00, 0x7F,
  0x00, 0x3E, 0x3E, 0x00, 0xFF, 0x00, 0x3E, 0x3E, 0x00, 0xFF, 0x00, 0x3E,
  0x3E, 0x00, 0xFF, 0x80, 0x7C, 0x3E, 0x00, 0xF7, 0x80, 0x7C, 0x1F, 0x01,
  0xF7, 0x80, 0x7C, 0x1F, 0x01, 0xE7, 0x80, 0x7C, 0x1F, 0x01, 0xE7, 0xC0,
  0x78, 0x1F, 0x01, 0xE3, 0xC0, 0xF8, 0x0F, 0x03, 0xE3, 0xC0, 0xF8, 0x0F,
  0x83, 0xC3, 0xC0, 0xF8, 0x0F, 0x83, 0xC3, 0xE0, 0xF0, 0x0F, 0x87, 0xC1,
  0xE1, 0xF0, 0x07, 0x87, 0xC1, 0xE1, 0xF0, 0x07, 0xC7, 0x81, 0xE1, 0xF0,
  0x07, 0xC7, 0x81, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0xF3, 0xE0, 0x03, 0xCF,
  0x80, 0xF3, 0xE0, 0x03, 0xCF, 0x00, 0xF3, 0xE0, 0x03, 0xEF, 0x00, 0xFB,
  0xC0, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x1F, 0x9F, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xC7,
  0xC0, 0x07, 0xE1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x7C,
  0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xC3, 0xE0, 0x07,
  0xE1, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0xF8, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0xE7, 0x80, 0x03, 0xC7, 0x80, 0x07,
  0x8F, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x78, 0x00,
  0xF1, 0xE0, 0x01, 0xF3, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x03, 0xE0, 0xFC, 0x1F,
  0x03, 0xE0, 0x3C, 0x07, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE1, 0xE0, 0xFC, 0x10, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F,
  0xFF, 0xDF, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xDF, 0xDF, 0xFB, 0xFF,
  0xEF, 0x3F, 0xF9, 0xE3, 0xFC, 0x3C, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x7C, 0x0F, 0x1F, 0xF0,
  0xF7, 0xFF, 0x8F, 0x7F, 0xFC, 0xFF, 0x0F, 0xCF, 0xC0, 0x7E, 0xFC, 0x03,
  0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xEF,
  0xE0, 0x7E, 0xFF, 0xFF, 0xCF, 0x7F, 0xFC, 0xF3, 0xFF, 0x8E, 0x1F, 0xE0,
  0x00, 0xFC, 0x00, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xC7, 0x0F,
  0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x23, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x78, 0x3E, 0x0F, 0xF9, 0xF0, 0xFF, 0xEF, 0x8F, 0xFF, 0xBC,
  0xFE, 0x3F, 0xE7, 0xC0, 0x7F, 0x7E, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xF8, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF8, 0x07, 0xE7, 0xE0, 0x7F, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFB, 0xC3, 0xFF, 0x9E, 0x0F, 0xF0, 0xF0, 0x00, 0xF8,
  0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x07, 0xE3, 0xE0,
  0x3E, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x06, 0x1F, 0xFF, 0xE0, 0xFF, 0xFE, 0x07, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFE, 0x0F,
  0xC2, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xE3, 0xC3, 0xFF, 0x9E, 0x3F,
  0xFE, 0xF3, 0xF8, 0xFF, 0x9F, 0x01, 0xFD, 0xF8, 0x07, 0xEF, 0x80, 0x1F,
  0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFB,
  0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xE0, 0x1F, 0x9F, 0x81,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFE, 0xF8, 0x3F, 0xC7, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE8, 0x00, 0x3E, 0x38, 0x07, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC1, 0xF0, 0x78, 0xFF, 0x8F, 0x7F, 0xF9,
  0xEF, 0xFF, 0xBF, 0xE7, 0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xF0, 0x7B, 0xEF, 0xFF, 0x78, 0xC0,
  0x00, 0x00, 0x07, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x03, 0xC0,
  0xF8, 0x1F, 0x83, 0xF0, 0x3C, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xFB, 0xFF, 0x7F, 0xCF, 0xF1,
  0xFC, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x7E, 0xF0, 0x0F, 0xCF, 0x01,
  0xF8, 0xF0, 0x1F, 0x0F, 0x03, 0xE0, 0xF0, 0x7C, 0x0F, 0x0F, 0x80, 0xF1,
  0xF8, 0x0F, 0x1F, 0x00, 0xF3, 0xE0, 0x0F, 0x7E, 0x00, 0xFF, 0xE0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xCF, 0x80, 0xF8, 0xFC, 0x0F, 0x07, 0xC0,
  0xF0, 0x3E, 0x0F, 0x03, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xF8, 0xF0, 0x0F,
  0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xEF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x71, 0xFF, 0x83, 0xFE, 0x3D, 0xFF,
  0xE7, 0xFF, 0x9E, 0xFF, 0xF3, 0xFF, 0xEF, 0xF1, 0xFF, 0xC7, 0xF7, 0xE0,
  0x3F, 0x80, 0xFB, 0xF0, 0x1F, 0xC0, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0xF8,
  0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xFC, 0x00, 0xF8, 0x03, 0xFE,
  0x00, 0x7C, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x1F, 0x00, 0x7F,
  0xC0, 0x0F, 0x80, 0x3F, 0xE0, 0x07, 0xC0, 0x1F, 0xF0, 0x03, 0xE0, 0x0F,
  0xF8, 0x01, 0xF0, 0x07, 0xFC, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0x7C, 0x01,
  0xFF, 0x00, 0x3E, 0x00, 0xFF, 0x80, 0x1F, 0x00, 0x7F, 0xC0, 0x0F, 0x80,
  0x3F, 0xE0, 0x07, 0xC0, 0x1F, 0xF0, 0x03, 0xE0, 0x0F, 0xF8, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x7C, 0x1C, 0x3F, 0xE3, 0xDF, 0xFE, 0x7B, 0xFF, 0xEF,
  0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF8, 0x3F, 0x87, 0xF0, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x9F,
  0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x3E,
  0x01, 0xF0, 0xFC, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0x1F, 0xF0, 0xF3, 0xFF, 0x8F,
  0x7F, 0xFC, 0xFF, 0x0F, 0xEF, 0xC0, 0x7E, 0xFC, 0x03, 0xEF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x03, 0xEF, 0xE0, 0x7E, 0xFF,
  0xFF, 0xCF, 0x7F, 0xFC, 0xF3, 0xFF, 0x8F, 0x1F, 0xE0, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0xE3, 0xC3, 0xFF, 0x9E, 0x3F, 0xFE, 0xF3,
  0xF8, 0x7F, 0x9F, 0x01, 0xFD, 0xF8, 0x07, 0xEF, 0x80, 0x1F, 0x7C, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xE0, 0x1F, 0x9F, 0x81, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFE, 0xF8, 0x3F, 0xC7, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0x0F, 0xFC, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0x83, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xEF, 0xC0, 0xE7, 0xC0, 0x13, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFB, 0xFB, 0xFD, 0xFF,
  0xFC, 0xFF, 0xFC, 0x3F, 0xFC, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F,
  0xC0, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03,
  0xF7, 0xC0, 0x3F, 0x7E, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFE, 0xF1, 0xFF,
  0xCF, 0x0F, 0xF8, 0xF0, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x0F,
  0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x07,
  0x80, 0x7C, 0x1F, 0x01, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x3E, 0x03, 0xE0,
  0xF0, 0x0F, 0x87, 0xC0, 0x1E, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xF3, 0xE0,
  0x03, 0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xDF, 0x00, 0xFE, 0x01, 0xF7, 0xC0, 0x3F,
  0x80, 0x7D, 0xF0, 0x0F, 0xE0, 0x1E, 0x3C, 0x03, 0xB8, 0x0F, 0x8F, 0x81,
  0xEF, 0x03, 0xE3, 0xE0, 0x7B, 0xC0, 0xF8, 0xF8, 0x1E, 0xF0, 0x3C, 0x1E,
  0x0F, 0x3C, 0x1F, 0x07, 0xC3, 0xC7, 0x87, 0xC1, 0xF0, 0xF1, 0xE1, 0xF0,
  0x7C, 0x3C, 0x78, 0x78, 0x0F, 0x1E, 0x1E, 0x3E, 0x03, 0xE7, 0x83, 0xCF,
  0x80, 0xF9, 0xE0, 0xF3, 0xE0, 0x3E, 0x78, 0x3C, 0xF0, 0x07, 0x9C, 0x0F,
  0x3C, 0x01, 0xEF, 0x01, 0xDF, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xF0,
  0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF0, 0x00,
  0xFC, 0x01, 0xFB, 0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0,
  0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x7C, 0x7C, 0x03,
  0xE3, 0xE0, 0x3E, 0x0F, 0x83, 0xF0, 0x7E, 0x1F, 0x01, 0xF1, 0xF0, 0x0F,
  0xDF, 0x80, 0x3E, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xC1, 0xE0,
  0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF8, 0x3E,
  0x03, 0xE0, 0xF0, 0x07, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x7C, 0x78, 0x00,
  0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x3F,
  0x80, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x7E, 0x07, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x03, 0xF0, 0x0F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x3F,
  0xC1, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x81, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0xF8, 0x00, 0x1F, 0x00, 0x0B, 0xFF,
  0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x40, 0x1F, 0xF2,
  0x00, 0x0E, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Medium47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 35, 12, 3, -34 },
  { 28, 14, 13, 20, 3, -34 },
  { 51, 25, 34, 27, 1, -34 },
  { 158, 20, 39, 25, 2, -36 },
  { 256, 33, 34, 37, 2, -34 },
  { 397, 29, 34, 31, 2, -34 },
  { 521, 5, 13, 11, 3, -34 },
  { 530, 11, 41, 14, 2, -34 },
  { 587, 11, 41, 14, 1, -34 },
  { 644, 20, 20, 23, 2, -36 },
  { 694, 21, 23, 25, 2, -28 },
  { 755, 7, 11, 12, 2, -5 },
  { 765, 11, 5, 14, 2, -15 },
  { 772, 6, 7, 12, 3, -6 },
  { 778, 17, 34, 18, 1, -34 },
  { 851, 21, 34, 25, 2, -34 },
  { 941, 13, 34, 25, 3, -34 },
  { 997, 20, 34, 25, 2, -34 },
  { 1082, 20, 34, 25, 2, -34 },
  { 1167, 23, 34, 25, 1, -34 },
  { 1265, 19, 34, 25, 3, -34 },
  { 1346, 21, 34, 25, 2, -34 },
  { 1436, 21, 34, 25, 2, -34 },
  { 1526, 21, 34, 25, 2, -34 },
  { 1616, 20, 34, 25, 2, -34 },
  { 1701, 6, 27, 12, 3, -26 },
  { 1722, 7, 32, 12, 2, -26 },
  { 1750, 21, 23, 25, 2, -28 },
  { 1811, 20, 13, 25, 2, -23 },
  { 1844, 21, 23, 25, 2, -28 },
  { 1905, 18, 35, 19, 0, -34 },
  { 1984, 34, 38, 38, 2, -34 },
  { 2146, 28, 34, 28, 0, -34 },
  { 2265, 22, 34, 28, 4, -34 },
  { 2359, 22, 34, 27, 3, -34 },
  { 2453, 24, 34, 31, 4, -34 },
  { 2555, 17, 34, 24, 4, -34 },
  { 2628, 17, 34, 23, 4, -34 },
  { 2701, 25, 34, 31, 3, -34 },
  { 2808, 24, 34, 32, 4, -34 },
  { 2910, 12, 34, 16, 2, -34 },
  { 2961, 12, 43, 13, -3, -34 },
  { 3026, 23, 34, 27, 4, -34 },
  { 3124, 17, 34, 22, 4, -34 },
  { 3197, 32, 34, 40, 4, -34 },
  { 3333, 25, 34, 33, 4, -34 },
  { 3440, 27, 34, 33, 3, -34 },
  { 3555, 20, 34, 26, 4, -34 },
  { 3640, 27, 42, 33, 3, -34 },
  { 3782, 23, 34, 27, 4, -34 },
  { 3880, 20, 34, 24, 2, -34 },
  { 3965, 22, 34, 24, 1, -34 },
  { 4059, 23, 34, 31, 4, -34 },
  { 4157, 26, 34, 26, 0, -34 },
  { 4268, 40, 34, 41, 0, -34 },
  { 4438, 25, 34, 25, 0, -34 },
  { 4545, 25, 34, 25, 0, -34 },
  { 4652, 21, 34, 24, 1, -34 },
  { 4742, 11, 41, 15, 3, -34 },
  { 4799, 17, 34, 18, 1, -34 },
  { 4872, 11, 41, 15, 1, -34 },
  { 4929, 23, 21, 25, 1, -34 },
  { 4990, 20, 3, 20, 0, 4 },
  { 4998, 10, 8, 14, 2, -36 },
  { 5008, 19, 26, 24, 2, -26 },
  { 5070, 20, 36, 27, 4, -36 },
  { 5160, 18, 26, 21, 2, -26 },
  { 5219, 21, 36, 27, 2, -36 },
  { 5314, 20, 26, 24, 2, -26 },
  { 5379, 16, 36, 15, 1, -36 },
  { 5451, 21, 37, 27, 2, -26 },
  { 5549, 19, 36, 27, 4, -36 },
  { 5635, 6, 35, 12, 3, -35 },
  { 5662, 11, 46, 12, -2, -35 },
  { 5726, 20, 36, 24, 4, -36 },
  { 5816, 4, 36, 12, 4, -36 },
  { 5834, 33, 26, 40, 4, -26 },
  { 5942, 19, 26, 27, 4, -26 },
  { 6004, 22, 26, 26, 2, -26 },
  { 6076, 20, 37, 27, 4, -26 },
  { 6169, 21, 37, 27, 2, -26 },
  { 6267, 13, 26, 18, 4, -26 },
  { 6310, 17, 26, 20, 2, -26 },
  { 6366, 14, 31, 16, 1, -31 },
  { 6421, 20, 25, 27, 3, -25 },
  { 6484, 22, 25, 22, 0, -25 },
  { 6553, 34, 25, 35, 0, -25 },
  { 6660, 21, 25, 23, 1, -25 },
  { 6726, 22, 36, 22, 0, -25 },
  { 6825, 17, 25, 20, 1, -25 },
  { 6879, 15, 41, 18, 1, -34 },
  { 6956, 4, 47, 24, 10, -36 },
  { 6980, 14, 41, 18, 2, -34 },
  { 7052, 21, 7, 25, 2, -20 },
};

const GFXfont NotoSans_SemiCondensed_Medium47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium47pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM47PT7B_H_
