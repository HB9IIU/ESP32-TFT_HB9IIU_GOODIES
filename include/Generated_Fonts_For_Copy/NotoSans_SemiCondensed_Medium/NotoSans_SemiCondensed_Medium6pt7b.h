#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM6PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM6PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x7F, 0xD0, 0x5F, 0x3C, 0xD7, 0x8A, 0xA0, 0xE4, 0xBF,
  0x80, 0xEA, 0x40, 0x95, 0x80, 0x5E, 0x80, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x5A, 0xF6, 0xF0, 0xD5, 0xE5, 0x70, 0xE8, 0xF0, 0x6F, 0x90, 0xF8, 0xF0,
  0xFA, 0xF0, 0xE5, 0x20, 0xEA, 0xF0, 0xF5, 0xA0, 0xA0, 0xB0, 0x39, 0x80,
  0xFC, 0x8F, 0x00, 0xD9, 0x77, 0xF7, 0x47, 0x00, 0x46, 0xE9, 0xFF, 0x72,
  0x30, 0xD6, 0xE0, 0xFB, 0xFA, 0x7A, 0x97, 0xBE, 0xD0, 0xEB, 0xF8, 0xEF,
  0xAB, 0xBB, 0xBD, 0xB7, 0xD0, 0xF9, 0x96, 0xFA, 0xF9, 0x96, 0x30, 0xFF,
  0xE8, 0xF0, 0xE9, 0x20, 0x99, 0x96, 0xB5, 0x20, 0xAD, 0x74, 0xA0, 0xA9,
  0x50, 0xA9, 0x20, 0xE9, 0x70, 0xEA, 0xC0, 0x95, 0xD5, 0xC0, 0x54, 0xE0,
  0xC0, 0x7F, 0x80, 0x93, 0xDE, 0xF3, 0x80, 0x2E, 0xDE, 0xFF, 0x80, 0x6E,
  0x80, 0xF6, 0xF0, 0x93, 0xDA, 0xF0, 0xF8, 0x93, 0xEA, 0xF8, 0xFD, 0x6A,
  0xF6, 0x80, 0xF7, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xE8, 0xDC, 0xBB, 0xB7,
  0x80, 0xB9, 0x00, 0xBF, 0x50, 0xAA, 0x80, 0xB9, 0x60, 0xDC, 0x59, 0x40,
  0xFC, 0xD5, 0x80, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Medium6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 2, 0, -4 },
  { 2, 2, 1, 3, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 5, 4, 5, 0, -4 },
  { 10, 4, 4, 4, 0, -4 },
  { 12, 1, 1, 1, 0, -4 },
  { 13, 2, 5, 2, 0, -4 },
  { 15, 2, 5, 2, 0, -4 },
  { 17, 3, 3, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 2, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 2, 4, 2, 0, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 2, 4, 3, 0, -4 },
  { 28, 3, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 3, 4, 3, 0, -4 },
  { 34, 3, 4, 3, 0, -4 },
  { 36, 3, 4, 3, 0, -4 },
  { 38, 3, 4, 3, 0, -4 },
  { 40, 3, 4, 3, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 1, 3, 2, 0, -3 },
  { 45, 1, 4, 2, 0, -3 },
  { 46, 3, 3, 3, 0, -4 },
  { 48, 3, 2, 3, 0, -3 },
  { 49, 3, 3, 3, 0, -4 },
  { 51, 2, 4, 2, 0, -4 },
  { 52, 5, 5, 5, 0, -4 },
  { 56, 4, 4, 4, 0, -4 },
  { 58, 2, 4, 4, 1, -4 },
  { 59, 3, 4, 3, 0, -4 },
  { 61, 3, 4, 4, 1, -4 },
  { 63, 2, 4, 3, 1, -4 },
  { 64, 2, 4, 3, 1, -4 },
  { 65, 4, 4, 4, 0, -4 },
  { 67, 3, 4, 4, 1, -4 },
  { 69, 2, 4, 2, 0, -4 },
  { 70, 1, 5, 2, 0, -4 },
  { 71, 2, 4, 3, 1, -4 },
  { 72, 2, 4, 3, 1, -4 },
  { 73, 4, 4, 5, 1, -4 },
  { 75, 3, 4, 4, 1, -4 },
  { 77, 4, 4, 4, 0, -4 },
  { 79, 2, 4, 3, 1, -4 },
  { 80, 4, 5, 4, 0, -4 },
  { 83, 2, 4, 3, 1, -4 },
  { 84, 3, 4, 3, 0, -4 },
  { 86, 3, 4, 3, 0, -4 },
  { 88, 4, 4, 4, 0, -4 },
  { 90, 3, 4, 3, 0, -4 },
  { 92, 5, 4, 5, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 3, 4, 3, 0, -4 },
  { 99, 3, 4, 3, 0, -4 },
  { 101, 2, 5, 2, 0, -4 },
  { 103, 2, 4, 2, 0, -4 },
  { 104, 2, 5, 2, 0, -4 },
  { 106, 3, 2, 3, 0, -4 },
  { 107, 3, 1, 3, 0, 0 },
  { 108, 2, 1, 2, 0, -5 },
  { 109, 3, 3, 3, 0, -3 },
  { 111, 3, 5, 3, 0, -5 },
  { 113, 3, 3, 3, 0, -3 },
  { 115, 3, 5, 3, 0, -5 },
  { 117, 3, 3, 3, 0, -3 },
  { 119, 2, 5, 2, 0, -5 },
  { 121, 3, 4, 3, 0, -3 },
  { 123, 3, 5, 3, 0, -5 },
  { 125, 1, 4, 2, 0, -4 },
  { 126, 1, 5, 2, 0, -4 },
  { 127, 3, 5, 3, 0, -5 },
  { 129, 1, 5, 2, 0, -5 },
  { 130, 5, 3, 5, 0, -3 },
  { 132, 3, 3, 3, 0, -3 },
  { 134, 3, 3, 3, 0, -3 },
  { 136, 3, 4, 3, 0, -3 },
  { 138, 3, 4, 3, 0, -3 },
  { 140, 2, 3, 2, 0, -3 },
  { 141, 2, 3, 3, 0, -3 },
  { 142, 2, 4, 2, 0, -4 },
  { 143, 3, 3, 3, 0, -3 },
  { 145, 3, 3, 3, 0, -3 },
  { 147, 4, 3, 4, 0, -3 },
  { 149, 3, 3, 3, 0, -3 },
  { 151, 3, 4, 3, 0, -3 },
  { 153, 2, 3, 3, 0, -3 },
  { 154, 2, 5, 2, 0, -4 },
  { 156, 1, 6, 3, 1, -5 },
  { 157, 2, 5, 2, 0, -4 },
  { 159, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Medium6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium6pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM6PT7B_H_
