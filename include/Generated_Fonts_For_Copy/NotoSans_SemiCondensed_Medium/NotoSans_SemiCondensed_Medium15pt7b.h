#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM15PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xD9, 0x99, 0x12, 0x12, 0x12, 0x7F, 0x7F, 0x34,
  0x24, 0xFF, 0x24, 0x24, 0x6C, 0x21, 0xFE, 0x68, 0xE1, 0xE3, 0xC9, 0xAF,
  0xE2, 0x08, 0x61, 0x2C, 0xC9, 0x22, 0x58, 0x94, 0xAF, 0xF6, 0xA4, 0x69,
  0x12, 0x4C, 0x92, 0x1C, 0x38, 0x34, 0x13, 0x09, 0x07, 0x83, 0x83, 0x6D,
  0x1E, 0x86, 0x67, 0x1E, 0xE0, 0xEA, 0x2B, 0x69, 0x24, 0x93, 0x26, 0xC6,
  0x22, 0x33, 0x33, 0x33, 0x26, 0xC0, 0x22, 0x9F, 0xCC, 0x5B, 0x20, 0x30,
  0xC3, 0x3F, 0x30, 0xC3, 0x00, 0xFA, 0xFF, 0xF0, 0x0C, 0x21, 0x84, 0x10,
  0xC2, 0x18, 0x61, 0x0C, 0x00, 0x73, 0xEC, 0xE1, 0x86, 0x18, 0x61, 0x8F,
  0x37, 0x80, 0x13, 0xD9, 0x11, 0x11, 0x11, 0x10, 0x73, 0x60, 0xC3, 0x0C,
  0x61, 0x08, 0x43, 0x0F, 0xC0, 0x73, 0x70, 0xC3, 0x19, 0xC0, 0xC3, 0x0E,
  0x3F, 0x80, 0x04, 0x0C, 0x1C, 0x14, 0x24, 0x64, 0x44, 0xFF, 0xFF, 0x04,
  0x04, 0xFB, 0xEC, 0x30, 0xF3, 0xE0, 0xC1, 0x0E, 0x3F, 0x80, 0x3D, 0xDC,
  0x20, 0xBB, 0xB8, 0x61, 0x87, 0x37, 0x80, 0xFF, 0xF0, 0xC2, 0x18, 0x61,
  0x0C, 0x21, 0x86, 0x00, 0x7B, 0x38, 0xF3, 0x79, 0xCC, 0xE1, 0x87, 0x37,
  0x80, 0x73, 0x68, 0xE1, 0x87, 0x37, 0x43, 0x0C, 0x6F, 0x00, 0xF0, 0x0F,
  0x6C, 0x00, 0x1B, 0x58, 0x04, 0x77, 0x30, 0xE0, 0x60, 0x40, 0xFC, 0x00,
  0x3F, 0x83, 0x83, 0x83, 0x1B, 0x88, 0x00, 0x7B, 0x60, 0xC3, 0x18, 0xC2,
  0x08, 0x00, 0x83, 0x00, 0x0E, 0x0C, 0x64, 0x0F, 0x3D, 0x92, 0x64, 0x99,
  0x26, 0x49, 0x9D, 0xF0, 0x06, 0x00, 0xFC, 0x18, 0x0E, 0x05, 0x06, 0x83,
  0x61, 0x31, 0x88, 0xFE, 0x43, 0x60, 0xB0, 0x60, 0xF9, 0xFF, 0x1E, 0x3C,
  0x5F, 0xB1, 0xE1, 0xC7, 0x8F, 0xF0, 0x1E, 0xFF, 0x06, 0x0C, 0x10, 0x30,
  0x60, 0xC0, 0xC4, 0xF8, 0xF8, 0xFE, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC2, 0xCE, 0xF8, 0xFF, 0xFC, 0x30, 0xC3, 0xFC, 0x30, 0xC3, 0x0F, 0xC0,
  0xFF, 0xFC, 0x30, 0xC3, 0xEF, 0xB0, 0xC3, 0x0C, 0x00, 0x1E, 0x7F, 0x40,
  0xC0, 0xC0, 0x8F, 0xCF, 0xC3, 0xC3, 0x63, 0x3F, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xF9, 0x24, 0x92, 0x4B, 0x80,
  0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC2, 0xC6, 0xCC, 0xD8, 0xD0,
  0xF0, 0xD8, 0xC8, 0xCC, 0xC6, 0xC3, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0F, 0xC0, 0xE0, 0xF8, 0x3E, 0x1F, 0xC5, 0xF1, 0x74, 0xDD, 0xA7,
  0x69, 0xCE, 0x73, 0x1C, 0xC4, 0xC1, 0xE1, 0xE1, 0xF1, 0xD9, 0xD9, 0xCD,
  0xCD, 0xC7, 0xC3, 0xC3, 0x3C, 0x3F, 0xB0, 0xD8, 0x2C, 0x1C, 0x0F, 0x07,
  0x83, 0xC3, 0x31, 0x8F, 0x80, 0xF9, 0xFB, 0x1E, 0x3C, 0x79, 0xBE, 0x60,
  0xC1, 0x83, 0x00, 0x3C, 0x3F, 0xB0, 0xD8, 0x2C, 0x1C, 0x0F, 0x07, 0x83,
  0xC3, 0x31, 0x8F, 0x80, 0xC0, 0x20, 0x18, 0xF9, 0xFB, 0x1E, 0x3C, 0x7F,
  0xBE, 0x66, 0xCD, 0x8F, 0x18, 0x7B, 0xF8, 0x20, 0xC1, 0xC1, 0x83, 0x0E,
  0x3F, 0x80, 0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0xC1,
  0xC3, 0x43, 0x62, 0x66, 0x26, 0x24, 0x34, 0x1C, 0x1C, 0x18, 0xC2, 0x1E,
  0x38, 0xD1, 0xC4, 0x8A, 0x26, 0x53, 0x36, 0xD8, 0xB6, 0x85, 0x14, 0x28,
  0xE1, 0xC7, 0x06, 0x30, 0xC3, 0x62, 0x26, 0x3C, 0x1C, 0x18, 0x1C, 0x3C,
  0x66, 0x62, 0xC3, 0xC3, 0x42, 0x66, 0x24, 0x3C, 0x38, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x7E, 0xFC, 0x10, 0x60, 0x83, 0x0C, 0x10, 0x60, 0x83, 0xF8,
  0xFB, 0x6D, 0xB6, 0xDB, 0x6E, 0xC1, 0x04, 0x18, 0x20, 0xC3, 0x04, 0x18,
  0x20, 0xC0, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x10, 0x18, 0x38,
  0x24, 0x64, 0x42, 0xC3, 0xFE, 0xCC, 0xFA, 0x30, 0xDF, 0xCE, 0x38, 0xFF,
  0xC1, 0x83, 0x07, 0xEC, 0x58, 0xF1, 0xE3, 0xC7, 0x9A, 0xF0, 0x7E, 0x21,
  0x08, 0x63, 0x2F, 0x04, 0x10, 0x5D, 0xCE, 0x18, 0x61, 0x87, 0x37, 0x40,
  0x7B, 0x38, 0x7F, 0x82, 0x0C, 0x5F, 0x3B, 0x19, 0xF6, 0x31, 0x8C, 0x63,
  0x18, 0x77, 0x38, 0x61, 0x86, 0x1C, 0xDD, 0x04, 0x1F, 0xCC, 0xC3, 0x0C,
  0x3F, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x40, 0xE3, 0xFF, 0xFC, 0x32, 0x03,
  0x33, 0x33, 0x33, 0x33, 0x3E, 0x40, 0xC1, 0x83, 0x06, 0x6D, 0x9A, 0x3C,
  0x68, 0xD9, 0x9B, 0x18, 0xFF, 0xFF, 0xFC, 0xBF, 0xD9, 0xCF, 0x11, 0xE2,
  0x3C, 0x47, 0x88, 0xF1, 0x1E, 0x23, 0xBF, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0x79, 0x9A, 0x14, 0x38, 0x70, 0xB3, 0x3C, 0xBD, 0x8B, 0x1E, 0x3C, 0x78,
  0xF3, 0x7E, 0xC1, 0x83, 0x06, 0x00, 0x77, 0x38, 0x61, 0x86, 0x1C, 0xDD,
  0x04, 0x10, 0x41, 0xBF, 0x31, 0x8C, 0x63, 0x18, 0xFC, 0x21, 0xC3, 0x8E,
  0x7E, 0x23, 0x3E, 0xC6, 0x31, 0x8C, 0x61, 0xC0, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0xDD, 0xC6, 0x8D, 0x13, 0x62, 0xC5, 0x0E, 0x0C, 0xC6, 0x69, 0xCD,
  0x29, 0x35, 0x26, 0xBC, 0x73, 0x8C, 0x61, 0x8C, 0xC6, 0xD8, 0xE1, 0xC3,
  0x85, 0x99, 0x63, 0xC6, 0x8D, 0x13, 0x62, 0xC5, 0x0E, 0x0C, 0x10, 0x63,
  0x86, 0x00, 0x7C, 0x21, 0x84, 0x31, 0x84, 0x3F, 0x19, 0xCC, 0x63, 0x1B,
  0x8C, 0x31, 0x8C, 0x61, 0x80, 0xFF, 0xFE, 0x8C, 0x44, 0x46, 0x37, 0x64,
  0x44, 0xC0, 0xF6, 0x70,
};

const GFXglyph NotoSans_SemiCondensed_Medium15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 4, 4, 6, 1, -11 },
  { 6, 8, 11, 9, 0, -11 },
  { 17, 6, 12, 8, 1, -11 },
  { 26, 10, 11, 12, 1, -11 },
  { 40, 9, 11, 10, 1, -11 },
  { 53, 2, 4, 3, 1, -11 },
  { 54, 3, 13, 5, 1, -11 },
  { 59, 4, 13, 5, 0, -11 },
  { 66, 6, 6, 7, 1, -11 },
  { 71, 6, 7, 8, 1, -9 },
  { 77, 2, 4, 4, 1, -2 },
  { 78, 4, 2, 5, 0, -5 },
  { 79, 2, 2, 4, 1, -2 },
  { 80, 6, 11, 6, 0, -11 },
  { 89, 6, 11, 8, 1, -11 },
  { 98, 4, 11, 8, 1, -11 },
  { 104, 6, 11, 8, 1, -11 },
  { 113, 6, 11, 8, 1, -11 },
  { 122, 8, 11, 8, 0, -11 },
  { 133, 6, 11, 8, 1, -11 },
  { 142, 6, 11, 8, 1, -11 },
  { 151, 6, 11, 8, 1, -11 },
  { 160, 6, 11, 8, 1, -11 },
  { 169, 6, 11, 8, 1, -11 },
  { 178, 2, 8, 4, 1, -8 },
  { 180, 3, 10, 4, 0, -8 },
  { 184, 6, 7, 8, 1, -9 },
  { 190, 6, 4, 8, 1, -7 },
  { 193, 6, 7, 8, 1, -9 },
  { 199, 6, 11, 6, 0, -11 },
  { 208, 10, 12, 12, 1, -11 },
  { 223, 9, 11, 9, 0, -11 },
  { 236, 7, 11, 9, 1, -11 },
  { 246, 7, 11, 9, 1, -11 },
  { 256, 8, 11, 10, 1, -11 },
  { 267, 6, 11, 8, 1, -11 },
  { 276, 6, 11, 7, 1, -11 },
  { 285, 8, 11, 10, 1, -11 },
  { 296, 8, 11, 10, 1, -11 },
  { 307, 3, 11, 5, 1, -11 },
  { 312, 4, 14, 4, -1, -11 },
  { 319, 8, 11, 9, 1, -11 },
  { 330, 6, 11, 7, 1, -11 },
  { 339, 10, 11, 13, 1, -11 },
  { 353, 8, 11, 11, 1, -11 },
  { 364, 9, 11, 11, 1, -11 },
  { 377, 7, 11, 8, 1, -11 },
  { 387, 9, 14, 11, 1, -11 },
  { 403, 7, 11, 9, 1, -11 },
  { 413, 6, 11, 8, 1, -11 },
  { 422, 7, 11, 8, 0, -11 },
  { 432, 8, 11, 10, 1, -11 },
  { 443, 8, 11, 8, 0, -11 },
  { 454, 13, 11, 13, 0, -11 },
  { 472, 8, 11, 8, 0, -11 },
  { 483, 8, 11, 8, 0, -11 },
  { 494, 7, 11, 8, 0, -11 },
  { 504, 3, 13, 5, 1, -11 },
  { 509, 6, 11, 6, 0, -11 },
  { 518, 4, 13, 5, 0, -11 },
  { 525, 8, 7, 8, 0, -11 },
  { 532, 7, 1, 6, 0, 1 },
  { 533, 3, 2, 4, 1, -11 },
  { 534, 6, 8, 8, 1, -8 },
  { 540, 7, 11, 8, 1, -11 },
  { 550, 5, 8, 7, 1, -8 },
  { 555, 6, 11, 8, 1, -11 },
  { 564, 6, 8, 8, 1, -8 },
  { 570, 5, 11, 5, 0, -11 },
  { 577, 6, 12, 8, 1, -8 },
  { 586, 6, 11, 9, 1, -11 },
  { 595, 2, 11, 4, 1, -11 },
  { 598, 4, 15, 4, -1, -11 },
  { 606, 7, 11, 8, 1, -11 },
  { 616, 2, 11, 4, 1, -11 },
  { 619, 11, 8, 13, 1, -8 },
  { 630, 6, 8, 9, 1, -8 },
  { 636, 7, 8, 8, 1, -8 },
  { 643, 7, 12, 8, 1, -8 },
  { 654, 6, 12, 8, 1, -8 },
  { 663, 5, 8, 6, 1, -8 },
  { 668, 5, 8, 7, 1, -8 },
  { 673, 5, 10, 5, 0, -10 },
  { 680, 6, 8, 9, 1, -8 },
  { 686, 7, 8, 7, 0, -8 },
  { 693, 11, 8, 11, 0, -8 },
  { 704, 7, 8, 7, 0, -8 },
  { 711, 7, 12, 7, 0, -8 },
  { 722, 6, 8, 6, 0, -8 },
  { 728, 5, 13, 6, 0, -11 },
  { 737, 1, 15, 8, 3, -11 },
  { 739, 4, 13, 6, 1, -11 },
  { 746, 6, 2, 8, 1, -6 },
};

const GFXfont NotoSans_SemiCondensed_Medium15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium15pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM15PT7B_H_
