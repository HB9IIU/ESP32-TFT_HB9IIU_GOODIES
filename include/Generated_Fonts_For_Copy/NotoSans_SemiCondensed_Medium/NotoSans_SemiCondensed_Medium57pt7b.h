#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM57PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xF7, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7C, 0x70, 0xFE, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0x83, 0xF7, 0xC1,
  0xFB, 0xE0, 0x7D, 0xF0, 0x3E, 0xF8, 0x1F, 0x7C, 0x0F, 0xBE, 0x07, 0xDF,
  0x03, 0xEF, 0x81, 0xF7, 0xC0, 0xFB, 0xE0, 0x78, 0xF0, 0x3C, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x7C, 0x03, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x0F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x01, 0xFF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0x80, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1E,
  0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x81, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFE, 0x7F, 0xFD, 0xFC, 0xFE, 0x3C, 0x1C, 0xFC, 0x3C,
  0x00, 0xFC, 0x3C, 0x00, 0xFC, 0x3C, 0x00, 0xFC, 0x3C, 0x00, 0xFC, 0x3C,
  0x00, 0xFC, 0x3C, 0x00, 0xFE, 0x3C, 0x00, 0x7F, 0xBC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3D, 0xFE, 0x00, 0x3C,
  0x7F, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x3F, 0x00, 0x3C, 0x1F, 0x00, 0x3C,
  0x1F, 0x00, 0x3C, 0x3F, 0x80, 0x3C, 0x3F, 0xF0, 0x3C, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80,
  0x07, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x07, 0xFF,
  0xC0, 0x07, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x03,
  0xE0, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x00,
  0x78, 0x0F, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x78, 0x00, 0x3E, 0x03,
  0xE0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x80, 0xF8, 0x3E,
  0x00, 0x07, 0xC0, 0x7C, 0x1E, 0x00, 0x03, 0xE0, 0x3E, 0x1F, 0x00, 0x01,
  0xF0, 0x1F, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x0F, 0x83, 0xF0, 0x3C, 0x0F,
  0x87, 0xC7, 0xFC, 0x1F, 0x07, 0xC7, 0xC7, 0xFF, 0x0F, 0x83, 0xE3, 0xE3,
  0xFF, 0xC3, 0xE3, 0xE3, 0xE3, 0xE3, 0xE1, 0xFF, 0xF1, 0xF1, 0xE0, 0xF8,
  0x7F, 0xF1, 0xF1, 0xF0, 0x7C, 0x1F, 0xF0, 0xF8, 0xF8, 0x1E, 0x07, 0xF0,
  0xF8, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x3C, 0x07, 0xC0, 0x00, 0x7C, 0x1E,
  0x03, 0xE0, 0x00, 0x3E, 0x0F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0xF8,
  0x00, 0x1F, 0x03, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xE0, 0x3E, 0x00, 0x0F,
  0x80, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0x3E,
  0x07, 0xC0, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0x83, 0xE0,
  0x01, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x01, 0xF8, 0x1F, 0xFF, 0x80, 0x3F, 0x07, 0xFF, 0xF8, 0x07, 0xE1,
  0xFE, 0x7F, 0x01, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x0F, 0xE0, 0x7F, 0x07,
  0xE1, 0xF8, 0x07, 0xF1, 0xF8, 0x3F, 0x00, 0x7F, 0x3F, 0x0F, 0xE0, 0x07,
  0xFF, 0xE1, 0xF8, 0x00, 0x7F, 0xF8, 0x3F, 0x00, 0x0F, 0xFF, 0x07, 0xF0,
  0x00, 0xFF, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0xFE, 0x07, 0xFF, 0xFF, 0x1F, 0xE0, 0x3F, 0xFF,
  0xC1, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x05, 0x00, 0x00, 0x00, 0xFE,
  0xFD, 0xFB, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x8F,
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80,
  0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0,
  0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x70, 0x3C, 0x0F, 0x7F, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xC3, 0xF0,
  0x0F, 0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF0, 0x03, 0x80, 0xC0,
  0x00, 0x80, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x8F, 0xCF, 0xE7, 0xE3,
  0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0x87, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7D, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x18, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFE, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x9F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF7,
  0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0x7C, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0xC0,
  0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7C, 0x7C,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x1F, 0x83,
  0xF8, 0x1F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFF, 0x7F, 0xBF, 0xFF, 0x3F, 0x7C, 0x3F, 0x38, 0x3F, 0x10, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3,
  0xF8, 0x0F, 0xF0, 0xF0, 0x01, 0xF8, 0x30, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xF0, 0x0F, 0xF0,
  0xE0, 0x01, 0xF8, 0x20, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xA0, 0x00, 0x1F, 0xDE, 0x00, 0x1F, 0xEF, 0xF9, 0xFF,
  0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0x00, 0x14, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x7E,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x7C, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x07,
  0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00,
  0x7C, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0,
  0x7C, 0x00, 0x7E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x10, 0x03, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x80,
  0x00, 0xFE, 0xE0, 0x03, 0xFC, 0xFF, 0xBF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x01, 0xD0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0xFC,
  0x7F, 0xE0, 0xF9, 0xFF, 0xF8, 0xFB, 0xFF, 0xFC, 0xFB, 0xFF, 0xFC, 0xFF,
  0xC1, 0xFE, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0xFE, 0x1F,
  0xF7, 0xFC, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0x7F, 0xE1, 0xFC, 0x03, 0xF8, 0xFC, 0x00, 0xFC,
  0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x07,
  0xC7, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF8, 0x7E, 0x01,
  0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0xF3, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0xDF, 0xF0, 0x3F, 0x83, 0xFC, 0x3F, 0x80, 0xFE, 0x1F, 0x80, 0x3F, 0x9F,
  0x80, 0x0F, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xE0, 0x07, 0xE3, 0xFC, 0x0F, 0xF1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0xE0, 0xFC, 0x03, 0xF8,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x9F, 0x00, 0x07,
  0xDF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80,
  0x0F, 0xEF, 0xE0, 0x0F, 0xF3, 0xF8, 0x0F, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xBF, 0x07, 0xFF, 0x9F, 0x80, 0xFF, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x01, 0x87, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7D,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9,
  0xFC, 0xFC, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0xCF,
  0xE7, 0xE3, 0xF1, 0xF8, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x0F, 0x87,
  0xC0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3C, 0x03, 0xF9, 0x80, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x07, 0xF8, 0x07, 0xC3, 0xE0,
  0x0F, 0xFF, 0x81, 0xE1, 0xF0, 0x1F, 0xFF, 0xC0, 0xF8, 0xF0, 0x1F, 0xFF,
  0xE0, 0x7C, 0xF8, 0x0F, 0xC0, 0xF0, 0x1E, 0x7C, 0x0F, 0xC0, 0xF8, 0x0F,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xBE, 0x07, 0xC0, 0x3E, 0x03, 0xFF, 0x03,
  0xE0, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x0F, 0x80, 0xFF, 0xC0, 0xF0, 0x07,
  0xC0, 0x7F, 0xE0, 0xF8, 0x03, 0xE0, 0x3F, 0xE0, 0x7C, 0x01, 0xF0, 0x1E,
  0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x78, 0x1F, 0x00, 0x7C, 0x07, 0xBE, 0x07,
  0x80, 0x3E, 0x07, 0xDF, 0x03, 0xE0, 0x3F, 0x03, 0xEF, 0x81, 0xF0, 0x1F,
  0x81, 0xE7, 0xC0, 0xFC, 0x1F, 0xC1, 0xF3, 0xE0, 0x3F, 0x1E, 0xF9, 0xF0,
  0xF0, 0x1F, 0xFF, 0x7F, 0xF8, 0x7C, 0x07, 0xFF, 0x1F, 0xF8, 0x3E, 0x01,
  0xFF, 0x07, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x04, 0x00, 0x07, 0xF8,
  0x00, 0x0E, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x0F,
  0xCF, 0x80, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F,
  0x01, 0xFF, 0xCF, 0xC0, 0x07, 0xF3, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F,
  0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFC,
  0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x8F, 0xC0, 0x1F, 0xF3, 0xF0, 0x01,
  0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFB, 0xF0, 0x03, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x3C, 0x0F, 0xF0, 0x00, 0xC1, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x0C, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0C, 0x00,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x7E, 0x0F, 0xFF, 0xC3, 0xF0, 0x03,
  0xFE, 0x1F, 0x80, 0x07, 0xF8, 0xFC, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x7F,
  0x3F, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0xE7,
  0xE0, 0x01, 0xFE, 0x3F, 0x00, 0x1F, 0xE1, 0xF8, 0x07, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xC0, 0x1F, 0x03, 0xFE, 0x00, 0x06, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x3F, 0x3F, 0xC0, 0x00,
  0x7E, 0x3F, 0xC0, 0x00, 0xFC, 0x3F, 0xC0, 0x01, 0xF8, 0x7F, 0xE0, 0x03,
  0xF0, 0x7F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xD0, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0xA0, 0xFF, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00,
  0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0,
  0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFE,
  0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0xFE, 0x1F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF8,
  0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC,
  0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01,
  0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFB, 0xE0, 0x00, 0x1F, 0x7F, 0xF7, 0xC0, 0x00, 0x3E,
  0xFF, 0xEF, 0xC0, 0x00, 0x7D, 0xFF, 0xCF, 0x80, 0x01, 0xF3, 0xFF, 0x9F,
  0x00, 0x03, 0xE7, 0xFF, 0x3F, 0x00, 0x07, 0xCF, 0xFE, 0x3E, 0x00, 0x1F,
  0x1F, 0xFC, 0x7C, 0x00, 0x3E, 0x3F, 0xF8, 0xFC, 0x00, 0x7C, 0x7F, 0xF0,
  0xF8, 0x01, 0xF0, 0xFF, 0xE1, 0xF0, 0x03, 0xE1, 0xFF, 0xC3, 0xF0, 0x07,
  0xC3, 0xFF, 0x83, 0xE0, 0x1F, 0x07, 0xFF, 0x07, 0xC0, 0x3E, 0x0F, 0xFE,
  0x0F, 0xC0, 0x7C, 0x1F, 0xFC, 0x0F, 0x81, 0xF0, 0x3F, 0xF8, 0x1F, 0x03,
  0xE0, 0x7F, 0xF0, 0x3F, 0x07, 0xC0, 0xFF, 0xE0, 0x3E, 0x1F, 0x01, 0xFF,
  0xC0, 0x7C, 0x3E, 0x03, 0xFF, 0x80, 0xFC, 0x7C, 0x07, 0xFF, 0x00, 0xF9,
  0xF0, 0x0F, 0xFE, 0x01, 0xF3, 0xE0, 0x1F, 0xFC, 0x03, 0xF7, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0x80, 0x1F, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xEF, 0xC0, 0x01, 0xFF, 0xBF, 0x80,
  0x07, 0xFE, 0x7E, 0x00, 0x1F, 0xF9, 0xFC, 0x00, 0x7F, 0xE3, 0xF0, 0x01,
  0xFF, 0x87, 0xE0, 0x07, 0xFE, 0x1F, 0xC0, 0x1F, 0xF8, 0x3F, 0x00, 0x7F,
  0xE0, 0xFE, 0x01, 0xFF, 0x81, 0xF8, 0x07, 0xFE, 0x07, 0xF0, 0x1F, 0xF8,
  0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x81, 0xFF, 0x80, 0x7E, 0x07, 0xFE, 0x01,
  0xFC, 0x1F, 0xF8, 0x03, 0xF8, 0x7F, 0xE0, 0x07, 0xE1, 0xFF, 0x80, 0x1F,
  0xC7, 0xFE, 0x00, 0x3F, 0x1F, 0xF8, 0x00, 0xFE, 0x7F, 0xE0, 0x01, 0xF9,
  0xFF, 0x80, 0x07, 0xF7, 0xFE, 0x00, 0x0F, 0xDF, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xE0, 0x3F,
  0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC, 0x3F, 0xFC, 0xFC,
  0x01, 0xFE, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0xFE, 0xFC, 0x03, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x7E,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFB,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F,
  0xC0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC1, 0xF8, 0x1F, 0xFC, 0x3F, 0x00, 0x7F, 0x87, 0xE0, 0x03, 0xF8,
  0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x07,
  0xF0, 0x7E, 0x0F, 0xFE, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8,
  0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC,
  0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x8F, 0xC0,
  0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xF0, 0x1F, 0x1F, 0xC0, 0x06,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF7, 0x80, 0x1F, 0xEF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x3F,
  0xFF, 0x00, 0x02, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E, 0x7F,
  0x00, 0x0F, 0xE7, 0xFC, 0x03, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x40, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xDF,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0x78, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xBE, 0x00, 0x3F,
  0x07, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xEF, 0x80, 0x1F,
  0x81, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xF3, 0xF0, 0x07,
  0xE0, 0x3F, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x7C, 0x03,
  0xF0, 0x0F, 0xC0, 0x3E, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x1F, 0x80,
  0xFC, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x0F, 0x83, 0xE0,
  0x7E, 0x00, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0xFC,
  0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x1F,
  0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x03,
  0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0xF8, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x1F, 0x7E, 0x00, 0x03, 0xEF, 0x80, 0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xC0,
  0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0xF7, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0,
  0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x03,
  0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xBE, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x3E, 0x03, 0xE0, 0x07,
  0xC0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0xF8,
  0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFE, 0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x0F, 0xE3, 0xFE, 0x06, 0x00, 0xFE, 0x08,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xF0, 0x3F, 0x7F, 0x80, 0x3F, 0x7F,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x7E, 0x01, 0xFF, 0x7F,
  0x87, 0xFF, 0x7F, 0xFF, 0xBF, 0x3F, 0xFF, 0x9F, 0x1F, 0xFF, 0x1F, 0x0F,
  0xFC, 0x1F, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0xE0, 0x3F,
  0x1F, 0xFC, 0x0F, 0xCF, 0xFF, 0x83, 0xF7, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3F, 0xE0, 0x3F, 0xCF, 0xF0, 0x07, 0xF3, 0xF8, 0x00, 0xFC, 0xFE, 0x00,
  0x3F, 0xBF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0, 0x01, 0xFB, 0xF8,
  0x00, 0xFC, 0xFF, 0x00, 0x3F, 0x3F, 0xE0, 0x1F, 0xCF, 0xFE, 0x1F, 0xE3,
  0xFF, 0xFF, 0xF8, 0xF9, 0xFF, 0xFC, 0x3E, 0x3F, 0xFE, 0x0F, 0x83, 0xFE,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xE0, 0x30, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x8F, 0xFC, 0x7C, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0x80, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1F, 0xE1, 0xF8, 0x3F, 0xFC, 0xFC,
  0x3F, 0xFF, 0x7E, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xC0, 0x7F,
  0xDF, 0xC0, 0x1F, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xF7, 0xF0, 0x07, 0xF9,
  0xFC, 0x07, 0xFC, 0xFF, 0x8F, 0xFE, 0x3F, 0xFF, 0xDF, 0x0F, 0xFF, 0xCF,
  0x83, 0xFF, 0xC7, 0xC0, 0xFF, 0xC3, 0xE0, 0x0E, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xE3,
  0xFC, 0x3F, 0x80, 0xFC, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x06, 0x1F, 0xF0, 0x7E, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x05, 0x00, 0x00, 0x0E,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x7F,
  0x8C, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x01, 0xFE, 0x0F, 0x83, 0xFF, 0xC7, 0xC3, 0xFF, 0xF3, 0xE3, 0xFF, 0xFD,
  0xF3, 0xFF, 0xFF, 0xF9, 0xFC, 0x07, 0xFD, 0xFC, 0x01, 0xFE, 0xFC, 0x00,
  0x7F, 0x7E, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7E,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x9F, 0xC0, 0x3F, 0xCF, 0xF8, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFD, 0xF8, 0x3F, 0xFC, 0xFC, 0x0F, 0xFC,
  0x7E, 0x00, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF2, 0x00, 0x01, 0xF8, 0xC0,
  0x03, 0xFC, 0x7E, 0x0F, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0xE0,
  0xFC, 0x7F, 0xF8, 0xFD, 0xFF, 0xFC, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7D, 0xFB, 0xFF, 0xFF, 0xCF, 0x84,
  0x00, 0x00, 0x00, 0x07, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xF8, 0x01, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x1F, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x7F, 0x8F, 0xEF,
  0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x87, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x07, 0xF7,
  0xE0, 0x03, 0xF3, 0xF0, 0x03, 0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x03, 0xF8,
  0x7E, 0x03, 0xF8, 0x3F, 0x03, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xC1, 0xF8,
  0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xFC, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x07, 0xFD, 0xF8, 0x03, 0xFC, 0xFE, 0x01, 0xFC, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFE, 0x0F,
  0xC0, 0x3F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xF1, 0xF8, 0x01, 0xFC,
  0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x3F, 0xE0, 0x1F, 0xF0,
  0x7C, 0x7F, 0xF8, 0x3F, 0xFE, 0x3E, 0x7F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xFF, 0xDF, 0xFF, 0xF7, 0xFC, 0x07, 0xFF,
  0x03, 0xFB, 0xFC, 0x03, 0xFE, 0x00, 0xFD, 0xFC, 0x00, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00,
  0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xE0,
  0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x80, 0x07, 0xC0,
  0x03, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0x80,
  0x07, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xFF,
  0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0xF8, 0x3F,
  0xE0, 0xF8, 0x7F, 0xF8, 0xF9, 0xFF, 0xFC, 0xF9, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F,
  0xE0, 0x3F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x1F,
  0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x1F, 0xE0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x20, 0x00, 0xF8, 0x3F, 0xE0, 0x3E, 0x1F, 0xFC, 0x0F, 0x8F, 0xFF,
  0x83, 0xF7, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0x3F, 0xCF, 0xF0,
  0x07, 0xF3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xEF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF,
  0x80, 0x07, 0xEF, 0xE0, 0x03, 0xFB, 0xF8, 0x00, 0xFC, 0xFF, 0x00, 0x7F,
  0x3F, 0xE0, 0x3F, 0xCF, 0xFF, 0x3F, 0xE3, 0xFF, 0xFF, 0xF0, 0xFD, 0xFF,
  0xFC, 0x3F, 0x3F, 0xFE, 0x0F, 0xC3, 0xFE, 0x03, 0xF0, 0x08, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x0F, 0x83, 0xFF, 0xC7,
  0xC3, 0xFF, 0xF3, 0xE3, 0xFF, 0xFD, 0xF3, 0xFF, 0xFF, 0xF9, 0xFC, 0x07,
  0xFD, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x7F,
  0x9F, 0xC0, 0x7F, 0xCF, 0xF8, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFD,
  0xF8, 0x3F, 0xFC, 0xFC, 0x0F, 0xFC, 0x7E, 0x00, 0xC0, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0xF8, 0x1F, 0xFC, 0x3F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF,
  0x9F, 0xFF, 0xFF, 0x87, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7F, 0xFF, 0xE7, 0xF8, 0x7E, 0x3F, 0x00,
  0x71, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xF3, 0x00, 0x1F, 0x9F, 0x03, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x08, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0xC1, 0xFF, 0xE0,
  0xFF, 0xF0, 0x3F, 0xF8, 0x0F, 0xFC, 0x00, 0xE0, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x7F,
  0x01, 0xFF, 0x7F, 0xEF, 0xFF, 0x3F, 0xFF, 0xDF, 0x3F, 0xFF, 0x9F, 0x1F,
  0xFF, 0x1F, 0x07, 0xFE, 0x1F, 0x00, 0x40, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3E,
  0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xBF, 0x00, 0x3F, 0xC0, 0x0F, 0xDF, 0x80, 0x1F, 0xE0,
  0x07, 0xE7, 0xC0, 0x0F, 0xF0, 0x03, 0xF3, 0xF0, 0x07, 0xFC, 0x01, 0xF1,
  0xF8, 0x07, 0xFE, 0x01, 0xF8, 0xFC, 0x03, 0xFF, 0x00, 0xFC, 0x3E, 0x01,
  0xE7, 0xC0, 0x7E, 0x1F, 0x81, 0xF3, 0xE0, 0x3E, 0x0F, 0xC0, 0xF9, 0xF0,
  0x3F, 0x07, 0xE0, 0x7C, 0xF8, 0x1F, 0x81, 0xF0, 0x3E, 0x3E, 0x0F, 0x80,
  0xFC, 0x3E, 0x1F, 0x07, 0xC0, 0x7E, 0x1F, 0x0F, 0x87, 0xE0, 0x3F, 0x0F,
  0x87, 0xC3, 0xF0, 0x0F, 0x87, 0xC1, 0xF1, 0xF0, 0x07, 0xE7, 0xC0, 0xF8,
  0xF8, 0x03, 0xF3, 0xE0, 0x7C, 0xFC, 0x01, 0xF9, 0xF0, 0x3E, 0x7E, 0x00,
  0x7C, 0xF8, 0x0F, 0x3E, 0x00, 0x3E, 0x78, 0x07, 0xDF, 0x00, 0x1F, 0x7C,
  0x03, 0xEF, 0x80, 0x0F, 0xFE, 0x01, 0xF7, 0xC0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xDF,
  0x80, 0x0F, 0xE3, 0xF0, 0x03, 0xF0, 0xFE, 0x01, 0xFC, 0x1F, 0x80, 0x7E,
  0x07, 0xF0, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x07, 0xE3,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xF7, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xF8, 0x07, 0xE0,
  0xFC, 0x01, 0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xEF, 0xC0, 0x01,
  0xFC, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xFC,
  0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E,
  0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x02, 0x1F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xE0,
  0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0x80,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x07, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x0F, 0xFC, 0x07, 0xFF, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x4F, 0xFE, 0x00,
  0x37, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xEC, 0x00, 0x7F, 0xF2, 0x00, 0x03, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Medium57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 7, 42, 15, 4, -41 },
  { 38, 17, 15, 24, 3, -41 },
  { 70, 31, 41, 33, 1, -41 },
  { 229, 24, 46, 30, 3, -43 },
  { 367, 41, 42, 45, 2, -41 },
  { 583, 35, 42, 37, 2, -41 },
  { 767, 7, 15, 13, 3, -41 },
  { 781, 14, 50, 18, 2, -41 },
  { 869, 13, 50, 18, 2, -41 },
  { 951, 24, 24, 28, 2, -43 },
  { 1023, 25, 28, 30, 2, -34 },
  { 1111, 9, 14, 15, 2, -7 },
  { 1127, 14, 5, 18, 2, -18 },
  { 1136, 7, 8, 15, 4, -7 },
  { 1143, 20, 41, 22, 1, -41 },
  { 1246, 25, 42, 30, 2, -41 },
  { 1378, 16, 41, 30, 4, -41 },
  { 1460, 25, 41, 30, 2, -41 },
  { 1589, 25, 42, 30, 2, -41 },
  { 1721, 28, 41, 30, 1, -41 },
  { 1865, 24, 42, 30, 3, -41 },
  { 1991, 24, 42, 30, 3, -41 },
  { 2117, 25, 41, 30, 2, -41 },
  { 2246, 25, 42, 30, 2, -41 },
  { 2378, 25, 42, 30, 2, -41 },
  { 2510, 7, 32, 15, 4, -31 },
  { 2538, 9, 38, 15, 2, -31 },
  { 2581, 25, 27, 30, 2, -34 },
  { 2666, 24, 16, 30, 3, -28 },
  { 2714, 26, 27, 30, 2, -34 },
  { 2802, 21, 42, 23, 1, -41 },
  { 2913, 41, 46, 47, 3, -41 },
  { 3149, 33, 41, 34, 0, -41 },
  { 3319, 26, 41, 34, 5, -41 },
  { 3453, 28, 42, 32, 3, -41 },
  { 3600, 29, 41, 37, 5, -41 },
  { 3749, 21, 41, 29, 5, -41 },
  { 3857, 21, 41, 27, 5, -41 },
  { 3965, 31, 42, 38, 3, -41 },
  { 4128, 29, 41, 38, 5, -41 },
  { 4277, 15, 41, 19, 2, -41 },
  { 4354, 15, 52, 15, -4, -41 },
  { 4452, 28, 41, 33, 5, -41 },
  { 4596, 21, 41, 27, 5, -41 },
  { 4704, 39, 41, 48, 5, -41 },
  { 4904, 30, 41, 40, 5, -41 },
  { 5058, 34, 42, 40, 3, -41 },
  { 5237, 24, 41, 32, 5, -41 },
  { 5360, 34, 51, 40, 3, -41 },
  { 5577, 27, 41, 33, 5, -41 },
  { 5716, 23, 42, 29, 3, -41 },
  { 5837, 27, 41, 29, 1, -41 },
  { 5976, 28, 42, 38, 5, -41 },
  { 6123, 32, 41, 32, 0, -41 },
  { 6287, 49, 41, 49, 0, -41 },
  { 6539, 31, 41, 31, 0, -41 },
  { 6698, 30, 41, 30, 0, -41 },
  { 6852, 25, 41, 29, 2, -41 },
  { 6981, 13, 50, 18, 4, -41 },
  { 7063, 20, 41, 22, 1, -41 },
  { 7166, 13, 50, 18, 1, -41 },
  { 7248, 27, 25, 30, 2, -41 },
  { 7333, 25, 4, 25, 0, 5 },
  { 7346, 13, 9, 17, 2, -44 },
  { 7361, 24, 32, 30, 2, -31 },
  { 7457, 26, 44, 32, 4, -43 },
  { 7600, 21, 32, 25, 3, -31 },
  { 7684, 25, 44, 32, 3, -43 },
  { 7822, 24, 32, 30, 3, -31 },
  { 7918, 20, 44, 18, 1, -44 },
  { 8028, 25, 45, 32, 3, -31 },
  { 8169, 24, 43, 32, 4, -43 },
  { 8298, 7, 42, 14, 4, -42 },
  { 8335, 12, 56, 14, -2, -42 },
  { 8419, 25, 43, 29, 4, -43 },
  { 8554, 6, 43, 14, 4, -43 },
  { 8587, 41, 31, 49, 4, -31 },
  { 8746, 24, 31, 32, 4, -31 },
  { 8839, 26, 32, 32, 3, -31 },
  { 8943, 26, 45, 32, 4, -31 },
  { 9090, 25, 45, 32, 3, -31 },
  { 9231, 17, 31, 22, 4, -31 },
  { 9297, 21, 32, 25, 2, -31 },
  { 9381, 17, 39, 20, 1, -38 },
  { 9464, 24, 32, 32, 4, -31 },
  { 9560, 27, 31, 27, 0, -31 },
  { 9665, 41, 31, 42, 1, -31 },
  { 9824, 26, 31, 28, 1, -31 },
  { 9925, 27, 45, 27, 0, -31 },
  { 10077, 20, 31, 24, 2, -31 },
  { 10155, 17, 50, 21, 2, -41 },
  { 10262, 5, 56, 29, 12, -43 },
  { 10297, 18, 50, 21, 2, -41 },
  { 10410, 26, 8, 30, 2, -24 },
};

const GFXfont NotoSans_SemiCondensed_Medium57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium57pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM57PT7B_H_
