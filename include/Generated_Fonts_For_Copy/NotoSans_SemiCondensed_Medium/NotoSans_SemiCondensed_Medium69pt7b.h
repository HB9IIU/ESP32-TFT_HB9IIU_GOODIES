#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM69PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium69pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE3, 0xF8, 0xFE, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x1F, 0xE7, 0xF9, 0xFE, 0xFF, 0xFF, 0xF7, 0xF9,
  0xFE, 0x3F, 0x07, 0x80, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFD,
  0xFC, 0x0F, 0xE7, 0xE0, 0x7F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0,
  0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7,
  0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x7E, 0x7E, 0x03,
  0xE1, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0xFC,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xDE, 0x7F, 0x8F, 0xF0,
  0xF0, 0x1C, 0x7F, 0x07, 0x80, 0x23, 0xF8, 0x3C, 0x00, 0x1F, 0x81, 0xE0,
  0x00, 0xFC, 0x0F, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x3F, 0x83, 0xC0, 0x01,
  0xFC, 0x1E, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x7F, 0xC7, 0x80, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xEF, 0xFE, 0x00,
  0x0F, 0x1F, 0xF0, 0x00, 0x78, 0x3F, 0x80, 0x03, 0xC0, 0xFE, 0x00, 0x1E,
  0x07, 0xF0, 0x00, 0xF0, 0x3F, 0x80, 0x07, 0x81, 0xFC, 0x00, 0x3C, 0x0F,
  0xE0, 0x01, 0xE0, 0x7F, 0x80, 0x0F, 0x07, 0xF7, 0x80, 0x78, 0x7F, 0xBF,
  0xC3, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0xFE, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7C,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x7C, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x0F, 0xC1, 0xFE, 0x07, 0xE0,
  0x3F, 0x0F, 0xC1, 0xFF, 0x81, 0xF0, 0x1F, 0x87, 0xE1, 0xFF, 0xE0, 0xFC,
  0x0F, 0xC7, 0xE1, 0xFF, 0xF8, 0x7E, 0x0F, 0xC3, 0xF1, 0xFF, 0xFE, 0x1F,
  0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F, 0xFF, 0xE1, 0xF8, 0xFC, 0x0F, 0xC3,
  0xFF, 0xF1, 0xF8, 0x7E, 0x07, 0xE0, 0xFF, 0xF0, 0xFC, 0x3F, 0x01, 0xF0,
  0x3F, 0xF0, 0xFC, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x7E, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x1F, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xE0,
  0x1F, 0x80, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x07, 0xF7, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0x0F,
  0xE0, 0x7F, 0xFF, 0xF0, 0x03, 0xF8, 0x3F, 0xE3, 0xFE, 0x00, 0xFE, 0x0F,
  0xF0, 0x7F, 0x80, 0x7F, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xC1, 0xFE, 0x01,
  0xFE, 0x07, 0xF0, 0xFF, 0x00, 0x7F, 0xC3, 0xF8, 0x3F, 0xC0, 0x0F, 0xF8,
  0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xFF, 0xC0,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x3F, 0x80, 0x00, 0xFF, 0xF8, 0x0F, 0xE0,
  0x00, 0x1F, 0xFC, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xFE,
  0x01, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFD, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFE, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x3C, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x70, 0x07, 0xC0, 0x19, 0xF8,
  0x1F, 0x07, 0xE7, 0xFE, 0x78, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x7E, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x18, 0x03, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC7, 0xF3, 0xFC, 0xFF, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE,
  0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x3F, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0x87, 0xFC, 0x07, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF,
  0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0xFE, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFF,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xFE,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F,
  0xFE, 0x07, 0xFF, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xEF, 0xE7, 0xF9,
  0xFD, 0xFE, 0x3F, 0xFF, 0x87, 0xF7, 0xE0, 0xFE, 0x78, 0x1F, 0xC6, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x0F, 0xFE,
  0x1F, 0xC0, 0x07, 0xF8, 0x3E, 0x00, 0x0F, 0xF0, 0x60, 0x00, 0x3F, 0xC1,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFC, 0x07, 0xFE, 0x0F, 0x80, 0x07, 0xFC,
  0x38, 0x00, 0x0F, 0xF0, 0x40, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xEC, 0x00, 0x00, 0xFF, 0x3C,
  0x00, 0x0F, 0xFC, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC3, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xF8, 0x3F, 0xC7, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE6, 0x00, 0x01, 0xFF, 0x3C, 0x00, 0x1F, 0xF1, 0xFF,
  0x9F, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xF8, 0x02, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x81, 0xFF, 0x00, 0x7E, 0x1F, 0xFF, 0x01, 0xF8, 0xFF, 0xFE, 0x0F,
  0xE7, 0xFF, 0xFE, 0x3F, 0xBF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xC0, 0x3F, 0xCF, 0xFC, 0x00, 0x7F, 0xBF, 0xE0, 0x00, 0xFE, 0xFF, 0x80,
  0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x03, 0xF8, 0xFF,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x0F, 0xFE,
  0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFE, 0x01,
  0xFF, 0x0F, 0xF0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0xFF, 0x00, 0x3F, 0x81, 0xFE, 0x01, 0xFE, 0x03, 0xFE,
  0x0F, 0xF0, 0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0xC0,
  0xFF, 0x80, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x1F, 0xE0, 0x01, 0xFE, 0x7F,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x3F, 0x9F, 0xE0, 0x01, 0xFE, 0x7F, 0xE0, 0x1F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0x07,
  0xFC, 0x0F, 0xF0, 0x07, 0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7E, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xF0, 0x00,
  0x7F, 0xDF, 0xE0, 0x01, 0xFF, 0x7F, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x7F, 0x0F, 0xFF, 0xF9, 0xFC,
  0x1F, 0xFF, 0xC7, 0xE0, 0x3F, 0xFE, 0x1F, 0x80, 0x3F, 0xE0, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x18, 0x1F, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1E,
  0x1F, 0xC7, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x7F, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x87, 0xF9, 0xFE, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x7F, 0x8F, 0xC1, 0xE0,
  0x07, 0x83, 0xF8, 0x7F, 0x9F, 0xF3, 0xFE, 0x7F, 0xCF, 0xF8, 0xFF, 0x1F,
  0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0x1F, 0xE3, 0xFC, 0x7F,
  0x0F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x3F, 0x0F, 0xE1, 0xF8, 0x3F,
  0x07, 0xE0, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xF9, 0xFE, 0x0F, 0xFC, 0xF0, 0x01, 0xFF, 0x20, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0xFF, 0xC0, 0x7C, 0x3F, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0x1F, 0x00, 0x7F,
  0xFF, 0xF0, 0x1F, 0x9F, 0x80, 0x7F, 0xE7, 0xF8, 0x07, 0xCF, 0xC0, 0x3F,
  0x80, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF7, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xFF, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0x3F, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xFC, 0x07,
  0xE0, 0x03, 0xF0, 0x0F, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xFF, 0x01,
  0xF8, 0x00, 0xFC, 0x03, 0xFF, 0x80, 0xFC, 0x00, 0x7E, 0x01, 0xFF, 0xC0,
  0x7E, 0x00, 0x3F, 0x00, 0xFB, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7D, 0xF0,
  0x1F, 0x80, 0x1F, 0xC0, 0x3E, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x7C,
  0x03, 0xE0, 0x07, 0xF0, 0x1F, 0xBE, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0x9F,
  0x00, 0xFC, 0x03, 0xFC, 0x0F, 0xCF, 0xC0, 0x7F, 0x03, 0xFE, 0x0F, 0xC7,
  0xE0, 0x1F, 0xF7, 0xEF, 0xFF, 0xE3, 0xF0, 0x07, 0xFF, 0xE7, 0xFF, 0xE0,
  0xF8, 0x03, 0xFF, 0xF1, 0xFF, 0xE0, 0x7E, 0x00, 0xFF, 0xF0, 0x7F, 0xE0,
  0x3F, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x08,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00,
  0x01, 0xF9, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x1F, 0xF8,
  0xFE, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x7F, 0xF8, 0xFE, 0x00, 0x0F, 0xFC,
  0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x1F, 0xFC,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC7, 0xFC, 0x0F, 0xFE, 0x00, 0x3C, 0x0F, 0xFC, 0x00,
  0x02, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x40, 0xFF, 0xE0,
  0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00,
  0x3F, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0x03, 0xFF, 0x0F,
  0xE0, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xEF,
  0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F, 0xF8, 0xFE, 0x00,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x07, 0xFE, 0x0F,
  0xE0, 0x01, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xEF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xF0, 0x00, 0x7C, 0x07, 0xFE, 0x00,
  0x00, 0x40, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x3F, 0x9F,
  0xE0, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00,
  0x7F, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x00, 0x1F, 0xC3, 0xFF,
  0x00, 0x00, 0xFE, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x3F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE,
  0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xF8, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0x80, 0x00, 0x3F,
  0xCF, 0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0,
  0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F,
  0x80, 0x7F, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE1, 0xFE, 0x00,
  0x03, 0xF8, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0x0F, 0xEF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xBF, 0xC0, 0x00, 0xFF, 0x87, 0xF8, 0x00, 0x3F, 0xC1, 0xFF, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xFF, 0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xFF,
  0xE7, 0xE0, 0x00, 0x03, 0xF7, 0xFF, 0xCF, 0xC0, 0x00, 0x0F, 0xCF, 0xFF,
  0x9F, 0xC0, 0x00, 0x1F, 0x9F, 0xFF, 0x1F, 0x80, 0x00, 0x3F, 0x3F, 0xFF,
  0x3F, 0x00, 0x00, 0xFC, 0x7F, 0xFE, 0x7F, 0x00, 0x01, 0xF8, 0xFF, 0xFC,
  0x7E, 0x00, 0x03, 0xF1, 0xFF, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xFF, 0xF1,
  0xFC, 0x00, 0x1F, 0x87, 0xFF, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xFF, 0xC3,
  0xF0, 0x00, 0xFC, 0x1F, 0xFF, 0x87, 0xF0, 0x01, 0xF8, 0x3F, 0xFF, 0x07,
  0xE0, 0x07, 0xF0, 0x7F, 0xFE, 0x0F, 0xC0, 0x0F, 0xC0, 0xFF, 0xFC, 0x1F,
  0xC0, 0x1F, 0x81, 0xFF, 0xF8, 0x1F, 0x80, 0x7F, 0x03, 0xFF, 0xF0, 0x3F,
  0x00, 0xFC, 0x07, 0xFF, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xFF, 0xC0, 0x7E,
  0x07, 0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0xFF, 0x01, 0xFC,
  0x1F, 0x80, 0x7F, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0xFF, 0xFC, 0x03, 0xF0,
  0xFC, 0x01, 0xFF, 0xF8, 0x07, 0xF1, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xE7,
  0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xCF, 0xC0, 0x0F, 0xFF, 0xC0, 0x1F, 0xDF,
  0x80, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xFB, 0xFC,
  0x00, 0x07, 0xFF, 0xCF, 0xF0, 0x00, 0x3F, 0xFE, 0x7F, 0x80, 0x01, 0xFF,
  0xF1, 0xFE, 0x00, 0x0F, 0xFF, 0x87, 0xF0, 0x00, 0x7F, 0xFC, 0x3F, 0xC0,
  0x03, 0xFF, 0xF0, 0xFF, 0x00, 0x1F, 0xFF, 0x87, 0xF8, 0x00, 0xFF, 0xFC,
  0x1F, 0xE0, 0x07, 0xFF, 0xE0, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFC, 0x01,
  0xFF, 0xF8, 0x1F, 0xE0, 0x0F, 0xFF, 0xC0, 0x7F, 0x80, 0x7F, 0xFE, 0x01,
  0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xC0, 0xFF,
  0xFC, 0x01, 0xFE, 0x07, 0xFF, 0xE0, 0x07, 0xF8, 0x3F, 0xFF, 0x00, 0x3F,
  0xC1, 0xFF, 0xF8, 0x00, 0xFF, 0x0F, 0xFF, 0xC0, 0x07, 0xF8, 0x7F, 0xFE,
  0x00, 0x1F, 0xE3, 0xFF, 0xF0, 0x00, 0x7F, 0x1F, 0xFF, 0x80, 0x03, 0xFC,
  0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xFF, 0xE0, 0x00, 0x7F, 0xBF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x0F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x0F,
  0xEF, 0xF0, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x9F, 0xC0, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xF3, 0xF8, 0x03, 0xFF, 0xDF, 0xC0, 0x03, 0xFE, 0xFE, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFB,
  0xF8, 0x00, 0xFF, 0xDF, 0xC0, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x0F,
  0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00, 0x1F, 0xF8,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xBF, 0xC0,
  0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x1F, 0xE1,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xC0,
  0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x01, 0xFF,
  0xC1, 0xFC, 0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x01, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x1F, 0xE0, 0x03,
  0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0,
  0x0F, 0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x7F, 0x8F, 0xE0, 0x00,
  0x3F, 0xC7, 0xF0, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x07, 0xFD, 0xFC, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFB, 0xFF, 0x87, 0xFC, 0x00, 0x78,
  0x7F, 0xC0, 0x00, 0xC3, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF4,
  0x00, 0x00, 0x7F, 0xB8, 0x00, 0x07, 0xFD, 0xFC, 0x00, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x7F, 0x9F, 0xF0, 0x00, 0x3F, 0xC3, 0xFF, 0x00,
  0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x01, 0xF9, 0xFC,
  0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFD, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xEF, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF7, 0xF0,
  0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC3,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xC1, 0xFC, 0x03,
  0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x7F,
  0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x00,
  0x3F, 0x81, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0xFC,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x83, 0xF8, 0x00, 0x1F, 0xC1,
  0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x3F, 0x8F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x1F,
  0xC7, 0xE0, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x3F, 0xBF, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x0F, 0xDF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF1, 0xFE, 0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x83,
  0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x01,
  0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xF0,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x1F, 0xE3, 0xF8, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF9,
  0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0,
  0x01, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x01, 0xFF,
  0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x3F, 0xE0, 0x60, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xFC, 0x07, 0xF7, 0xFC, 0x00, 0x7F, 0x7F,
  0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0x7F, 0xC0,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0x3F, 0xFF, 0xF3, 0xF3, 0xFF, 0xFE, 0x3F,
  0x1F, 0xFF, 0xC3, 0xF0, 0x7F, 0xF0, 0x1F, 0x00, 0x78, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x0F, 0xFF,
  0x00, 0xFE, 0x3F, 0xFF, 0x81, 0xFC, 0xFF, 0xFF, 0x83, 0xFB, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x1F, 0xFC, 0x01, 0xFF,
  0x3F, 0xF0, 0x01, 0xFE, 0x7F, 0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xFD,
  0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0xFE, 0xFF, 0x00,
  0x01, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFE, 0x00, 0x0F, 0xF7, 0xFC, 0x00,
  0x3F, 0xCF, 0xFC, 0x00, 0x7F, 0x9F, 0xFC, 0x01, 0xFE, 0x3F, 0xFE, 0x0F,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF0, 0xFC, 0xFF, 0xFF, 0xE1, 0xF8, 0xFF, 0xFF,
  0x83, 0xF0, 0xFF, 0xFC, 0x07, 0xE0, 0x7F, 0xF0, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xC1, 0xF0,
  0x7F, 0xC0, 0x04, 0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFE, 0x00, 0x08, 0x7F, 0xC0, 0x06, 0x1F, 0xFE, 0x1F,
  0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x7F, 0xF8, 0x7F, 0x03, 0xFF,
  0xF8, 0xFE, 0x0F, 0xFF, 0xF9, 0xFC, 0x3F, 0xFF, 0xFB, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF1, 0xFF, 0x83, 0xFF, 0xE7, 0xFC, 0x01, 0xFF, 0xCF, 0xF0, 0x01,
  0xFF, 0x9F, 0xE0, 0x01, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x03,
  0xFD, 0xFC, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x1F, 0xF3, 0xFC,
  0x00, 0x3F, 0xE3, 0xFC, 0x01, 0xFF, 0xC7, 0xFE, 0x0F, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0xFE, 0x0F, 0xFF, 0xF8, 0xFC, 0x07, 0xFF,
  0xE1, 0xF8, 0x07, 0xFF, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0x01, 0xFE,
  0x07, 0xF8, 0x03, 0xFC, 0x3F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xF9, 0xFC,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x01, 0x07, 0xFC, 0x00, 0x1C, 0x0F, 0xFC,
  0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x03, 0xFE, 0x0C, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0xFC,
  0x0F, 0xFF, 0xE1, 0xF8, 0x3F, 0xFF, 0xE3, 0xF0, 0xFF, 0xFF, 0xEF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFE, 0x0F, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0x3F,
  0xC0, 0x07, 0xFE, 0x7F, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F,
  0xCF, 0xF0, 0x00, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0x1F, 0xF8, 0x3F, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFB, 0xF8, 0x3F, 0xFF, 0xE7, 0xF0,
  0x1F, 0xFF, 0x8F, 0xE0, 0x1F, 0xFC, 0x1F, 0xC0, 0x03, 0x80, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x84, 0x00, 0x01, 0xFF, 0x0F, 0x00, 0x07, 0xFC, 0x1F, 0xF0,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC1, 0xFF, 0xE0,
  0xFE, 0x3F, 0xFF, 0x87, 0xF3, 0xFF, 0xFE, 0x3F, 0xBF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x83, 0xFF, 0x7F, 0xF0, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x7C,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x01, 0xFE, 0xE7, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xC0, 0x0C, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x7F, 0x8F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xE0, 0xFE, 0x00, 0xFF,
  0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x00,
  0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFE, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFE, 0x3F, 0xC0, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFB, 0xF8, 0x00, 0xFF, 0xCF, 0xF0,
  0x03, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x80, 0xFF, 0x00,
  0xFE, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x3F,
  0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0xFF, 0x0F, 0xE0,
  0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x7E, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x3F, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x1F, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xCF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xC0, 0xFF, 0xFE,
  0x07, 0xFD, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFE, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x07, 0xE0, 0xFF, 0xF8, 0x3F, 0x0F, 0xFF, 0xE1, 0xF8,
  0xFF, 0xFF, 0x8F, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xE0,
  0xFF, 0xDF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0x80,
  0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0,
  0x07, 0xF8, 0x0F, 0xFC, 0x1F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x3F,
  0xFC, 0x03, 0xF0, 0xFF, 0xFE, 0x07, 0xE3, 0xFF, 0xFE, 0x0F, 0xEF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFC, 0x0F, 0xFC, 0x7F, 0xF0, 0x07,
  0xFC, 0xFF, 0xC0, 0x07, 0xF9, 0xFF, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xFC,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xF0,
  0x00, 0xFF, 0x3F, 0xF0, 0x01, 0xFE, 0x7F, 0xF0, 0x07, 0xF8, 0xFF, 0xFC,
  0x7F, 0xF1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFB, 0xFF, 0xFF, 0x07, 0xF3, 0xFF,
  0xFE, 0x0F, 0xE3, 0xFF, 0xF0, 0x1F, 0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x7C,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0xFC,
  0x0F, 0xFF, 0xE1, 0xF8, 0x3F, 0xFF, 0xE3, 0xF0, 0xFF, 0xFF, 0xEF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFE, 0x07, 0xFF, 0x8F, 0xF0, 0x03, 0xFF, 0x3F,
  0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x7F,
  0xCF, 0xF0, 0x01, 0xFF, 0x8F, 0xF0, 0x07, 0xFF, 0x1F, 0xF8, 0x3F, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFB, 0xF8, 0x3F, 0xFF, 0xE7, 0xF0,
  0x1F, 0xFF, 0x8F, 0xE0, 0x1F, 0xFC, 0x1F, 0xC0, 0x03, 0x80, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x07, 0xFD, 0xF8, 0x7F,
  0xEF, 0xC7, 0xFF, 0x7E, 0x7F, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x7F, 0x80, 0x7C, 0xFF, 0x00, 0x0C, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFE, 0x03, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFE, 0x18, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x1C, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFD, 0xFE, 0x00, 0xFF, 0xEF,
  0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0xFD, 0xF9, 0xFF, 0xFF, 0xCF, 0xC7, 0xFF,
  0xFC, 0x7E, 0x1F, 0xFF, 0xC3, 0xF0, 0x3F, 0xFC, 0x1F, 0x80, 0x1E, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xE7, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xF9, 0xFC,
  0x00, 0x7F, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x3E, 0xFC, 0x00, 0xFC, 0x3F,
  0x80, 0x3F, 0x7E, 0x00, 0xFE, 0x1F, 0xC0, 0x1F, 0xBF, 0x00, 0x7F, 0x0F,
  0xE0, 0x0F, 0xDF, 0x80, 0x3F, 0x83, 0xF8, 0x07, 0xC7, 0xE0, 0x1F, 0x81,
  0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0xC0, 0xFE, 0x03, 0xF1, 0xF8, 0x0F, 0xE0,
  0x7F, 0x01, 0xF8, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x3F, 0x03, 0xF0,
  0x0F, 0xE0, 0xFC, 0x1F, 0x83, 0xF8, 0x07, 0xF0, 0x7E, 0x0F, 0xC1, 0xFC,
  0x03, 0xF8, 0x3F, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x3F, 0x81, 0xF8, 0x7E,
  0x00, 0x7F, 0x1F, 0x80, 0xFC, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x7E, 0x3F,
  0x80, 0x1F, 0xC7, 0xE0, 0x3F, 0x1F, 0xC0, 0x07, 0xE3, 0xE0, 0x0F, 0x8F,
  0xC0, 0x03, 0xF3, 0xF0, 0x07, 0xE7, 0xE0, 0x01, 0xFD, 0xF8, 0x03, 0xF7,
  0xF0, 0x00, 0xFE, 0xFC, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0xFD,
  0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x1F,
  0x7E, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x01,
  0xFE, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xC0, 0x07,
  0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0x7F,
  0x00, 0x01, 0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x07, 0xF8, 0x3F, 0xC0, 0x03,
  0xFC, 0x7F, 0x80, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0x1F, 0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xC7, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x04, 0xFF,
  0xF8, 0x00, 0x37, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x80, 0x00, 0x7F, 0xE2, 0x00, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Medium69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 10, 50, 18, 4, -49 },
  { 64, 21, 18, 29, 4, -49 },
  { 112, 37, 49, 40, 2, -49 },
  { 339, 29, 56, 36, 4, -52 },
  { 542, 49, 51, 55, 3, -50 },
  { 855, 42, 51, 45, 3, -50 },
  { 1123, 8, 18, 16, 4, -49 },
  { 1141, 16, 60, 21, 3, -49 },
  { 1261, 16, 60, 21, 2, -49 },
  { 1381, 30, 28, 34, 2, -52 },
  { 1486, 30, 33, 36, 3, -41 },
  { 1610, 10, 17, 18, 3, -8 },
  { 1632, 17, 7, 21, 2, -22 },
  { 1647, 9, 10, 18, 4, -9 },
  { 1659, 25, 49, 26, 1, -49 },
  { 1813, 30, 51, 36, 3, -50 },
  { 2005, 19, 49, 36, 5, -49 },
  { 2122, 30, 50, 36, 3, -50 },
  { 2310, 30, 51, 36, 3, -50 },
  { 2502, 34, 49, 36, 1, -49 },
  { 2711, 29, 50, 36, 4, -49 },
  { 2893, 30, 51, 36, 3, -50 },
  { 3085, 31, 49, 36, 2, -49 },
  { 3275, 30, 51, 36, 3, -50 },
  { 3467, 30, 51, 36, 3, -50 },
  { 3659, 10, 39, 18, 4, -38 },
  { 3708, 11, 47, 18, 2, -38 },
  { 3773, 30, 34, 36, 3, -42 },
  { 3901, 30, 19, 36, 3, -34 },
  { 3973, 30, 34, 36, 3, -42 },
  { 4101, 25, 51, 28, 1, -50 },
  { 4261, 49, 56, 56, 4, -50 },
  { 4604, 41, 49, 41, 0, -49 },
  { 4856, 32, 49, 41, 6, -49 },
  { 5052, 33, 51, 39, 4, -50 },
  { 5263, 36, 49, 45, 6, -49 },
  { 5484, 25, 49, 35, 6, -49 },
  { 5638, 25, 49, 33, 6, -49 },
  { 5792, 37, 51, 46, 4, -50 },
  { 6028, 35, 49, 47, 6, -49 },
  { 6243, 18, 49, 23, 2, -49 },
  { 6354, 18, 63, 19, -5, -49 },
  { 6496, 34, 49, 39, 6, -49 },
  { 6705, 25, 49, 33, 6, -49 },
  { 6859, 47, 49, 59, 6, -49 },
  { 7147, 37, 49, 49, 6, -49 },
  { 7374, 41, 51, 49, 4, -50 },
  { 7636, 29, 49, 38, 6, -49 },
  { 7814, 41, 62, 49, 4, -50 },
  { 8132, 33, 49, 40, 6, -49 },
  { 8335, 29, 51, 35, 3, -50 },
  { 8520, 33, 49, 35, 1, -49 },
  { 8723, 34, 50, 46, 6, -49 },
  { 8936, 39, 49, 39, 0, -49 },
  { 9175, 59, 49, 59, 0, -49 },
  { 9537, 37, 49, 37, 0, -49 },
  { 9764, 36, 49, 36, 0, -49 },
  { 9985, 31, 49, 35, 2, -49 },
  { 10175, 16, 60, 22, 5, -49 },
  { 10295, 25, 49, 26, 1, -49 },
  { 10449, 15, 60, 22, 2, -49 },
  { 10562, 33, 29, 37, 2, -49 },
  { 10682, 30, 5, 30, 0, 6 },
  { 10701, 15, 11, 20, 3, -53 },
  { 10722, 28, 39, 36, 3, -38 },
  { 10859, 31, 53, 39, 5, -52 },
  { 11065, 26, 39, 31, 3, -38 },
  { 11192, 31, 53, 39, 3, -52 },
  { 11398, 30, 39, 36, 3, -38 },
  { 11545, 24, 53, 22, 1, -53 },
  { 11704, 31, 55, 39, 3, -38 },
  { 11918, 29, 52, 39, 5, -52 },
  { 12107, 8, 51, 17, 5, -51 },
  { 12158, 16, 68, 17, -3, -51 },
  { 12294, 30, 52, 35, 5, -52 },
  { 12489, 7, 52, 17, 5, -52 },
  { 12535, 49, 38, 59, 5, -38 },
  { 12768, 29, 38, 39, 5, -38 },
  { 12906, 32, 39, 38, 3, -38 },
  { 13062, 31, 55, 39, 5, -38 },
  { 13276, 31, 55, 39, 3, -38 },
  { 13490, 21, 38, 27, 5, -38 },
  { 13590, 24, 39, 30, 3, -38 },
  { 13707, 21, 47, 24, 1, -46 },
  { 13831, 29, 38, 39, 5, -37 },
  { 13969, 33, 37, 33, 0, -37 },
  { 14122, 49, 37, 51, 1, -37 },
  { 14349, 32, 37, 34, 1, -37 },
  { 14497, 33, 54, 33, 0, -37 },
  { 14720, 25, 37, 29, 2, -37 },
  { 14836, 21, 60, 26, 2, -49 },
  { 14994, 6, 69, 35, 14, -53 },
  { 15046, 22, 60, 26, 2, -49 },
  { 15211, 30, 10, 36, 3, -29 },
};

const GFXfont NotoSans_SemiCondensed_Medium69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium69pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM69PT7B_H_
