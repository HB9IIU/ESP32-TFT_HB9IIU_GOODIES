#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM44PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF9, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xC0, 0x00, 0x01, 0xCF, 0xBF, 0xFF, 0xFF,
  0x88, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE1, 0xEF, 0x0F, 0x78, 0x7B, 0xC3,
  0xDE, 0x0E, 0xF0, 0x77, 0x83, 0xBC, 0x1C, 0x00, 0xF0, 0x70, 0x00, 0xF0,
  0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0,
  0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xC1, 0xC0, 0x03, 0xC1,
  0xC0, 0x03, 0x83, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0x83, 0xC0, 0x07, 0x83,
  0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0x07, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x0F, 0x07,
  0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0E,
  0x00, 0x1E, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0xFE, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xF3, 0xF7, 0x1C, 0xF8,
  0xE0, 0x1F, 0x1C, 0x03, 0xE3, 0x80, 0x7C, 0x70, 0x0F, 0x8E, 0x00, 0xF9,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x03,
  0xFE, 0x00, 0x7F, 0xE0, 0x0E, 0x7C, 0x01, 0xC7, 0xC0, 0x38, 0x78, 0x07,
  0x0F, 0x00, 0xE1, 0xF0, 0x1C, 0x7F, 0xC3, 0x9F, 0x7F, 0xFF, 0xEF, 0xFF,
  0xF8, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x80, 0x7F, 0x80,
  0x0E, 0x01, 0xFF, 0x80, 0x3C, 0x03, 0xCF, 0x00, 0x70, 0x0F, 0x0F, 0x01,
  0xE0, 0x1E, 0x1E, 0x03, 0xC0, 0x3C, 0x3C, 0x0F, 0x00, 0x78, 0x38, 0x1E,
  0x00, 0xE0, 0x70, 0x78, 0x01, 0xC0, 0xE0, 0xF0, 0x03, 0x81, 0xC3, 0xC0,
  0x07, 0x03, 0x87, 0x80, 0x0F, 0x07, 0x1E, 0x00, 0x1E, 0x1E, 0x3C, 0x7E,
  0x3C, 0x3C, 0xF1, 0xFE, 0x38, 0x79, 0xE7, 0xFE, 0x7D, 0xE7, 0x9E, 0x3C,
  0x7F, 0xCF, 0x3C, 0x3C, 0xFF, 0x1C, 0x78, 0x78, 0x78, 0x78, 0xE0, 0xF0,
  0x00, 0xE1, 0xC1, 0xE0, 0x03, 0xC3, 0x83, 0xC0, 0x07, 0x07, 0x07, 0x80,
  0x1E, 0x0E, 0x0F, 0x00, 0x38, 0x1C, 0x1E, 0x00, 0xF0, 0x38, 0x3C, 0x01,
  0xC0, 0x78, 0x78, 0x07, 0x80, 0xF0, 0xF0, 0x0E, 0x00, 0xE3, 0xC0, 0x3C,
  0x01, 0xFF, 0x80, 0x70, 0x01, 0xFE, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x3C,
  0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x0F, 0x87, 0xFF, 0x81, 0xF1, 0xF9,
  0xF8, 0x3E, 0x3E, 0x1F, 0x07, 0x8F, 0x81, 0xF1, 0xF1, 0xF0, 0x1F, 0x3E,
  0x3E, 0x01, 0xFF, 0x87, 0xC0, 0x3F, 0xF0, 0xF8, 0x03, 0xFC, 0x1F, 0x00,
  0x3F, 0x03, 0xE0, 0x07, 0xF0, 0x7E, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0x3E, 0x07, 0xFF, 0xC3, 0xE0, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x83, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E,
  0x0F, 0x81, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xF0,
  0x3C, 0x0F, 0x81, 0xE0, 0x3C, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0,
  0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x38, 0x78,
  0x7F, 0xDC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0xE0, 0x0F, 0x7C, 0x03, 0xCF, 0x01, 0xE3, 0xE0, 0xF8, 0x7C, 0x1C,
  0x1E, 0x01, 0x02, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x3E, 0xF9, 0xF3, 0xE7, 0x8F, 0x1E,
  0x78, 0xF1, 0xC3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x73, 0xEF,
  0xBF, 0xFB, 0xE2, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0xF8, 0x0F,
  0xFF, 0x83, 0xF1, 0xF8, 0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xC0, 0x1E, 0x78,
  0x03, 0xDF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0x78, 0x03, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x1F, 0x07, 0xC3, 0xFB,
  0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xF0, 0x3F, 0x07,
  0xF0, 0xFF, 0x1F, 0xF3, 0xEF, 0xFC, 0xF7, 0x8F, 0x30, 0xF2, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x80,
  0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0xC1, 0xF8, 0xE0, 0x1F, 0x88, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0x81, 0xF8, 0xC0,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xFF, 0x00, 0x7F,
  0x80, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x60, 0x07, 0xEF, 0xCF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF,
  0x83, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1E, 0xF0,
  0x00, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0x71, 0xE0, 0x07, 0x8F, 0x00, 0x78,
  0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x01, 0xC0, 0xF0, 0x1E, 0x07, 0x81,
  0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x20, 0x07, 0xFF, 0xC0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE1, 0xC3, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xFB, 0x00, 0x3F, 0x7F, 0x7F, 0xCF, 0xFF, 0xF1,
  0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE,
  0x07, 0xFF, 0xC1, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x8F, 0xC1,
  0xF7, 0xFE, 0x3D, 0xFF, 0xE7, 0xBF, 0xFE, 0xFE, 0x07, 0xDF, 0x80, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0x78, 0x03, 0xEF, 0x80, 0x7D, 0xF0, 0x0F, 0x1F, 0x03, 0xE3,
  0xFB, 0xF8, 0x3F, 0xFF, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC, 0xF8,
  0x0F, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xF0,
  0x1F, 0x1F, 0x07, 0xC3, 0xF1, 0xF8, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0xE0, 0xF8, 0x7E, 0x3E, 0x07, 0xEF, 0x80,
  0x7D, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x0F, 0xFE, 0x03, 0xF7, 0xE0, 0xFC, 0x7F, 0xFF, 0x07, 0xFF,
  0xC0, 0x7F, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1F, 0xFF,
  0x87, 0xE1, 0xF8, 0xF8, 0x1F, 0x3E, 0x01, 0xF7, 0xC0, 0x1E, 0xF0, 0x03,
  0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFE, 0x01, 0xFB, 0xE0, 0x3F, 0x7E, 0x1F, 0xE7, 0xFF, 0xBC, 0xFF, 0xEF,
  0x87, 0xF9, 0xF0, 0x10, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x82, 0x1F, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x7B, 0xEF, 0xFF, 0xF9, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3E, 0xFF, 0xFF,
  0xFE, 0x20, 0x1E, 0x3E, 0x3F, 0x3F, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3C, 0x3C, 0x7C, 0x78, 0x78, 0x70, 0xF0, 0x00, 0x00, 0x60, 0x00,
  0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC,
  0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03,
  0xE0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFE, 0x3F,
  0xFF, 0x8F, 0xFF, 0xE7, 0x83, 0xF1, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x01, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x78, 0x1F, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x07, 0xFC, 0x1E, 0x3C, 0x0F,
  0xFE, 0x1E, 0x38, 0x1F, 0xFE, 0x0E, 0x78, 0x3E, 0x1E, 0x0E, 0x78, 0x7C,
  0x1E, 0x0E, 0x70, 0x78, 0x1E, 0x0F, 0x70, 0x70, 0x1E, 0x0F, 0xF0, 0x70,
  0x1E, 0x0F, 0xF0, 0xF0, 0x1E, 0x0F, 0xF0, 0xF0, 0x1E, 0x0F, 0xF0, 0xF0,
  0x1E, 0x0E, 0xF0, 0xF0, 0x1E, 0x0E, 0xF0, 0x70, 0x3E, 0x1E, 0xF0, 0x78,
  0x3E, 0x1E, 0x70, 0x7C, 0x7E, 0x3C, 0x70, 0x3F, 0xE7, 0xF8, 0x78, 0x3F,
  0xE7, 0xF8, 0x78, 0x0F, 0x83, 0xE0, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0x00, 0x07, 0xFE, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x7C, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0,
  0xF8, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0xF8,
  0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0x07, 0xFC,
  0xF0, 0x07, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03,
  0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x1F, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0x00, 0x7E, 0xF0,
  0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF0, 0x07, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xF0, 0xF8, 0x7F, 0x00,
  0x41, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x06, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFC,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF0,
  0x07, 0xF3, 0xC0, 0x0F, 0xCF, 0x00, 0x1F, 0xBC, 0x00, 0x3E, 0xF0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0xF0, 0x01, 0xF3, 0xC0, 0x0F, 0xCF,
  0x01, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0x3E, 0x1F, 0xC0, 0x04,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0x78, 0x03, 0xFF, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x7C, 0x00, 0x0F,
  0x7C, 0x00, 0x0F, 0x7E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3F, 0x00, 0x0F,
  0x1F, 0x80, 0x0F, 0x1F, 0xC0, 0x0F, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x8F, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xE0, 0x7C, 0x0F, 0xEF, 0xEF, 0xFD, 0xFF, 0x3F, 0xC3, 0xC0, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0x3C, 0x00, 0xF9, 0xE0, 0x0F, 0x8F, 0x00, 0xF8, 0x78,
  0x0F, 0x83, 0xC0, 0x7C, 0x1E, 0x07, 0xC0, 0xF0, 0x7C, 0x07, 0x87, 0xC0,
  0x3C, 0x3E, 0x01, 0xE3, 0xE0, 0x0F, 0x3E, 0x00, 0x7B, 0xF0, 0x03, 0xDF,
  0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xE7, 0xC0, 0x3E, 0x3F, 0x01,
  0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x7C, 0x1E, 0x03,
  0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x07, 0xCF,
  0x00, 0x3F, 0x78, 0x00, 0xFB, 0xC0, 0x03, 0xE0, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFD, 0xE0, 0x03, 0xDF, 0xF7, 0x80, 0x0F, 0x7F, 0xDF, 0x00, 0x3D, 0xFF,
  0x3C, 0x01, 0xE7, 0xFC, 0xF0, 0x07, 0x9F, 0xF3, 0xE0, 0x1E, 0x7F, 0xC7,
  0x80, 0xF1, 0xFF, 0x1E, 0x03, 0xC7, 0xFC, 0x7C, 0x0F, 0x1F, 0xF0, 0xF0,
  0x78, 0x7F, 0xC3, 0xC1, 0xE1, 0xFF, 0x0F, 0x87, 0x87, 0xFC, 0x1E, 0x3C,
  0x1F, 0xF0, 0x78, 0xF0, 0x7F, 0xC1, 0xF3, 0xC1, 0xFF, 0x03, 0xDE, 0x07,
  0xFC, 0x0F, 0x78, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0x7F, 0x01, 0xFF,
  0x01, 0xFC, 0x07, 0xFC, 0x07, 0xF0, 0x1F, 0xF0, 0x0F, 0x80, 0x7F, 0xC0,
  0x3E, 0x01, 0xFF, 0x00, 0xF8, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFB, 0xE0, 0x0F, 0xF7, 0xC0, 0x1F, 0xE7, 0xC0, 0x3F,
  0xCF, 0x80, 0x7F, 0x8F, 0x80, 0xFF, 0x0F, 0x81, 0xFE, 0x1F, 0x03, 0xFC,
  0x1F, 0x07, 0xF8, 0x3E, 0x0F, 0xF0, 0x3E, 0x1F, 0xE0, 0x7C, 0x3F, 0xC0,
  0x7C, 0x7F, 0x80, 0xF8, 0xFF, 0x00, 0xF9, 0xFE, 0x01, 0xFB, 0xFC, 0x01,
  0xF7, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xC1, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF9, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C,
  0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0xE0, 0x3F, 0x80,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x00,
  0xFD, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0x78, 0x03, 0xEF, 0x00, 0x7D, 0xE0, 0x1F, 0xBC, 0x07,
  0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x83, 0xFF, 0xC0, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0xE0,
  0x3F, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0x00, 0xFC, 0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0x7C,
  0xF0, 0x03, 0xE7, 0x80, 0x1F, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x00,
  0x7C, 0x78, 0x07, 0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x3C, 0x1F, 0x01, 0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0x78, 0x0F,
  0x83, 0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x87, 0x80, 0x3E, 0x3C,
  0x01, 0xF1, 0xE0, 0x07, 0xCF, 0x00, 0x3E, 0x78, 0x00, 0xFB, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0x0F,
  0x9F, 0x00, 0x4F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF8,
  0x00, 0x7F, 0x80, 0x3E, 0xFF, 0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE1, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1E, 0xF8, 0x00, 0xFB, 0xF0, 0x03, 0xE7, 0xE0, 0x3F, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0xF8, 0x00, 0x0F,
  0xBC, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xC3, 0xC0, 0x03,
  0xE1, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x1E, 0x00,
  0x7C, 0x0F, 0x80, 0x3C, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x07,
  0xC1, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x7C, 0x78, 0x00,
  0x3E, 0x3C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7D, 0xE0, 0x03, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0xC0, 0x0F,
  0x9F, 0x00, 0x3F, 0x00, 0x3E, 0x7C, 0x01, 0xFC, 0x00, 0xF8, 0xF0, 0x07,
  0xF8, 0x03, 0xC3, 0xC0, 0x1F, 0xE0, 0x1F, 0x0F, 0x80, 0x7F, 0x80, 0x7C,
  0x3E, 0x03, 0xDE, 0x01, 0xF0, 0x78, 0x0F, 0x3C, 0x07, 0x81, 0xE0, 0x3C,
  0xF0, 0x1E, 0x07, 0xC0, 0xF3, 0xC0, 0xF8, 0x1F, 0x07, 0x8F, 0x03, 0xE0,
  0x3C, 0x1E, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x78, 0x3C, 0x03, 0xE1, 0xE1,
  0xE1, 0xF0, 0x0F, 0x8F, 0x07, 0x87, 0xC0, 0x1E, 0x3C, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0xF3, 0xE0, 0x07, 0xDE, 0x03,
  0xCF, 0x80, 0x1F, 0x78, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x1E, 0xF0, 0x00,
  0xF7, 0x80, 0x7B, 0xC0, 0x03, 0xDC, 0x01, 0xEF, 0x00, 0x0F, 0x70, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x1F,
  0x00, 0xF8, 0x0F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xC3, 0xE0, 0x07,
  0xC3, 0xE0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0xC3, 0xE0, 0x0F,
  0x81, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF1, 0xF0, 0x07, 0xC3, 0xE0,
  0x0F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x83,
  0xE0, 0x0F, 0x07, 0x80, 0x1F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0xF8,
  0x00, 0x3D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0x78, 0x00,
  0x7B, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x03, 0xC1, 0xE0, 0x1E, 0x0F,
  0x00, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x70, 0x07, 0x87, 0x80, 0x3C, 0x3C,
  0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x7E, 0x1F, 0x07, 0xC1, 0xF0,
  0x78, 0x1E, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0x7E, 0xFE, 0x18,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x7F, 0xFC, 0x7F, 0xFF, 0x7F, 0xFF, 0xDF, 0x81, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xFC,
  0x3F, 0xDF, 0xFE, 0xF3, 0xFF, 0x3C, 0x7F, 0x8F, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0xFB, 0xFF, 0x0F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xE0, 0x7C, 0xFC, 0x03, 0xEF, 0xC0, 0x3E,
  0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1E, 0xF8, 0x03, 0xEF, 0xC0, 0x3E, 0xFE, 0x07, 0xEF, 0xF8, 0xFC, 0xF7,
  0xFF, 0x8F, 0x3F, 0xF0, 0xF1, 0xFE, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0x1F,
  0xFF, 0x3F, 0xFE, 0x3E, 0x02, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x01, 0x3F,
  0xDF, 0x1F, 0xFF, 0x0F, 0xFF, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x7F, 0x1F, 0x0F, 0xFD, 0xF1, 0xFF,
  0xFF, 0x3F, 0xFF, 0xF3, 0xE0, 0x7F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x78,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x7C, 0x01, 0xF7, 0xC0, 0x3F, 0x7E, 0x07, 0xF3, 0xF1, 0xFF, 0x1F, 0xFF,
  0xF1, 0xFF, 0xCF, 0x07, 0xF8, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0xCF, 0xC3, 0xE0, 0x7C, 0xF8, 0x07, 0x9E, 0x00, 0xF3, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x23, 0xFC, 0x7C, 0x3F, 0xFF, 0x83, 0xFF,
  0xF0, 0x1F, 0xF8, 0x00, 0xF0, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xE0, 0xF8,
  0x43, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFF, 0xE7,
  0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0xF0, 0xFF, 0xCF,
  0x1F, 0xFE, 0xF3, 0xFF, 0xFF, 0x3E, 0x07, 0xF7, 0xC0, 0x3F, 0x7C, 0x03,
  0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xF7, 0xE0, 0x7F, 0x3F, 0x1F, 0xF1,
  0xFF, 0xFF, 0x1F, 0xFD, 0xF0, 0x7F, 0x9F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE2, 0x00, 0x7E, 0x3E, 0x1F,
  0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x40, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x1F, 0xC3, 0xEF,
  0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFD, 0xFC, 0x0F, 0xBF, 0x00, 0xFF, 0xE0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00,
  0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xE0, 0x77, 0xFF, 0xFF, 0xB8, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7E, 0x3E, 0xFF, 0xBF, 0xCF, 0xE0, 0xE0, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xFF, 0xE0, 0x1F,
  0x7C, 0x07, 0xCF, 0x81, 0xF1, 0xF0, 0x7C, 0x3E, 0x1F, 0x07, 0xC3, 0xC0,
  0xF8, 0xF8, 0x1F, 0x3E, 0x03, 0xEF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01,
  0xFF, 0xE0, 0x3F, 0xBE, 0x07, 0xE7, 0xC0, 0xF8, 0x7C, 0x1F, 0x0F, 0x83,
  0xE0, 0xF8, 0x7C, 0x0F, 0x8F, 0x81, 0xF1, 0xF0, 0x1F, 0x3E, 0x01, 0xF7,
  0xC0, 0x3E, 0xF8, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0xF0, 0xFE, 0x07, 0xF0, 0xF3, 0xFF, 0x1F, 0xF8, 0xF7, 0xFF,
  0xBF, 0xFC, 0xFF, 0xFF, 0xBF, 0xFE, 0xFE, 0x0F, 0xF0, 0x3E, 0xFC, 0x07,
  0xE0, 0x3E, 0xFC, 0x07, 0xE0, 0x1E, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x03,
  0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03,
  0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03,
  0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03,
  0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03,
  0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03, 0xC0, 0x1F, 0xF8, 0x03,
  0xC0, 0x1F, 0xF0, 0xFE, 0x1E, 0x7F, 0xF3, 0xDF, 0xFE, 0x7F, 0xFF, 0xEF,
  0xE0, 0x7D, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0x03,
  0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3E, 0x07, 0xE7,
  0xC0, 0x3E, 0x7C, 0x01, 0xE7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x03, 0xE3, 0xE0,
  0x3E, 0x3F, 0x8F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0xF0,
  0xFC, 0x0F, 0x3F, 0xF0, 0xF7, 0xFF, 0x8F, 0xFF, 0xFC, 0xFE, 0x07, 0xCF,
  0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0xC0, 0x3E, 0xFC, 0x03, 0xEF, 0xE0,
  0x7C, 0xFF, 0x9F, 0xCF, 0xFF, 0xF8, 0xFB, 0xFF, 0x0F, 0x9F, 0xE0, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0xF0, 0xFF, 0xCF, 0x1F, 0xFE, 0xF3, 0xFF,
  0xFF, 0x3E, 0x07, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1F,
  0x7C, 0x03, 0xF7, 0xE0, 0x7F, 0x3F, 0x0F, 0xF1, 0xFF, 0xFF, 0x1F, 0xFD,
  0xF0, 0x7F, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0xF0, 0xFF, 0x8F, 0xFC, 0xFF,
  0xEF, 0xFF, 0xF8, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xF8,
  0x7F, 0xFD, 0xFF, 0xFF, 0xF3, 0xEF, 0x80, 0x5E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xFF,
  0x07, 0xFF, 0xFF, 0xBF, 0xFE, 0x3F, 0xF8, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00,
  0xFC, 0x47, 0xFE, 0x1F, 0xF0, 0x7F, 0x80, 0xF8, 0x03, 0xFF, 0x00, 0x7F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x1F, 0xBE, 0x07, 0xF7, 0xF3, 0xFE, 0xFF, 0xFB, 0xCF,
  0xFE, 0x78, 0x7F, 0x8F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xDE, 0x00, 0x3C,
  0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x1E, 0x00, 0xF0, 0xF8, 0x0F, 0x87, 0xC0,
  0x7C, 0x1E, 0x03, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x1E, 0x0F, 0x00,
  0xF0, 0xF8, 0x07, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0xDE,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xB8, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x78,
  0x03, 0xE0, 0x1F, 0x7C, 0x07, 0xE0, 0x1F, 0x7C, 0x07, 0xF0, 0x1E, 0x3C,
  0x07, 0xF0, 0x1E, 0x3C, 0x0F, 0x70, 0x3E, 0x3C, 0x0F, 0x70, 0x3E, 0x3E,
  0x0F, 0x78, 0x3C, 0x1E, 0x0E, 0x78, 0x3C, 0x1E, 0x1E, 0x78, 0x7C, 0x1E,
  0x1E, 0x38, 0x7C, 0x1F, 0x1E, 0x3C, 0x78, 0x0F, 0x1C, 0x3C, 0x78, 0x0F,
  0x3C, 0x3C, 0xF8, 0x0F, 0x3C, 0x1C, 0xF0, 0x0F, 0xBC, 0x1E, 0xF0, 0x07,
  0xB8, 0x1E, 0xF0, 0x07, 0xB8, 0x1E, 0xF0, 0x07, 0xF8, 0x0E, 0xE0, 0x07,
  0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03,
  0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xF7, 0xC0, 0x3E,
  0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x9F,
  0x00, 0xFB, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x7B, 0xE0, 0x0F,
  0x9E, 0x00, 0xF1, 0xF0, 0x1F, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0xC7,
  0xC0, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8, 0x00, 0xFB, 0xC0, 0x07,
  0xDF, 0x00, 0x3C, 0xF8, 0x03, 0xE3, 0xC0, 0x1F, 0x1F, 0x00, 0xF0, 0xF8,
  0x0F, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0xF8, 0x3E, 0x03, 0xC1, 0xF0,
  0x1E, 0x0F, 0x00, 0xF8, 0xF8, 0x03, 0xC7, 0xC0, 0x1E, 0x3C, 0x00, 0xF9,
  0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x04, 0x00, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0xC0, 0xFC, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x83, 0xFC, 0x0F, 0xC0,
  0x3F, 0x80, 0xFF, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0xC0, 0xFF, 0x00, 0xFC, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xF0, 0x3F,
  0x80, 0x7E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0xC0, 0x3E, 0x03, 0xF0, 0x7F, 0x87, 0xE0, 0x3E, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xC0, 0x78, 0x00, 0x08, 0x00,
  0x2F, 0xF0, 0x07, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0x7F,
  0xA0, 0x00, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Medium44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 32, 11, 3, -31 },
  { 25, 13, 11, 18, 3, -31 },
  { 43, 24, 31, 26, 1, -31 },
  { 136, 19, 36, 23, 2, -33 },
  { 222, 31, 32, 35, 2, -32 },
  { 346, 27, 32, 29, 2, -32 },
  { 454, 4, 11, 10, 3, -31 },
  { 460, 10, 39, 14, 2, -32 },
  { 509, 11, 39, 14, 1, -32 },
  { 563, 18, 18, 22, 2, -33 },
  { 604, 19, 21, 23, 2, -26 },
  { 654, 7, 11, 11, 2, -5 },
  { 664, 11, 4, 14, 1, -14 },
  { 670, 6, 7, 11, 3, -6 },
  { 676, 15, 32, 17, 1, -32 },
  { 736, 19, 32, 23, 2, -32 },
  { 812, 12, 31, 23, 3, -31 },
  { 859, 19, 32, 23, 2, -32 },
  { 935, 19, 32, 23, 2, -32 },
  { 1011, 21, 32, 23, 1, -32 },
  { 1095, 19, 31, 23, 2, -31 },
  { 1169, 19, 32, 23, 2, -32 },
  { 1245, 19, 31, 23, 2, -31 },
  { 1319, 19, 32, 23, 2, -32 },
  { 1395, 19, 32, 23, 2, -32 },
  { 1471, 6, 25, 11, 3, -24 },
  { 1490, 8, 30, 11, 1, -24 },
  { 1520, 19, 21, 23, 2, -26 },
  { 1570, 19, 13, 23, 2, -22 },
  { 1601, 19, 21, 23, 2, -26 },
  { 1651, 17, 33, 18, 0, -32 },
  { 1722, 32, 36, 36, 2, -32 },
  { 1866, 26, 32, 26, 0, -32 },
  { 1970, 20, 31, 26, 4, -31 },
  { 2048, 22, 32, 25, 2, -32 },
  { 2136, 22, 31, 29, 4, -31 },
  { 2222, 16, 31, 22, 4, -31 },
  { 2284, 16, 31, 21, 4, -31 },
  { 2346, 24, 32, 29, 2, -32 },
  { 2442, 22, 31, 30, 4, -31 },
  { 2528, 11, 31, 15, 2, -31 },
  { 2571, 11, 40, 12, -3, -31 },
  { 2626, 21, 31, 25, 4, -31 },
  { 2708, 16, 31, 21, 4, -31 },
  { 2770, 30, 31, 37, 4, -31 },
  { 2887, 23, 31, 31, 4, -31 },
  { 2977, 27, 32, 31, 2, -32 },
  { 3085, 19, 31, 24, 4, -31 },
  { 3159, 27, 39, 31, 2, -32 },
  { 3291, 21, 31, 25, 4, -31 },
  { 3373, 18, 32, 22, 2, -32 },
  { 3445, 20, 31, 22, 1, -31 },
  { 3523, 22, 31, 29, 4, -31 },
  { 3609, 25, 31, 25, 0, -31 },
  { 3706, 38, 31, 38, 0, -31 },
  { 3854, 24, 31, 24, 0, -31 },
  { 3947, 23, 31, 23, 0, -31 },
  { 4037, 20, 31, 22, 1, -31 },
  { 4115, 10, 39, 14, 3, -32 },
  { 4164, 16, 32, 17, 0, -32 },
  { 4228, 10, 39, 14, 1, -32 },
  { 4277, 21, 20, 24, 1, -32 },
  { 4330, 19, 3, 19, 0, 4 },
  { 4338, 9, 7, 13, 2, -34 },
  { 4346, 18, 24, 23, 2, -24 },
  { 4400, 20, 33, 25, 3, -33 },
  { 4483, 16, 24, 20, 2, -24 },
  { 4531, 20, 33, 25, 2, -33 },
  { 4614, 19, 24, 23, 2, -24 },
  { 4671, 15, 34, 14, 1, -34 },
  { 4735, 20, 35, 25, 2, -24 },
  { 4823, 19, 33, 25, 3, -33 },
  { 4902, 5, 33, 11, 3, -33 },
  { 4923, 10, 44, 11, -2, -33 },
  { 4978, 19, 33, 22, 3, -33 },
  { 5057, 5, 33, 11, 3, -33 },
  { 5078, 32, 24, 38, 3, -24 },
  { 5174, 19, 24, 25, 3, -24 },
  { 5231, 20, 24, 24, 2, -24 },
  { 5291, 20, 35, 25, 3, -24 },
  { 5379, 20, 35, 25, 2, -24 },
  { 5467, 13, 24, 17, 3, -24 },
  { 5506, 15, 24, 19, 2, -24 },
  { 5551, 13, 29, 15, 1, -29 },
  { 5599, 19, 24, 25, 3, -24 },
  { 5656, 21, 24, 21, 0, -24 },
  { 5719, 32, 24, 33, 0, -24 },
  { 5815, 20, 24, 21, 1, -24 },
  { 5875, 21, 35, 21, 0, -24 },
  { 5967, 16, 24, 18, 1, -24 },
  { 6015, 14, 38, 16, 1, -31 },
  { 6082, 4, 43, 22, 9, -33 },
  { 6104, 13, 38, 16, 2, -31 },
  { 6166, 19, 7, 23, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_Medium44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium44pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM44PT7B_H_
