#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM33PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM33PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x00, 0xFF,
  0xFF, 0xF3, 0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0x6E, 0x19, 0x86, 0x61,
  0x80, 0x03, 0x86, 0x00, 0xE3, 0x80, 0x30, 0xE0, 0x0C, 0x38, 0x07, 0x0C,
  0x01, 0xC3, 0x00, 0x71, 0xC1, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0,
  0xE1, 0x80, 0x38, 0x60, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xC3, 0x83, 0xFF,
  0xFE, 0xFF, 0xFF, 0x87, 0x0C, 0x01, 0xC7, 0x00, 0x61, 0xC0, 0x18, 0x70,
  0x06, 0x1C, 0x03, 0x86, 0x00, 0xE3, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x07, 0xFC, 0x7F, 0xFB, 0xFF, 0xEF, 0x30, 0xB8, 0xC0, 0xE3, 0x03, 0x8C,
  0x0F, 0xB0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0xDE, 0x03,
  0x3C, 0x0C, 0xF0, 0x33, 0xE0, 0xCE, 0xF3, 0xFB, 0xFF, 0xCF, 0xFE, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x1E, 0x00, 0xE0, 0x3F, 0x00,
  0xE0, 0x7F, 0x81, 0xC0, 0x73, 0x81, 0xC0, 0x61, 0xC3, 0x80, 0xE1, 0xC3,
  0x80, 0xE1, 0xC7, 0x00, 0xE1, 0xC7, 0x00, 0xE1, 0xCE, 0x00, 0xE1, 0xCE,
  0x00, 0x61, 0xCC, 0xFC, 0x73, 0x9C, 0xFE, 0x7F, 0x99, 0xCE, 0x3F, 0x39,
  0x86, 0x1E, 0x31, 0x87, 0x00, 0x73, 0x87, 0x00, 0x63, 0x87, 0x00, 0xE3,
  0x87, 0x00, 0xC3, 0x87, 0x01, 0xC1, 0x87, 0x01, 0x81, 0xC6, 0x03, 0x81,
  0xCE, 0x03, 0x80, 0xFE, 0x07, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xC3, 0x80, 0x3C, 0x38, 0x03, 0xC3, 0x80, 0x3C, 0x38,
  0x01, 0xC3, 0x80, 0x1E, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0xC0, 0xE3, 0xDE, 0x0E, 0x78, 0xF1, 0xE7, 0x07, 0x9C, 0xF0,
  0x3F, 0xCF, 0x03, 0xFC, 0xF0, 0x1F, 0x87, 0x00, 0xF0, 0x78, 0x1F, 0x87,
  0xFF, 0xFC, 0x3F, 0xF9, 0xE1, 0xFE, 0x0F, 0xFF, 0xEE, 0xEE, 0xE6, 0x60,
  0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0x70,
  0x70, 0xF0, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x70, 0x78, 0x38, 0x38,
  0x3C, 0x1C, 0x1C, 0x0E, 0x07, 0xE0, 0x70, 0x70, 0x38, 0x38, 0x1C, 0x1C,
  0x1E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E,
  0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xC0, 0x63, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0,
  0x07, 0xC0, 0x3B, 0x81, 0xCE, 0x0F, 0x1C, 0x18, 0x78, 0x21, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x39, 0xDE, 0xF7, 0x39, 0xDC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07, 0x80,
  0x70, 0x0F, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0x7F, 0xE1, 0xE3, 0xC7, 0x83,
  0xCF, 0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xB8, 0x0F, 0x70, 0x1E, 0xE0,
  0x39, 0xC0, 0x73, 0xC1, 0xE3, 0xC3, 0xC7, 0xFF, 0x07, 0xFC, 0x07, 0xF0,
  0x01, 0xC1, 0xF0, 0xFC, 0x7F, 0x3F, 0xFE, 0xF7, 0x3C, 0x8F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0x7F, 0xE3, 0xFF, 0xE3,
  0xC3, 0xC2, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0xE3, 0xFF, 0xE3, 0x83, 0xE2, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x3F, 0xC0,
  0x7E, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE8, 0x03, 0xDF, 0xFF, 0x3F, 0xFC, 0x3F, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xB8, 0x03, 0xB8,
  0x03, 0x78, 0x07, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x1C, 0x78, 0x38, 0x78,
  0x38, 0x78, 0x70, 0x78, 0x70, 0x78, 0xE0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x7F, 0xF1, 0xFF, 0xC7, 0xFF, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0xDC, 0x0F, 0xFE, 0x3F, 0xFC, 0x61, 0xF8, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x80,
  0xFB, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0x03, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F,
  0x80, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x9F, 0x0E,
  0xFF, 0x3F, 0xFE, 0xF8, 0x7B, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0xFE, 0x03, 0xFC, 0x0E, 0x78, 0x79, 0xFF, 0xE3, 0xFF, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x07, 0xC0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x3C, 0x0E,
  0x38, 0x3C, 0x7C, 0xF0, 0x7F, 0xC0, 0x7E, 0x01, 0xFF, 0x07, 0xDF, 0x1E,
  0x0F, 0x38, 0x0E, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xF7, 0x81,
  0xCF, 0xDF, 0x8F, 0xFE, 0x07, 0xF8, 0x07, 0xC0, 0x3F, 0xC0, 0xFF, 0xC3,
  0xE3, 0xC7, 0x83, 0xCE, 0x03, 0xBC, 0x07, 0x78, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3D, 0xC0, 0x7B, 0xC1, 0xF7, 0xEF, 0xE7, 0xFF, 0xC7, 0xF7, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x07, 0xFE, 0x0F,
  0xF8, 0x1F, 0xC0, 0x7F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x3B, 0xDE, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0x7B, 0x9C,
  0xEE, 0x70, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0x3C, 0x00, 0x60, 0x00, 0x0F, 0x87, 0xFF, 0x1F, 0xFC,
  0xE1, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x78, 0x07, 0x81, 0xC0, 0x03,
  0x87, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x38, 0x3F, 0xC7, 0x60, 0xFF, 0x8F,
  0xC3, 0x87, 0x1F, 0x8E, 0x0E, 0x1F, 0x1C, 0x1C, 0x3C, 0x38, 0x38, 0x78,
  0x70, 0x70, 0xF0, 0xE0, 0xC3, 0xE1, 0xC3, 0x87, 0xC3, 0x87, 0x0F, 0xC7,
  0x9F, 0x3B, 0x87, 0xF7, 0xE7, 0x07, 0xC7, 0xC7, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x60, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEF, 0x00, 0x3C, 0xE0, 0x07,
  0x1C, 0x00, 0xE3, 0xC0, 0x3C, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xF0, 0x3C,
  0x1E, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0x80, 0x70, 0xE0,
  0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x1C, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x07, 0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0xE7, 0x07, 0xEE, 0x03, 0xDC, 0x03,
  0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x3D, 0xC0, 0x7B, 0xFF, 0xE7, 0xFE, 0x0F,
  0xFF, 0x9C, 0x0F, 0xB8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x03, 0xDF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF0, 0x01, 0xF8,
  0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0x0E, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x02, 0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFE, 0xFE, 0x00,
  0x7F, 0xF8, 0x3F, 0xFE, 0x1C, 0x3F, 0x8E, 0x03, 0xE7, 0x00, 0xFB, 0x80,
  0x3D, 0xC0, 0x0E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x70, 0x07,
  0xB8, 0x03, 0xDC, 0x03, 0xCE, 0x07, 0xC7, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xF8, 0x7C, 0x0E, 0x3E, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x80, 0x3D, 0xF0, 0x0F, 0x3E, 0x03,
  0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFC, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xE3, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xF3, 0xFF, 0xFF, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x0F, 0xFE, 0xFE, 0xFC, 0x20, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0,
  0x78, 0xE0, 0x78, 0xE0, 0xF0, 0xE1, 0xE0, 0xE1, 0xC0, 0xE3, 0xC0, 0xE7,
  0x80, 0xEF, 0x00, 0xEF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xF3, 0xC0, 0xE1,
  0xE0, 0xE1, 0xE0, 0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0x3C, 0xE0,
  0x3C, 0xE0, 0x1E, 0xE0, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0xE0, 0x1D,
  0xFB, 0x80, 0x77, 0xEE, 0x01, 0xDF, 0x9C, 0x0E, 0x7E, 0x70, 0x39, 0xF9,
  0xC0, 0xE7, 0xE3, 0x87, 0x1F, 0x8E, 0x1C, 0x7E, 0x38, 0x71, 0xF8, 0x73,
  0x87, 0xE1, 0xCE, 0x1F, 0x87, 0x38, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0x1F, 0x81, 0xE0, 0x7E, 0x07, 0x81, 0xF8, 0x1E, 0x07, 0xF0,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xB8, 0x0F, 0xDE, 0x07, 0xE7, 0x03, 0xF3, 0xC1, 0xF8, 0xF0, 0xFC, 0x78,
  0x7E, 0x1E, 0x3F, 0x0F, 0x1F, 0x83, 0xCF, 0xC0, 0xE7, 0xE0, 0x7B, 0xF0,
  0x1D, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x0F, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7,
  0xC0, 0x7C, 0xF0, 0x07, 0x9C, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x0F, 0x3C,
  0x01, 0xE3, 0xE0, 0x78, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0xFC,
  0x03, 0xFF, 0x8F, 0xFF, 0x38, 0xFE, 0xE0, 0x7B, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xB8, 0x3E, 0xFF, 0xF3, 0xFF, 0x8F,
  0xF8, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0x07, 0xC7, 0xC0, 0x7C, 0xF0, 0x07, 0x9C, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xEE, 0x00, 0x3D,
  0xE0, 0x0F, 0x3C, 0x01, 0xE3, 0xE0, 0x78, 0x3F, 0xFF, 0x03, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0xE3,
  0xF8, 0xE0, 0x7C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0,
  0x3C, 0xE0, 0x78, 0xE1, 0xF8, 0xFF, 0xE0, 0xFF, 0xC0, 0xE1, 0xC0, 0xE1,
  0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0x3C, 0xE0,
  0x3C, 0xE0, 0x1E, 0xE0, 0x1F, 0x07, 0xE0, 0x7F, 0xF3, 0xFF, 0x9F, 0x0E,
  0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0xC0, 0x7F, 0xFF, 0xEF, 0xFF, 0x1F, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0,
  0x01, 0xFC, 0x00, 0x77, 0x00, 0x3D, 0xC0, 0x0E, 0x78, 0x03, 0x8E, 0x01,
  0xE3, 0x80, 0x78, 0xF0, 0x1C, 0x1C, 0x0F, 0x07, 0x03, 0xC1, 0xE0, 0xE0,
  0x78, 0x38, 0x0E, 0x1E, 0x03, 0x87, 0x00, 0xF1, 0xC0, 0x1C, 0xF0, 0x07,
  0x38, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0xF0, 0x07, 0x00, 0x7F, 0x00, 0xF0, 0x07,
  0x70, 0x0F, 0x00, 0xF7, 0x00, 0xF8, 0x0F, 0x78, 0x1F, 0x80, 0xE7, 0x81,
  0xF8, 0x0E, 0x38, 0x1F, 0x81, 0xE3, 0x81, 0xDC, 0x1E, 0x3C, 0x39, 0xC1,
  0xC3, 0xC3, 0x9C, 0x1C, 0x1C, 0x39, 0xC3, 0xC1, 0xC3, 0x8E, 0x3C, 0x1C,
  0x78, 0xE3, 0x81, 0xE7, 0x0E, 0x38, 0x0E, 0x70, 0xE3, 0x80, 0xE7, 0x07,
  0x78, 0x0E, 0xF0, 0x77, 0x00, 0xEE, 0x07, 0x70, 0x07, 0xE0, 0x77, 0x00,
  0x7E, 0x03, 0x70, 0x07, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x3E, 0x00, 0x3C, 0x01, 0xE0, 0x70, 0x07, 0x9E, 0x01, 0xE3, 0xC0, 0xF0,
  0xF0, 0x3C, 0x1E, 0x1E, 0x07, 0x87, 0x00, 0xF3, 0xC0, 0x1C, 0xE0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x1D, 0xE0, 0x0F, 0x3C, 0x03, 0x8F, 0x01, 0xE1, 0xE0,
  0x70, 0x38, 0x3C, 0x0F, 0x0E, 0x01, 0xC7, 0x80, 0x7B, 0xC0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xDE, 0x01, 0xCF, 0x01, 0xE3, 0xC0, 0xE1, 0xE0, 0xF0,
  0x70, 0x70, 0x3C, 0x78, 0x0E, 0x38, 0x07, 0xBC, 0x01, 0xDC, 0x00, 0xFE,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE0, 0x01, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x07, 0xC0, 0x06, 0xE0, 0x0E, 0xE0, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x38,
  0x38, 0x38, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x70, 0xF0, 0xF0, 0x60, 0x0F, 0xE0, 0xFF,
  0xC3, 0xFF, 0x84, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC1, 0xFF, 0x1F,
  0xFD, 0xFC, 0xF7, 0x83, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x07, 0xDE,
  0x7F, 0x7F, 0xDC, 0xFE, 0x70, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x79, 0xF0, 0xF7, 0xF9, 0xFF, 0xFB,
  0xE0, 0xF7, 0xC0, 0xEF, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0xFF, 0x81, 0xFF, 0x07, 0xBF, 0xFF,
  0x77, 0xFC, 0xE3, 0xF0, 0x0F, 0xE3, 0xFF, 0x7F, 0xE7, 0x82, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x17, 0xFE, 0x3F, 0xE1, 0xFE, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC7, 0xE7, 0x3F, 0xDD, 0xFF,
  0xF7, 0x87, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0xF7, 0xFF, 0xCF,
  0xF7, 0x1F, 0x9C, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1C, 0x1E, 0xF0, 0x3B,
  0x80, 0xEE, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x9F, 0xBE, 0x3F, 0xF8, 0x3F, 0xC0, 0x07,
  0xF0, 0xFF, 0x0F, 0xE1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xFC, 0xFF,
  0xCF, 0xFC, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x00, 0x1F, 0x9C, 0xFF, 0x77, 0xFF, 0xDE, 0x1F, 0xF0, 0x3F, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0xFF, 0x03, 0xDF, 0xFF, 0x3F, 0xDC, 0x7E, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF6, 0x07, 0x9F, 0xFE, 0x7F, 0xF0, 0xFF, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0xFC, 0xF7, 0xFB, 0xFF, 0xFF, 0xC3, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1C, 0x2F, 0xFF, 0x20, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x04, 0x3C, 0x78, 0xF0,
  0x40, 0x00, 0x0F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C,
  0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xFF, 0x7E,
  0xF0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x1E, 0xE0, 0xF3, 0x83, 0x8E, 0x1E, 0x38, 0xF0, 0xE7, 0x83,
  0xBC, 0x0E, 0xE0, 0x3F, 0xC0, 0xFF, 0x03, 0xDE, 0x0E, 0x3C, 0x38, 0xF0,
  0xE1, 0xE3, 0x83, 0x8E, 0x0F, 0x38, 0x1E, 0xE0, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0xE0,
  0xF8, 0xE7, 0xFB, 0xFE, 0xFF, 0xFB, 0xFE, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E,
  0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x07, 0xF0, 0x3C, 0x07, 0xF0, 0x3C,
  0x07, 0xF0, 0x3C, 0x07, 0xF0, 0x3C, 0x07, 0xF0, 0x3C, 0x07, 0xF0, 0x3C,
  0x07, 0xF0, 0x3C, 0x07, 0xF0, 0x3C, 0x07, 0xF0, 0x3C, 0x07, 0xF0, 0x3C,
  0x07, 0xF0, 0x3C, 0x07, 0xE3, 0xF3, 0x9F, 0xEF, 0xFF, 0xFE, 0x0F, 0xF8,
  0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x70,
  0x0F, 0xC0, 0x7F, 0xE1, 0xFF, 0xE3, 0xC1, 0xEF, 0x03, 0xDC, 0x03, 0xB8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xDE, 0x07, 0x9E, 0x0F, 0x3F, 0x7C, 0x3F, 0xF0, 0x1F, 0xC0, 0xE3, 0xE1,
  0xCF, 0xF3, 0xFF, 0xF7, 0xC1, 0xEF, 0x81, 0xDE, 0x03, 0xFC, 0x07, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFF, 0x03,
  0xFE, 0x0F, 0x7F, 0xFE, 0xFF, 0xF9, 0xE7, 0xE3, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x1F,
  0x9C, 0xFF, 0x77, 0xFF, 0xDE, 0x1F, 0xF0, 0x3F, 0xC0, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0xFF,
  0x03, 0xDF, 0xFF, 0x3F, 0xDC, 0x7E, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0xE3, 0xF9, 0xFE,
  0xFF, 0xF8, 0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x00, 0x1F, 0xC3, 0xFF, 0x7F,
  0xE7, 0x02, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0xFF, 0xBF, 0xFF, 0xE7, 0xFC, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFB,
  0x1F, 0xC7, 0xF0, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0xC0, 0xF7, 0x83, 0xDF, 0xFF, 0x3F, 0xDC, 0x7E, 0x30, 0xF0,
  0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x38, 0x1C, 0x38,
  0x3C, 0x3C, 0x38, 0x1C, 0x38, 0x1C, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E,
  0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0xF0,
  0x3C, 0x07, 0x70, 0x3C, 0x0F, 0x70, 0x3E, 0x0F, 0x78, 0x7E, 0x0E, 0x78,
  0x7E, 0x0E, 0x38, 0x76, 0x1E, 0x38, 0x77, 0x1E, 0x38, 0xE7, 0x1C, 0x3C,
  0xE7, 0x1C, 0x1C, 0xE3, 0x1C, 0x1C, 0xE3, 0xB8, 0x1D, 0xC3, 0xB8, 0x1F,
  0xC3, 0xB8, 0x0F, 0xC1, 0xB8, 0x0F, 0xC1, 0xB0, 0x0F, 0x81, 0xF0, 0x0F,
  0x81, 0xF0, 0x07, 0x80, 0xF0, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x1C,
  0x38, 0x1E, 0x78, 0x0E, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1C, 0x3C, 0x3C,
  0x3C, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x1E, 0x78,
  0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x3C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x1E,
  0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x78, 0x00, 0x7F, 0xF7, 0xFF,
  0x7F, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x41, 0xF0, 0xFC, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x1E, 0x3F, 0x0F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFC, 0x1F, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xC0, 0x3E, 0x0F, 0xC0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x03, 0xF0, 0x3C, 0x1F, 0x0F, 0x03,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x87, 0xC3,
  0xF0, 0xF0, 0x00, 0x3E, 0x02, 0xFF, 0x0F, 0xFF, 0xFE, 0x0F, 0xE8, 0x03,
  0x80,
};

const GFXglyph NotoSans_SemiCondensed_Medium33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 24, 9, 2, -24 },
  { 13, 10, 9, 14, 2, -24 },
  { 25, 18, 24, 19, 1, -24 },
  { 79, 14, 27, 17, 2, -25 },
  { 127, 24, 24, 26, 1, -24 },
  { 199, 20, 24, 21, 1, -24 },
  { 259, 4, 9, 8, 2, -24 },
  { 264, 8, 29, 10, 1, -24 },
  { 293, 8, 29, 10, 1, -24 },
  { 322, 14, 14, 16, 1, -25 },
  { 347, 15, 16, 17, 1, -20 },
  { 377, 5, 8, 9, 1, -4 },
  { 382, 8, 3, 10, 1, -10 },
  { 385, 4, 4, 9, 2, -4 },
  { 387, 12, 24, 13, 0, -24 },
  { 423, 15, 24, 17, 1, -24 },
  { 468, 10, 24, 17, 2, -24 },
  { 498, 15, 24, 17, 1, -24 },
  { 543, 15, 24, 17, 1, -24 },
  { 588, 16, 24, 17, 1, -24 },
  { 636, 14, 24, 17, 2, -24 },
  { 678, 14, 24, 17, 2, -24 },
  { 720, 15, 24, 17, 1, -24 },
  { 765, 15, 24, 17, 1, -24 },
  { 810, 15, 24, 17, 1, -24 },
  { 855, 4, 18, 9, 2, -18 },
  { 864, 5, 22, 9, 1, -18 },
  { 878, 15, 16, 17, 1, -20 },
  { 908, 15, 9, 17, 1, -16 },
  { 925, 15, 16, 17, 1, -20 },
  { 955, 13, 24, 13, 0, -24 },
  { 994, 23, 27, 27, 2, -24 },
  { 1072, 19, 24, 19, 0, -24 },
  { 1129, 15, 24, 20, 3, -24 },
  { 1174, 16, 24, 19, 2, -24 },
  { 1222, 17, 24, 22, 3, -24 },
  { 1273, 12, 24, 17, 3, -24 },
  { 1309, 12, 24, 16, 3, -24 },
  { 1345, 18, 24, 22, 2, -24 },
  { 1399, 16, 24, 22, 3, -24 },
  { 1447, 9, 24, 11, 1, -24 },
  { 1474, 8, 31, 9, -2, -24 },
  { 1505, 16, 24, 19, 3, -24 },
  { 1553, 12, 24, 16, 3, -24 },
  { 1589, 22, 24, 28, 3, -24 },
  { 1655, 17, 24, 23, 3, -24 },
  { 1706, 19, 24, 23, 2, -24 },
  { 1763, 14, 24, 18, 3, -24 },
  { 1805, 19, 30, 23, 2, -24 },
  { 1877, 16, 24, 19, 3, -24 },
  { 1925, 14, 24, 17, 1, -24 },
  { 1967, 16, 24, 17, 0, -24 },
  { 2015, 16, 24, 22, 3, -24 },
  { 2063, 18, 24, 18, 0, -24 },
  { 2117, 28, 24, 28, 0, -24 },
  { 2201, 18, 24, 18, 0, -24 },
  { 2255, 17, 24, 17, 0, -24 },
  { 2306, 15, 24, 17, 1, -24 },
  { 2351, 8, 29, 11, 2, -24 },
  { 2380, 12, 24, 13, 0, -24 },
  { 2416, 7, 29, 11, 1, -24 },
  { 2442, 16, 15, 18, 1, -24 },
  { 2472, 14, 2, 14, 0, 3 },
  { 2476, 7, 5, 10, 1, -25 },
  { 2481, 14, 18, 17, 1, -18 },
  { 2513, 15, 25, 19, 2, -25 },
  { 2560, 12, 18, 15, 2, -18 },
  { 2587, 14, 25, 19, 2, -25 },
  { 2631, 14, 18, 17, 2, -18 },
  { 2663, 12, 25, 11, 0, -25 },
  { 2701, 14, 26, 19, 2, -18 },
  { 2747, 14, 25, 19, 2, -25 },
  { 2791, 4, 25, 8, 2, -25 },
  { 2804, 7, 33, 8, -1, -25 },
  { 2833, 14, 25, 17, 3, -25 },
  { 2877, 4, 25, 8, 2, -25 },
  { 2890, 24, 18, 28, 2, -18 },
  { 2944, 14, 18, 19, 2, -18 },
  { 2976, 15, 18, 18, 2, -18 },
  { 3010, 15, 26, 19, 2, -18 },
  { 3059, 14, 26, 19, 2, -18 },
  { 3105, 10, 18, 13, 2, -18 },
  { 3128, 12, 18, 14, 1, -18 },
  { 3155, 10, 22, 11, 1, -22 },
  { 3183, 14, 18, 19, 2, -18 },
  { 3215, 16, 18, 16, 0, -18 },
  { 3251, 24, 18, 24, 0, -18 },
  { 3305, 16, 18, 16, 0, -18 },
  { 3341, 16, 26, 16, 0, -18 },
  { 3393, 12, 18, 14, 1, -18 },
  { 3420, 10, 29, 12, 1, -24 },
  { 3457, 3, 33, 17, 7, -25 },
  { 3470, 10, 29, 12, 1, -24 },
  { 3507, 15, 5, 17, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_Medium33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium33pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM33PT7B_H_
