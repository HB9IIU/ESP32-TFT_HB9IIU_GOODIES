#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM16PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM16PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0x3C, 0xDE, 0xF7, 0x20, 0x1B, 0x09, 0x04, 0x8F, 0xF1,
  0x21, 0x93, 0xFF, 0xFF, 0x24, 0x12, 0x09, 0x00, 0x10, 0xFB, 0xF4, 0x8D,
  0x1E, 0x0F, 0x0E, 0x17, 0x2B, 0xF0, 0x81, 0x00, 0x60, 0x9E, 0x22, 0x44,
  0x49, 0x09, 0x21, 0x2B, 0xBD, 0x5B, 0x49, 0x0B, 0x22, 0x24, 0x45, 0x90,
  0xE0, 0x10, 0x3E, 0x13, 0x09, 0x86, 0x81, 0xC1, 0xC7, 0xB3, 0x8F, 0x43,
  0xB3, 0xCF, 0x30, 0xFE, 0x6B, 0x69, 0x24, 0x9B, 0x26, 0x40, 0xE2, 0x33,
  0x31, 0x11, 0x33, 0x32, 0x6C, 0x30, 0xCF, 0xCC, 0x7B, 0x34, 0x80, 0x10,
  0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0xFA, 0xE0, 0xF0, 0x0C, 0x21, 0x86,
  0x10, 0xC2, 0x08, 0x61, 0x0C, 0x00, 0x30, 0xFB, 0x36, 0x28, 0x70, 0xE1,
  0xC3, 0x87, 0x8B, 0x33, 0xC0, 0x3B, 0xF6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0xFA, 0x30, 0x20, 0xC1, 0x86, 0x18, 0x20, 0xC3, 0x07, 0xF0, 0x31,
  0xFA, 0x30, 0x20, 0xCF, 0x1E, 0x06, 0x06, 0x0E, 0x37, 0xC0, 0x0E, 0x0E,
  0x1E, 0x16, 0x26, 0x66, 0x46, 0xFF, 0xFF, 0x06, 0x06, 0xFD, 0x83, 0x06,
  0x0F, 0x91, 0x81, 0x03, 0x05, 0x1B, 0xE0, 0x0C, 0xF9, 0x86, 0x0C, 0x17,
  0xB1, 0x43, 0x87, 0x8F, 0x33, 0xC0, 0xFE, 0x08, 0x30, 0x60, 0x83, 0x04,
  0x18, 0x30, 0xC1, 0x80, 0x30, 0xFB, 0x16, 0x2C, 0xCF, 0x1E, 0x66, 0x87,
  0x0F, 0x33, 0xE0, 0x30, 0xF3, 0x34, 0x28, 0x70, 0xFF, 0xBA, 0x04, 0x18,
  0x67, 0x80, 0xF4, 0x03, 0xC0, 0xF4, 0x03, 0xE8, 0x02, 0x1C, 0x63, 0x0C,
  0x0E, 0x07, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x81, 0x81, 0xC0, 0xE0,
  0x67, 0x38, 0x40, 0x33, 0xF8, 0xC1, 0x0C, 0x63, 0x08, 0x20, 0x03, 0x0C,
  0x1F, 0x8C, 0x19, 0x01, 0xE7, 0x99, 0x13, 0x22, 0x64, 0x4C, 0x99, 0x9F,
  0xD8, 0x01, 0x80, 0x1F, 0x80, 0x1C, 0x0E, 0x05, 0x86, 0xC3, 0x21, 0x19,
  0xFC, 0xFE, 0x61, 0xE0, 0xF0, 0x60, 0xFE, 0xC6, 0xC2, 0xC2, 0xFE, 0xFE,
  0xC3, 0xC3, 0xC3, 0xC6, 0xFC, 0x0C, 0x3F, 0x60, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x72, 0x3E, 0xFE, 0x63, 0xB0, 0xD8, 0x2C, 0x1E, 0x0F,
  0x07, 0x82, 0xC3, 0x67, 0x3F, 0x00, 0xFF, 0x0C, 0x30, 0xFF, 0xFC, 0x30,
  0xC3, 0x0F, 0xC0, 0xFF, 0x0C, 0x30, 0xC3, 0xFC, 0x30, 0xC3, 0x0C, 0x00,
  0x0C, 0x1F, 0x98, 0x58, 0x0C, 0x06, 0x03, 0x1F, 0x83, 0xC1, 0xE0, 0xDC,
  0x67, 0xF0, 0xC1, 0xC1, 0xC1, 0xC1, 0xFF, 0xFF, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xF4, 0x44, 0x44, 0x44, 0x44, 0xF0, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x3E, 0xC7, 0xC6, 0xCC, 0xD8, 0xD0, 0xF8, 0xD8, 0xCC, 0xC6, 0xC6,
  0xC3, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xC0, 0xE0, 0x7C,
  0x1F, 0xC2, 0xE8, 0x5D, 0x1B, 0xB2, 0x72, 0x4E, 0x59, 0xCE, 0x38, 0xC7,
  0x18, 0x80, 0xE1, 0xF0, 0xFC, 0x7B, 0x3D, 0x9E, 0x6F, 0x37, 0x8F, 0xC3,
  0xE1, 0xF0, 0x60, 0x0C, 0x3F, 0x98, 0xF8, 0x3C, 0x1E, 0x07, 0x03, 0x81,
  0xC1, 0xE0, 0xDC, 0xC7, 0xC0, 0xFD, 0x8F, 0x1E, 0x3C, 0x7F, 0xBE, 0x60,
  0xC1, 0x83, 0x00, 0x0C, 0x3F, 0x98, 0xF8, 0x3C, 0x1E, 0x07, 0x03, 0x81,
  0xC1, 0xE0, 0xDC, 0xC7, 0xC0, 0x60, 0x18, 0x06, 0xFC, 0xC6, 0xC6, 0xC6,
  0xC6, 0xFC, 0xCC, 0xCC, 0xC6, 0xC6, 0xC3, 0x31, 0xFC, 0x70, 0xC1, 0x83,
  0x83, 0x04, 0x18, 0xFE, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3,
  0x67, 0x3E, 0xC1, 0xA0, 0x98, 0xCC, 0x62, 0x21, 0x30, 0xD8, 0x68, 0x14,
  0x0E, 0x07, 0x00, 0xC3, 0x0D, 0x0C, 0x24, 0x71, 0x99, 0xE6, 0x65, 0x98,
  0x92, 0x42, 0xCB, 0x0F, 0x3C, 0x38, 0xF0, 0xE1, 0x81, 0x86, 0x00, 0xE3,
  0x31, 0x0D, 0x82, 0x81, 0xC0, 0xE0, 0x70, 0x6C, 0x66, 0x31, 0xB0, 0xE0,
  0xC3, 0x62, 0x66, 0x34, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x7E,
  0x06, 0x04, 0x0C, 0x08, 0x18, 0x30, 0x30, 0x60, 0x40, 0xFF, 0xFC, 0xCC,
  0xCC, 0xCC, 0xCC, 0xCC, 0xFF, 0xC1, 0x06, 0x08, 0x30, 0xC1, 0x06, 0x18,
  0x20, 0xC0, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF, 0x18, 0x1C, 0x34,
  0x26, 0x62, 0xC3, 0xFE, 0xCC, 0xF9, 0xF0, 0xC1, 0x7F, 0x18, 0xF3, 0xF4,
  0xC1, 0x83, 0x06, 0xCF, 0xF8, 0xF0, 0xE1, 0xC3, 0x8F, 0x9F, 0xE0, 0x3D,
  0xEC, 0x30, 0x83, 0x0C, 0x31, 0x7C, 0x06, 0x0C, 0x19, 0xB7, 0xF8, 0xF1,
  0xC3, 0x87, 0x8F, 0x3B, 0xF0, 0x38, 0xFB, 0x14, 0x3F, 0xF0, 0x30, 0x72,
  0x7C, 0x3C, 0x82, 0x1E, 0xF8, 0x82, 0x08, 0x20, 0x82, 0x08, 0x36, 0xFF,
  0x1E, 0x38, 0x70, 0xF1, 0xE7, 0x7E, 0x0C, 0x1F, 0xE7, 0x80, 0xC1, 0x83,
  0x06, 0xEF, 0xF8, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x30, 0xF3, 0xFF, 0xFF,
  0x33, 0x03, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC1, 0x83, 0x06, 0x3C,
  0xDB, 0x34, 0x78, 0xD9, 0x93, 0x36, 0x30, 0xFF, 0xFF, 0xFF, 0xD8, 0xCF,
  0xDE, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x30,
  0xDD, 0xFF, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0x38, 0xFB, 0x1E, 0x38,
  0x70, 0xF1, 0xE2, 0x7C, 0xD9, 0xFF, 0x1E, 0x1C, 0x38, 0x71, 0xF3, 0xFD,
  0x83, 0x06, 0x0C, 0x00, 0x36, 0xFF, 0x1E, 0x38, 0x70, 0xF1, 0xE7, 0x7E,
  0x0C, 0x18, 0x30, 0x60, 0xDF, 0xF1, 0x8C, 0x63, 0x18, 0xC0, 0x77, 0xE1,
  0x87, 0x0C, 0x33, 0xF8, 0x21, 0x1F, 0xF6, 0x31, 0x8C, 0x63, 0x0E, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE7, 0x7A, 0xC3, 0xC2, 0x46, 0x66, 0x64,
  0x2C, 0x3C, 0x38, 0x18, 0xC6, 0x3C, 0x62, 0x4E, 0x26, 0xF6, 0x69, 0x66,
  0x94, 0x29, 0x43, 0x9C, 0x31, 0xC0, 0xC2, 0x66, 0x2C, 0x3C, 0x18, 0x38,
  0x2C, 0x66, 0xC7, 0xC3, 0xC2, 0x46, 0x66, 0x64, 0x2C, 0x3C, 0x18, 0x18,
  0x18, 0x10, 0xF0, 0xE0, 0xFF, 0xC6, 0x62, 0x33, 0x18, 0xF8, 0x19, 0x8C,
  0x63, 0x1B, 0x06, 0x31, 0x8C, 0x61, 0x84, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3,
  0x18, 0xC6, 0x30, 0x6C, 0x63, 0x18, 0xCC, 0x40, 0xE3, 0xFC,
};

const GFXglyph NotoSans_SemiCondensed_Medium16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 11, 4, 1, -11 },
  { 4, 5, 4, 7, 1, -11 },
  { 7, 9, 11, 9, 0, -11 },
  { 20, 7, 13, 8, 1, -12 },
  { 32, 11, 12, 13, 1, -12 },
  { 49, 9, 12, 10, 1, -12 },
  { 63, 2, 4, 4, 1, -11 },
  { 64, 3, 14, 5, 1, -11 },
  { 70, 4, 14, 5, 0, -11 },
  { 77, 6, 7, 8, 1, -12 },
  { 83, 7, 7, 8, 1, -9 },
  { 90, 2, 4, 4, 1, -2 },
  { 91, 3, 1, 5, 1, -5 },
  { 92, 2, 2, 4, 1, -2 },
  { 93, 6, 11, 6, 0, -11 },
  { 102, 7, 12, 8, 1, -12 },
  { 113, 5, 11, 8, 1, -11 },
  { 120, 7, 12, 8, 1, -12 },
  { 131, 7, 12, 8, 1, -12 },
  { 142, 8, 11, 8, 0, -11 },
  { 153, 7, 11, 8, 1, -11 },
  { 163, 7, 12, 8, 1, -12 },
  { 174, 7, 11, 8, 1, -11 },
  { 184, 7, 12, 8, 1, -12 },
  { 195, 7, 12, 8, 1, -12 },
  { 206, 2, 9, 4, 1, -9 },
  { 209, 2, 11, 4, 1, -9 },
  { 212, 7, 8, 8, 1, -10 },
  { 219, 7, 5, 8, 1, -8 },
  { 224, 7, 8, 8, 1, -10 },
  { 231, 6, 12, 6, 0, -12 },
  { 240, 11, 12, 13, 1, -11 },
  { 257, 9, 11, 9, 0, -11 },
  { 270, 8, 11, 10, 1, -11 },
  { 281, 8, 12, 9, 1, -12 },
  { 293, 9, 11, 11, 1, -11 },
  { 306, 6, 11, 8, 1, -11 },
  { 315, 6, 11, 8, 1, -11 },
  { 324, 9, 12, 11, 1, -12 },
  { 338, 8, 11, 11, 1, -11 },
  { 349, 4, 11, 5, 1, -11 },
  { 355, 4, 14, 4, -1, -11 },
  { 362, 8, 11, 9, 1, -11 },
  { 373, 6, 11, 8, 1, -11 },
  { 382, 11, 11, 14, 1, -11 },
  { 398, 9, 11, 11, 1, -11 },
  { 411, 9, 12, 11, 1, -12 },
  { 425, 7, 11, 9, 1, -11 },
  { 435, 9, 15, 11, 1, -12 },
  { 452, 8, 11, 9, 1, -11 },
  { 463, 6, 12, 8, 1, -12 },
  { 472, 8, 11, 8, 0, -11 },
  { 483, 8, 11, 11, 1, -11 },
  { 494, 9, 11, 9, 0, -11 },
  { 507, 14, 11, 14, 0, -11 },
  { 527, 9, 11, 9, 0, -11 },
  { 540, 8, 11, 8, 0, -11 },
  { 551, 8, 11, 8, 0, -11 },
  { 562, 4, 14, 5, 1, -11 },
  { 569, 6, 11, 6, 0, -11 },
  { 578, 4, 14, 5, 0, -11 },
  { 585, 8, 6, 9, 0, -11 },
  { 591, 7, 1, 7, 0, 1 },
  { 592, 3, 2, 5, 1, -12 },
  { 593, 6, 9, 8, 1, -9 },
  { 600, 7, 12, 9, 1, -12 },
  { 611, 6, 9, 7, 1, -9 },
  { 618, 7, 12, 9, 1, -12 },
  { 629, 7, 9, 8, 1, -9 },
  { 637, 6, 12, 5, 0, -12 },
  { 646, 7, 13, 9, 1, -9 },
  { 658, 7, 12, 9, 1, -12 },
  { 669, 2, 12, 4, 1, -12 },
  { 672, 4, 16, 4, -1, -12 },
  { 680, 7, 12, 8, 1, -12 },
  { 691, 2, 12, 4, 1, -12 },
  { 694, 12, 9, 14, 1, -9 },
  { 708, 7, 9, 9, 1, -9 },
  { 716, 7, 9, 9, 1, -9 },
  { 724, 7, 13, 9, 1, -9 },
  { 736, 7, 13, 9, 1, -9 },
  { 748, 5, 9, 6, 1, -9 },
  { 754, 5, 9, 7, 1, -9 },
  { 760, 5, 11, 6, 0, -11 },
  { 767, 7, 9, 9, 1, -9 },
  { 775, 8, 9, 8, 0, -9 },
  { 784, 12, 9, 12, 0, -9 },
  { 798, 8, 9, 8, 0, -9 },
  { 807, 8, 13, 8, 0, -9 },
  { 820, 5, 9, 7, 1, -9 },
  { 826, 5, 14, 6, 0, -11 },
  { 835, 2, 16, 8, 3, -12 },
  { 839, 5, 14, 6, 1, -11 },
  { 848, 7, 2, 8, 1, -7 },
};

const GFXfont NotoSans_SemiCondensed_Medium16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium16pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM16PT7B_H_
