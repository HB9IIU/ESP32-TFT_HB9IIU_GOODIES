#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM34PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium34pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x70,
  0x00, 0x0F, 0x7F, 0xEE, 0xF3, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x76,
  0x1D, 0x87, 0x61, 0xC0, 0x03, 0x87, 0x00, 0xE1, 0x80, 0x38, 0xE0, 0x0C,
  0x38, 0x03, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xC1, 0xFF, 0xFF, 0x7F, 0xFF,
  0xC1, 0x87, 0x00, 0x61, 0xC0, 0x38, 0x70, 0x0E, 0x18, 0x03, 0x86, 0x0F,
  0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x87, 0x0E, 0x01, 0xC3, 0x00, 0x70,
  0xC0, 0x1C, 0x70, 0x06, 0x1C, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x03, 0xFC, 0x3F, 0xFD, 0xFF, 0xEF, 0x31, 0xB8, 0xC0,
  0xE3, 0x03, 0x8C, 0x0F, 0x30, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x80, 0x7F,
  0x00, 0xFE, 0x03, 0x3C, 0x0C, 0x70, 0x31, 0xC0, 0xC7, 0x83, 0x3F, 0xFF,
  0xEF, 0xFF, 0x1F, 0xF8, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x0C,
  0x00, 0x00, 0x1F, 0x80, 0x38, 0x1F, 0xE0, 0x38, 0x0E, 0x70, 0x18, 0x07,
  0x1C, 0x1C, 0x03, 0x0E, 0x0C, 0x03, 0x87, 0x0E, 0x01, 0xC3, 0x87, 0x00,
  0xE1, 0xC7, 0x00, 0x70, 0xE3, 0x80, 0x18, 0x73, 0x8F, 0x0E, 0x39, 0xDF,
  0xC7, 0x39, 0xCF, 0xF1, 0xFC, 0xEE, 0x38, 0xFC, 0xE7, 0x1C, 0x18, 0x73,
  0x86, 0x00, 0x71, 0xC3, 0x80, 0x38, 0xE1, 0xC0, 0x38, 0x70, 0xE0, 0x1C,
  0x38, 0x70, 0x1C, 0x1C, 0x30, 0x0E, 0x0E, 0x38, 0x0E, 0x03, 0x9C, 0x07,
  0x01, 0xFC, 0x07, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0x80, 0x07,
  0xFE, 0x00, 0x3C, 0xF0, 0x01, 0xC3, 0xC0, 0x1E, 0x0E, 0x00, 0xF0, 0xF0,
  0x03, 0x87, 0x80, 0x1E, 0x78, 0x00, 0xF7, 0xC0, 0x03, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x1F, 0xF0, 0x78, 0xF7, 0xC3, 0xCF, 0x1F, 0x1C,
  0x70, 0x79, 0xE7, 0x81, 0xEE, 0x3C, 0x07, 0xF1, 0xE0, 0x1F, 0x07, 0x80,
  0xF8, 0x3C, 0x0F, 0xE1, 0xFF, 0xFF, 0x87, 0xFF, 0x3E, 0x0F, 0xF0, 0xF8,
  0xFF, 0xFF, 0xEE, 0x66, 0x60, 0x07, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x38,
  0x78, 0x78, 0x70, 0x70, 0x70, 0x70, 0xF0, 0xF0, 0xF0, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x78, 0x38, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0xF0, 0x70,
  0x38, 0x38, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x3C,
  0x38, 0x70, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x04, 0x38,
  0x4F, 0x77, 0xBF, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x1D, 0xC0, 0x3B, 0x80,
  0xE3, 0x83, 0xC7, 0x83, 0x04, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x3C, 0xE7, 0x9E, 0x71, 0xC7, 0x38, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xE0,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x00, 0x01, 0x80, 0x1F, 0xE0, 0x7F, 0xE1, 0xF7, 0xC3, 0xC3,
  0xCF, 0x03, 0x9E, 0x07, 0xB8, 0x0F, 0x70, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0,
  0x3D, 0xC0, 0x7B, 0xC0, 0xF7, 0x81, 0xC7, 0x87, 0x8F, 0xFE, 0x0F, 0xFC,
  0x0F, 0xE0, 0x03, 0xC1, 0xF0, 0xFC, 0x7F, 0x7F, 0xFE, 0xF6, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x01, 0x80, 0x3F, 0xE1,
  0xFF, 0xE3, 0xE7, 0xE3, 0x03, 0xC4, 0x03, 0x80, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0x00, 0x7F, 0xE3, 0xFF,
  0xE3, 0xE7, 0xE2, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x01, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xFF, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF8, 0x07,
  0xBF, 0xFF, 0x7F, 0xFC, 0x7F, 0xE0, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xB8, 0x03, 0xB8, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x38,
  0x0E, 0x38, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x38, 0x70, 0x38,
  0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x9C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xFF, 0x0F,
  0xFF, 0x3F, 0xFE, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x7B, 0xFF, 0xCF, 0xFF, 0x1F, 0xF0,
  0x00, 0x70, 0x1F, 0xE1, 0xFF, 0x8F, 0xC2, 0x3C, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x7E, 0x3B, 0xFE, 0xFE, 0xFB, 0xC0,
  0xFF, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0,
  0x3D, 0xE1, 0xF3, 0xFF, 0x8F, 0xFC, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x03, 0x80, 0x1F, 0xE0, 0xFF, 0xE1, 0xE1,
  0xE7, 0x81, 0xCF, 0x03, 0xDC, 0x07, 0xBC, 0x0F, 0x78, 0x1C, 0x78, 0x78,
  0x7F, 0xE0, 0x7F, 0x80, 0x7E, 0x03, 0xFE, 0x0F, 0x1F, 0x3C, 0x1E, 0x70,
  0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x00, 0xEF, 0x03, 0xDF, 0xFF,
  0x1F, 0xFC, 0x0F, 0xF0, 0x01, 0x00, 0x1F, 0xC0, 0xFF, 0xE1, 0xF7, 0xC7,
  0x83, 0xCE, 0x03, 0x9C, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x1D, 0xC0,
  0x7B, 0x80, 0xF7, 0x83, 0xE7, 0xFF, 0xCF, 0xFB, 0x87, 0xE7, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x1F, 0x0F, 0xFC, 0x1F,
  0xF0, 0x3F, 0x80, 0x67, 0xBF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0xFF, 0xFC, 0x31, 0xE7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x39, 0xE7, 0x9C, 0x71, 0xCE, 0x00, 0x00, 0x06, 0x00,
  0x3C, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x01,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x1F, 0x80,
  0x3C, 0x00, 0x60, 0x00, 0x02, 0x01, 0xFF, 0x3F, 0xFC, 0xFB, 0xE4, 0x07,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x0F, 0x80, 0xF0, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x38, 0x00, 0x0E, 0x70, 0x3F, 0x0E, 0x70, 0xFF, 0x86, 0x60, 0xF7, 0x87,
  0xE1, 0xC3, 0x87, 0xE3, 0xC3, 0x87, 0xE3, 0x83, 0x87, 0xE3, 0x83, 0x87,
  0xC3, 0x83, 0x87, 0xC3, 0x83, 0x87, 0xE3, 0x83, 0x87, 0xE3, 0x87, 0x8E,
  0xE1, 0xC7, 0xCE, 0xE1, 0xFC, 0xFC, 0xE0, 0xF8, 0xF8, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x40, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00,
  0x79, 0xE0, 0x07, 0x9E, 0x00, 0x70, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x0E, 0x07, 0x01, 0xE0, 0x78, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF,
  0x83, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0x80, 0x1C, 0x78, 0x01, 0xE7, 0x80,
  0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0F, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xE0, 0x3E, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1C,
  0xE0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xFC, 0xE0, 0x3E, 0xE0, 0x1E,
  0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x3E,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0x60, 0x07, 0xFF, 0x0F, 0xFF,
  0x1F, 0xFF, 0x3E, 0x02, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x01, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0xFF, 0xE0, 0x7F, 0xFC,
  0x3F, 0xFF, 0x1C, 0x07, 0xCE, 0x01, 0xF7, 0x00, 0x7B, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xDC, 0x03, 0xEE, 0x07, 0xE7, 0xFF, 0xE3, 0xFF, 0xC1, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x30, 0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3E, 0x00, 0x8F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x77, 0x80, 0x1D, 0xE0, 0x07, 0x3C, 0x01, 0xCF, 0x80,
  0x71, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF, 0x80, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xFF,
  0xFF, 0xCF, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC1, 0xFB,
  0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x0F, 0xBF, 0xFE, 0xFC, 0x70, 0xF0, 0x0F, 0xF0,
  0x1E, 0xF0, 0x3C, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0xF0, 0xF1, 0xE0, 0xF3,
  0xC0, 0xF3, 0xC0, 0xF7, 0x80, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFB,
  0xC0, 0xF1, 0xE0, 0xF1, 0xE0, 0xF0, 0xF0, 0xF0, 0xF8, 0xF0, 0x78, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x0E, 0xFD,
  0xC0, 0x1D, 0xFB, 0x80, 0x3B, 0xF7, 0x80, 0xE7, 0xE7, 0x01, 0xCF, 0xCE,
  0x03, 0x9F, 0x9E, 0x0E, 0x3F, 0x1C, 0x1C, 0x7E, 0x38, 0x38, 0xFC, 0x78,
  0xE1, 0xF8, 0x71, 0xC3, 0xF0, 0xE3, 0x87, 0xE1, 0xCE, 0x0F, 0xC1, 0xDC,
  0x1F, 0x83, 0xB8, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x0F, 0x81,
  0xF8, 0x1E, 0x03, 0xF0, 0x1C, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFE, 0x01, 0xFB, 0x80, 0x7E, 0xF0, 0x1F, 0x9E, 0x07,
  0xE7, 0x81, 0xF8, 0xF0, 0x7E, 0x3C, 0x1F, 0x87, 0x87, 0xE1, 0xE1, 0xF8,
  0x3C, 0x7E, 0x07, 0x1F, 0x81, 0xE7, 0xE0, 0x3D, 0xF8, 0x0F, 0x7E, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0x00, 0x60, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3E, 0x07,
  0xC7, 0x80, 0x3E, 0x78, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x01, 0xE7,
  0x80, 0x1E, 0x7C, 0x03, 0xC3, 0xE0, 0x7C, 0x1F, 0xFF, 0x80, 0xFF, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0xE3, 0xFF, 0xCF, 0xFF, 0xB8, 0x1F, 0xE0, 0x3F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xF8, 0x7E,
  0xFF, 0xF3, 0xFF, 0x8F, 0xF0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x3E, 0x07, 0xC7, 0x80, 0x3E,
  0x78, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x7C,
  0x03, 0xC3, 0xE0, 0x7C, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0xFF, 0xE0, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x7C, 0xE0,
  0x3C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0,
  0x78, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xC0, 0xE1, 0xE0, 0xE0, 0xE0, 0xE0,
  0xF0, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0,
  0x1E, 0xE0, 0x0F, 0x03, 0x00, 0x7F, 0xE7, 0xFF, 0x9F, 0xFE, 0xF0, 0x13,
  0xC0, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0xC0,
  0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3B, 0x01, 0xEF, 0xFF, 0x3F, 0xF8, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xE7, 0x81, 0xF3, 0xFF,
  0xF0, 0xFF, 0xF0, 0x1F, 0xF0, 0xF0, 0x01, 0xEE, 0x00, 0x39, 0xC0, 0x0F,
  0x3C, 0x01, 0xE7, 0x80, 0x38, 0x70, 0x07, 0x0F, 0x01, 0xE1, 0xE0, 0x3C,
  0x1C, 0x07, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x07, 0x07, 0x00, 0xE1, 0xE0,
  0x1E, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0xBC, 0x00, 0x77, 0x00,
  0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0xF0, 0x07, 0x80, 0x7B, 0x80, 0x7C, 0x03, 0xDC, 0x03, 0xE0,
  0x1C, 0xF0, 0x1F, 0x00, 0xE7, 0x80, 0xFC, 0x0F, 0x1C, 0x0E, 0xE0, 0x78,
  0xE0, 0x77, 0x03, 0xC7, 0x83, 0xB8, 0x1C, 0x3C, 0x1D, 0xE0, 0xE0, 0xE1,
  0xE7, 0x0F, 0x07, 0x0E, 0x38, 0x78, 0x38, 0x71, 0xC3, 0x81, 0xE3, 0x8F,
  0x1C, 0x0F, 0x3C, 0x39, 0xE0, 0x39, 0xC1, 0xCF, 0x01, 0xCE, 0x0E, 0x70,
  0x0F, 0x70, 0x7B, 0x80, 0x7B, 0x81, 0xDC, 0x01, 0xF8, 0x0F, 0xE0, 0x0F,
  0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x00,
  0x7C, 0x00, 0x78, 0x03, 0xC0, 0x78, 0x03, 0xCE, 0x01, 0xE3, 0xC0, 0xF0,
  0x78, 0x3C, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x1E, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x80, 0x1E, 0xF0, 0x0F, 0x3C, 0x03, 0x87, 0x81, 0xE1, 0xE0,
  0x70, 0x3C, 0x3C, 0x0F, 0x0E, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x0F, 0xF0,
  0x03, 0xDE, 0x01, 0xE7, 0x80, 0x70, 0xF0, 0x3C, 0x3C, 0x0E, 0x07, 0x07,
  0x81, 0xE1, 0xE0, 0x38, 0xF0, 0x0F, 0x3C, 0x01, 0xCE, 0x00, 0x7F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0xFF, 0xE0, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0xFF, 0xFF,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x70,
  0x0E, 0x70, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x0E,
  0x70, 0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x78, 0x3C, 0x1E,
  0x0F, 0x01, 0x80, 0x7F, 0xC3, 0xFF, 0x86, 0x1F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x0F, 0xFC, 0xFF, 0xF7, 0xE1, 0xDE, 0x07, 0xF0, 0x1F,
  0xC0, 0x7F, 0x03, 0xDC, 0x1F, 0x7D, 0xFD, 0xFF, 0x73, 0xF8, 0xC0, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x71, 0xE0, 0xEF, 0xF1, 0xFF, 0xF3, 0xF3, 0xE7, 0x81, 0xEF, 0x03, 0xDC,
  0x03, 0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xEE, 0x01, 0xDE, 0x07, 0xBC, 0x0F, 0x7F, 0xFC, 0xEF, 0xF1, 0x8F, 0xC0,
  0x03, 0xC1, 0xFF, 0x3F, 0xF7, 0xC6, 0x78, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x81,
  0x7F, 0xF3, 0xFF, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x83, 0x0F, 0x1F, 0xDE, 0x7F, 0xFD,
  0xF3, 0xFF, 0xC1, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xDE, 0x0F,
  0xBF, 0xFF, 0x3F, 0xEE, 0x3F, 0x1C, 0x07, 0x80, 0x7F, 0x83, 0xFF, 0x1E,
  0x1E, 0x70, 0x3B, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x01, 0x7F, 0xF8,
  0xFF, 0xE0, 0xFF, 0x00, 0x03, 0xF0, 0x7F, 0x0F, 0xF0, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x7F, 0xEF, 0xFE, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x07, 0x00, 0x3F, 0x9C, 0xFF,
  0xBB, 0xE3, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xBC,
  0x1F, 0x7F, 0xFE, 0x7F, 0xFC, 0x7E, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x20, 0x1E, 0x7F, 0xF8, 0xFF, 0xE0, 0xFF, 0x80, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x70,
  0xEF, 0xF3, 0xFF, 0xEF, 0xCF, 0xBC, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xF0, 0x7F, 0xF7, 0x00, 0x07,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x0E, 0x3C, 0x78,
  0x60, 0x00, 0x00, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x71, 0xE3, 0xFF,
  0xFE, 0xF8, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x01, 0xE0, 0x7B, 0x83, 0xCE, 0x0E, 0x38, 0x78, 0xE3,
  0xC3, 0x9E, 0x0E, 0xF0, 0x3B, 0xC0, 0xFF, 0x03, 0xFE, 0x0F, 0x38, 0x38,
  0xF0, 0xE1, 0xE3, 0x87, 0x8E, 0x0F, 0x38, 0x1E, 0xE0, 0x7B, 0x80, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0,
  0x60, 0xCF, 0xF3, 0xFC, 0xFF, 0xF7, 0xFE, 0xF8, 0xFF, 0x3E, 0xF0, 0x7C,
  0x0E, 0xF0, 0x3C, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38,
  0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38,
  0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38,
  0x0F, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0F, 0x01, 0x83, 0x3F, 0xCF, 0xFF,
  0xBF, 0x3E, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xC0, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xE3,
  0xE7, 0x83, 0xDE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0x3C, 0x1E, 0x7F,
  0xF8, 0x7F, 0xF0, 0x3F, 0x80, 0x01, 0xC1, 0xDF, 0xE3, 0xFF, 0xE7, 0xE7,
  0xCF, 0x03, 0xDE, 0x07, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xDC, 0x03, 0xBC, 0x0F, 0x7C, 0x3E, 0xFF,
  0xF9, 0xDF, 0xE3, 0x9F, 0x87, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x07, 0x00, 0x3F, 0x9C,
  0xFF, 0xBB, 0xE7, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xBC, 0x1F, 0x7F, 0xFE, 0x7F, 0xFC, 0x7E, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF1, 0xFE, 0xFB, 0xFE, 0xF8, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x07,
  0x01, 0xFF, 0x9F, 0xFC, 0xF0, 0xCF, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xD0,
  0x0E, 0xFF, 0xF7, 0xFF, 0x1F, 0xF0, 0x18, 0x06, 0x03, 0x80, 0xE0, 0xFF,
  0xFF, 0xF3, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xFF, 0x1F, 0xC3, 0xF0, 0xF0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xEE, 0x03,
  0xDE, 0x0F, 0xBF, 0xFF, 0x3F, 0xEE, 0x3F, 0x9C, 0xF0, 0x0F, 0x70, 0x0F,
  0x78, 0x0E, 0x78, 0x1E, 0x38, 0x1E, 0x38, 0x1C, 0x3C, 0x3C, 0x1C, 0x3C,
  0x1C, 0x38, 0x1E, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x3E, 0x07, 0xB8,
  0x1F, 0x03, 0x9E, 0x0F, 0x81, 0xCF, 0x06, 0xE1, 0xE3, 0x87, 0x70, 0xF1,
  0xC3, 0xB8, 0x70, 0xE1, 0xDC, 0x38, 0x78, 0xE7, 0x3C, 0x1C, 0xE3, 0x9E,
  0x0E, 0x71, 0xCE, 0x07, 0x38, 0xE7, 0x03, 0xDC, 0x33, 0x80, 0xFC, 0x1F,
  0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0x80,
  0xF8, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x0F, 0x3C, 0x1E, 0x3C, 0x3C, 0x1E,
  0x3C, 0x0E, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x3C,
  0x1E, 0x78, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x0E, 0x78,
  0x1E, 0x38, 0x1E, 0x3C, 0x1C, 0x3C, 0x3C, 0x1C, 0x3C, 0x1E, 0x38, 0x0E,
  0x38, 0x0E, 0x78, 0x0F, 0x70, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7F, 0xF7, 0xFF,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC1, 0xF0, 0xFC, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x1E, 0x3F, 0x0F, 0x03, 0xF0, 0x1E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xFC, 0x1F, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF8, 0x1F, 0x81, 0xF0, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0F, 0xC0, 0x78, 0x3F,
  0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0xC1, 0xF0, 0x7E, 0x0F, 0x80, 0x7F, 0x03, 0xFF, 0xCF, 0x9F, 0xFC,
  0x07, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Medium34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 24, 9, 2, -24 },
  { 16, 10, 9, 14, 2, -24 },
  { 28, 18, 24, 20, 1, -24 },
  { 82, 14, 28, 18, 2, -26 },
  { 131, 25, 25, 27, 1, -25 },
  { 210, 21, 25, 22, 1, -25 },
  { 276, 4, 9, 8, 2, -24 },
  { 281, 8, 29, 10, 1, -24 },
  { 310, 8, 29, 10, 1, -24 },
  { 339, 15, 14, 17, 1, -26 },
  { 366, 15, 16, 18, 1, -20 },
  { 396, 6, 8, 9, 1, -4 },
  { 402, 8, 3, 10, 1, -11 },
  { 405, 5, 4, 9, 2, -4 },
  { 408, 13, 24, 13, 0, -24 },
  { 447, 15, 25, 18, 1, -25 },
  { 494, 10, 24, 18, 2, -24 },
  { 524, 15, 25, 18, 1, -25 },
  { 571, 15, 25, 18, 1, -25 },
  { 618, 16, 24, 18, 1, -24 },
  { 666, 14, 24, 18, 2, -24 },
  { 708, 14, 25, 18, 2, -25 },
  { 752, 15, 24, 18, 1, -24 },
  { 797, 15, 25, 18, 1, -25 },
  { 844, 15, 25, 18, 1, -25 },
  { 891, 5, 19, 9, 2, -19 },
  { 903, 6, 23, 9, 1, -19 },
  { 921, 15, 16, 18, 1, -20 },
  { 951, 15, 10, 18, 1, -17 },
  { 970, 15, 16, 18, 1, -20 },
  { 1000, 13, 25, 14, 0, -25 },
  { 1041, 24, 27, 28, 2, -24 },
  { 1122, 20, 24, 20, 0, -24 },
  { 1182, 16, 24, 20, 3, -24 },
  { 1230, 16, 25, 19, 2, -25 },
  { 1280, 17, 24, 22, 3, -24 },
  { 1331, 12, 24, 17, 3, -24 },
  { 1367, 12, 24, 16, 3, -24 },
  { 1403, 18, 25, 23, 2, -25 },
  { 1460, 17, 24, 23, 3, -24 },
  { 1511, 9, 24, 11, 1, -24 },
  { 1538, 8, 31, 9, -2, -24 },
  { 1569, 16, 24, 19, 3, -24 },
  { 1617, 12, 24, 16, 3, -24 },
  { 1653, 23, 24, 29, 3, -24 },
  { 1722, 18, 24, 24, 3, -24 },
  { 1776, 20, 25, 24, 2, -25 },
  { 1839, 14, 24, 19, 3, -24 },
  { 1881, 20, 31, 24, 2, -25 },
  { 1959, 16, 24, 20, 3, -24 },
  { 2007, 14, 25, 17, 2, -25 },
  { 2051, 17, 24, 17, 0, -24 },
  { 2102, 17, 24, 23, 3, -24 },
  { 2153, 19, 24, 19, 0, -24 },
  { 2210, 29, 24, 29, 0, -24 },
  { 2297, 18, 24, 18, 0, -24 },
  { 2351, 18, 24, 18, 0, -24 },
  { 2405, 15, 24, 17, 1, -24 },
  { 2450, 7, 29, 11, 3, -24 },
  { 2476, 13, 24, 13, 0, -24 },
  { 2515, 8, 29, 11, 1, -24 },
  { 2544, 16, 14, 18, 1, -24 },
  { 2572, 15, 2, 15, 0, 3 },
  { 2576, 8, 5, 10, 1, -26 },
  { 2581, 14, 19, 18, 1, -19 },
  { 2615, 15, 26, 19, 3, -26 },
  { 2664, 12, 19, 15, 2, -19 },
  { 2693, 15, 26, 19, 2, -26 },
  { 2742, 14, 19, 18, 2, -19 },
  { 2776, 12, 26, 11, 0, -26 },
  { 2815, 15, 27, 19, 2, -19 },
  { 2866, 14, 26, 19, 3, -26 },
  { 2912, 4, 25, 9, 2, -25 },
  { 2925, 7, 33, 9, -1, -25 },
  { 2954, 14, 26, 17, 3, -26 },
  { 3000, 3, 26, 9, 3, -26 },
  { 3010, 24, 19, 29, 3, -19 },
  { 3067, 14, 19, 19, 3, -19 },
  { 3101, 15, 19, 19, 2, -19 },
  { 3137, 15, 27, 19, 3, -19 },
  { 3188, 15, 27, 19, 2, -19 },
  { 3239, 10, 19, 13, 3, -19 },
  { 3263, 13, 19, 15, 1, -19 },
  { 3294, 10, 22, 12, 1, -22 },
  { 3322, 15, 18, 19, 2, -18 },
  { 3356, 16, 18, 16, 0, -18 },
  { 3392, 25, 18, 25, 0, -18 },
  { 3449, 16, 18, 17, 0, -18 },
  { 3485, 16, 26, 16, 0, -18 },
  { 3537, 12, 18, 14, 1, -18 },
  { 3564, 10, 29, 13, 1, -24 },
  { 3601, 3, 34, 17, 7, -26 },
  { 3614, 11, 29, 13, 1, -24 },
  { 3654, 15, 4, 18, 1, -14 },
};

const GFXfont NotoSans_SemiCondensed_Medium34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium34pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM34PT7B_H_
