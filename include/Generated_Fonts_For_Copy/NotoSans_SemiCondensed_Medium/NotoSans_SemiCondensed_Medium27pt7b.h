#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM27PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM27PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium27pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x02, 0xFF, 0x80, 0xE7, 0xC7, 0xC6,
  0xC6, 0xC6, 0xC6, 0xC6, 0x06, 0x30, 0x18, 0xC0, 0xC3, 0x03, 0x18, 0x0C,
  0x63, 0xFF, 0xFF, 0xFF, 0xC3, 0x18, 0x18, 0x60, 0x63, 0x81, 0x8C, 0x3F,
  0xFE, 0xFF, 0xF8, 0xE3, 0x03, 0x0C, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03,
  0x18, 0x00, 0x06, 0x00, 0x60, 0x06, 0x01, 0xFE, 0x7F, 0xE7, 0x66, 0xE6,
  0x0E, 0x60, 0x66, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x6F, 0x06,
  0x70, 0x67, 0x86, 0x7F, 0xFE, 0xFF, 0xC1, 0xF0, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x18, 0x01, 0x0F, 0x80, 0xC1, 0xF8, 0x38, 0x73, 0x06, 0x0C, 0x71,
  0xC1, 0x86, 0x30, 0x30, 0xCE, 0x06, 0x19, 0x80, 0xC7, 0x73, 0x9C, 0xCC,
  0xF9, 0xFB, 0xBB, 0x9E, 0x66, 0x31, 0x0C, 0xC6, 0x03, 0x18, 0xC0, 0x63,
  0x18, 0x18, 0x63, 0x03, 0x0C, 0x60, 0xC1, 0x8C, 0x18, 0x1F, 0x06, 0x03,
  0xE0, 0x02, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0x1C, 0x03, 0x0E, 0x01,
  0x87, 0x00, 0xE3, 0x00, 0x73, 0x80, 0x1F, 0x80, 0x07, 0x80, 0x0F, 0xC1,
  0xCF, 0x70, 0xC7, 0x3C, 0xE7, 0x0F, 0x73, 0x83, 0xF1, 0xC0, 0xF8, 0xE0,
  0x78, 0x3C, 0x7E, 0x1F, 0xFB, 0x83, 0xF0, 0xF0, 0xFB, 0x6D, 0xB0, 0x1E,
  0x30, 0xE1, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x30, 0x60, 0xE1, 0xC1, 0x83, 0x83, 0x07, 0x80, 0xE1, 0x87, 0x0E, 0x38,
  0x61, 0x87, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x63, 0x8E, 0x71,
  0xCE, 0x00, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x0E, 0x6F, 0xFF, 0xCF, 0xE0,
  0x78, 0x1B, 0x87, 0x31, 0xC7, 0x08, 0x80, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x77, 0x76, 0xEC, 0xC0, 0xFF, 0xFF, 0xC0, 0x5F, 0xF0,
  0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03,
  0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x0E, 0x00,
  0x02, 0x01, 0xF8, 0x3F, 0xC7, 0x0E, 0x70, 0xE6, 0x06, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x06,
  0x70, 0xE7, 0x9E, 0x3F, 0xC1, 0xF8, 0x0E, 0x3C, 0xFB, 0xBE, 0x68, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x04,
  0x03, 0xF8, 0xFF, 0xC6, 0x0E, 0x40, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0x06, 0x07, 0xFC, 0xFF, 0xE6, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC1, 0xF8, 0x1F, 0x80, 0x3E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0xFC, 0x1E, 0xFF, 0xC7, 0xF8, 0x01,
  0xC0, 0x1E, 0x00, 0xF0, 0x0D, 0x80, 0xEC, 0x06, 0x60, 0x73, 0x03, 0x18,
  0x30, 0xC3, 0x86, 0x18, 0x31, 0xC1, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x7F, 0xE7, 0xFE, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0xF8, 0x7F, 0xC2, 0x3E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0xC1, 0xEF, 0xFC, 0x7F, 0x80, 0x00,
  0x80, 0xFE, 0x1F, 0xE3, 0xC0, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xEF,
  0xCF, 0xFE, 0xF8, 0xEF, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x07, 0x70,
  0x77, 0x8E, 0x3F, 0xE1, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0x02, 0x03,
  0xFC, 0x7F, 0xE7, 0x0E, 0x60, 0x66, 0x06, 0x70, 0xE7, 0x0E, 0x3F, 0xC1,
  0xF8, 0x1F, 0x83, 0xBC, 0x70, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77,
  0x0E, 0x7F, 0xE3, 0xF8, 0x04, 0x03, 0xF8, 0x7F, 0xC7, 0x0E, 0xE0, 0xEE,
  0x06, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0x79, 0xF3, 0xFF, 0x1E, 0x70,
  0x06, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x3C, 0x7F, 0x87, 0xE0, 0x5F, 0xF0,
  0x00, 0x00, 0x2F, 0xF8, 0x27, 0x77, 0x00, 0x00, 0x00, 0x00, 0x77, 0x76,
  0xEC, 0xC0, 0x00, 0x10, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x70, 0x1F, 0x0F, 0x83, 0xE0,
  0xF8, 0x0E, 0x00, 0x80, 0x00, 0x0C, 0x1F, 0xEF, 0xFD, 0x07, 0x00, 0xC0,
  0x30, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x1C, 0x07, 0x00, 0x00,
  0x00, 0x08, 0x07, 0x01, 0xC0, 0x70, 0x03, 0xFE, 0x00, 0x7F, 0xF0, 0x0E,
  0x03, 0x81, 0x80, 0x0C, 0x38, 0x00, 0xE3, 0x0F, 0xC6, 0x61, 0xFC, 0x66,
  0x38, 0xC7, 0x63, 0x0C, 0x7E, 0x70, 0xC7, 0xE7, 0x0C, 0x7E, 0x70, 0xC6,
  0xE7, 0x1C, 0x66, 0x31, 0xC6, 0x63, 0xF7, 0xC6, 0x1E, 0x38, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x02, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x06, 0xE0, 0x0E, 0x60, 0x0E,
  0x70, 0x0E, 0x70, 0x1C, 0x30, 0x1C, 0x38, 0x1C, 0x38, 0x3F, 0xF8, 0x3F,
  0xFC, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x0E, 0xE0,
  0x07, 0xFF, 0xC7, 0xFF, 0x38, 0x3D, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x81,
  0xDC, 0x1C, 0xFF, 0xC7, 0xFF, 0x38, 0x3D, 0xC0, 0xEE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x0E, 0xE1, 0xF7, 0xFF, 0x3F, 0xE0, 0x00, 0x80, 0x1F, 0xF1,
  0xFF, 0x8F, 0x02, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF8, 0x61, 0xFF, 0x81, 0xFE, 0xFF, 0xC3, 0xFF, 0x8E, 0x0F,
  0x38, 0x1E, 0xE0, 0x3B, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xB8, 0x1E, 0xE7,
  0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x00, 0x00, 0xC0, 0x3F, 0xF1, 0xFF, 0xCF, 0x02,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x0F,
  0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0x70, 0x1C, 0xF0,
  0x73, 0xFF, 0xC3, 0xFE, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xC0, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x39, 0xFF, 0xF8, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE3, 0xFF, 0x7C, 0xE0, 0x7F, 0x03, 0xB8, 0x39, 0xC3, 0x8E, 0x1C,
  0x71, 0xC3, 0x9C, 0x1D, 0xC0, 0xEE, 0x07, 0xF8, 0x3F, 0xC1, 0xC7, 0x0E,
  0x38, 0x70, 0xE3, 0x87, 0x9C, 0x1C, 0xE0, 0x77, 0x03, 0xF8, 0x0E, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFC, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x03, 0xFF, 0xC0, 0x6F, 0xD8,
  0x0D, 0xFB, 0x83, 0xBF, 0x70, 0x67, 0xE6, 0x0C, 0xFC, 0xE3, 0x9F, 0x9C,
  0x63, 0xF1, 0x8C, 0x7E, 0x3B, 0x8F, 0xC7, 0x61, 0xF8, 0x6C, 0x3F, 0x0F,
  0x87, 0xE1, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0x80, 0xF0, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFD, 0xC1, 0xFB, 0x83, 0xF3, 0x87,
  0xE3, 0x8F, 0xC7, 0x1F, 0x87, 0x3F, 0x0E, 0x7E, 0x0E, 0xFC, 0x1D, 0xF8,
  0x1F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x80, 0x78, 0x01, 0x80, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0x83, 0xC3, 0x80, 0xE3, 0x80, 0x39, 0xC0, 0x1C,
  0xE0, 0x0E, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xEC, 0x00, 0xE7, 0x00,
  0x73, 0x80, 0x39, 0xC0, 0x1C, 0xF0, 0x1E, 0x38, 0x0E, 0x1F, 0x1F, 0x07,
  0xFF, 0x00, 0xFE, 0x00, 0xFF, 0x8F, 0xFE, 0xE1, 0xEE, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xEF, 0xFE, 0xFF, 0x8F, 0xC0, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x01, 0x80, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0x83, 0xC3, 0x80, 0xE3, 0x80, 0x39, 0xC0, 0x1C,
  0xE0, 0x0E, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xEC, 0x00, 0xE7, 0x00,
  0x73, 0x80, 0x39, 0xC0, 0x1C, 0xF0, 0x1E, 0x38, 0x0E, 0x1F, 0x1F, 0x07,
  0xFF, 0x00, 0xFE, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0xFF, 0x87, 0xFF, 0x38, 0x79, 0xC0, 0xEE, 0x07, 0x70,
  0x3B, 0x81, 0xDC, 0x1C, 0xE1, 0xE7, 0xFE, 0x3F, 0xC1, 0xC7, 0x0E, 0x1C,
  0x70, 0xE3, 0x83, 0x9C, 0x1C, 0xE0, 0x77, 0x03, 0xB8, 0x0E, 0x06, 0x07,
  0xFD, 0xFF, 0xB8, 0x2E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x1E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0xFC, 0x3F, 0xFF,
  0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xDC,
  0x0E, 0x78, 0x78, 0xFF, 0xC1, 0xFE, 0x00, 0xE0, 0x0E, 0xC0, 0x1D, 0xC0,
  0x73, 0x80, 0xE7, 0x01, 0xC7, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x18, 0x30,
  0x38, 0xE0, 0x71, 0xC0, 0x63, 0x00, 0xEE, 0x01, 0xDC, 0x01, 0xB0, 0x03,
  0x60, 0x07, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x38, 0x0E, 0xC0, 0x70,
  0x1D, 0xC0, 0xF0, 0x33, 0x83, 0xE0, 0xE7, 0x06, 0xC1, 0xC6, 0x0D, 0x83,
  0x8E, 0x1B, 0x87, 0x1C, 0x77, 0x1C, 0x38, 0xE6, 0x38, 0x71, 0x8C, 0x70,
  0x67, 0x1C, 0xE0, 0xEE, 0x39, 0x81, 0xDC, 0x37, 0x03, 0xB0, 0x6E, 0x03,
  0x60, 0xFC, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xE0, 0x1E, 0x03, 0xC0, 0x1C,
  0x07, 0x80, 0x70, 0x1C, 0x70, 0x70, 0xE0, 0xE0, 0xE3, 0x81, 0xC6, 0x01,
  0xDC, 0x03, 0xB0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0xEE, 0x03, 0x9C, 0x07, 0x1C, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0x3B,
  0x80, 0x78, 0xE0, 0x1D, 0xC0, 0xE7, 0x03, 0x8E, 0x1C, 0x38, 0x70, 0x73,
  0x81, 0xCE, 0x03, 0xB0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFE, 0x38, 0xE3, 0x8E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0xFF, 0xC0, 0xE0,
  0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80,
  0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0xFF,
  0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C,
  0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x06, 0x00, 0x78, 0x03, 0xC0, 0x3F, 0x01,
  0x98, 0x1C, 0xE0, 0xC3, 0x06, 0x1C, 0x60, 0x63, 0x03, 0xB8, 0x0E, 0xFF,
  0xFF, 0xFF, 0xE1, 0xC3, 0x86, 0x0C, 0x0F, 0x0F, 0xF8, 0xE7, 0x80, 0x70,
  0x0E, 0x01, 0xC3, 0xF9, 0xFF, 0x70, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x1E,
  0xFE, 0xCF, 0x98, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE7, 0x8F, 0xFC, 0xFF, 0xEF, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xF0, 0xEF, 0xFC, 0xCF, 0x80, 0x0F,
  0x87, 0xF3, 0xFD, 0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06,
  0x01, 0xC0, 0x78, 0x4F, 0xF1, 0xFC, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x0E, 0x73, 0xFB, 0x7F, 0xF7, 0x07, 0x70, 0x7E, 0x07,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0x60, 0x77, 0x07, 0x78, 0xF3, 0xFB,
  0x1F, 0x30, 0x0F, 0x03, 0xFC, 0x3D, 0xE7, 0x0E, 0x60, 0x7E, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x78, 0x23, 0xFE, 0x1F,
  0xE0, 0x03, 0x83, 0xF1, 0xF8, 0x70, 0x18, 0x06, 0x03, 0xF3, 0xFC, 0xFF,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x00, 0x0E, 0x33, 0xFB, 0x7F, 0xF7, 0x07, 0x70, 0x7E,
  0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0x60, 0x77, 0x07, 0x78, 0xF3,
  0xFB, 0x1F, 0x30, 0x03, 0x00, 0x70, 0x07, 0x40, 0xF7, 0xFE, 0x7F, 0xC0,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x39, 0xE7, 0xFE, 0xFF,
  0xFE, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x06, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1C, 0x71, 0xC0, 0x00, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0xFB, 0xE0, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xEE, 0x1C, 0xE1, 0xCE, 0x38,
  0xE7, 0x0E, 0xE0, 0xFC, 0x0F, 0xE0, 0xFF, 0x0E, 0x70, 0xE3, 0x8E, 0x38,
  0xE1, 0xCE, 0x0E, 0xE0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xC7, 0x07, 0x9B, 0xFB, 0xFB, 0xFF, 0xFF, 0xF8, 0x78, 0x7E, 0x0E,
  0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C,
  0x1F, 0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38,
  0x38, 0xC7, 0x9B, 0xFB, 0xFF, 0xF8, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x18, 0x0F, 0x80,
  0xFE, 0x0F, 0x78, 0xE0, 0xE7, 0x07, 0x70, 0x1B, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xD8, 0x0C, 0xE0, 0xE7, 0x8F, 0x1F, 0xF0, 0x7F, 0x00, 0xC7,
  0x8D, 0xFC, 0xFF, 0xEF, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xF1, 0xEF, 0xFC, 0xEF, 0x8E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x33, 0xFB, 0x7F, 0xF7,
  0x07, 0x70, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0x60, 0x77,
  0x07, 0x78, 0xF3, 0xFB, 0x1F, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0xC7, 0xCF, 0xDF, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1F, 0x1F, 0xFF, 0xBB, 0x80, 0xE0,
  0x3C, 0x07, 0xC0, 0xFC, 0x0F, 0x80, 0xE0, 0x1C, 0x07, 0xC3, 0xBF, 0xEF,
  0xF0, 0x18, 0x0C, 0x06, 0x07, 0xFF, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1F, 0x87, 0xC0, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1F,
  0x83, 0xF0, 0x7F, 0x1E, 0xFE, 0xCF, 0x98, 0xE0, 0x3F, 0x01, 0xDC, 0x1C,
  0xE0, 0xE7, 0x07, 0x18, 0x70, 0xE3, 0x87, 0x18, 0x19, 0xC0, 0xEE, 0x07,
  0x60, 0x1B, 0x00, 0xF8, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0xF0, 0x76, 0x0F,
  0x06, 0x70, 0xF0, 0xE7, 0x0F, 0x0E, 0x71, 0xF8, 0xE3, 0x19, 0x8C, 0x31,
  0x98, 0xC3, 0x99, 0x9C, 0x3B, 0x9D, 0xC1, 0xB1, 0xD8, 0x1B, 0x0D, 0x81,
  0xB0, 0xF8, 0x1F, 0x0F, 0x80, 0xE0, 0xF0, 0x0E, 0x07, 0x00, 0x70, 0x7B,
  0x83, 0x8E, 0x38, 0x71, 0xC1, 0xDC, 0x07, 0xE0, 0x3E, 0x00, 0xE0, 0x0F,
  0x80, 0x7C, 0x07, 0x70, 0x71, 0xC3, 0x8E, 0x38, 0x3B, 0xC1, 0xE0, 0xE0,
  0x3F, 0x01, 0xDC, 0x1C, 0xE0, 0xE7, 0x07, 0x1C, 0x70, 0xE3, 0x83, 0x1C,
  0x1C, 0xC0, 0xEE, 0x03, 0x70, 0x1B, 0x00, 0xF8, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0xF8, 0x07, 0x80, 0x00, 0xFF, 0xBF,
  0xEF, 0xF8, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x01,
  0xC0, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0x1F, 0x1C, 0x1C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x38, 0xF8, 0xE0, 0xF8, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x1C, 0x1C, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0,
  0xF8, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1F, 0x07, 0x1F,
  0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0xF8, 0xF0, 0x7E, 0x1F,
  0xFF, 0x83, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Medium27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 8, 7, 11, 2, -19 },
  { 16, 14, 19, 16, 1, -19 },
  { 50, 12, 23, 14, 1, -21 },
  { 85, 19, 20, 21, 1, -20 },
  { 133, 17, 20, 18, 1, -20 },
  { 176, 3, 7, 6, 2, -19 },
  { 179, 7, 23, 8, 1, -19 },
  { 200, 6, 23, 8, 1, -19 },
  { 218, 11, 12, 13, 1, -21 },
  { 235, 12, 13, 14, 1, -16 },
  { 255, 4, 7, 7, 1, -3 },
  { 259, 6, 3, 8, 1, -9 },
  { 262, 3, 4, 7, 2, -4 },
  { 264, 10, 19, 10, 0, -19 },
  { 288, 12, 20, 14, 1, -20 },
  { 318, 7, 19, 14, 2, -19 },
  { 335, 12, 20, 14, 1, -20 },
  { 365, 12, 20, 14, 1, -20 },
  { 395, 13, 19, 14, 1, -19 },
  { 426, 12, 19, 14, 1, -19 },
  { 455, 12, 20, 14, 1, -20 },
  { 485, 12, 19, 14, 1, -19 },
  { 514, 12, 20, 14, 1, -20 },
  { 544, 12, 20, 14, 1, -20 },
  { 574, 3, 15, 7, 2, -15 },
  { 580, 4, 19, 7, 1, -15 },
  { 590, 12, 13, 14, 1, -16 },
  { 610, 12, 7, 14, 1, -13 },
  { 621, 12, 13, 14, 1, -16 },
  { 641, 10, 20, 11, 0, -20 },
  { 666, 20, 21, 22, 1, -19 },
  { 719, 16, 19, 16, 0, -19 },
  { 757, 13, 19, 16, 2, -19 },
  { 788, 14, 20, 15, 1, -20 },
  { 823, 14, 19, 18, 2, -19 },
  { 857, 10, 19, 14, 2, -19 },
  { 881, 10, 19, 13, 2, -19 },
  { 905, 14, 20, 18, 2, -20 },
  { 940, 14, 19, 18, 2, -19 },
  { 974, 7, 19, 9, 1, -19 },
  { 991, 7, 24, 7, -2, -19 },
  { 1012, 13, 19, 15, 2, -19 },
  { 1043, 10, 19, 13, 2, -19 },
  { 1067, 19, 19, 23, 2, -19 },
  { 1113, 15, 19, 19, 2, -19 },
  { 1149, 17, 20, 19, 1, -20 },
  { 1192, 12, 19, 15, 2, -19 },
  { 1221, 17, 25, 19, 1, -20 },
  { 1275, 13, 19, 16, 2, -19 },
  { 1306, 11, 20, 14, 1, -20 },
  { 1334, 13, 19, 14, 0, -19 },
  { 1365, 14, 19, 18, 2, -19 },
  { 1399, 15, 19, 15, 0, -19 },
  { 1435, 23, 19, 23, 0, -19 },
  { 1490, 15, 19, 15, 0, -19 },
  { 1526, 14, 19, 14, 0, -19 },
  { 1560, 12, 19, 14, 1, -19 },
  { 1589, 6, 23, 9, 2, -19 },
  { 1607, 10, 19, 10, 0, -19 },
  { 1631, 6, 23, 9, 1, -19 },
  { 1649, 13, 11, 14, 1, -19 },
  { 1667, 12, 2, 12, 0, 2 },
  { 1670, 6, 5, 8, 1, -21 },
  { 1674, 11, 15, 14, 1, -15 },
  { 1695, 12, 21, 15, 2, -21 },
  { 1727, 10, 15, 12, 1, -15 },
  { 1746, 12, 21, 15, 1, -21 },
  { 1778, 12, 15, 14, 1, -15 },
  { 1801, 10, 21, 9, 0, -21 },
  { 1828, 12, 21, 15, 1, -15 },
  { 1860, 11, 21, 15, 2, -21 },
  { 1889, 3, 20, 7, 2, -20 },
  { 1897, 6, 26, 7, -1, -20 },
  { 1917, 12, 21, 14, 2, -21 },
  { 1949, 3, 21, 7, 2, -21 },
  { 1957, 19, 15, 23, 2, -15 },
  { 1993, 11, 15, 15, 2, -15 },
  { 2014, 13, 15, 15, 1, -15 },
  { 2039, 12, 21, 15, 2, -15 },
  { 2071, 12, 21, 15, 1, -15 },
  { 2103, 8, 15, 10, 2, -15 },
  { 2118, 10, 15, 12, 1, -15 },
  { 2137, 9, 18, 9, 0, -18 },
  { 2158, 11, 15, 15, 2, -15 },
  { 2179, 13, 15, 13, 0, -15 },
  { 2204, 20, 15, 20, 0, -15 },
  { 2242, 13, 15, 13, 0, -15 },
  { 2267, 13, 21, 13, 0, -15 },
  { 2302, 10, 15, 11, 1, -15 },
  { 2321, 8, 23, 10, 1, -19 },
  { 2344, 2, 27, 14, 6, -21 },
  { 2351, 8, 23, 10, 1, -19 },
  { 2374, 12, 3, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_Medium27pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium27pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium27pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM27PT7B_H_
