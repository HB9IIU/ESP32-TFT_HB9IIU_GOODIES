#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM40PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x73,
  0x9C, 0xE7, 0x00, 0x00, 0xF7, 0xFF, 0xFF, 0x00, 0xF8, 0xFF, 0x8F, 0x78,
  0xF7, 0x8F, 0x78, 0xF7, 0x0F, 0x70, 0xF7, 0x0F, 0x70, 0x77, 0x07, 0x70,
  0x70, 0x00, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x03, 0x83,
  0x83, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x38, 0x70, 0x03,
  0xC3, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x78,
  0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x07, 0x07, 0x00, 0x38,
  0x38, 0x01, 0xC3, 0xC0, 0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x07, 0x00,
  0x38, 0x38, 0x01, 0xC3, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0xFF, 0x81, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFD, 0xF3, 0x84, 0xF1,
  0xC0, 0x78, 0xE0, 0x3C, 0x70, 0x1F, 0x38, 0x07, 0xDC, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x77, 0xE0, 0x39,
  0xF0, 0x1C, 0x78, 0x0E, 0x3C, 0x07, 0x1F, 0x83, 0x9F, 0xF9, 0xFF, 0x7F,
  0xFF, 0x3F, 0xFF, 0x03, 0xFE, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x1E, 0x00, 0x1C, 0x03, 0xF8, 0x01, 0xC0, 0x7F, 0xC0, 0x38,
  0x0F, 0x1C, 0x03, 0x80, 0xF1, 0xE0, 0x70, 0x0E, 0x1E, 0x07, 0x00, 0xE0,
  0xE0, 0xF0, 0x0E, 0x0E, 0x0E, 0x00, 0xE0, 0xE1, 0xE0, 0x0E, 0x0E, 0x1C,
  0x00, 0xE0, 0xE3, 0xC0, 0x0E, 0x0E, 0x38, 0x20, 0xE1, 0xE7, 0x9F, 0x8F,
  0x1E, 0x73, 0xFC, 0x71, 0xCF, 0x3D, 0xE7, 0xFC, 0xE7, 0x8E, 0x3F, 0x9E,
  0x70, 0xF1, 0xE1, 0xC7, 0x07, 0x00, 0x3C, 0x70, 0x70, 0x03, 0x87, 0x07,
  0x00, 0x78, 0x70, 0x70, 0x07, 0x07, 0x07, 0x00, 0xF0, 0x70, 0x70, 0x0E,
  0x07, 0x07, 0x01, 0xE0, 0x70, 0xF0, 0x1C, 0x07, 0x8E, 0x03, 0xC0, 0x3F,
  0xE0, 0x38, 0x03, 0xFC, 0x07, 0x80, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xE0, 0x02, 0x3F, 0xF0, 0x3C, 0x7C, 0xF8, 0x3C, 0x78,
  0x7C, 0x3C, 0xF8, 0x3E, 0x7C, 0xF0, 0x3E, 0x78, 0xF0, 0x1F, 0xF8, 0xF0,
  0x0F, 0xF0, 0xF0, 0x07, 0xF0, 0xF0, 0x03, 0xE0, 0xF8, 0x07, 0xF0, 0xFE,
  0x1F, 0xF8, 0x7F, 0xFF, 0x7C, 0x3F, 0xFE, 0x7E, 0x0F, 0xF8, 0x3F, 0xFF,
  0xDE, 0xF7, 0xB9, 0xCE, 0x73, 0x9C, 0x07, 0x83, 0x83, 0xC3, 0xC1, 0xE1,
  0xE0, 0xF0, 0xF0, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x1E,
  0x03, 0x80, 0xF0, 0x1C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x0E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81,
  0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x04, 0x1C, 0x0B, 0xCE, 0x3D, 0xFF, 0xFE, 0xFF, 0xFF, 0x9F,
  0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xEF, 0x00, 0xF3, 0xC0, 0xF1, 0xF0,
  0x78, 0x78, 0x08, 0x30, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3E, 0x7C, 0xF1,
  0xE3, 0xCF, 0x1E, 0x3C, 0x71, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x07, 0xFC, 0x07, 0xFF, 0x07, 0xFF, 0xC7, 0xC1, 0xE3, 0xC0, 0x79, 0xE0,
  0x3D, 0xF0, 0x1E, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7D, 0xE0, 0x3C, 0xF0,
  0x1E, 0x7C, 0x1F, 0x1F, 0x1F, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x00,
  0x01, 0xE0, 0x7C, 0x1F, 0x87, 0xF1, 0xFE, 0x7F, 0xFF, 0x7F, 0x8F, 0x61,
  0xE4, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x07, 0xE0, 0x1F, 0xFC, 0x1F, 0xFF, 0x1F, 0xFF,
  0xC7, 0x01, 0xF3, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF,
  0x9F, 0xFF, 0xC7, 0x01, 0xF2, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x1F, 0xC0, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x70,
  0x1F, 0xBF, 0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3B,
  0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x00, 0x71, 0xE0, 0x1E, 0x3C, 0x03, 0x87,
  0x80, 0xF0, 0xF0, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x78, 0x38, 0x0F,
  0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x8F,
  0xFF, 0xC7, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x7C, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF,
  0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x80, 0x1F, 0x78, 0x3F,
  0x3F, 0xFF, 0x9F, 0xFF, 0x87, 0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x03,
  0xFF, 0x83, 0xFF, 0xC1, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x3F, 0x0F, 0x7F, 0xE7, 0xFF,
  0xF3, 0xF8, 0xFD, 0xF8, 0x1F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x7C, 0x0F,
  0x1F, 0x0F, 0x87, 0xFF, 0x83, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0xC7, 0xE7,
  0x80, 0xF3, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1E, 0x78, 0x0F, 0x3C, 0x07,
  0x9F, 0x07, 0x87, 0xC7, 0xC1, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xC0, 0x3F,
  0xF8, 0x3E, 0x7E, 0x3E, 0x0F, 0xBE, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFE, 0x0F, 0x9F, 0xFF,
  0xC7, 0xFF, 0xC0, 0xFF, 0x80, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F,
  0xFF, 0xC7, 0xC1, 0xE7, 0xC0, 0x7B, 0xC0, 0x3D, 0xE0, 0x1F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7D, 0xF0,
  0x7E, 0xFF, 0xFF, 0x3F, 0xF7, 0x8F, 0xF3, 0xC0, 0xC1, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x7E,
  0x1F, 0xFE, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0x77, 0xFF, 0xFF, 0xB0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xF8, 0x1C, 0x7C, 0xF9,
  0xF3, 0xC3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0xF9, 0xE3, 0xC7, 0x9E, 0x3C, 0x78, 0xE3, 0xC0, 0x00, 0x00, 0x80,
  0x01, 0xC0, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01,
  0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x20, 0x00, 0x00, 0x0F, 0xE0, 0x7F,
  0xF3, 0xFF, 0xF3, 0xFF, 0xF6, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x00, 0x78, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x07, 0x87, 0x80, 0x00, 0x1C, 0x3C, 0x0F, 0xF0,
  0xF1, 0xC1, 0xFF, 0xC3, 0x9C, 0x1F, 0xFE, 0x1C, 0xE0, 0xF0, 0xF0, 0xE7,
  0x0F, 0x07, 0x87, 0x78, 0x70, 0x3C, 0x3F, 0x83, 0x81, 0xE1, 0xFC, 0x3C,
  0x0E, 0x0F, 0xE1, 0xE0, 0x70, 0x7F, 0x0F, 0x03, 0x83, 0xB8, 0x78, 0x1C,
  0x1D, 0xC1, 0xC1, 0xE0, 0xEE, 0x0E, 0x0F, 0x8F, 0x78, 0x78, 0xFC, 0xF1,
  0xC1, 0xFE, 0x7F, 0x0E, 0x07, 0xE3, 0xF0, 0x78, 0x04, 0x02, 0x01, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0xC0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF3, 0x80, 0x01,
  0xE7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0xF0, 0x0F, 0x01,
  0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1E, 0x1E, 0x00, 0x3E, 0x7C, 0x00, 0x3C,
  0xF8, 0x00, 0x79, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xE0,
  0xFF, 0x80, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x80, 0xFD,
  0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0x7B,
  0xE0, 0x1F, 0x7C, 0x07, 0xCF, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F, 0xFF, 0x87,
  0xFF, 0xFC, 0xF8, 0x0F, 0xDF, 0x00, 0x7B, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x07, 0xDF,
  0xFF, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0x80, 0x00, 0x7F, 0x00,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x80, 0x43, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xFE, 0x1E, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0x81, 0xFC, 0x7C,
  0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0xF8, 0x00, 0xF7, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x7C, 0x00, 0xFB, 0xE0, 0x07, 0x9F, 0x00,
  0x7C, 0xF8, 0x0F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x7F, 0xFE, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFE, 0xFF, 0xFD, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xC0, 0x30, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F,
  0x78, 0x00, 0x3D, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x1F,
  0x00, 0x3C, 0x7F, 0x83, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x01, 0xFF,
  0xF0, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xDF, 0xFB, 0xFE, 0x7F, 0x87,
  0xC0, 0xF8, 0x01, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8,
  0x0F, 0x8F, 0x81, 0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF8, 0x7C, 0x0F,
  0x8F, 0x80, 0xF9, 0xF0, 0x0F, 0x9E, 0x00, 0xFB, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xCF, 0x80, 0xF8, 0x7C,
  0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0xF8, 0x1F, 0x0F, 0x80,
  0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x03, 0xCF, 0x80, 0x3E, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xEF, 0xF7, 0x00, 0x0E, 0xFF, 0x78, 0x01,
  0xEF, 0xF7, 0x80, 0x1C, 0xFF, 0x38, 0x01, 0xCF, 0xF3, 0xC0, 0x3C, 0xFF,
  0x3C, 0x03, 0x8F, 0xF1, 0xC0, 0x38, 0xFF, 0x1E, 0x07, 0x8F, 0xF1, 0xE0,
  0x70, 0xFF, 0x0E, 0x07, 0x0F, 0xF0, 0xF0, 0xF0, 0xFF, 0x0F, 0x0E, 0x0F,
  0xF0, 0x70, 0xE0, 0xFF, 0x07, 0x9E, 0x0F, 0xF0, 0x79, 0xC0, 0xFF, 0x03,
  0x9C, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0x80,
  0xFF, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0,
  0x0F, 0x00, 0xF0, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFD, 0xE0,
  0x0F, 0xF7, 0xC0, 0x3F, 0xCF, 0x80, 0xFF, 0x1E, 0x03, 0xFC, 0x7C, 0x0F,
  0xF0, 0xF0, 0x3F, 0xC3, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x1F, 0x0F, 0xF0,
  0x3C, 0x3F, 0xC0, 0xF8, 0xFF, 0x01, 0xF3, 0xFC, 0x03, 0xCF, 0xF0, 0x0F,
  0xBF, 0xC0, 0x1E, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F,
  0x80, 0xF8, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3F,
  0x00, 0xFC, 0x1F, 0xE3, 0xF8, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x9F, 0xFF, 0xEF, 0x83,
  0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE,
  0x01, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xE3, 0xFD, 0xFF, 0xFC,
  0xFF, 0xFC, 0x7F, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x80, 0xF8, 0x3E, 0x00, 0x7C, 0x3C, 0x00,
  0x3C, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x3C, 0x00,
  0x3E, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0xFC, 0x1F, 0xE3, 0xF8, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xF8, 0x1F, 0x8F, 0x80, 0xF8, 0xF8, 0x07, 0x8F, 0x80, 0x78,
  0xF8, 0x07, 0xCF, 0x80, 0x78, 0xF8, 0x07, 0x8F, 0x80, 0x78, 0xF8, 0x0F,
  0x8F, 0x83, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0x87,
  0x80, 0xF8, 0x7C, 0x0F, 0x83, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0xF8,
  0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0xF8, 0x07, 0xCF,
  0x80, 0x3E, 0xF8, 0x01, 0xF0, 0x07, 0xF8, 0x1F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFE, 0x7C, 0x06, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x1F, 0xF8, 0x7E, 0xFF, 0xFE, 0xFF,
  0xF8, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xE3, 0xF8, 0xFE, 0x1F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0x80,
  0x07, 0xDE, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F,
  0x0F, 0x00, 0x3C, 0x3E, 0x00, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1E, 0x07,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xE0,
  0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xC0,
  0x03, 0xCF, 0x00, 0x07, 0x3C, 0x00, 0x1E, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xFE, 0x00, 0x78, 0x00, 0xF7, 0x80, 0x1F,
  0x00, 0x3D, 0xE0, 0x0F, 0xC0, 0x1F, 0x78, 0x03, 0xF0, 0x07, 0x9F, 0x00,
  0xFE, 0x01, 0xE3, 0xC0, 0x3F, 0x80, 0x78, 0xF0, 0x1F, 0xE0, 0x3E, 0x3C,
  0x07, 0xB8, 0x0F, 0x0F, 0x81, 0xEF, 0x03, 0xC1, 0xE0, 0x73, 0xC0, 0xF0,
  0x78, 0x3C, 0xF0, 0x3C, 0x1E, 0x0F, 0x1C, 0x1E, 0x07, 0x83, 0xC7, 0x87,
  0x80, 0xF0, 0xE1, 0xE1, 0xE0, 0x3C, 0x78, 0x78, 0x78, 0x0F, 0x1E, 0x0E,
  0x3C, 0x03, 0xC7, 0x83, 0xCF, 0x00, 0x79, 0xC0, 0xF3, 0xC0, 0x1E, 0xF0,
  0x3C, 0xF0, 0x07, 0xBC, 0x07, 0x78, 0x01, 0xEF, 0x01, 0xDE, 0x00, 0x3B,
  0x80, 0x7F, 0x80, 0x0E, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0xC0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0xFB, 0xE0, 0x07, 0x8F, 0x00,
  0x7C, 0x7C, 0x03, 0xC1, 0xE0, 0x3E, 0x07, 0x81, 0xE0, 0x3E, 0x1F, 0x00,
  0xF0, 0xF0, 0x07, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xFF, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0xC0, 0x0F, 0x9E, 0x00, 0x78, 0xF8,
  0x07, 0xC3, 0xC0, 0x3C, 0x1F, 0x03, 0xE0, 0x78, 0x1E, 0x03, 0xE1, 0xF0,
  0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0x80, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0x9E, 0x00, 0x7C, 0xF8, 0x03, 0xC3, 0xC0, 0x1E, 0x1F,
  0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0xF8, 0x0F, 0x07, 0x80, 0x7C, 0x7C,
  0x01, 0xE3, 0xC0, 0x0F, 0x3E, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0x70, 0x01, 0xEF, 0x00, 0x38, 0xE0, 0x0F, 0x1E, 0x01, 0xC1, 0xC0,
  0x78, 0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x78, 0x78, 0x07, 0x0E, 0x00, 0xF3,
  0xC0, 0x0E, 0x70, 0x01, 0xFE, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x0F, 0x07, 0x07, 0xF0, 0x3F, 0xFC, 0x3F,
  0xFE, 0x3E, 0x3E, 0x10, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x07, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF, 0xFC, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x7F, 0xFF, 0xFF, 0x7F,
  0xE7, 0x3F, 0xC7, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF1, 0xF8, 0x3C,
  0xFF, 0x0F, 0x7F, 0xE3, 0xFF, 0xFC, 0xFC, 0x0F, 0xBE, 0x03, 0xEF, 0x80,
  0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x1E, 0xF8, 0x07, 0xBE,
  0x03, 0xEF, 0xE1, 0xF3, 0xFF, 0xFC, 0xF7, 0xFE, 0x38, 0xFF, 0x00, 0x03,
  0xF8, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xE7, 0xC0, 0x4F, 0x00, 0x1E, 0x00,
  0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x31, 0xFF,
  0xE1, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x07,
  0xC3, 0xC7, 0xFC, 0xF3, 0xFF, 0xBC, 0xFF, 0xFF, 0x7C, 0x0F, 0xDE, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x78,
  0x07, 0xDF, 0x03, 0xF7, 0xE1, 0xFC, 0xFF, 0xEF, 0x1F, 0xFB, 0xC3, 0xF8,
  0xF0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC7, 0xC7, 0xC0, 0xF3,
  0xC0, 0x79, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0xC7, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xF0,
  0x00, 0xC0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF1, 0xF0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x01, 0xFF, 0xBF, 0xFD, 0xFF, 0xEF, 0xFF, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x00, 0x07, 0xC3, 0xC7, 0xFC, 0xF3, 0xFF, 0xBC, 0xFF, 0xFF,
  0x7C, 0x0F, 0xDE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x03, 0xF7, 0xE1, 0xFC, 0xFF, 0xEF,
  0x1F, 0xFB, 0xC3, 0xF8, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0xF9, 0xC0, 0x7E, 0x7F, 0xFF, 0x1F, 0xFF, 0x83, 0xFF,
  0xC0, 0x06, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF1, 0xF8, 0x79, 0xFF,
  0x3D, 0xFF, 0xDF, 0xFF, 0xEF, 0xC0, 0xF7, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3C, 0x6F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x03,
  0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE1, 0xFF, 0xF7, 0xFB, 0xF8, 0x60, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x0F, 0xF8, 0x0F, 0xBC, 0x0F, 0x9E, 0x07, 0x8F, 0x07, 0x87, 0x87,
  0x83, 0xC7, 0xC1, 0xE7, 0xC0, 0xF3, 0xC0, 0x7B, 0xC0, 0x3F, 0xF0, 0x1F,
  0xFC, 0x0F, 0xDE, 0x07, 0xCF, 0x83, 0xC3, 0xC1, 0xE1, 0xF0, 0xF0, 0x7C,
  0x78, 0x1E, 0x3C, 0x0F, 0x9E, 0x03, 0xEF, 0x00, 0xF7, 0x80, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE1, 0xF8, 0x1F, 0x8E, 0x7F, 0xC7, 0xFC, 0xFF, 0xFE, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0x80, 0xF8, 0x0F, 0xF8,
  0x0F, 0x80, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0,
  0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF,
  0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F,
  0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F,
  0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xE1, 0xF8, 0x71, 0xFF, 0x3D,
  0xFF, 0xDF, 0xFF, 0xEF, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3C, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xFC, 0xFC, 0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x80, 0x7F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0x78, 0x07, 0x9F, 0x01, 0xE3, 0xE1,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xE1, 0xF8, 0x3C, 0xFF,
  0x0F, 0x7F, 0xE3, 0xFD, 0xFC, 0xFC, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0x7B,
  0xC0, 0x1E, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7B, 0xE0, 0x1E, 0xF8, 0x07, 0xBF, 0x03,
  0xEF, 0xE1, 0xF3, 0xFF, 0xFC, 0xF7, 0xFE, 0x3C, 0xFE, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC3, 0xC7, 0xFC,
  0xF3, 0xFF, 0xBC, 0xFD, 0xFF, 0x7C, 0x0F, 0xDE, 0x01, 0xFF, 0x80, 0x7F,
  0xE0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x03,
  0xF7, 0xE1, 0xFC, 0xFF, 0xEF, 0x1F, 0xFB, 0xC3, 0xF8, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0xFE, 0x3F, 0xF7,
  0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0xE0, 0xFF, 0xF7, 0xFF, 0xBE, 0x1E,
  0xF0, 0x0B, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xFC,
  0x03, 0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0xFE, 0x07, 0xBF, 0xFE, 0xFF, 0xF1, 0xFF, 0x80, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x11, 0xFF, 0x0F, 0xF0, 0x7F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFF, 0x0F, 0xEF, 0xFF, 0xF3, 0xFF, 0x78, 0xFF, 0x3C, 0xF0, 0x01,
  0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x7C, 0x78, 0x0F,
  0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x01, 0xEF, 0x00, 0x3D, 0xE0,
  0x07, 0xBC, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x7B, 0xC0, 0x7C, 0x03, 0xDE, 0x03,
  0xF0, 0x1E, 0xF0, 0x1F, 0x81, 0xE7, 0x81, 0xFC, 0x0F, 0x1E, 0x0F, 0xE0,
  0x78, 0xF0, 0x77, 0x83, 0xC7, 0x83, 0x9C, 0x3C, 0x3C, 0x3C, 0xE1, 0xE0,
  0xF1, 0xE7, 0x0F, 0x07, 0x8E, 0x3C, 0x78, 0x3C, 0x71, 0xE7, 0x81, 0xE7,
  0x87, 0x3C, 0x07, 0xBC, 0x39, 0xE0, 0x3D, 0xC1, 0xEF, 0x01, 0xEE, 0x0F,
  0x70, 0x0F, 0x70, 0x3F, 0x80, 0x3F, 0x81, 0xFC, 0x01, 0xF8, 0x0F, 0xE0,
  0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0xF0,
  0x07, 0xFE, 0x03, 0xE7, 0xC0, 0xF0, 0xF0, 0x7C, 0x3E, 0x1E, 0x07, 0x8F,
  0x80, 0xF3, 0xC0, 0x3D, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0x7C, 0xF0, 0x1E,
  0x3E, 0x0F, 0x87, 0x83, 0xC1, 0xF1, 0xE0, 0x3C, 0xF8, 0x07, 0xBC, 0x01,
  0xF0, 0xF0, 0x01, 0xFF, 0x00, 0x7D, 0xE0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0,
  0x3C, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0xC1,
  0xE0, 0x3C, 0x3C, 0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x0F, 0x3C, 0x01, 0xEF,
  0x00, 0x3D, 0xE0, 0x03, 0xBC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x01, 0x80, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x18, 0x0F, 0xC0, 0xFE, 0x0F, 0xF0, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x03,
  0xE0, 0xFE, 0x07, 0xC0, 0x3F, 0x01, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF8, 0x07, 0xF8, 0x1F, 0xC0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x01, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x0F,
  0xF0, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0xFF, 0x07, 0xF0, 0x3E,
  0x00, 0x3E, 0x00, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0xFF, 0xF8, 0x0F, 0xF4,
  0x00, 0xE0,
};

const GFXglyph NotoSans_SemiCondensed_Medium40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 29, 10, 3, -29 },
  { 20, 12, 11, 17, 2, -29 },
  { 37, 21, 29, 23, 1, -29 },
  { 114, 17, 32, 21, 2, -30 },
  { 182, 28, 29, 32, 2, -29 },
  { 284, 24, 29, 26, 2, -29 },
  { 371, 5, 11, 9, 2, -29 },
  { 378, 9, 35, 12, 2, -29 },
  { 418, 10, 35, 12, 1, -29 },
  { 462, 17, 16, 20, 1, -30 },
  { 496, 17, 19, 21, 2, -24 },
  { 537, 7, 10, 10, 1, -5 },
  { 546, 10, 4, 12, 1, -13 },
  { 551, 5, 5, 10, 3, -5 },
  { 555, 15, 29, 15, 0, -29 },
  { 610, 17, 29, 21, 2, -29 },
  { 672, 11, 29, 21, 3, -29 },
  { 712, 17, 29, 21, 2, -29 },
  { 774, 17, 29, 21, 2, -29 },
  { 836, 19, 29, 21, 1, -29 },
  { 905, 17, 29, 21, 2, -29 },
  { 967, 17, 29, 21, 2, -29 },
  { 1029, 18, 29, 21, 1, -29 },
  { 1095, 17, 29, 21, 2, -29 },
  { 1157, 17, 29, 21, 2, -29 },
  { 1219, 5, 22, 10, 3, -22 },
  { 1233, 7, 27, 10, 1, -22 },
  { 1257, 17, 19, 21, 2, -24 },
  { 1298, 17, 12, 21, 2, -20 },
  { 1324, 17, 19, 21, 2, -24 },
  { 1365, 15, 29, 16, 0, -29 },
  { 1420, 29, 32, 33, 2, -29 },
  { 1536, 23, 29, 24, 0, -29 },
  { 1620, 19, 29, 24, 3, -29 },
  { 1689, 20, 29, 23, 2, -29 },
  { 1762, 21, 29, 26, 3, -29 },
  { 1839, 15, 29, 20, 3, -29 },
  { 1894, 15, 29, 19, 3, -29 },
  { 1949, 22, 29, 26, 2, -29 },
  { 2029, 21, 29, 27, 3, -29 },
  { 2106, 11, 29, 13, 1, -29 },
  { 2146, 11, 37, 11, -3, -29 },
  { 2197, 20, 29, 23, 3, -29 },
  { 2270, 15, 29, 19, 3, -29 },
  { 2325, 28, 29, 34, 3, -29 },
  { 2427, 22, 29, 28, 3, -29 },
  { 2507, 24, 29, 28, 2, -29 },
  { 2594, 17, 29, 22, 3, -29 },
  { 2656, 24, 36, 28, 2, -29 },
  { 2764, 20, 29, 23, 3, -29 },
  { 2837, 16, 29, 20, 2, -29 },
  { 2895, 20, 29, 20, 0, -29 },
  { 2968, 20, 29, 27, 3, -29 },
  { 3041, 22, 29, 22, 0, -29 },
  { 3121, 34, 29, 34, 0, -29 },
  { 3245, 21, 29, 22, 0, -29 },
  { 3322, 21, 29, 21, 0, -29 },
  { 3399, 18, 29, 20, 1, -29 },
  { 3465, 9, 35, 13, 3, -29 },
  { 3505, 15, 29, 15, 0, -29 },
  { 3560, 9, 35, 13, 1, -29 },
  { 3600, 19, 18, 21, 1, -29 },
  { 3643, 17, 2, 17, 0, 4 },
  { 3648, 8, 7, 12, 2, -31 },
  { 3655, 16, 22, 21, 2, -22 },
  { 3699, 18, 30, 23, 3, -30 },
  { 3767, 15, 22, 18, 2, -22 },
  { 3809, 18, 30, 23, 2, -30 },
  { 3877, 17, 22, 21, 2, -22 },
  { 3924, 13, 31, 13, 1, -31 },
  { 3975, 18, 32, 23, 2, -22 },
  { 4047, 17, 30, 23, 3, -30 },
  { 4111, 4, 30, 10, 3, -30 },
  { 4126, 9, 40, 10, -2, -30 },
  { 4171, 17, 30, 20, 3, -30 },
  { 4235, 4, 30, 10, 3, -30 },
  { 4250, 28, 22, 34, 3, -22 },
  { 4327, 17, 22, 23, 3, -22 },
  { 4374, 18, 22, 22, 2, -22 },
  { 4424, 18, 32, 23, 3, -22 },
  { 4496, 18, 32, 23, 2, -22 },
  { 4568, 12, 22, 15, 3, -22 },
  { 4601, 14, 22, 17, 2, -22 },
  { 4640, 12, 26, 14, 1, -26 },
  { 4679, 17, 22, 23, 3, -22 },
  { 4726, 19, 22, 19, 0, -22 },
  { 4779, 29, 22, 30, 0, -22 },
  { 4859, 18, 22, 19, 1, -22 },
  { 4909, 19, 32, 19, 0, -22 },
  { 4985, 15, 22, 17, 1, -22 },
  { 5027, 13, 35, 15, 1, -29 },
  { 5084, 4, 39, 20, 8, -30 },
  { 5104, 13, 35, 15, 1, -29 },
  { 5161, 17, 6, 21, 2, -17 },
};

const GFXfont NotoSans_SemiCondensed_Medium40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium40pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM40PT7B_H_
