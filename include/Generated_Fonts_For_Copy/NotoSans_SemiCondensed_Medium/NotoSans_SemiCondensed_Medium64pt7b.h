#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM64PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium64pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F, 0x1F, 0x8F, 0xC7,
  0xE3, 0xF1, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8,
  0x7C, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0xFE, 0xFF, 0x7F,
  0xFF, 0xFF, 0xEF, 0xF3, 0xF8, 0x70, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xBF, 0x03, 0xF7, 0xE0,
  0x7E, 0xFC, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0,
  0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x3F, 0xF7,
  0x9F, 0xC7, 0xF0, 0xF0, 0x38, 0xFC, 0x1E, 0x00, 0x3F, 0x83, 0xC0, 0x07,
  0xF0, 0x78, 0x00, 0xFE, 0x0F, 0x00, 0x1F, 0xC1, 0xE0, 0x03, 0xF8, 0x3C,
  0x00, 0x3F, 0x87, 0x80, 0x07, 0xF8, 0xF0, 0x00, 0xFF, 0xDE, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xCF, 0xF8, 0x00, 0x78, 0xFF, 0x00, 0x0F, 0x0F,
  0xE0, 0x01, 0xE0, 0xFC, 0x00, 0x3C, 0x1F, 0x80, 0x07, 0x83, 0xF0, 0x00,
  0xF0, 0x7E, 0x00, 0x1E, 0x0F, 0xF0, 0x03, 0xC3, 0xFF, 0xC0, 0x79, 0xFE,
  0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x07, 0xF3, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x00, 0x1F,
  0x81, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0,
  0x7E, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x00, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0,
  0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x1F, 0x80,
  0x00, 0x3E, 0x03, 0xF0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x0F, 0xC3, 0xFF,
  0x0F, 0xC0, 0xF8, 0x7C, 0x3F, 0xFC, 0x3E, 0x07, 0xC7, 0xE3, 0xFF, 0xF1,
  0xF0, 0x7E, 0x3E, 0x1F, 0xFF, 0x8F, 0xE7, 0xE3, 0xF1, 0xF8, 0x7E, 0x3F,
  0xFF, 0x1F, 0x0F, 0x81, 0xF0, 0xFF, 0xF0, 0xF8, 0x7C, 0x0F, 0x83, 0xFF,
  0x0F, 0x87, 0xE0, 0x7E, 0x0F, 0xF0, 0x7C, 0x3E, 0x01, 0xF0, 0x00, 0x07,
  0xE1, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xF0,
  0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x07, 0xC0,
  0x3E, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x7E, 0x01, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x00, 0x3E, 0x07, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x7C,
  0x00, 0x07, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xF8, 0x1F, 0xFF, 0xE0, 0x07, 0xF0, 0x7F,
  0xDF, 0xE0, 0x0F, 0xE0, 0xFF, 0x1F, 0xE0, 0x1F, 0xC3, 0xFC, 0x1F, 0xE0,
  0x3F, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x1F, 0xC0, 0x1F, 0xE1, 0xFC, 0x3F,
  0x80, 0x1F, 0xE7, 0xF0, 0x7F, 0x00, 0x1F, 0xEF, 0xE0, 0xFE, 0x00, 0x3F,
  0xFF, 0x81, 0xF8, 0x00, 0x3F, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0,
  0x7F, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0x7F, 0xFF, 0xC0, 0x7F,
  0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x0B, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFC, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x60, 0x1F, 0x00, 0x67, 0xC0, 0xF0, 0x3E, 0x7F, 0xCF, 0x3F, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x10, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x0F,
  0xC0, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0x3C, 0x03, 0x80, 0x00, 0xC0, 0x30, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC7, 0xF1, 0xFC,
  0x7F, 0x1F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8, 0x7C,
  0x1F, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x1C,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x9F, 0xF0, 0x1F, 0xC0,
  0x7F, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x01, 0xFC,
  0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7E, 0xFE, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE,
  0x7E, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x83, 0xFC, 0x03, 0xF8, 0x1F, 0xF0, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F,
  0xFE, 0x3F, 0xFF, 0x3F, 0xDF, 0xBF, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xF7,
  0xC1, 0xF9, 0xC0, 0xFC, 0x40, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFE, 0x3F, 0xF8, 0x7F, 0x00, 0x7F,
  0x83, 0xC0, 0x03, 0xFC, 0x18, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0x87,
  0xFF, 0x1F, 0x80, 0x1F, 0xE1, 0xC0, 0x01, 0xFE, 0x20, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF6, 0x00, 0x03, 0xFE, 0xFC, 0x01, 0xFF, 0x9F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0x7F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03,
  0xE3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x7E,
  0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xE0, 0x7F, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x01, 0xF8, 0x07,
  0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xE0, 0x01, 0xFC,
  0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x87, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE8, 0x00,
  0x07, 0xFB, 0x00, 0x03, 0xFC, 0xFC, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xF0,
  0x18, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x00, 0xFE, 0x3F, 0xFC, 0x0F, 0xC7,
  0xFF, 0xE0, 0xFC, 0xFF, 0xFF, 0x0F, 0xDF, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF,
  0xCF, 0xFC, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xEF, 0xF0, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0x7F, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xE1, 0xFC, 0x03, 0xFC,
  0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0x3F,
  0xC7, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFE, 0x7E,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0xFC, 0x7F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xF8, 0x3F, 0xC0, 0x3F, 0x81,
  0xFE, 0x0F, 0xF0, 0x0F, 0xF9, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0x3F, 0xF0, 0x3F, 0xE0, 0xFF, 0x83, 0xF8,
  0x07, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7E, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xC3,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0x1F, 0xF0, 0x3F, 0x80, 0x7F, 0x87, 0xF0, 0x03,
  0xF8, 0x7F, 0x00, 0x1F, 0xCF, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xF7, 0xF0,
  0x01, 0xFE, 0x7F, 0x80, 0x3F, 0xE7, 0xFC, 0x0F, 0xFE, 0x3F, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0x7E, 0x0F, 0xFF, 0xE7, 0xE0, 0x7F, 0xFC, 0x7E, 0x01,
  0xFF, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x20, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xDF, 0xEF, 0xFF,
  0xFB, 0xFC, 0xFE, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC7, 0xF7, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0x9F, 0x83, 0x80, 0x0F,
  0x87, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF3, 0xFC, 0x7F, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7,
  0xF1, 0xFC, 0x7E, 0x3F, 0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1,
  0xF8, 0x7C, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x3F,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xCF, 0xF1,
  0xFF, 0x9E, 0x00, 0x7F, 0x90, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x7F, 0xFE, 0x07, 0xC1, 0xF0, 0x07, 0xFF,
  0xF8, 0x1F, 0x8F, 0xC0, 0x3F, 0xFF, 0xE0, 0x3E, 0x3E, 0x01, 0xFF, 0xFF,
  0x80, 0xF8, 0xF8, 0x0F, 0xE0, 0x3E, 0x03, 0xE7, 0xE0, 0x3F, 0x00, 0xF8,
  0x07, 0xDF, 0x01, 0xF8, 0x03, 0xE0, 0x1F, 0x7C, 0x07, 0xE0, 0x0F, 0x80,
  0x7D, 0xF0, 0x1F, 0x00, 0x3E, 0x01, 0xF7, 0xC0, 0xFC, 0x00, 0xF8, 0x07,
  0xFF, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0x7F,
  0xE0, 0x3E, 0x00, 0x7E, 0x01, 0xFF, 0x80, 0xF8, 0x01, 0xF8, 0x07, 0xFE,
  0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xFB, 0xE0,
  0x3F, 0x00, 0x7E, 0x03, 0xEF, 0xC0, 0xFC, 0x01, 0xF8, 0x0F, 0xBF, 0x01,
  0xF0, 0x0F, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3F, 0x81, 0xF1, 0xF0, 0x1F,
  0x81, 0xFF, 0x0F, 0xC7, 0xC0, 0x3F, 0xFF, 0xBF, 0xFE, 0x1F, 0x00, 0xFF,
  0xFC, 0xFF, 0xF0, 0x7E, 0x01, 0xFF, 0xE1, 0xFF, 0xC0, 0xF8, 0x03, 0xFF,
  0x03, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x03, 0xFF, 0x3F,
  0x80, 0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE3, 0xF8, 0x00, 0xFF, 0xCF, 0xE0,
  0x00, 0xFF, 0x3F, 0x80, 0x01, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xBF,
  0x80, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0x00, 0x1E, 0x07, 0xFC, 0x00, 0x08, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x0C, 0x0F, 0xFF, 0x81, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x07, 0xFF, 0x83, 0xF8,
  0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x07, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x8F,
  0xE0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x07, 0xF8, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFF, 0x0F, 0xE0,
  0x00, 0xFF, 0x83, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF7, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xE0, 0x01, 0xF0, 0x3F, 0xE0, 0x00, 0x0C, 0x1F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x1F,
  0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xF0, 0x00,
  0x7F, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF0, 0x7F, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFE, 0xC3, 0xFE, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x1E, 0x00, 0xFC,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xE7, 0xE0,
  0x00, 0x7F, 0x8F, 0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00,
  0x0F, 0xF0, 0x7E, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xE0, 0x1F, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0x1F, 0x80, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x0F, 0xF0,
  0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x07, 0xE7, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0xBF, 0xE0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x7E,
  0x01, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xFC, 0x03, 0xF0,
  0x03, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x07, 0xF8, 0x1F, 0x80,
  0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x0F, 0xF0, 0xFC, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x1F, 0xE3, 0xF0, 0x00, 0x1F, 0xE7, 0xE0, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0xDF, 0x80, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFB,
  0xF0, 0x00, 0x01, 0xF7, 0xFF, 0x7E, 0x00, 0x00, 0x7E, 0xFF, 0xEF, 0xC0,
  0x00, 0x0F, 0xDF, 0xFC, 0xFC, 0x00, 0x01, 0xF3, 0xFF, 0xDF, 0x80, 0x00,
  0x7E, 0x7F, 0xFB, 0xF0, 0x00, 0x0F, 0xCF, 0xFF, 0x3F, 0x00, 0x01, 0xF1,
  0xFF, 0xE7, 0xE0, 0x00, 0x7E, 0x7F, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xFF,
  0x8F, 0xC0, 0x01, 0xF1, 0xFF, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0xFE, 0x3F,
  0x00, 0x0F, 0xC7, 0xFF, 0xC3, 0xF0, 0x01, 0xF0, 0xFF, 0xF8, 0x7E, 0x00,
  0x7E, 0x1F, 0xFF, 0x0F, 0xC0, 0x0F, 0xC3, 0xFF, 0xE0, 0xFC, 0x01, 0xF0,
  0x7F, 0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xFF, 0x83, 0xF0, 0x0F, 0xC1, 0xFF,
  0xF0, 0x3F, 0x01, 0xF0, 0x3F, 0xFE, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xC0,
  0xFC, 0x0F, 0xC0, 0xFF, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0xFF, 0x01, 0xF8,
  0x7E, 0x03, 0xFF, 0xE0, 0x3F, 0x0F, 0xC0, 0x7F, 0xFC, 0x03, 0xF1, 0xF0,
  0x0F, 0xFF, 0x80, 0x7E, 0x7E, 0x01, 0xFF, 0xF0, 0x0F, 0xCF, 0xC0, 0x3F,
  0xFE, 0x00, 0xFD, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xF0,
  0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xBF, 0x80, 0x01, 0xFF, 0xE7,
  0xF0, 0x00, 0x7F, 0xF9, 0xFC, 0x00, 0x1F, 0xFE, 0x3F, 0x80, 0x07, 0xFF,
  0xCF, 0xE0, 0x01, 0xFF, 0xF1, 0xFC, 0x00, 0x7F, 0xFC, 0x7F, 0x80, 0x1F,
  0xFF, 0x0F, 0xE0, 0x07, 0xFF, 0xC3, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0x00,
  0x7F, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0x03, 0xF8, 0x07, 0xFF, 0xC0, 0x7F,
  0x01, 0xFF, 0xF0, 0x1F, 0xC0, 0x7F, 0xFC, 0x03, 0xF8, 0x1F, 0xFF, 0x00,
  0xFF, 0x07, 0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xFC,
  0x00, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xC3, 0xFF, 0xC0, 0x07, 0xF0, 0xFF,
  0xF0, 0x00, 0xFE, 0x3F, 0xFC, 0x00, 0x3F, 0x8F, 0xFF, 0x00, 0x07, 0xF3,
  0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0xF0, 0x00, 0x3F, 0xBF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xEF, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xE7,
  0xF0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x1F, 0xE0,
  0x7F, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x05, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFE, 0x01, 0xFF, 0xCF, 0xE0, 0x03, 0xFE, 0xFE, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x07, 0xFC, 0xFE,
  0x01, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xEF, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x3F, 0xE0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0xFF, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x05, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0x80,
  0x3F, 0xF0, 0x7F, 0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFC, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x1F, 0xF0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8,
  0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0,
  0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF8, 0xFE, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xFC, 0x00, 0xF1, 0xFE, 0x00, 0x0C,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0xFF, 0x03, 0xFF, 0xBF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x01, 0xFE,
  0x3F, 0xE0, 0x03, 0xFC, 0x1F, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x01,
  0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0xC0,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x1F,
  0xC0, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x03,
  0xF8, 0x3F, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xBE,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x7E, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0xFE, 0x03,
  0xF0, 0x01, 0xF3, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x07, 0xE3, 0xF0, 0x03,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x8F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x00,
  0xFE, 0x03, 0xF0, 0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0xFC, 0x07,
  0xF0, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x01,
  0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF8, 0x00,
  0x1F, 0xC7, 0xE0, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0x8F,
  0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0xC0, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFD,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0xFB, 0xF8, 0x00,
  0x03, 0xF7, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F,
  0xE3, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x1F,
  0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x7C,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x7E, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x03, 0xF0, 0x3F, 0xE0, 0xE0, 0x03, 0xF8, 0x20, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3, 0xFF, 0xE1, 0xFD, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xF7, 0xFF, 0xFE,
  0xFD, 0xFF, 0xFF, 0xBF, 0x3F, 0xFF, 0xCF, 0xC7, 0xFF, 0xE1, 0xF0, 0xFF,
  0xE0, 0x7C, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x0F, 0xF0, 0x0F, 0xC3, 0xFF,
  0xC0, 0xFC, 0xFF, 0xFE, 0x0F, 0xDF, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0x8F,
  0xFF, 0x9F, 0xFC, 0xFF, 0xC0, 0x3F, 0xCF, 0xF8, 0x01, 0xFC, 0xFF, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x1F, 0xCF,
  0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0xF8, 0xF8, 0xFF,
  0xFF, 0x0F, 0x87, 0xFF, 0xC0, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x1F, 0xE0, 0x0C, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x02, 0x1F, 0xF0, 0x1E, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0x83, 0xF0, 0x1F, 0xFE, 0x3F, 0x07, 0xFF, 0xF3, 0xF0,
  0xFF, 0xFF, 0xBF, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0x9F, 0xFF, 0x3F, 0xC0,
  0x3F, 0xF3, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xF3, 0xFE, 0x03, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xBF, 0x07, 0xFF, 0xF1, 0xF0, 0x3F, 0xFE, 0x1F,
  0x01, 0xFF, 0xC1, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x3F, 0xE0, 0xFF, 0x07, 0xF0, 0x0F, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x00,
  0x0F, 0xCF, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x0C, 0x3F, 0xE0, 0x07,
  0x83, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0xFE, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x81, 0xF0, 0x1F, 0xFE, 0x1F, 0x07, 0xFF, 0xF1, 0xF0, 0xFF,
  0xFF, 0x9F, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0x9F, 0xFF, 0x3F, 0xC0, 0x3F,
  0xF3, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0x7F, 0x7F,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xF3, 0xFE, 0x03, 0xFF, 0x1F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xBF, 0x07, 0xFF, 0xF3, 0xF0, 0x3F, 0xFE, 0x3F, 0x01,
  0xFF, 0xC3, 0xF0, 0x01, 0xC0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x20, 0x00, 0x0F, 0xE3, 0x80, 0x01, 0xFE, 0x3F, 0x80,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x03, 0xFC, 0x07, 0xE1, 0xFF,
  0xE0, 0xFC, 0xFF, 0xFF, 0x1F, 0xBF, 0xFF, 0xF3, 0xF7, 0xFF, 0xFE, 0x7F,
  0xFE, 0xFF, 0xEF, 0xFC, 0x03, 0xFD, 0xFF, 0x00, 0x3F, 0xBF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x0F, 0xE0, 0x18, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x00, 0x30, 0x01, 0xF8, 0x03, 0xF8, 0x0F,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xFD, 0x07, 0xFB, 0xFF, 0xE7, 0xFF, 0xCF, 0xFF, 0x1F,
  0xFC, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFE, 0xFC, 0x00,
  0x3F, 0x9F, 0x80, 0x0F, 0xE3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0xFE, 0x0F,
  0xC0, 0x3F, 0xC1, 0xF8, 0x0F, 0xF0, 0x3F, 0x01, 0xFC, 0x07, 0xE0, 0x7F,
  0x00, 0xFC, 0x1F, 0xC0, 0x1F, 0x87, 0xF0, 0x03, 0xF1, 0xFC, 0x00, 0x7E,
  0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x01, 0xFB, 0xFC, 0x00, 0x3F, 0x7F, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x03, 0xFE,
  0x7F, 0x00, 0x7F, 0x8F, 0xF0, 0x0F, 0xE0, 0xFE, 0x01, 0xF8, 0x0F, 0xE0,
  0x3F, 0x01, 0xFE, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x1F, 0x80,
  0x3F, 0xC3, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F, 0x8F, 0xC0, 0x07, 0xF1,
  0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0xFE, 0xFC, 0x00,
  0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF8, 0x1F, 0xF0, 0x01, 0xFE, 0x07, 0xC3, 0xFF, 0xE0,
  0x3F, 0xFC, 0x3E, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFB, 0xFF, 0xFE, 0x7F,
  0xFF, 0xCF, 0xDF, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFC, 0xFF, 0xFF, 0x9F,
  0xFB, 0xFF, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFE, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x07, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xE0,
  0x01, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0xF8, 0x0F, 0xF0, 0x1F,
  0x07, 0xFF, 0x83, 0xE3, 0xFF, 0xFC, 0x7E, 0xFF, 0xFF, 0xCF, 0xDF, 0xFF,
  0xF9, 0xFF, 0xF1, 0xFF, 0xBF, 0xF0, 0x0F, 0xF7, 0xFC, 0x00, 0xFE, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFC, 0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0x87, 0xF0, 0x01, 0xFC,
  0x3F, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x7F, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x0F, 0xF0, 0x0F, 0x83, 0xFF,
  0xC0, 0xFC, 0xFF, 0xFE, 0x0F, 0xCF, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0x8F,
  0xFF, 0x0F, 0xFC, 0xFF, 0xC0, 0x3F, 0xCF, 0xF8, 0x01, 0xFE, 0xFF, 0x00,
  0x0F, 0xEF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xF0, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xCF,
  0xFE, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0xF0, 0xFC, 0xFF,
  0xFF, 0x0F, 0xC7, 0xFF, 0xC0, 0xFC, 0x1F, 0xF8, 0x0F, 0xC0, 0x3C, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x81, 0xF0, 0x1F, 0xFE, 0x1F, 0x07, 0xFF, 0xF1, 0xF0,
  0xFF, 0xFF, 0x9F, 0x1F, 0xFF, 0xFF, 0xF1, 0xFF, 0x0F, 0xFF, 0x3F, 0xC0,
  0x1F, 0xF3, 0xF8, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xF7, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0xF3, 0xFE, 0x03, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xBF, 0x07, 0xFF, 0xF3, 0xF0, 0x3F, 0xFE, 0x3F,
  0x01, 0xFF, 0xC3, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x07,
  0xFF, 0xE1, 0xFF, 0xFC, 0x7F, 0xEF, 0xDF, 0xFD, 0xFB, 0xFF, 0xBF, 0xFC,
  0x17, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFE, 0x07,
  0xEF, 0xE0, 0x03, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x10, 0x7F, 0xFF, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0E, 0x00, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07,
  0xFE, 0xFF, 0x03, 0xFF, 0xDF, 0xFF, 0xFD, 0xF9, 0xFF, 0xFF, 0xBF, 0x3F,
  0xFF, 0xE7, 0xE3, 0xFF, 0xF8, 0xFC, 0x1F, 0xFC, 0x1F, 0x80, 0x3C, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x01, 0xFC, 0x07,
  0xE0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xF8, 0x00, 0x7E,
  0x7E, 0x00, 0x3F, 0xE0, 0x03, 0xF9, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xC7,
  0xF0, 0x03, 0xFF, 0x00, 0x3F, 0x1F, 0xC0, 0x1F, 0x7C, 0x00, 0xFC, 0x3F,
  0x00, 0x7D, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xF7, 0xE0, 0x1F, 0x83, 0xF8,
  0x0F, 0xCF, 0x80, 0x7E, 0x0F, 0xE0, 0x3F, 0x3E, 0x01, 0xF8, 0x1F, 0x80,
  0xF8, 0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xE3, 0xF0, 0x3F, 0x01, 0xFC, 0x1F,
  0x8F, 0xC0, 0xFC, 0x07, 0xF0, 0x7E, 0x1F, 0x03, 0xF0, 0x0F, 0xC1, 0xF0,
  0x7C, 0x1F, 0xC0, 0x3F, 0x07, 0xC1, 0xF8, 0x7E, 0x00, 0xFE, 0x3F, 0x07,
  0xE1, 0xF8, 0x03, 0xF8, 0xFC, 0x0F, 0x87, 0xE0, 0x07, 0xE3, 0xE0, 0x3E,
  0x3F, 0x80, 0x1F, 0x8F, 0x80, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x03, 0xF3,
  0xF0, 0x01, 0xFD, 0xF8, 0x07, 0xCF, 0xC0, 0x03, 0xF7, 0xC0, 0x1F, 0x3F,
  0x00, 0x0F, 0xDF, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0x7C, 0x01, 0xFF, 0xE0,
  0x00, 0x7D, 0xF0, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFC, 0x7F, 0x00,
  0x1F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x00, 0xFE, 0x07, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F,
  0xBF, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F,
  0xC0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0,
  0x7F, 0x00, 0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xF8,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x03,
  0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x80,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x04, 0x1F, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x13, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xE8, 0x00, 0x3F, 0xFC, 0x80, 0x00, 0x3E,
  0x00,
};

const GFXglyph NotoSans_SemiCondensed_Medium64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 9, 47, 17, 4, -46 },
  { 54, 19, 17, 27, 4, -46 },
  { 95, 35, 46, 37, 1, -46 },
  { 297, 27, 53, 34, 3, -49 },
  { 476, 45, 47, 51, 3, -46 },
  { 741, 39, 47, 42, 3, -46 },
  { 971, 7, 17, 15, 4, -46 },
  { 986, 15, 56, 20, 3, -46 },
  { 1091, 15, 56, 20, 2, -46 },
  { 1196, 28, 27, 32, 2, -49 },
  { 1291, 28, 31, 34, 3, -38 },
  { 1400, 10, 15, 17, 2, -7 },
  { 1419, 16, 6, 20, 2, -20 },
  { 1431, 8, 9, 17, 4, -8 },
  { 1440, 23, 46, 25, 1, -46 },
  { 1573, 28, 47, 33, 3, -46 },
  { 1738, 17, 46, 33, 5, -46 },
  { 1836, 28, 46, 33, 3, -46 },
  { 1997, 27, 47, 33, 3, -46 },
  { 2156, 31, 46, 33, 1, -46 },
  { 2335, 26, 47, 33, 4, -46 },
  { 2488, 28, 47, 33, 3, -46 },
  { 2653, 29, 46, 33, 2, -46 },
  { 2820, 28, 47, 33, 3, -46 },
  { 2985, 28, 47, 33, 3, -46 },
  { 3150, 9, 36, 17, 4, -35 },
  { 3191, 10, 43, 17, 2, -35 },
  { 3245, 28, 32, 34, 3, -39 },
  { 3357, 28, 19, 34, 3, -32 },
  { 3424, 28, 32, 34, 3, -39 },
  { 3536, 23, 47, 26, 1, -46 },
  { 3672, 46, 51, 52, 3, -46 },
  { 3966, 38, 46, 38, 0, -46 },
  { 4185, 30, 46, 38, 5, -46 },
  { 4358, 31, 47, 36, 4, -46 },
  { 4541, 34, 46, 42, 5, -46 },
  { 4737, 23, 46, 32, 6, -46 },
  { 4870, 23, 46, 31, 6, -46 },
  { 5003, 34, 47, 42, 4, -46 },
  { 5203, 32, 46, 43, 6, -46 },
  { 5387, 17, 46, 21, 2, -46 },
  { 5485, 16, 59, 17, -4, -46 },
  { 5603, 31, 46, 37, 6, -46 },
  { 5782, 24, 46, 31, 5, -46 },
  { 5920, 43, 46, 54, 6, -46 },
  { 6168, 34, 46, 45, 6, -46 },
  { 6364, 37, 47, 45, 4, -46 },
  { 6582, 28, 46, 35, 5, -46 },
  { 6743, 37, 57, 45, 4, -46 },
  { 7007, 31, 46, 37, 5, -46 },
  { 7186, 26, 47, 32, 3, -46 },
  { 7339, 30, 46, 32, 1, -46 },
  { 7512, 32, 47, 43, 5, -46 },
  { 7700, 36, 46, 36, 0, -46 },
  { 7907, 55, 46, 55, 0, -46 },
  { 8224, 34, 46, 35, 0, -46 },
  { 8420, 33, 46, 33, 0, -46 },
  { 8610, 28, 46, 32, 2, -46 },
  { 8771, 14, 56, 21, 5, -46 },
  { 8869, 23, 46, 25, 1, -46 },
  { 9002, 14, 56, 21, 2, -46 },
  { 9100, 30, 28, 34, 2, -46 },
  { 9205, 28, 4, 28, 0, 6 },
  { 9219, 13, 10, 19, 3, -49 },
  { 9236, 26, 36, 33, 3, -35 },
  { 9353, 28, 50, 36, 5, -49 },
  { 9528, 24, 36, 28, 3, -35 },
  { 9636, 28, 50, 36, 3, -49 },
  { 9811, 27, 36, 33, 3, -35 },
  { 9933, 22, 49, 21, 1, -49 },
  { 10068, 28, 50, 36, 3, -35 },
  { 10243, 27, 49, 36, 5, -49 },
  { 10409, 8, 48, 16, 4, -48 },
  { 10457, 15, 63, 16, -3, -48 },
  { 10576, 27, 49, 33, 5, -49 },
  { 10742, 6, 49, 16, 5, -49 },
  { 10779, 45, 35, 55, 5, -35 },
  { 10976, 27, 35, 36, 5, -35 },
  { 11095, 29, 36, 36, 3, -35 },
  { 11226, 28, 50, 36, 5, -35 },
  { 11401, 28, 50, 36, 3, -35 },
  { 11576, 19, 35, 25, 5, -35 },
  { 11660, 22, 36, 28, 3, -35 },
  { 11759, 20, 43, 22, 1, -42 },
  { 11867, 27, 36, 36, 5, -35 },
  { 11989, 30, 35, 31, 0, -35 },
  { 12121, 46, 35, 47, 1, -35 },
  { 12323, 29, 35, 31, 1, -35 },
  { 12450, 31, 50, 31, 0, -35 },
  { 12644, 23, 35, 27, 2, -35 },
  { 12745, 20, 56, 24, 2, -46 },
  { 12885, 6, 64, 32, 13, -49 },
  { 12933, 20, 56, 24, 2, -46 },
  { 13073, 28, 9, 34, 3, -27 },
};

const GFXfont NotoSans_SemiCondensed_Medium64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium64pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM64PT7B_H_
