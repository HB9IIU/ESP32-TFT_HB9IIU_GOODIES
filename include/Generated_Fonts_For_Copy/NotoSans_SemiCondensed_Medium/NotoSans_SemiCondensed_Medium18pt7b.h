#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM18PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium18pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6C, 0x92, 0x40, 0x7C, 0xDE, 0x73, 0x9C, 0x80, 0x09, 0x82,
  0x61, 0x90, 0x64, 0x7F, 0xC4, 0xC1, 0x30, 0x4C, 0xFF, 0xCC, 0x83, 0x20,
  0x98, 0x26, 0x00, 0x10, 0x10, 0x7E, 0xF6, 0xD0, 0xD0, 0xF0, 0x3C, 0x1E,
  0x13, 0x13, 0xDE, 0xFC, 0x10, 0x10, 0x70, 0xC6, 0x84, 0x26, 0x61, 0x32,
  0x09, 0xB0, 0x4D, 0x33, 0x5B, 0xCE, 0x92, 0x0D, 0x98, 0x4C, 0xC6, 0x24,
  0x31, 0x23, 0x0F, 0x00, 0x3C, 0x0D, 0xC1, 0x98, 0x33, 0x06, 0xC0, 0x70,
  0x1E, 0x07, 0x66, 0xCE, 0xD8, 0xF3, 0x0C, 0x77, 0xC7, 0xCE, 0xFF, 0xC0,
  0x36, 0x64, 0xCC, 0xCC, 0xCC, 0xCC, 0xC6, 0x63, 0xC3, 0x0C, 0x61, 0x0C,
  0x63, 0x18, 0xC6, 0x23, 0x19, 0x88, 0x10, 0x22, 0x4F, 0xF3, 0x85, 0x1B,
  0x22, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x10, 0xFB, 0x40,
  0xFF, 0xF8, 0x06, 0x18, 0x30, 0x41, 0x83, 0x04, 0x18, 0x30, 0x41, 0x83,
  0x0C, 0x00, 0x3C, 0x7E, 0xC6, 0xC2, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2,
  0xC6, 0x6E, 0x3C, 0x19, 0xDB, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x80,
  0x7C, 0xFE, 0x86, 0x06, 0x06, 0x06, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xFF,
  0xFF, 0x7C, 0xFE, 0x86, 0x06, 0x06, 0x0C, 0x7C, 0x0E, 0x06, 0x03, 0x06,
  0xCE, 0xFC, 0x07, 0x03, 0x83, 0xC1, 0x61, 0xB1, 0x98, 0x8C, 0xC6, 0xC3,
  0x7F, 0xC0, 0xC0, 0x60, 0x30, 0x7E, 0x7E, 0xC0, 0xC0, 0xC0, 0xFC, 0x7E,
  0x06, 0x03, 0x02, 0x06, 0xCE, 0xFC, 0x1E, 0x7E, 0x60, 0xC0, 0xC0, 0xFC,
  0xE6, 0xC3, 0xC3, 0xC3, 0xC2, 0x6E, 0x3C, 0xFF, 0xFF, 0x06, 0x06, 0x04,
  0x0C, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x30, 0x60, 0x3C, 0xEE, 0xC6, 0xC6,
  0xC6, 0x7C, 0x3C, 0x6E, 0xC6, 0xC3, 0xC3, 0xE6, 0x7C, 0x38, 0x7E, 0xC6,
  0xC2, 0xC3, 0xC3, 0xC7, 0x7A, 0x02, 0x06, 0x06, 0x9C, 0x78, 0xDD, 0x00,
  0x00, 0xF8, 0xDD, 0x00, 0x00, 0xDB, 0x40, 0x01, 0x07, 0x1C, 0x70, 0xC0,
  0xF0, 0x1C, 0x07, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0x70,
  0x1C, 0x07, 0x0E, 0x38, 0xE0, 0x80, 0x7D, 0xFC, 0x18, 0x30, 0x61, 0x86,
  0x18, 0x30, 0x00, 0x01, 0x83, 0x00, 0x0F, 0x80, 0xC7, 0x08, 0x0C, 0xC0,
  0x2C, 0xF9, 0xE4, 0x4E, 0x62, 0x73, 0x13, 0x99, 0x9E, 0x4C, 0xB3, 0x98,
  0x80, 0x06, 0x04, 0x1F, 0xE0, 0x08, 0x00, 0x0C, 0x01, 0xC0, 0x78, 0x0D,
  0x01, 0xB0, 0x66, 0x0C, 0x41, 0x8C, 0x7F, 0x8C, 0x31, 0x83, 0x60, 0x6C,
  0x0E, 0xFC, 0xFE, 0x86, 0x83, 0x86, 0x8E, 0xFC, 0x86, 0x83, 0x83, 0x83,
  0xFE, 0xFC, 0x1F, 0x9F, 0x98, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x18, 0x0F, 0x61, 0xF0, 0xF8, 0x7F, 0x21, 0xD0, 0x68, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC1, 0xA1, 0xDF, 0xCF, 0xC0, 0xFF, 0xF8, 0x20, 0x83,
  0xFF, 0xE0, 0x82, 0x08, 0x3F, 0xFC, 0xFF, 0xF8, 0x20, 0x82, 0x0F, 0xFF,
  0x82, 0x08, 0x20, 0x80, 0x1F, 0xCF, 0xE6, 0x01, 0x80, 0xC0, 0x30, 0x0C,
  0x7F, 0x1F, 0xC0, 0xF0, 0x36, 0x0D, 0xE7, 0x1F, 0xC0, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1F, 0xFF, 0xFF, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18,
  0xFE, 0x66, 0x66, 0x66, 0x66, 0x66, 0xF0, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x13, 0x3F, 0x40, 0x83, 0x86, 0x8C, 0x8C, 0x98, 0xB0, 0xF0, 0xD8,
  0x9C, 0x8C, 0x86, 0x86, 0x83, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x3F, 0xFC, 0xC0, 0x7E, 0x07, 0xE0, 0xFA, 0x0F, 0xB0, 0xBB, 0x1B,
  0x91, 0xB9, 0x93, 0x9B, 0x38, 0xB3, 0x8E, 0x38, 0xE3, 0x86, 0x30, 0xC1,
  0xF0, 0xF8, 0x76, 0x3B, 0x1C, 0xCE, 0x67, 0x1B, 0x8D, 0xC3, 0xE0, 0xF0,
  0x78, 0x18, 0x1F, 0x0F, 0xF1, 0x83, 0x60, 0x6C, 0x0D, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x58, 0x19, 0x83, 0x3D, 0xC1, 0xF0, 0xF9, 0xFA, 0x1C, 0x38,
  0x70, 0xE7, 0xFC, 0x81, 0x02, 0x04, 0x08, 0x00, 0x1F, 0x0F, 0xF1, 0x83,
  0x60, 0x6C, 0x0D, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x19, 0x83, 0x3D,
  0xC1, 0xF0, 0x06, 0x00, 0x60, 0x0E, 0xF8, 0xFE, 0x86, 0x86, 0x86, 0x86,
  0xFC, 0xF8, 0x8C, 0x8C, 0x86, 0x86, 0x83, 0x3F, 0xFF, 0x06, 0x0C, 0x0E,
  0x0F, 0x07, 0x06, 0x0C, 0x1F, 0x7F, 0xC0, 0xFF, 0xFF, 0xC2, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x26, 0x19,
  0xCE, 0x3F, 0x00, 0xC0, 0xF0, 0x36, 0x19, 0x86, 0x61, 0x8C, 0x43, 0x30,
  0xCC, 0x12, 0x07, 0x81, 0xE0, 0x30, 0x0C, 0x00, 0xC1, 0x87, 0x87, 0x0D,
  0x8E, 0x1B, 0x1E, 0x36, 0x2C, 0x4C, 0xD9, 0x89, 0x93, 0x1B, 0x36, 0x34,
  0x68, 0x68, 0xF0, 0x70, 0xE0, 0xE1, 0xC1, 0x83, 0x00, 0xE1, 0x98, 0x63,
  0x30, 0xCC, 0x1E, 0x07, 0x00, 0xC0, 0x78, 0x16, 0x0C, 0xC6, 0x31, 0x86,
  0xC1, 0xC0, 0xC1, 0xB0, 0xD8, 0xC6, 0x63, 0x60, 0xB0, 0x70, 0x38, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0xFE, 0xFE, 0x06, 0x0C, 0x0C, 0x18, 0x30,
  0x30, 0x60, 0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xFF, 0xC0, 0x81, 0x83, 0x03, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x30,
  0x60, 0x60, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFF,
  0x08, 0x06, 0x07, 0x02, 0xC3, 0x21, 0x19, 0x85, 0x83, 0xFF, 0xC6, 0x30,
  0x3C, 0xFC, 0x18, 0x33, 0xFC, 0xF1, 0xE3, 0xCE, 0xF4, 0xC0, 0xC0, 0xC0,
  0xC0, 0xDC, 0xFE, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xE7, 0xDE, 0x3D,
  0xFC, 0x30, 0xC3, 0x0C, 0x30, 0x64, 0xF0, 0x03, 0x03, 0x03, 0x03, 0x3B,
  0x7F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x67, 0x7B, 0x3C, 0x7E, 0xC6,
  0xC2, 0xFF, 0xFF, 0xC0, 0xC0, 0x62, 0x3E, 0x1E, 0x78, 0xC1, 0x87, 0xDF,
  0x8C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x00, 0x3B, 0x7F, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x67, 0x7B, 0x03, 0x03, 0xC6, 0xFE, 0xC0, 0xC0,
  0xC0, 0xC0, 0xDE, 0xFF, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xF3, 0xFF, 0xFF, 0xC0, 0x33, 0x03, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0xF0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC3, 0xC6, 0xCC, 0xD8, 0xF8, 0xF8, 0xCC,
  0xCE, 0xC6, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xDC, 0x77, 0xF7, 0xF8, 0xC7,
  0x86, 0x3C, 0x31, 0xE1, 0x8F, 0x0C, 0x78, 0x63, 0xC3, 0x1E, 0x18, 0xC0,
  0xDE, 0xFF, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x3C, 0x7E,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0xDC, 0xFE, 0xE3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xE3, 0xF7, 0xDE, 0xC0, 0xC0, 0xC0, 0xC0, 0x3B, 0x7F,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x67, 0x7B, 0x03, 0x03, 0x03, 0x03,
  0xDF, 0xFE, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x7B, 0xFC, 0x30, 0xF0,
  0xE0, 0xC3, 0x8F, 0xE0, 0x20, 0x87, 0xFF, 0x61, 0x86, 0x18, 0x60, 0x83,
  0x4F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x67, 0x7B, 0xC1,
  0xE1, 0x98, 0xCC, 0x46, 0x61, 0xB0, 0xD0, 0x78, 0x1C, 0x0C, 0x00, 0xC3,
  0x1E, 0x38, 0xD9, 0xC6, 0xCB, 0x26, 0x5B, 0x16, 0xD8, 0xB2, 0xC7, 0x14,
  0x38, 0xE0, 0xC7, 0x00, 0xE3, 0x31, 0x8D, 0x86, 0x81, 0xC0, 0xE0, 0xF0,
  0x6C, 0x63, 0x71, 0xC0, 0xC1, 0xE1, 0x98, 0xCC, 0x62, 0x61, 0xB0, 0xD8,
  0x38, 0x1C, 0x0C, 0x06, 0x03, 0x03, 0x07, 0x80, 0xFF, 0xF1, 0x86, 0x30,
  0xC6, 0x30, 0xC3, 0xF0, 0x0C, 0x71, 0x04, 0x10, 0x43, 0x3C, 0xF0, 0xC1,
  0x04, 0x10, 0x41, 0xC3, 0xFF, 0xFF, 0xC0, 0xC7, 0x18, 0xC6, 0x30, 0x87,
  0x39, 0x18, 0xC6, 0x33, 0x98, 0x61, 0xFF, 0x8E,
};

const GFXglyph NotoSans_SemiCondensed_Medium18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 13, 5, 1, -13 },
  { 6, 5, 5, 8, 1, -13 },
  { 10, 10, 13, 10, 0, -13 },
  { 27, 8, 15, 9, 1, -14 },
  { 42, 13, 13, 14, 1, -13 },
  { 64, 11, 13, 12, 1, -13 },
  { 82, 2, 5, 4, 1, -13 },
  { 84, 4, 16, 6, 1, -13 },
  { 92, 5, 16, 6, 0, -13 },
  { 102, 7, 8, 9, 1, -14 },
  { 109, 8, 9, 9, 1, -11 },
  { 118, 3, 4, 5, 1, -2 },
  { 120, 4, 2, 6, 1, -6 },
  { 121, 3, 2, 5, 1, -2 },
  { 122, 7, 13, 7, 0, -13 },
  { 134, 8, 13, 9, 1, -13 },
  { 147, 5, 13, 9, 1, -13 },
  { 156, 8, 13, 9, 1, -13 },
  { 169, 8, 13, 9, 1, -13 },
  { 182, 9, 13, 9, 0, -13 },
  { 197, 8, 13, 9, 1, -13 },
  { 210, 8, 13, 9, 1, -13 },
  { 223, 8, 13, 9, 1, -13 },
  { 236, 8, 13, 9, 1, -13 },
  { 249, 8, 13, 9, 1, -13 },
  { 262, 3, 10, 5, 1, -10 },
  { 266, 3, 12, 5, 1, -10 },
  { 271, 8, 9, 9, 1, -11 },
  { 280, 8, 5, 9, 1, -9 },
  { 285, 8, 9, 9, 1, -11 },
  { 294, 7, 13, 7, 0, -13 },
  { 306, 13, 15, 15, 1, -13 },
  { 331, 11, 13, 11, 0, -13 },
  { 349, 8, 13, 11, 2, -13 },
  { 362, 9, 13, 10, 1, -13 },
  { 377, 9, 13, 12, 2, -13 },
  { 392, 6, 13, 9, 2, -13 },
  { 402, 6, 13, 9, 2, -13 },
  { 412, 10, 13, 12, 1, -13 },
  { 429, 9, 13, 12, 2, -13 },
  { 444, 4, 13, 6, 1, -13 },
  { 451, 4, 17, 5, -1, -13 },
  { 460, 8, 13, 10, 2, -13 },
  { 473, 6, 13, 9, 2, -13 },
  { 483, 12, 13, 15, 2, -13 },
  { 503, 9, 13, 13, 2, -13 },
  { 518, 11, 13, 13, 1, -13 },
  { 536, 7, 13, 10, 2, -13 },
  { 548, 11, 16, 13, 1, -13 },
  { 570, 8, 13, 10, 2, -13 },
  { 583, 7, 13, 9, 1, -13 },
  { 595, 9, 13, 9, 0, -13 },
  { 610, 10, 13, 12, 1, -13 },
  { 627, 10, 13, 10, 0, -13 },
  { 644, 15, 13, 16, 0, -13 },
  { 669, 10, 13, 10, 0, -13 },
  { 686, 9, 13, 9, 0, -13 },
  { 701, 8, 13, 9, 1, -13 },
  { 714, 4, 16, 6, 1, -13 },
  { 722, 7, 13, 7, 0, -13 },
  { 734, 5, 16, 6, 0, -13 },
  { 744, 9, 8, 10, 0, -13 },
  { 753, 8, 1, 8, 0, 2 },
  { 754, 4, 3, 5, 1, -14 },
  { 756, 7, 10, 9, 1, -10 },
  { 765, 8, 14, 10, 1, -14 },
  { 779, 6, 10, 8, 1, -10 },
  { 787, 8, 14, 10, 1, -14 },
  { 801, 8, 10, 9, 1, -10 },
  { 811, 7, 14, 6, 0, -14 },
  { 824, 8, 14, 10, 1, -10 },
  { 838, 8, 14, 10, 1, -14 },
  { 852, 2, 13, 5, 1, -13 },
  { 856, 4, 17, 5, -1, -13 },
  { 865, 8, 14, 9, 1, -14 },
  { 879, 2, 14, 5, 1, -14 },
  { 883, 13, 10, 15, 1, -10 },
  { 900, 8, 10, 10, 1, -10 },
  { 910, 8, 10, 10, 1, -10 },
  { 920, 8, 14, 10, 1, -10 },
  { 934, 8, 14, 10, 1, -10 },
  { 948, 6, 10, 7, 1, -10 },
  { 956, 6, 10, 8, 1, -10 },
  { 964, 6, 12, 6, 0, -12 },
  { 973, 8, 10, 10, 1, -10 },
  { 983, 9, 10, 9, 0, -10 },
  { 995, 13, 10, 13, 0, -10 },
  { 1012, 9, 10, 9, 0, -10 },
  { 1024, 9, 14, 9, 0, -10 },
  { 1040, 6, 10, 8, 1, -10 },
  { 1048, 6, 16, 7, 0, -13 },
  { 1060, 1, 18, 9, 4, -14 },
  { 1063, 5, 16, 7, 1, -13 },
  { 1073, 8, 3, 9, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Medium18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium18pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM18PT7B_H_
