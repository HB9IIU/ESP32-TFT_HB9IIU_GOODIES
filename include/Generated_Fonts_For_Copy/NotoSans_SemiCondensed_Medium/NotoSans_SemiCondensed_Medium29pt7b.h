#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM29PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM29PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x60, 0x06, 0xFF, 0xE0,
  0xE7, 0xE7, 0xE7, 0xE7, 0xE3, 0xE3, 0xC3, 0xC3, 0x07, 0x18, 0x0C, 0x30,
  0x18, 0xE0, 0x31, 0xC0, 0x63, 0x01, 0xC6, 0x1F, 0xFF, 0xBF, 0xFF, 0x0C,
  0x70, 0x18, 0xE0, 0x31, 0x80, 0xE3, 0x01, 0x86, 0x1F, 0xFF, 0xBF, 0xFF,
  0x0C, 0x70, 0x18, 0xC0, 0x71, 0x80, 0xC3, 0x01, 0x86, 0x03, 0x1C, 0x00,
  0x02, 0x00, 0x10, 0x01, 0xE0, 0x7F, 0xE7, 0xFF, 0x39, 0x09, 0x88, 0x1C,
  0x40, 0x72, 0x03, 0xD0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0x78, 0x08,
  0xE0, 0x47, 0x02, 0x3E, 0x13, 0xBF, 0xFD, 0xFF, 0xC0, 0x60, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x3C, 0x03, 0x83, 0xF0, 0x18, 0x19, 0xC1, 0xC1, 0xC6,
  0x0C, 0x0E, 0x30, 0xE0, 0x71, 0x86, 0x03, 0x8E, 0x70, 0x1C, 0x63, 0x00,
  0xE3, 0x38, 0xC3, 0x19, 0x9F, 0x19, 0xDD, 0xDC, 0xFC, 0xCC, 0x63, 0xCE,
  0x63, 0x80, 0x63, 0x1C, 0x07, 0x18, 0xE0, 0x30, 0xC7, 0x03, 0x86, 0x38,
  0x18, 0x31, 0xC1, 0xC1, 0xCC, 0x0C, 0x07, 0xE0, 0xE0, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xF8, 0x03, 0xDE, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C,
  0x03, 0x8E, 0x00, 0x77, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFE, 0x0E, 0x71, 0xC7, 0x3C, 0x79, 0xCE, 0x0F, 0xF3, 0x81, 0xF8, 0xE0,
  0x3C, 0x3C, 0x0F, 0x87, 0x9F, 0xF1, 0xFF, 0xDE, 0x1F, 0xC3, 0xC0, 0xFF,
  0xFF, 0xF6, 0x0E, 0x18, 0x71, 0xC3, 0x8E, 0x1C, 0x38, 0x71, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xE1, 0xC3, 0x87, 0x07, 0x0E, 0x0E, 0x0C,
  0x1C, 0xE0, 0xC1, 0xC1, 0xC3, 0x83, 0x07, 0x0E, 0x1C, 0x18, 0x30, 0x70,
  0xE1, 0xC3, 0x86, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x0C, 0x38, 0x61, 0x80,
  0x07, 0x00, 0x70, 0x06, 0x08, 0x61, 0xF6, 0xFF, 0xFF, 0x1F, 0x80, 0xF8,
  0x1D, 0x83, 0x9C, 0x38, 0xE1, 0x08, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x7B, 0x9C, 0xE6, 0x73, 0x00, 0xFF, 0xFF,
  0xF8, 0x4F, 0xFE, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x38, 0x0E, 0x00, 0x0F, 0x80, 0xFE, 0x0F,
  0xF8, 0xF0, 0xE7, 0x07, 0x38, 0x39, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xEE, 0x0E, 0x70, 0x73,
  0x83, 0x8F, 0x38, 0x7F, 0xC0, 0xFC, 0x00, 0x07, 0x0F, 0x1F, 0x3F, 0x77,
  0xE7, 0x47, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x1F, 0x83, 0xFF, 0x3F, 0xF8, 0xC1, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0x83, 0xFF, 0x3F, 0xFC, 0xC0, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x01, 0xE0, 0xFE, 0x07, 0xE0, 0x3F, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x7C, 0x03, 0xB8, 0x7D, 0xFF, 0xC7,
  0xFC, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xE0, 0x1B,
  0x80, 0xEE, 0x03, 0x38, 0x1C, 0xE0, 0xE3, 0x83, 0x0E, 0x1C, 0x38, 0x60,
  0xE3, 0x83, 0x8F, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x7F, 0xC7, 0xFC, 0xFF, 0xCE, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE8, 0x0E, 0xE7, 0xEF, 0xFC, 0xFF, 0x00, 0x03,
  0xF0, 0x7F, 0x87, 0xFC, 0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x67, 0xC7, 0x7F, 0x3F, 0x3D, 0xE0, 0xFF, 0x03, 0xF0, 0x1F, 0x80, 0xEE,
  0x07, 0x70, 0x3B, 0x83, 0x8F, 0x3C, 0x3F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x00, 0x0F, 0x81, 0xFF,
  0x1F, 0x7C, 0xE0, 0xE7, 0x07, 0x38, 0x39, 0xC1, 0xCF, 0x0E, 0x3D, 0xE0,
  0xFE, 0x07, 0xF0, 0x7F, 0xC7, 0x8F, 0x38, 0x3F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x81, 0xDE, 0x3C, 0xFF, 0xC1, 0xFC, 0x00, 0x0F, 0x81, 0xFE, 0x1F,
  0xF8, 0xE1, 0xEF, 0x07, 0x70, 0x1B, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x83,
  0xDC, 0x3E, 0xFF, 0xF3, 0xFB, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x10, 0xF0, 0xFF, 0x87, 0xF0, 0x00, 0x6F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x4F, 0xFE, 0x33, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3D,
  0xCE, 0x77, 0x39, 0x80, 0x00, 0x18, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x03, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x01, 0x80, 0x04, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xE0, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x81, 0xF0, 0x0E,
  0x00, 0x40, 0x00, 0x3F, 0x1F, 0xF9, 0xFF, 0xA0, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0xFC, 0x01, 0xE0, 0xF0, 0x1C, 0x01, 0xC1, 0xC0, 0x07, 0x1C, 0x00, 0x18,
  0xC1, 0xFC, 0xEE, 0x3F, 0xC7, 0x61, 0x86, 0x1B, 0x1C, 0x30, 0xD8, 0xC1,
  0x86, 0xC6, 0x0C, 0x3E, 0x30, 0x61, 0xF1, 0x83, 0x0D, 0x8E, 0x38, 0xEC,
  0x73, 0x6E, 0x61, 0xFB, 0xE3, 0x83, 0x0E, 0x0C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x10, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0xC0,
  0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x07, 0x03, 0x83, 0x81, 0xFF,
  0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x70, 0x1C, 0x78, 0x0F, 0x38, 0x03, 0x9C,
  0x01, 0xDE, 0x00, 0xFE, 0x00, 0x38, 0xFF, 0x03, 0xFF, 0xCF, 0xFF, 0xBC,
  0x1E, 0xF0, 0x3B, 0xC0, 0xEF, 0x03, 0xBC, 0x0E, 0xF0, 0x73, 0xFF, 0x8F,
  0xFE, 0x3C, 0x7E, 0xF0, 0x3B, 0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x3F,
  0xC0, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC0, 0x07, 0xF0, 0x7F, 0xF3, 0xFF,
  0x9F, 0x02, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xF3, 0x87, 0xFE, 0x0F, 0xF8, 0xFF, 0x81, 0xFF, 0xC3,
  0xFF, 0xE7, 0x83, 0xEF, 0x03, 0xDE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x0F, 0xF0, 0x1D, 0xE0, 0xFB, 0xFF, 0xE7, 0xFF, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF9,
  0xE0, 0x27, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x07,
  0x70, 0x0E, 0xF0, 0x1C, 0xFC, 0x78, 0xFF, 0xF0, 0xFF, 0xC0, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1C, 0xFF,
  0xFF, 0x7C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x8F, 0xFF, 0xFB, 0xC0, 0xE0, 0x3B, 0x81, 0xEE,
  0x0F, 0x38, 0x38, 0xE1, 0xC3, 0x8E, 0x0E, 0x78, 0x39, 0xC0, 0xEE, 0x03,
  0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xE7, 0x03, 0x8E, 0x0E, 0x3C, 0x38, 0x70,
  0xE1, 0xE3, 0x83, 0x8E, 0x07, 0x38, 0x1E, 0xE0, 0x3C, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF,
  0xFF, 0xFE, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x7F, 0xB8, 0x0F, 0xF7, 0x01, 0xBE, 0xE0, 0x77, 0xCE, 0x0E, 0xF9,
  0xC1, 0x9F, 0x38, 0x73, 0xE3, 0x0E, 0x7C, 0x71, 0x8F, 0x8E, 0x71, 0xF0,
  0xCE, 0x3E, 0x1D, 0x87, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0x83, 0xE0,
  0xF0, 0x7C, 0x0E, 0x0E, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x80, 0xFB, 0x81, 0xF7, 0x83, 0xE7, 0x07, 0xCF, 0x0F, 0x8E, 0x1F, 0x0E,
  0x3E, 0x1C, 0x7C, 0x1C, 0xF8, 0x39, 0xF0, 0x3B, 0xE0, 0x7F, 0xC0, 0x7F,
  0x80, 0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xFC,
  0x0F, 0xFF, 0x0F, 0x03, 0xC7, 0x00, 0xF7, 0x80, 0x3B, 0x80, 0x1D, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1D, 0xE0, 0x0E, 0x70, 0x0F, 0x3C, 0x0F, 0x0F, 0x9F,
  0x83, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x07, 0xFF, 0x3F, 0xFD, 0xE1, 0xEF,
  0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x7F, 0x83, 0xBD, 0xFD, 0xFF,
  0xCF, 0xF8, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0x03,
  0xC7, 0x00, 0xF7, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1D,
  0xE0, 0x0E, 0x70, 0x0F, 0x3C, 0x0F, 0x0F, 0x9F, 0x83, 0xFF, 0x80, 0xFF,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0x3C, 0x3C, 0xF0, 0x7B, 0xC0, 0xEF, 0x03,
  0xBC, 0x0E, 0xF0, 0x73, 0xC3, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0xC3, 0xC7,
  0x0F, 0x1E, 0x3C, 0x38, 0xF0, 0x73, 0xC1, 0xCF, 0x03, 0xBC, 0x0F, 0xF0,
  0x1C, 0x0F, 0xC3, 0xFF, 0x7F, 0xF7, 0x02, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x78, 0x07, 0xFB, 0xFF, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF8, 0x07, 0x70, 0x1E, 0xE0, 0x39, 0xF9, 0xF1, 0xFF, 0xC0,
  0xFE, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E,
  0x38, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x1C, 0x38,
  0x1C, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0x60, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x1C, 0x03, 0xF0,
  0x0E, 0x03, 0xDC, 0x0F, 0x01, 0xCE, 0x07, 0xC0, 0xE7, 0x03, 0xE0, 0x73,
  0x81, 0xB0, 0x38, 0xE1, 0xDC, 0x38, 0x70, 0xEE, 0x1C, 0x38, 0x77, 0x0E,
  0x1C, 0x31, 0x87, 0x07, 0x38, 0xE7, 0x03, 0x9C, 0x73, 0x81, 0xCE, 0x39,
  0xC0, 0xE6, 0x0C, 0xE0, 0x37, 0x06, 0x60, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF8, 0x07, 0xC0, 0x7C, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x3C, 0x38, 0x1C, 0x38,
  0x1E, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0x70, 0x1C, 0x78, 0x1C, 0x38,
  0x38, 0x3C, 0x78, 0x1C, 0x70, 0x1E, 0xF0, 0x0F, 0xE0, 0x0E, 0xE0, 0x3D,
  0xC0, 0x71, 0xC1, 0xE3, 0x83, 0x87, 0x87, 0x07, 0x1C, 0x0F, 0x38, 0x0E,
  0xE0, 0x1D, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x00, 0x70, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF, 0xFC, 0xE0, 0x0E,
  0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07,
  0x00, 0xE0, 0x0E, 0xFF, 0xFF, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xFF, 0xFF, 0xF0, 0x02,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xE0, 0x0D, 0x80, 0x77, 0x01, 0x8E, 0x0E,
  0x38, 0x30, 0x71, 0xC1, 0xC6, 0x03, 0xB8, 0x0E, 0xE0, 0x1C, 0xFF, 0xF8,
  0xF1, 0xE3, 0x87, 0x0F, 0x83, 0xFE, 0x3D, 0xE2, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF3, 0xFF, 0x7F, 0x77, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x1F,
  0x7F, 0xF3, 0xF3, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x9F, 0x1D, 0xFC, 0xFF, 0xF7, 0x83, 0xBC, 0x1F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x1D, 0xF1, 0xEF,
  0xFE, 0x73, 0xE0, 0x07, 0xC3, 0xFC, 0xFF, 0x3C, 0x07, 0x00, 0xE0, 0x3C,
  0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x78, 0xCF, 0xF8,
  0x7F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x3C,
  0xE7, 0xFF, 0x3F, 0xFB, 0xC3, 0xDC, 0x0E, 0xE0, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xF1, 0xF3, 0xFD, 0x8F,
  0xCC, 0x0F, 0x80, 0xFF, 0x0F, 0x7C, 0xE0, 0xE7, 0x03, 0x38, 0x1F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1E, 0x18,
  0xFF, 0xC1, 0xFE, 0x07, 0xC3, 0xF1, 0xE4, 0x70, 0x1C, 0x07, 0x03, 0xFB,
  0xFE, 0xFF, 0x87, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0x0F, 0x18, 0xFE, 0xCF, 0xFE,
  0xF0, 0xF7, 0x03, 0xB8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xDC,
  0x0E, 0xE0, 0x77, 0x03, 0xBC, 0x7C, 0xFF, 0xE3, 0xF7, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x80, 0xF7, 0xFF, 0x3F, 0xF0, 0x7F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE7, 0xCE, 0xFE, 0xFF, 0xFF, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x5F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x08, 0x71, 0xC7, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFE,
  0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x81,
  0xDC, 0x1C, 0xE1, 0xE7, 0x1E, 0x38, 0xE1, 0xCE, 0x0E, 0xE0, 0x7F, 0x03,
  0xFC, 0x1E, 0xF0, 0xE3, 0x87, 0x1E, 0x38, 0x71, 0xC1, 0xCE, 0x0F, 0x70,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE7, 0x83,
  0xC7, 0x7F, 0x7F, 0xBF, 0xFB, 0xFD, 0xE1, 0xF0, 0xFF, 0x07, 0x03, 0xF0,
  0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81,
  0xF8, 0x1C, 0x0F, 0xC0, 0xE0, 0x7E, 0x07, 0x03, 0xF0, 0x38, 0x1F, 0x81,
  0xC0, 0xFC, 0x0E, 0x07, 0xE7, 0xCE, 0xFE, 0xFF, 0xFF, 0x07, 0xF0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0x07, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70,
  0x39, 0xC0, 0xEF, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x03, 0x9C,
  0x0E, 0x70, 0x38, 0xE1, 0xC1, 0xFF, 0x03, 0xF0, 0xE7, 0xC7, 0x7F, 0x3F,
  0xFD, 0xE0, 0xEF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xE0, 0xFF, 0x07, 0x7C, 0x7B, 0xFF, 0x9C, 0xF8, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0F, 0x19,
  0xFE, 0xCF, 0xFE, 0xF0, 0xF7, 0x03, 0xB8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xBC, 0x7C, 0xFF, 0xE3, 0xF7,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0xE7, 0xF7, 0xFF, 0xFF, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x1F, 0x8F, 0xF9, 0xEF, 0x70, 0x0E,
  0x01, 0xE0, 0x1F, 0x01, 0xF8, 0x1F, 0x80, 0xF8, 0x07, 0x00, 0x70, 0x1D,
  0x83, 0xBF, 0xF3, 0xF8, 0x18, 0x0C, 0x06, 0x07, 0xFF, 0xFF, 0xFC, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x8F,
  0xC3, 0xE0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0x1F, 0x7F,
  0xB3, 0xF3, 0xE0, 0x1F, 0x80, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x38, 0x1C, 0xE0, 0x73, 0x81, 0xCC, 0x03, 0x70, 0x0F,
  0xC0, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0xE0, 0x70, 0x3B, 0x83, 0xC1, 0xDC,
  0x1E, 0x0E, 0xE1, 0xF0, 0xE7, 0x0D, 0x87, 0x1C, 0x6E, 0x38, 0xE7, 0x71,
  0xC7, 0x39, 0x8C, 0x39, 0xCC, 0xE0, 0xCC, 0x77, 0x07, 0x63, 0xB8, 0x3F,
  0x0D, 0x81, 0xF0, 0x7C, 0x07, 0x83, 0xE0, 0x3C, 0x1F, 0x01, 0xE0, 0x70,
  0x70, 0x3D, 0xE0, 0xE3, 0x87, 0x07, 0x3C, 0x1C, 0xE0, 0x3F, 0x00, 0xFC,
  0x01, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0xFC, 0x07, 0x38, 0x1C, 0xF0, 0xE1,
  0xC7, 0x83, 0xBC, 0x0F, 0xE0, 0x1F, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x06, 0x18, 0x1C, 0xE0, 0x73, 0x80, 0xCC, 0x03,
  0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0E, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xE0,
  0x70, 0x38, 0x0F, 0xFF, 0xFF, 0x03, 0x87, 0xC3, 0xE3, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x0F, 0x07, 0x80, 0xE0, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1F, 0x0F, 0x80, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x7C,
  0x3E, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC0,
  0x78, 0x7C, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF1,
  0xF0, 0xF0, 0x40, 0x00, 0x7E, 0x0F, 0xFF, 0xF1, 0xFF, 0x01, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Medium29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 21, 8, 2, -21 },
  { 12, 8, 8, 12, 2, -21 },
  { 20, 15, 21, 17, 1, -21 },
  { 60, 13, 24, 15, 1, -22 },
  { 99, 21, 21, 23, 1, -21 },
  { 155, 18, 21, 19, 1, -21 },
  { 203, 3, 8, 7, 2, -21 },
  { 206, 7, 26, 9, 1, -21 },
  { 229, 7, 26, 9, 1, -21 },
  { 252, 12, 12, 14, 1, -22 },
  { 270, 13, 14, 15, 1, -17 },
  { 293, 5, 7, 7, 1, -3 },
  { 298, 7, 3, 9, 1, -9 },
  { 301, 4, 4, 7, 2, -4 },
  { 303, 11, 21, 11, 0, -21 },
  { 332, 13, 21, 15, 1, -21 },
  { 367, 8, 21, 15, 2, -21 },
  { 388, 13, 21, 15, 1, -21 },
  { 423, 13, 21, 15, 1, -21 },
  { 458, 14, 21, 15, 1, -21 },
  { 495, 12, 21, 15, 2, -21 },
  { 527, 13, 21, 15, 1, -21 },
  { 562, 13, 21, 15, 1, -21 },
  { 597, 13, 21, 15, 1, -21 },
  { 632, 13, 21, 15, 1, -21 },
  { 667, 4, 16, 8, 2, -16 },
  { 675, 5, 20, 8, 1, -16 },
  { 688, 13, 14, 15, 1, -17 },
  { 711, 13, 8, 15, 1, -14 },
  { 724, 13, 14, 15, 1, -17 },
  { 747, 11, 21, 12, 0, -21 },
  { 776, 21, 23, 24, 1, -21 },
  { 837, 17, 21, 17, 0, -21 },
  { 882, 14, 21, 17, 2, -21 },
  { 919, 14, 21, 17, 2, -21 },
  { 956, 15, 21, 19, 2, -21 },
  { 996, 10, 21, 15, 3, -21 },
  { 1023, 10, 21, 14, 3, -21 },
  { 1050, 15, 21, 19, 2, -21 },
  { 1090, 14, 21, 20, 3, -21 },
  { 1127, 8, 21, 10, 1, -21 },
  { 1148, 7, 27, 8, -2, -21 },
  { 1172, 14, 21, 17, 3, -21 },
  { 1209, 11, 21, 14, 2, -21 },
  { 1238, 19, 21, 25, 3, -21 },
  { 1288, 15, 21, 20, 3, -21 },
  { 1328, 17, 21, 20, 2, -21 },
  { 1373, 13, 21, 16, 2, -21 },
  { 1408, 17, 26, 20, 2, -21 },
  { 1464, 14, 21, 17, 2, -21 },
  { 1501, 12, 21, 15, 1, -21 },
  { 1533, 14, 21, 15, 0, -21 },
  { 1570, 15, 21, 19, 2, -21 },
  { 1610, 16, 21, 16, 0, -21 },
  { 1652, 25, 21, 25, 0, -21 },
  { 1718, 16, 21, 16, 0, -21 },
  { 1760, 15, 21, 15, 0, -21 },
  { 1800, 13, 21, 15, 1, -21 },
  { 1835, 7, 26, 9, 2, -21 },
  { 1858, 11, 21, 11, 0, -21 },
  { 1887, 6, 26, 9, 1, -21 },
  { 1907, 14, 13, 15, 1, -21 },
  { 1930, 13, 1, 13, 0, 3 },
  { 1932, 6, 4, 9, 1, -22 },
  { 1935, 12, 16, 15, 1, -16 },
  { 1959, 13, 22, 16, 2, -22 },
  { 1995, 11, 16, 13, 1, -16 },
  { 2017, 13, 22, 16, 1, -22 },
  { 2053, 13, 16, 15, 1, -16 },
  { 2079, 10, 22, 9, 0, -22 },
  { 2107, 13, 23, 16, 1, -16 },
  { 2145, 12, 22, 17, 2, -22 },
  { 2178, 3, 22, 7, 2, -22 },
  { 2187, 6, 29, 7, -1, -22 },
  { 2209, 13, 22, 15, 2, -22 },
  { 2245, 3, 22, 7, 2, -22 },
  { 2254, 21, 16, 25, 2, -16 },
  { 2296, 12, 16, 17, 2, -16 },
  { 2320, 14, 16, 16, 1, -16 },
  { 2348, 13, 23, 16, 2, -16 },
  { 2386, 13, 23, 16, 1, -16 },
  { 2424, 9, 16, 11, 2, -16 },
  { 2442, 11, 16, 13, 1, -16 },
  { 2464, 9, 19, 10, 0, -19 },
  { 2486, 12, 16, 17, 2, -16 },
  { 2510, 14, 16, 14, 0, -16 },
  { 2538, 21, 16, 21, 0, -16 },
  { 2580, 14, 16, 14, 0, -16 },
  { 2608, 14, 23, 14, 0, -16 },
  { 2649, 10, 16, 12, 1, -16 },
  { 2669, 9, 26, 11, 1, -21 },
  { 2699, 3, 29, 15, 6, -22 },
  { 2710, 9, 26, 11, 1, -21 },
  { 2740, 13, 4, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_Medium29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium29pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM29PT7B_H_
