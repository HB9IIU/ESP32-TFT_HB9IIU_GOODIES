#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM8PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB4, 0x35, 0xF5, 0xE6, 0x2F, 0x43, 0xB6, 0x4A, 0xCB, 0x9B,
  0x2D, 0xB0, 0x62, 0x98, 0xD9, 0x3C, 0xC0, 0x5A, 0xA4, 0x95, 0x5C, 0x4F,
  0x60, 0x22, 0xF2, 0x60, 0xC0, 0xC0, 0x25, 0x25, 0x00, 0x69, 0x99, 0x96,
  0x75, 0x50, 0xE1, 0x12, 0x4F, 0xE1, 0x27, 0x1E, 0x22, 0x6A, 0xF2, 0x64,
  0xE1, 0x1E, 0x24, 0xE9, 0x96, 0xF1, 0x22, 0x44, 0x69, 0x66, 0x97, 0x69,
  0x97, 0x16, 0xC3, 0xC3, 0x80, 0x16, 0xC3, 0xFF, 0x86, 0x3C, 0xE4, 0xA0,
  0x80, 0x39, 0x1B, 0xEB, 0xBD, 0x03, 0x80, 0x23, 0x14, 0xE9, 0x44, 0xF6,
  0xFB, 0xC0, 0x34, 0x88, 0x47, 0xCA, 0x99, 0x9E, 0xF2, 0x69, 0xC0, 0xF2,
  0x69, 0x00, 0x3A, 0x21, 0x34, 0xBC, 0x99, 0x9F, 0x99, 0xD5, 0x70, 0x24,
  0x92, 0x56, 0xBA, 0xCC, 0xAB, 0x92, 0x49, 0xC0, 0x8C, 0x77, 0xBE, 0xD4,
  0x99, 0xDB, 0xB9, 0x32, 0x63, 0x14, 0xB8, 0xD6, 0xE9, 0x00, 0x32, 0x63,
  0x14, 0xB8, 0x60, 0xCA, 0xAC, 0xAB, 0x78, 0x42, 0x1E, 0xF4, 0x44, 0x44,
  0x99, 0x99, 0x9E, 0x99, 0x55, 0x62, 0x93, 0x26, 0xB3, 0x66, 0xC9, 0x80,
  0x95, 0x66, 0x59, 0x95, 0x62, 0x22, 0xF2, 0x24, 0x4F, 0xFE, 0x91, 0x22,
  0x40, 0xD5, 0x5C, 0x26, 0x59, 0xE0, 0xC0, 0x77, 0x9F, 0x9A, 0xDB, 0xC0,
  0x72, 0x30, 0x11, 0x79, 0x97, 0x7F, 0x87, 0x6B, 0xA4, 0x80, 0x79, 0x97,
  0x16, 0x9A, 0xDB, 0x40, 0xBC, 0xBF, 0x97, 0x4D, 0x40, 0xFC, 0xFD, 0x6B,
  0x50, 0xF6, 0xD0, 0x79, 0x97, 0xF6, 0xF9, 0x00, 0x79, 0x97, 0x11, 0xEA,
  0xE8, 0xF0, 0x5D, 0x26, 0xB6, 0xF0, 0x96, 0x66, 0xB6, 0xE5, 0x92, 0xF6,
  0x69, 0x96, 0x66, 0x4C, 0xE9, 0x70, 0x29, 0x64, 0x98, 0xFF, 0x89, 0x34,
  0xB0, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Medium8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 3, 2, 3, 0, -6 },
  { 3, 4, 6, 5, 0, -6 },
  { 6, 4, 6, 4, 0, -6 },
  { 9, 6, 6, 6, 0, -6 },
  { 14, 5, 6, 5, 0, -6 },
  { 18, 1, 2, 2, 0, -6 },
  { 19, 2, 7, 2, 0, -6 },
  { 21, 2, 7, 2, 0, -6 },
  { 23, 4, 3, 4, 0, -6 },
  { 25, 4, 4, 4, 0, -5 },
  { 27, 2, 2, 2, 0, -1 },
  { 28, 2, 1, 2, 0, -3 },
  { 29, 2, 1, 2, 0, -1 },
  { 30, 3, 6, 3, 0, -6 },
  { 33, 4, 6, 4, 0, -6 },
  { 36, 2, 6, 4, 1, -6 },
  { 38, 4, 6, 4, 0, -6 },
  { 41, 4, 6, 4, 0, -6 },
  { 44, 4, 6, 4, 0, -6 },
  { 47, 4, 6, 4, 0, -6 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 6, 4, 0, -6 },
  { 59, 4, 6, 4, 0, -6 },
  { 62, 2, 4, 2, 0, -4 },
  { 63, 2, 5, 2, 0, -4 },
  { 65, 4, 4, 4, 0, -5 },
  { 67, 4, 2, 4, 0, -4 },
  { 68, 4, 4, 4, 0, -5 },
  { 70, 3, 6, 3, 0, -6 },
  { 73, 6, 7, 7, 0, -6 },
  { 79, 5, 6, 5, 0, -6 },
  { 83, 3, 6, 5, 1, -6 },
  { 86, 4, 6, 5, 0, -6 },
  { 89, 4, 6, 5, 1, -6 },
  { 92, 3, 6, 4, 1, -6 },
  { 95, 3, 6, 4, 1, -6 },
  { 98, 5, 6, 5, 0, -6 },
  { 102, 4, 6, 5, 1, -6 },
  { 105, 2, 6, 3, 0, -6 },
  { 107, 3, 8, 2, -1, -6 },
  { 110, 4, 6, 5, 1, -6 },
  { 113, 3, 6, 4, 1, -6 },
  { 116, 5, 6, 7, 1, -6 },
  { 120, 4, 6, 6, 1, -6 },
  { 123, 5, 6, 6, 0, -6 },
  { 127, 3, 6, 4, 1, -6 },
  { 130, 5, 7, 6, 0, -6 },
  { 135, 4, 6, 5, 1, -6 },
  { 138, 4, 6, 4, 0, -6 },
  { 141, 4, 6, 4, 0, -6 },
  { 144, 4, 6, 5, 1, -6 },
  { 147, 4, 6, 4, 0, -6 },
  { 150, 7, 6, 7, 0, -6 },
  { 156, 4, 6, 4, 0, -6 },
  { 159, 4, 6, 4, 0, -6 },
  { 162, 4, 6, 4, 0, -6 },
  { 165, 1, 7, 3, 1, -6 },
  { 166, 3, 6, 3, 0, -6 },
  { 169, 2, 7, 3, 0, -6 },
  { 171, 4, 4, 4, 0, -6 },
  { 173, 3, 1, 3, 0, 0 },
  { 174, 2, 1, 2, 0, -6 },
  { 175, 4, 4, 4, 0, -4 },
  { 177, 3, 6, 5, 1, -6 },
  { 180, 3, 4, 4, 0, -4 },
  { 182, 4, 6, 5, 0, -6 },
  { 185, 4, 4, 4, 0, -4 },
  { 187, 3, 6, 3, 0, -6 },
  { 190, 4, 6, 5, 0, -4 },
  { 193, 3, 6, 5, 1, -6 },
  { 196, 1, 6, 2, 1, -6 },
  { 197, 1, 8, 2, 0, -6 },
  { 198, 3, 6, 4, 1, -6 },
  { 201, 1, 6, 2, 1, -6 },
  { 202, 5, 4, 7, 1, -4 },
  { 205, 3, 4, 5, 1, -4 },
  { 207, 4, 4, 4, 0, -4 },
  { 209, 3, 6, 5, 1, -4 },
  { 212, 4, 6, 5, 0, -4 },
  { 215, 2, 4, 3, 1, -4 },
  { 216, 3, 4, 3, 0, -4 },
  { 218, 3, 5, 3, 0, -5 },
  { 220, 3, 4, 5, 1, -4 },
  { 222, 4, 4, 4, 0, -4 },
  { 224, 6, 4, 6, 0, -4 },
  { 227, 4, 4, 4, 0, -4 },
  { 229, 4, 6, 4, 0, -4 },
  { 232, 3, 4, 3, 0, -4 },
  { 234, 3, 7, 3, 0, -6 },
  { 237, 1, 8, 4, 2, -6 },
  { 238, 3, 7, 3, 0, -6 },
  { 241, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_SemiCondensed_Medium8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium8pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM8PT7B_H_
