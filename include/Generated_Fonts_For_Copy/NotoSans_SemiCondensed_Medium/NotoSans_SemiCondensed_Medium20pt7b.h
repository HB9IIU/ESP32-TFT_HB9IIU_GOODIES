#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM20PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xB6, 0xDA, 0x48, 0x2F, 0xC0, 0xCF, 0x3C, 0xF3, 0x4C, 0x0C,
  0xC1, 0x90, 0x22, 0x04, 0x47, 0xFE, 0x33, 0x06, 0x60, 0xC8, 0xFF, 0xFF,
  0xFC, 0x4C, 0x19, 0x83, 0x30, 0x64, 0x00, 0x08, 0x06, 0x1F, 0xDD, 0x2C,
  0x86, 0x43, 0xE0, 0xF8, 0x0F, 0x05, 0x82, 0x71, 0x6F, 0xF7, 0xF0, 0x20,
  0x10, 0x78, 0x63, 0x61, 0x0C, 0x8C, 0x23, 0x20, 0x8D, 0x83, 0x24, 0xCD,
  0xB7, 0x9E, 0x93, 0x06, 0xCC, 0x13, 0x30, 0xCC, 0xC3, 0x13, 0x18, 0x6C,
  0x61, 0xE0, 0x3E, 0x06, 0x70, 0x63, 0x06, 0x30, 0x76, 0x03, 0xC0, 0x38,
  0x07, 0xC6, 0xC6, 0x6C, 0x7C, 0xC3, 0xCC, 0x1C, 0xFF, 0xE7, 0xE7, 0xFF,
  0x40, 0x39, 0x18, 0xCC, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x31, 0x86, 0x38,
  0xC6, 0x62, 0x33, 0x33, 0x33, 0x33, 0x36, 0x66, 0xC0, 0x18, 0x18, 0x99,
  0xFF, 0x18, 0x3C, 0x66, 0x66, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0xFF, 0xFC,
  0x60, 0x30, 0x18, 0x0C, 0x00, 0x7B, 0x68, 0xFF, 0x5F, 0x80, 0x06, 0x0C,
  0x10, 0x60, 0xC3, 0x06, 0x0C, 0x30, 0x60, 0x83, 0x06, 0x18, 0x00, 0x08,
  0x1F, 0x19, 0xDC, 0x6C, 0x36, 0x1B, 0x0F, 0x83, 0xC1, 0xE1, 0xF0, 0xD8,
  0x66, 0x33, 0xF0, 0xF8, 0x1C, 0xF7, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0x7E, 0x73, 0x90, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x18,
  0x1C, 0x1C, 0x1C, 0x0C, 0x0F, 0xFF, 0xFC, 0xFE, 0xC7, 0x03, 0x03, 0x03,
  0x06, 0x38, 0x3F, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFE, 0x03, 0x01, 0xC0,
  0x70, 0x3C, 0x1B, 0x04, 0xC3, 0x31, 0x8C, 0x63, 0x3F, 0xFF, 0xFC, 0x0C,
  0x03, 0x00, 0xC0, 0x7F, 0x7F, 0x60, 0x40, 0x40, 0xFC, 0xFF, 0x03, 0x03,
  0x03, 0x03, 0x03, 0xFF, 0xFC, 0x1F, 0x18, 0x18, 0x08, 0x0C, 0x06, 0xF3,
  0xFD, 0xC6, 0xC1, 0xE0, 0xF0, 0xEC, 0x67, 0xF1, 0xF0, 0xFF, 0xFF, 0xC0,
  0xC0, 0x60, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x0C, 0x06, 0x07, 0x03, 0x03,
  0x80, 0x7E, 0x33, 0xB0, 0xD8, 0x66, 0x33, 0xF0, 0xF0, 0xFC, 0xE3, 0x61,
  0xF0, 0x78, 0x6F, 0x73, 0xF0, 0x7E, 0x73, 0xB0, 0xD8, 0x6C, 0x36, 0x1F,
  0x0E, 0xFA, 0x3B, 0x01, 0x80, 0xC0, 0xC7, 0xE3, 0xC0, 0x7D, 0x80, 0x00,
  0x5F, 0x80, 0x7D, 0x80, 0x00, 0x1F, 0x6D, 0x00, 0x00, 0x81, 0xC3, 0x87,
  0x0E, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0x80, 0x40, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xFC, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x38, 0x3C, 0x78, 0xE0,
  0xC0, 0x40, 0x00, 0xFE, 0x46, 0x03, 0x03, 0x06, 0x0E, 0x1C, 0x18, 0x10,
  0x10, 0x00, 0x10, 0x38, 0x38, 0x0F, 0xE0, 0x60, 0xC3, 0x01, 0x98, 0x43,
  0x47, 0xCF, 0x31, 0x1C, 0xC4, 0x72, 0x11, 0xC8, 0xC7, 0x33, 0x3C, 0xFF,
  0x91, 0xCC, 0x60, 0x00, 0xC0, 0x81, 0xFE, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x01, 0xB0, 0x19, 0x81, 0x98, 0x39, 0x83, 0x0C, 0x3F, 0xC7, 0xFC,
  0x60, 0xE6, 0x06, 0xE0, 0x6C, 0x07, 0xFE, 0x67, 0xB0, 0xF8, 0x7C, 0x36,
  0x3B, 0xF1, 0x8E, 0xC3, 0xE0, 0xF0, 0x78, 0x7F, 0xF7, 0xF0, 0x1F, 0xCE,
  0x27, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x3F, 0x87, 0xE0, 0xFE, 0x3F, 0xCC, 0x3B, 0x07, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1B, 0x0E, 0xFF, 0x3F, 0x00, 0xFF, 0xFF,
  0x06, 0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x00,
  0x1F, 0xE7, 0x99, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x30, 0xFE, 0x1F, 0xC0,
  0x7C, 0x0D, 0x81, 0xB8, 0x33, 0xFE, 0x3F, 0xC0, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x30, 0xFB, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0x7C, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x67, 0xF7, 0x00, 0xC3,
  0xE1, 0xB1, 0x99, 0x8D, 0xC6, 0xC3, 0xE1, 0xF0, 0xCC, 0x67, 0x31, 0x98,
  0x6C, 0x3E, 0x0C, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0F, 0xFF, 0xC0, 0xE0, 0x3F, 0x01, 0xFC, 0x1F, 0xE0, 0xFF, 0x05,
  0xEC, 0x6F, 0x63, 0x7B, 0x13, 0xCD, 0x9E, 0x6C, 0xF3, 0x47, 0x8E, 0x3C,
  0x71, 0xE3, 0x0C, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xD8, 0xF6, 0x3C, 0xCF,
  0x3B, 0xC6, 0xF1, 0xDC, 0x37, 0x0F, 0xC1, 0xF0, 0x30, 0x02, 0x01, 0xF8,
  0x39, 0xC6, 0x06, 0x60, 0x6E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xE0, 0x76, 0x06, 0x70, 0xE3, 0xFC, 0x1F, 0x80, 0xFE, 0xFF, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC7, 0xFE, 0xF0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x02, 0x01,
  0xF8, 0x39, 0xC6, 0x06, 0x60, 0x7E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xE0, 0x76, 0x06, 0x70, 0xE3, 0xFC, 0x1F, 0x80, 0x18, 0x01, 0xC0,
  0x0E, 0xFE, 0x7F, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0xF9, 0xF8, 0xCC, 0x63,
  0x31, 0x98, 0x6C, 0x36, 0x0C, 0x7F, 0xE3, 0xC0, 0xC0, 0xC0, 0x70, 0x3C,
  0x1E, 0x07, 0x03, 0x03, 0x83, 0xFE, 0xFC, 0xFF, 0xFF, 0xF0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x1F, 0x06, 0x7F, 0x8F, 0xC0, 0xC0, 0x6C, 0x1D, 0x83, 0x30,
  0x67, 0x0C, 0x63, 0x0C, 0x61, 0x8C, 0x1B, 0x03, 0x60, 0x6C, 0x07, 0x00,
  0xE0, 0x1C, 0x00, 0xC1, 0xC1, 0xB0, 0xE0, 0xD8, 0x70, 0xCC, 0x2C, 0x66,
  0x36, 0x33, 0x9B, 0x18, 0xCD, 0x9C, 0x64, 0x6C, 0x36, 0x36, 0x1B, 0x1B,
  0x07, 0x85, 0x83, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0xE0, 0xCE, 0x30,
  0xC6, 0x0D, 0x81, 0xB0, 0x1C, 0x03, 0x80, 0x70, 0x1B, 0x03, 0x60, 0xC6,
  0x38, 0xC6, 0x0D, 0xC1, 0xC0, 0xE0, 0xD8, 0x77, 0x18, 0xCE, 0x33, 0x06,
  0xC1, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF,
  0xFF, 0x07, 0x06, 0x0C, 0x0C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xC0, 0xFF,
  0xFF, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xF8,
  0xC0, 0xC1, 0x81, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60,
  0xC0, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x18, 0x0E,
  0x0F, 0x06, 0xC6, 0x63, 0x1B, 0x0D, 0x83, 0xFF, 0x80, 0xE6, 0x30, 0x3E,
  0x7F, 0x03, 0x03, 0x0F, 0x7F, 0xC3, 0xC3, 0xC3, 0xEF, 0x7B, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0xE6, 0xFB, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0xFB, 0x7C, 0x3E, 0xFD, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xE0, 0xFC,
  0xF8, 0x01, 0x80, 0xC0, 0x60, 0x33, 0xDB, 0xFF, 0x8F, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3E, 0x3B, 0xFC, 0xF6, 0x3C, 0x3F, 0x98, 0xD8, 0x6C, 0x1F,
  0xFF, 0x01, 0x80, 0xE0, 0x3F, 0x8F, 0xC0, 0x1E, 0x74, 0xC1, 0x87, 0xDF,
  0x8C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x00, 0x3D, 0xBF, 0xF8,
  0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE3, 0xBF, 0xCF, 0x60, 0x30, 0x1C,
  0x19, 0xFC, 0x78, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0xE6, 0xFB, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x86, 0x5D, 0x0F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x11, 0xC4, 0x03, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7,
  0x39, 0xBD, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC7, 0xC6, 0xCC, 0xD8, 0xF0,
  0xF8, 0xD8, 0xCC, 0xCE, 0xC6, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xCE, 0x39, 0xBE, 0xFB, 0x8E, 0x3F, 0x0C, 0x3E, 0x18, 0x7C, 0x30, 0xF8,
  0x61, 0xF0, 0xC3, 0xE1, 0x87, 0xC3, 0x0F, 0x86, 0x18, 0xCF, 0x6F, 0xB8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x60, 0x3E, 0x3F,
  0x98, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE3, 0xBB, 0x8F, 0x80, 0xCE,
  0x6F, 0xB8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xFF, 0xBF, 0xDC,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0x3D, 0xBF, 0xF8, 0xF8, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xE3, 0xBF, 0xCF, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xCF,
  0x7F, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x00, 0x7D, 0xFF, 0x06, 0x0F,
  0x0F, 0x87, 0x83, 0x07, 0xFF, 0xF0, 0x30, 0xC7, 0xFF, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0F, 0x3C, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0xC3, 0x63, 0xBF, 0xCF, 0x60, 0xC1, 0xF8, 0x66, 0x19, 0x8C, 0x63, 0x0C,
  0xC3, 0x60, 0xD8, 0x1E, 0x07, 0x01, 0xC0, 0xC3, 0x86, 0xC7, 0x19, 0x8E,
  0x33, 0x34, 0x66, 0x6C, 0xC6, 0xDB, 0x0D, 0x36, 0x1E, 0x2C, 0x3C, 0x70,
  0x38, 0xE0, 0x61, 0xC0, 0xE1, 0xB1, 0xCC, 0xC7, 0xC1, 0xE0, 0x60, 0x78,
  0x7C, 0x33, 0x31, 0xF8, 0x60, 0xC1, 0xF8, 0x66, 0x19, 0x8C, 0x33, 0x0C,
  0xC3, 0x60, 0x78, 0x1E, 0x07, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x0F, 0x03,
  0x80, 0xFF, 0xFC, 0x30, 0xE1, 0x86, 0x0C, 0x30, 0xE1, 0xFF, 0xF8, 0x1C,
  0xE3, 0x0C, 0x30, 0xC3, 0x18, 0xC1, 0x83, 0x0C, 0x30, 0xC3, 0x0E, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0x83, 0x0C, 0x30, 0xC3, 0x0E, 0x0C,
  0xE3, 0x0C, 0x30, 0xC3, 0x38, 0xE0, 0xF9, 0xCF, 0x80,
};

const GFXglyph NotoSans_SemiCondensed_Medium20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 8, 1, -14 },
  { 11, 11, 14, 12, 0, -14 },
  { 31, 9, 16, 10, 1, -15 },
  { 49, 14, 14, 16, 1, -14 },
  { 74, 12, 14, 13, 1, -14 },
  { 95, 2, 5, 5, 1, -14 },
  { 97, 5, 17, 6, 1, -14 },
  { 108, 4, 17, 6, 1, -14 },
  { 117, 8, 8, 10, 1, -15 },
  { 125, 9, 10, 10, 1, -12 },
  { 137, 3, 5, 5, 1, -2 },
  { 139, 4, 2, 6, 1, -6 },
  { 140, 3, 3, 5, 1, -3 },
  { 142, 7, 14, 8, 0, -14 },
  { 155, 9, 15, 10, 1, -15 },
  { 172, 6, 14, 10, 1, -14 },
  { 183, 9, 14, 10, 1, -14 },
  { 199, 8, 14, 10, 1, -14 },
  { 213, 10, 14, 10, 0, -14 },
  { 231, 8, 14, 10, 1, -14 },
  { 245, 9, 14, 10, 1, -14 },
  { 261, 9, 14, 10, 1, -14 },
  { 277, 9, 14, 10, 1, -14 },
  { 293, 9, 14, 10, 1, -14 },
  { 309, 3, 11, 5, 1, -11 },
  { 314, 3, 14, 5, 1, -11 },
  { 320, 9, 10, 10, 1, -12 },
  { 332, 9, 6, 10, 1, -10 },
  { 339, 9, 10, 10, 1, -12 },
  { 351, 8, 14, 8, 0, -14 },
  { 365, 14, 16, 16, 1, -14 },
  { 393, 12, 14, 12, 0, -14 },
  { 414, 9, 14, 12, 2, -14 },
  { 430, 10, 14, 11, 1, -14 },
  { 448, 10, 14, 13, 2, -14 },
  { 466, 7, 14, 10, 2, -14 },
  { 479, 7, 14, 10, 2, -14 },
  { 492, 11, 14, 13, 1, -14 },
  { 512, 10, 14, 14, 2, -14 },
  { 530, 5, 14, 7, 1, -14 },
  { 539, 5, 18, 5, -1, -14 },
  { 551, 9, 14, 11, 2, -14 },
  { 567, 7, 14, 10, 2, -14 },
  { 580, 13, 14, 17, 2, -14 },
  { 603, 10, 14, 14, 2, -14 },
  { 621, 12, 15, 14, 1, -15 },
  { 644, 8, 14, 11, 2, -14 },
  { 658, 12, 18, 14, 1, -15 },
  { 685, 9, 14, 12, 2, -14 },
  { 701, 8, 14, 10, 1, -14 },
  { 715, 10, 14, 10, 0, -14 },
  { 733, 10, 14, 13, 2, -14 },
  { 751, 11, 14, 11, 0, -14 },
  { 771, 17, 14, 17, 0, -14 },
  { 801, 11, 14, 11, 0, -14 },
  { 821, 10, 14, 10, 0, -14 },
  { 839, 8, 14, 10, 1, -14 },
  { 853, 5, 17, 6, 1, -14 },
  { 864, 7, 14, 8, 0, -14 },
  { 877, 4, 17, 6, 1, -14 },
  { 886, 9, 8, 11, 1, -14 },
  { 895, 9, 1, 9, 0, 2 },
  { 897, 4, 3, 6, 1, -15 },
  { 899, 8, 11, 10, 1, -11 },
  { 910, 9, 15, 11, 1, -15 },
  { 927, 7, 11, 9, 1, -11 },
  { 937, 9, 15, 11, 1, -15 },
  { 954, 9, 11, 10, 1, -11 },
  { 967, 7, 15, 6, 0, -15 },
  { 981, 9, 16, 11, 1, -11 },
  { 999, 9, 15, 11, 1, -15 },
  { 1016, 3, 15, 5, 1, -15 },
  { 1022, 5, 20, 5, -1, -15 },
  { 1035, 8, 15, 10, 2, -15 },
  { 1050, 3, 15, 5, 1, -15 },
  { 1056, 15, 11, 17, 1, -11 },
  { 1077, 9, 11, 11, 1, -11 },
  { 1090, 9, 11, 11, 1, -11 },
  { 1103, 9, 16, 11, 1, -11 },
  { 1121, 9, 16, 11, 1, -11 },
  { 1139, 6, 11, 8, 1, -11 },
  { 1148, 7, 11, 9, 1, -11 },
  { 1158, 6, 13, 7, 0, -13 },
  { 1168, 9, 11, 11, 1, -11 },
  { 1181, 10, 11, 10, 0, -11 },
  { 1195, 15, 11, 15, 0, -11 },
  { 1216, 9, 11, 10, 0, -11 },
  { 1229, 10, 16, 10, 0, -11 },
  { 1249, 7, 11, 8, 1, -11 },
  { 1259, 6, 17, 7, 1, -14 },
  { 1272, 2, 20, 10, 4, -15 },
  { 1277, 6, 17, 7, 1, -14 },
  { 1290, 9, 2, 10, 1, -8 },
};

const GFXfont NotoSans_SemiCondensed_Medium20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium20pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM20PT7B_H_
