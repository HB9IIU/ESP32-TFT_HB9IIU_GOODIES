#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM46PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium46pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xDE, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0x78, 0x40, 0xF8, 0xFF, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF, 0x07, 0xF8,
  0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xDC, 0x1E, 0xE0, 0xF0, 0x00,
  0x78, 0x38, 0x00, 0x38, 0x1C, 0x00, 0x1C, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x07, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF8, 0x0E, 0x07, 0x00, 0x07, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0x70,
  0x38, 0x0F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x0F,
  0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xE0, 0x01,
  0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x3F, 0xFF,
  0xE7, 0xFF, 0xFC, 0x7E, 0x61, 0xC7, 0x86, 0x00, 0xF8, 0x60, 0x0F, 0x86,
  0x00, 0xF8, 0x60, 0x07, 0x86, 0x00, 0x7E, 0x60, 0x07, 0xFE, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x06, 0xFE, 0x00, 0x63, 0xF0, 0x06, 0x1F, 0x00, 0x61, 0xF0, 0x06, 0x1F,
  0x00, 0x61, 0xFC, 0x06, 0x3E, 0xF8, 0x6F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x87, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x1F, 0xF0,
  0x01, 0xC0, 0x1F, 0xF8, 0x01, 0xE0, 0x0F, 0x1E, 0x00, 0xF0, 0x07, 0x0F,
  0x00, 0xF0, 0x07, 0x83, 0xC0, 0x78, 0x03, 0xC1, 0xE0, 0x78, 0x01, 0xE0,
  0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x1E, 0x00, 0x3C,
  0x1E, 0x1E, 0x00, 0x1E, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x8F, 0x00, 0x07,
  0x83, 0xC7, 0x8F, 0xC3, 0xC1, 0xE7, 0x8F, 0xF0, 0xE1, 0xE3, 0xCF, 0xFC,
  0x78, 0xF3, 0xC7, 0x9E, 0x1F, 0xF1, 0xE7, 0x87, 0x8F, 0xF9, 0xE3, 0xC3,
  0xC3, 0xF0, 0xF1, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x78, 0x00, 0x78, 0x70,
  0x3C, 0x00, 0x78, 0x78, 0x1E, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x3C, 0x0E,
  0x07, 0x80, 0x1E, 0x07, 0x03, 0xC0, 0x1E, 0x03, 0x81, 0xC0, 0x0F, 0x01,
  0xE1, 0xE0, 0x07, 0x00, 0xF0, 0xF0, 0x07, 0x80, 0x3C, 0xF8, 0x03, 0x80,
  0x1F, 0xF8, 0x03, 0xC0, 0x07, 0xF8, 0x03, 0xC0, 0x01, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFD, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x1E, 0x03, 0xC0, 0x01,
  0xE0, 0x3C, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xC1, 0xFF,
  0xC0, 0x7C, 0x3F, 0x7E, 0x07, 0xC7, 0xE3, 0xF0, 0x7C, 0x7C, 0x1F, 0x8F,
  0x8F, 0x80, 0xFC, 0xF8, 0xF8, 0x07, 0xDF, 0x8F, 0x80, 0x3F, 0xF0, 0xF8,
  0x03, 0xFE, 0x0F, 0x80, 0x1F, 0xE0, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0xE0, 0x7E, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xCF, 0xC1,
  0xFF, 0xF8, 0x7E, 0x07, 0xFE, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE,
  0xF7, 0x9C, 0xE0, 0x03, 0xE0, 0x78, 0x1E, 0x07, 0xC0, 0xF0, 0x3E, 0x07,
  0x81, 0xF0, 0x3C, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0xF8, 0x0F,
  0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0,
  0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x0F, 0x81,
  0xE0, 0x78, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x3C, 0x38, 0x7F, 0xF7, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0x78, 0x03, 0xCF, 0x80, 0xF8, 0xF8, 0x3E, 0x1F, 0x83, 0xC1, 0xE0,
  0x18, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3E, 0x7D,
  0xF3, 0xE7, 0xCF, 0x1E, 0x7C, 0xF1, 0xE3, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE3, 0x00, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8,
  0x3F, 0x0F, 0xC3, 0xE0, 0x7C, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x01,
  0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x7C,
  0x3E, 0x07, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0xFE, 0x0F, 0xF0, 0xFF, 0x8F, 0xBC, 0xFF,
  0xFF, 0x9F, 0x78, 0xF9, 0x87, 0xC8, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xFC, 0x01, 0xFF, 0xF0,
  0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0x7C, 0x0F, 0xC3, 0x00, 0x7E, 0x20, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x78, 0x0F, 0xC2, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x03, 0xE8, 0x00, 0x3E, 0xC0, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xBC,
  0x00, 0x1E, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00,
  0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x3C, 0x1F, 0x00, 0xF0,
  0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0x87,
  0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x1F, 0x40, 0x07, 0xEC, 0x01, 0xF9, 0xFF, 0xFF, 0x3F,
  0xFF, 0xC7, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFC,
  0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x7C, 0x0F, 0x9F, 0xF0, 0xFB, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF,
  0x07, 0xEF, 0xE0, 0x3E, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x1F,
  0x7C, 0x01, 0xF3, 0xE0, 0x3E, 0x3F, 0x07, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF,
  0xC0, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3, 0xE0, 0x7C, 0x3F,
  0x0F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x01,
  0xFF, 0xF0, 0x3F, 0x1F, 0x87, 0xE0, 0xFC, 0x7C, 0x03, 0xEF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0x7C, 0x03, 0xE7, 0xF9, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x07, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF8, 0x7E, 0x0F, 0xC7, 0xC0, 0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xF7, 0xC0, 0x3F, 0x7E, 0x0F, 0xF3, 0xFF,
  0xFF, 0x3F, 0xFD, 0xF1, 0xFF, 0x9F, 0x07, 0xF1, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x83, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0,
  0x3F, 0xF0, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x78, 0xC0, 0x3C,
  0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xEF, 0x9F, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF,
  0x1E, 0x38, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00,
  0x3F, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFF,
  0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x38, 0x1F, 0x88, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0x40,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x0F, 0x0F, 0x01, 0xFF, 0x07, 0x8F, 0x03, 0xFF, 0xC1, 0xC7, 0x83,
  0xFF, 0xE0, 0xF7, 0x81, 0xF0, 0xF0, 0x7B, 0xC1, 0xE0, 0x78, 0x3D, 0xE0,
  0xF0, 0x3C, 0x1E, 0xE0, 0xF0, 0x1E, 0x07, 0x70, 0x78, 0x0F, 0x03, 0xF8,
  0x3C, 0x07, 0x81, 0xFC, 0x1E, 0x03, 0xC1, 0xFE, 0x0F, 0x01, 0xE0, 0xFF,
  0x07, 0x80, 0xF0, 0x7F, 0x83, 0xC0, 0xF8, 0x3F, 0xC1, 0xE0, 0x7C, 0x1C,
  0xE0, 0xF8, 0x3E, 0x1E, 0x78, 0x3E, 0x7F, 0x9E, 0x3C, 0x1F, 0xF9, 0xFF,
  0x1E, 0x07, 0xF8, 0xFF, 0x07, 0x80, 0xF8, 0x1E, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x01, 0x80, 0x01, 0xFF, 0x0F, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0xF8, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E,
  0x00, 0x1E, 0x03, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F,
  0x01, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC,
  0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0x80, 0xFF, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8,
  0x01, 0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xEF, 0x80, 0x3E,
  0x7C, 0x07, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x3E, 0x01, 0xFD, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xEF, 0x80, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0xE0, 0x78, 0xFE, 0x00, 0x23, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x18, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xF0,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0xF8, 0x1F, 0xF0, 0xF8, 0x03, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF8,
  0xF8, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0xFD, 0xFF,
  0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xBE, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xFF, 0xFE,
  0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFE, 0x1F, 0xE0, 0x1E, 0x1F, 0x80, 0x02, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0x7C, 0x00, 0x0F, 0x7E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3F, 0x80,
  0x0F, 0x1F, 0xC0, 0x0F, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFC, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03,
  0xE8, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x8F, 0xE0, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0xFC, 0xF8, 0x07, 0xE3, 0xE0, 0x1F,
  0x0F, 0x80, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x0F,
  0x87, 0xC0, 0x3E, 0x3E, 0x00, 0xF9, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0xBE,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x0F, 0xEF, 0x80,
  0x3F, 0x1F, 0x00, 0xF8, 0x7E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xF0, 0x3E,
  0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x3E, 0x01,
  0xF8, 0xF8, 0x03, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x3E,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFD, 0xE0, 0x00, 0xF7, 0xFB, 0xC0, 0x01, 0xEF, 0xF7, 0xC0, 0x03,
  0xDF, 0xE7, 0x80, 0x0F, 0x3F, 0xCF, 0x00, 0x1E, 0x7F, 0x9F, 0x00, 0x3C,
  0xFF, 0x1E, 0x00, 0xF3, 0xFE, 0x3C, 0x01, 0xE7, 0xFC, 0x7C, 0x03, 0xCF,
  0xF8, 0x78, 0x0F, 0x1F, 0xF0, 0xF0, 0x1E, 0x3F, 0xE1, 0xE0, 0x7C, 0x7F,
  0xC1, 0xE0, 0xF0, 0xFF, 0x83, 0xC1, 0xE1, 0xFF, 0x07, 0x87, 0xC3, 0xFE,
  0x0F, 0x8F, 0x07, 0xFC, 0x0F, 0x1E, 0x0F, 0xF8, 0x1E, 0x7C, 0x1F, 0xF0,
  0x3E, 0xF0, 0x3F, 0xE0, 0x3D, 0xE0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0x80,
  0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x07, 0xFC, 0x03,
  0xF0, 0x0F, 0xF8, 0x03, 0xE0, 0x1F, 0xF0, 0x07, 0xC0, 0x3E, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xEF, 0x80, 0x1F, 0xF7,
  0xC0, 0x0F, 0xF9, 0xF0, 0x07, 0xFC, 0xF8, 0x03, 0xFE, 0x3E, 0x01, 0xFF,
  0x1F, 0x80, 0xFF, 0x87, 0xC0, 0x7F, 0xC3, 0xF0, 0x3F, 0xE0, 0xF8, 0x1F,
  0xF0, 0x3E, 0x0F, 0xF8, 0x1F, 0x07, 0xFC, 0x07, 0xC3, 0xFE, 0x03, 0xF1,
  0xFF, 0x00, 0xF8, 0xFF, 0x80, 0x7E, 0x7F, 0xC0, 0x1F, 0x3F, 0xE0, 0x0F,
  0xDF, 0xF0, 0x03, 0xEF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFC, 0x07, 0xF0, 0x7E,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF1, 0xF8, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x3F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x3F, 0xCF, 0x80,
  0x7E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x07, 0xEF,
  0x80, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0,
  0xFF, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFC,
  0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x01,
  0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x81, 0xFC, 0x07, 0xF0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0xF8, 0x3F, 0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x3E,
  0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00,
  0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x0F, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xF8,
  0x3E, 0x03, 0xE0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xF8, 0x0F,
  0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0x03,
  0xFF, 0x01, 0xFF, 0xFC, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xF0, 0x3C, 0xF8,
  0x01, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x00, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF,
  0xE7, 0xFF, 0xF8, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFB,
  0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xF0, 0x1F, 0x87, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x1E, 0x00,
  0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x1E, 0x03, 0xE0,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x87,
  0xC0, 0x03, 0xE1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0xF0, 0x00, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF8, 0x00, 0xFB, 0xE0,
  0x03, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xE0, 0x03, 0xC7, 0x80, 0x1F, 0xC0,
  0x0F, 0x8F, 0x80, 0x3F, 0xC0, 0x1F, 0x1F, 0x00, 0x7F, 0x80, 0x3E, 0x3E,
  0x01, 0xEF, 0x00, 0x78, 0x7C, 0x03, 0xDE, 0x01, 0xF0, 0x78, 0x07, 0x9E,
  0x03, 0xE0, 0xF8, 0x0F, 0x3C, 0x07, 0xC1, 0xF0, 0x3E, 0x78, 0x0F, 0x03,
  0xE0, 0x78, 0xF8, 0x3E, 0x03, 0xC0, 0xF1, 0xF0, 0x7C, 0x07, 0xC1, 0xE1,
  0xE0, 0xF8, 0x0F, 0x87, 0xC3, 0xC1, 0xF0, 0x1F, 0x0F, 0x07, 0xC3, 0xC0,
  0x1E, 0x1E, 0x07, 0x8F, 0x80, 0x3E, 0x3C, 0x0F, 0x1F, 0x00, 0x7C, 0xF8,
  0x1E, 0x3E, 0x00, 0xF9, 0xE0, 0x3E, 0x78, 0x00, 0xF3, 0xC0, 0x3D, 0xF0,
  0x01, 0xE7, 0x80, 0x7B, 0xE0, 0x03, 0xFF, 0x00, 0xF7, 0xC0, 0x07, 0xFC,
  0x01, 0xEF, 0x00, 0x07, 0xF8, 0x01, 0xDE, 0x00, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0,
  0x0F, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x0F,
  0x83, 0xE0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7D, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xFC, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x81, 0xF0,
  0x0F, 0x81, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1C, 0xE0, 0x00,
  0xF3, 0xC0, 0x03, 0xC7, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x7C, 0x03, 0xC0,
  0xF0, 0x0F, 0x03, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1F, 0x0F, 0x00, 0x3C,
  0x3C, 0x00, 0xF9, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFE, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xDF, 0xE1, 0x80, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xFF, 0x87, 0xFF, 0xF3, 0xFF, 0xFE, 0xFE,
  0x07, 0xDF, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xFC, 0x7F, 0xDF, 0xFE, 0x79, 0xFF,
  0xCF, 0x1F, 0xE1, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x3F, 0x81, 0xF3, 0xFF, 0x0F,
  0xBF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFC, 0x1F, 0x9F, 0xC0, 0x7E, 0xFC, 0x01,
  0xF7, 0xE0, 0x0F, 0xBE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7F, 0x00, 0xFB, 0xF8,
  0x0F, 0x9F, 0xFB, 0xFC, 0xFF, 0xFF, 0xC7, 0x9F, 0xFC, 0x3C, 0x3F, 0xC0,
  0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFF, 0xE3, 0xF0, 0x11, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x19, 0xFF, 0xFC, 0x7F,
  0xFE, 0x1F, 0xFF, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0xFE, 0x3E, 0x1F,
  0xF9, 0xF1, 0xFF, 0xEF, 0x9F, 0xFF, 0xFC, 0xFC, 0x1F, 0xEF, 0xC0, 0x7F,
  0x7C, 0x01, 0xFB, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0xBF, 0x00,
  0xFC, 0xF8, 0x0F, 0xE7, 0xFB, 0xFF, 0x1F, 0xFE, 0xF8, 0x7F, 0xE3, 0xC1,
  0xFE, 0x1E, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xFD, 0xFC,
  0x3E, 0x07, 0xE3, 0xC0, 0x3E, 0x7C, 0x01, 0xE7, 0xC0, 0x1F, 0x78, 0x01,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x61, 0xFE, 0xFE, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0xFE, 0x0F,
  0xFE, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x03, 0xF8, 0x78, 0x7F, 0xE7, 0xC7, 0xFF, 0xBE, 0x7F,
  0xFF, 0xF3, 0xF0, 0x7F, 0xBF, 0x01, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x3F,
  0x78, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFB,
  0xE0, 0x07, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xF3, 0xE0, 0x3F, 0x9F, 0xEF,
  0xFC, 0x7F, 0xFB, 0xE1, 0xFF, 0xDF, 0x07, 0xF8, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x80, 0x0F,
  0xC7, 0x00, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0xFF, 0x0F, 0x9F, 0xF8, 0xFB, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFF, 0x07, 0xEF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x7B, 0xEF, 0xFE, 0x78, 0x00, 0x00,
  0x03, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE,
  0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE0, 0x03, 0xC1, 0xF0, 0x7C,
  0x1F, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x0F, 0xFF,
  0xEF, 0xFB, 0xFC, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xFF, 0x80, 0x7E, 0xF8,
  0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x0F,
  0x8F, 0xC0, 0xF8, 0xF8, 0x0F, 0x9F, 0x00, 0xFB, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFE, 0xFC, 0x0F, 0xC7, 0xC0, 0xF8, 0x3E,
  0x0F, 0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x0F, 0x8F, 0x80,
  0x7C, 0xF8, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0xFE, 0x03, 0xF8, 0x78,
  0xFF, 0xC7, 0xFF, 0x3E, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xEF,
  0xF0, 0x7F, 0x81, 0xFF, 0xF0, 0x1F, 0x80, 0x7F, 0xF0, 0x0F, 0xC0, 0x3F,
  0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x07,
  0xFE, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x00,
  0xFF, 0xC0, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x07, 0xC0,
  0x1F, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xFE, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0x3E, 0x00, 0xFF, 0xC0, 0x1F,
  0x00, 0x7F, 0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x07, 0xC0, 0x1F, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0xF0, 0xFF, 0x0F, 0x1F, 0xF8, 0xFB, 0xFF, 0xCF, 0xFF,
  0xFE, 0xFF, 0x03, 0xEF, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF0, 0x3E, 0x3F, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x1F, 0x78, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0x78, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xE0,
  0x3F, 0x0F, 0xEF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0xF0, 0xFE, 0x07, 0xCF, 0xFC, 0x3E, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xF0,
  0x7E, 0x7F, 0x01, 0xFB, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x0F, 0xBF,
  0x00, 0x7D, 0xFC, 0x07, 0xEF, 0xE0, 0x3E, 0x7F, 0xFF, 0xF3, 0xEF, 0xFF,
  0x1F, 0x3F, 0xF0, 0xF8, 0xFF, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x78, 0x7F, 0xE7, 0xC7, 0xFF, 0xBE, 0x7F, 0xFF, 0xF3, 0xF0, 0x7F,
  0xBF, 0x01, 0xFD, 0xF0, 0x07, 0xEF, 0x80, 0x3F, 0x78, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00,
  0x7E, 0xF8, 0x03, 0xF3, 0xE0, 0x3F, 0x9F, 0xEF, 0xFC, 0x7F, 0xFB, 0xE1,
  0xFF, 0x9F, 0x07, 0xF8, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0xF0, 0x7F,
  0xC7, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xC7, 0xFC, 0x0F, 0xE0, 0x3F, 0x00,
  0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x3F, 0xFF, 0x7F, 0xFF,
  0x7F, 0x7E, 0xF8, 0x06, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x1F,
  0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x7F, 0xF0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFD, 0xC3, 0xFF, 0x0F, 0xFC, 0x0F,
  0xF0, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xF7, 0xC0, 0x3F, 0x7C, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFE, 0xF1, 0xFF,
  0xCF, 0x0F, 0xF0, 0xF0, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xE7, 0xC0, 0x0F,
  0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F,
  0x80, 0x78, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x3C, 0x03, 0xC1,
  0xF0, 0x0F, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xF3, 0xE0,
  0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xDF, 0x00, 0xFC, 0x01, 0xE7, 0xC0, 0x3F,
  0x00, 0xF9, 0xF0, 0x0F, 0xE0, 0x3E, 0x3C, 0x07, 0xF8, 0x0F, 0x8F, 0x01,
  0xFE, 0x03, 0xC3, 0xE0, 0x7F, 0x81, 0xF0, 0xF8, 0x1C, 0xF0, 0x7C, 0x1E,
  0x0F, 0x3C, 0x1E, 0x07, 0x83, 0xCF, 0x07, 0x81, 0xF0, 0xF3, 0xC3, 0xE0,
  0x7C, 0x78, 0x78, 0xF8, 0x0F, 0x1E, 0x1E, 0x3C, 0x03, 0xC7, 0x87, 0x8F,
  0x00, 0xF9, 0xE1, 0xE3, 0xC0, 0x3E, 0x70, 0x3D, 0xF0, 0x07, 0xBC, 0x0F,
  0x78, 0x01, 0xEF, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0xF7, 0x80, 0x1E, 0xE0,
  0x1D, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x00,
  0xF8, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x80, 0xF8, 0x7C, 0x0F, 0x81, 0xF0,
  0x7C, 0x0F, 0x87, 0xC0, 0x3E, 0x3E, 0x01, 0xF3, 0xE0, 0x07, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xDF, 0x00, 0x7C, 0xF8, 0x03,
  0xE3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x01, 0xF1, 0xF0, 0x0F,
  0x9F, 0x80, 0x3E, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF7,
  0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0,
  0x1F, 0x07, 0x80, 0x7C, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF0, 0x3E,
  0x03, 0xE0, 0xF0, 0x0F, 0x87, 0xC0, 0x1E, 0x1F, 0x00, 0x7C, 0x78, 0x01,
  0xF3, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x3F,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x03, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3F,
  0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0xFC, 0x0F, 0xF0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x3E, 0x00, 0x3F, 0xC0,
  0x1F, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xC0, 0x7F, 0xE8, 0x00,
  0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Medium46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 34, 12, 3, -33 },
  { 27, 13, 12, 19, 3, -33 },
  { 47, 25, 33, 27, 1, -33 },
  { 151, 20, 38, 24, 2, -35 },
  { 246, 33, 33, 37, 2, -33 },
  { 383, 28, 33, 30, 2, -33 },
  { 499, 5, 12, 11, 3, -33 },
  { 507, 11, 40, 14, 2, -33 },
  { 562, 11, 40, 14, 1, -33 },
  { 617, 19, 19, 23, 2, -35 },
  { 663, 20, 22, 24, 2, -27 },
  { 718, 7, 11, 12, 2, -5 },
  { 728, 11, 4, 14, 2, -14 },
  { 734, 6, 7, 12, 3, -6 },
  { 740, 16, 33, 18, 1, -33 },
  { 806, 20, 33, 24, 2, -33 },
  { 889, 13, 33, 24, 3, -33 },
  { 943, 20, 33, 24, 2, -33 },
  { 1026, 20, 33, 24, 2, -33 },
  { 1109, 22, 33, 24, 1, -33 },
  { 1200, 19, 33, 24, 3, -33 },
  { 1279, 20, 33, 24, 2, -33 },
  { 1362, 20, 33, 24, 2, -33 },
  { 1445, 20, 33, 24, 2, -33 },
  { 1528, 20, 33, 24, 2, -33 },
  { 1611, 6, 26, 12, 3, -25 },
  { 1631, 7, 31, 12, 2, -25 },
  { 1659, 20, 23, 24, 2, -28 },
  { 1717, 20, 13, 24, 2, -23 },
  { 1750, 20, 23, 24, 2, -28 },
  { 1808, 18, 34, 19, 0, -33 },
  { 1885, 33, 37, 38, 2, -33 },
  { 2038, 27, 33, 27, 0, -33 },
  { 2150, 21, 33, 27, 4, -33 },
  { 2237, 22, 33, 26, 3, -33 },
  { 2328, 24, 33, 30, 4, -33 },
  { 2427, 17, 33, 23, 4, -33 },
  { 2498, 17, 33, 22, 4, -33 },
  { 2569, 24, 33, 30, 3, -33 },
  { 2668, 23, 33, 31, 4, -33 },
  { 2763, 12, 33, 15, 2, -33 },
  { 2813, 12, 42, 12, -3, -33 },
  { 2876, 22, 33, 26, 4, -33 },
  { 2967, 17, 33, 22, 4, -33 },
  { 3038, 31, 33, 39, 4, -33 },
  { 3166, 25, 33, 32, 4, -33 },
  { 3270, 27, 33, 32, 3, -33 },
  { 3382, 20, 33, 25, 4, -33 },
  { 3465, 27, 41, 32, 3, -33 },
  { 3604, 22, 33, 26, 4, -33 },
  { 3695, 19, 33, 23, 2, -33 },
  { 3774, 21, 33, 23, 1, -33 },
  { 3861, 23, 33, 31, 4, -33 },
  { 3956, 26, 33, 26, 0, -33 },
  { 4064, 39, 33, 40, 0, -33 },
  { 4225, 25, 33, 25, 0, -33 },
  { 4329, 24, 33, 24, 0, -33 },
  { 4428, 21, 33, 23, 1, -33 },
  { 4515, 11, 40, 15, 3, -33 },
  { 4570, 17, 33, 18, 0, -33 },
  { 4641, 11, 40, 15, 1, -33 },
  { 4696, 22, 20, 25, 1, -33 },
  { 4751, 20, 3, 20, 0, 4 },
  { 4759, 10, 7, 14, 2, -35 },
  { 4768, 19, 25, 24, 2, -25 },
  { 4828, 21, 35, 26, 3, -35 },
  { 4920, 17, 25, 20, 2, -25 },
  { 4974, 21, 35, 26, 2, -35 },
  { 5066, 20, 25, 24, 2, -25 },
  { 5129, 16, 35, 15, 1, -35 },
  { 5199, 21, 36, 26, 2, -25 },
  { 5294, 20, 35, 26, 3, -35 },
  { 5382, 6, 34, 12, 3, -34 },
  { 5408, 10, 45, 12, -2, -34 },
  { 5465, 20, 35, 23, 3, -35 },
  { 5553, 5, 35, 12, 3, -35 },
  { 5575, 33, 25, 39, 3, -25 },
  { 5679, 20, 25, 26, 3, -25 },
  { 5742, 21, 25, 26, 2, -25 },
  { 5808, 21, 36, 26, 3, -25 },
  { 5903, 21, 36, 26, 2, -25 },
  { 5998, 14, 25, 18, 3, -25 },
  { 6042, 16, 25, 20, 2, -25 },
  { 6092, 14, 30, 16, 1, -30 },
  { 6145, 20, 25, 26, 3, -25 },
  { 6208, 22, 25, 22, 0, -25 },
  { 6277, 34, 25, 34, 0, -25 },
  { 6384, 21, 25, 22, 1, -25 },
  { 6450, 22, 36, 22, 0, -25 },
  { 6549, 17, 25, 19, 1, -25 },
  { 6603, 15, 40, 17, 1, -33 },
  { 6678, 3, 46, 23, 10, -35 },
  { 6696, 14, 40, 17, 2, -33 },
  { 6766, 20, 6, 24, 2, -19 },
};

const GFXfont NotoSans_SemiCondensed_Medium46pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium46pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium46pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM46PT7B_H_
