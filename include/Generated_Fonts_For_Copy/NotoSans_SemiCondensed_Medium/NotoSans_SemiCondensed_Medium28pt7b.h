#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM28PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0xC0, 0x5F, 0xF0, 0xE7, 0xE7, 0xE7,
  0xE7, 0xC7, 0xC7, 0xC7, 0x06, 0x38, 0x0C, 0x60, 0x18, 0xC0, 0x71, 0x80,
  0xE3, 0x01, 0x86, 0x1F, 0xFF, 0xBF, 0xFF, 0x0C, 0x60, 0x38, 0xC0, 0x61,
  0x80, 0xC7, 0x0F, 0xFF, 0xDF, 0xFF, 0x86, 0x30, 0x1C, 0x60, 0x30, 0xC0,
  0x63, 0x80, 0xC7, 0x01, 0x8C, 0x00, 0x06, 0x00, 0x60, 0x0F, 0xC3, 0xFF,
  0x7F, 0xE7, 0x60, 0xE6, 0x0E, 0x60, 0x76, 0x07, 0xE0, 0x3F, 0x80, 0xFE,
  0x07, 0xF0, 0x67, 0x06, 0x30, 0x63, 0xC6, 0x7F, 0xFE, 0xFF, 0xC0, 0xF0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x3C, 0x07, 0x07, 0xE0, 0x60, 0x67, 0x06,
  0x0E, 0x70, 0xC0, 0xE3, 0x0C, 0x0C, 0x31, 0x80, 0xC3, 0x18, 0x0E, 0x33,
  0x80, 0xE3, 0x33, 0xC6, 0x77, 0x7E, 0x7E, 0x66, 0x73, 0xCE, 0xE3, 0x00,
  0xCC, 0x30, 0x1C, 0xC3, 0x01, 0x8C, 0x30, 0x38, 0xC3, 0x03, 0x0E, 0x30,
  0x70, 0x67, 0x06, 0x07, 0xE0, 0xE0, 0x3C, 0x0F, 0xC0, 0x0F, 0xF0, 0x0E,
  0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x3F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xE1, 0xCF, 0x78, 0xE7, 0x1C, 0x77, 0x07,
  0x73, 0x81, 0xF9, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x7F, 0x1F, 0xFB, 0xC3,
  0xF8, 0xF0, 0xFF, 0xFD, 0xB0, 0x0E, 0x38, 0x61, 0xC3, 0x0E, 0x1C, 0x30,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xE1, 0xC3, 0x83, 0x87,
  0x07, 0x07, 0xE1, 0x87, 0x0E, 0x38, 0x61, 0xC7, 0x1C, 0x70, 0xC3, 0x0C,
  0x71, 0xC7, 0x1C, 0x71, 0x8E, 0x39, 0xC7, 0x38, 0x06, 0x00, 0x60, 0x06,
  0x0C, 0x63, 0xFF, 0xFF, 0xFF, 0x0F, 0x01, 0xF8, 0x19, 0x83, 0x9C, 0x70,
  0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x77, 0x76,
  0x6E, 0xC0, 0xFF, 0xFF, 0xF8, 0x5F, 0xF0, 0x00, 0xC0, 0x70, 0x1C, 0x0E,
  0x03, 0x80, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x06,
  0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x03, 0x80, 0x1F, 0x83, 0xFC, 0x39,
  0xE7, 0x0E, 0x70, 0x76, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0,
  0x3E, 0x07, 0xE0, 0x7E, 0x07, 0x60, 0x77, 0x07, 0x70, 0xE3, 0x9E, 0x3F,
  0xC1, 0xF8, 0x07, 0x0F, 0x3F, 0x7F, 0xF7, 0x67, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x1F, 0x87,
  0xFE, 0xF9, 0xE4, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x8F, 0xFE, 0x71, 0xE4, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x60, 0x0E, 0x1F, 0xC1, 0xF0, 0x1F, 0xC0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x7C, 0x1E, 0xFF, 0xE7, 0xF8, 0x01, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x6E, 0x07, 0x70, 0x33, 0x83, 0x9C, 0x38,
  0xE1, 0x87, 0x1C, 0x38, 0xC1, 0xCE, 0x0E, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x7F, 0xDF, 0xFB, 0xFF, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0x9F, 0xF8, 0x07, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xF8, 0x7B, 0xFE, 0x7F, 0x80, 0x07,
  0xE0, 0xFF, 0x0F, 0x80, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x70,
  0xEF, 0xE7, 0xFF, 0x3C, 0x1D, 0xE0, 0xEE, 0x03, 0x70, 0x1D, 0x80, 0xCE,
  0x0E, 0x70, 0x71, 0xC7, 0x8F, 0xF8, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x00, 0x1F, 0xC1, 0xFF, 0x1E, 0x3C, 0xE0, 0xE6,
  0x07, 0x38, 0x39, 0xC1, 0xC7, 0x1C, 0x1F, 0xC0, 0x7C, 0x0F, 0xF0, 0xF3,
  0xC7, 0x07, 0x70, 0x3B, 0x80, 0xFC, 0x06, 0xE0, 0x73, 0x87, 0x9F, 0xF8,
  0x3F, 0x80, 0x1F, 0x83, 0xFC, 0x79, 0xE7, 0x0E, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x77, 0x0F, 0x7F, 0xB3, 0xFF, 0x0E, 0x70, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x3C, 0x7F, 0x87, 0xF0, 0xFF, 0xA0, 0x00, 0x00,
  0x2F, 0xF8, 0x77, 0x72, 0x00, 0x00, 0x00, 0x00, 0x77, 0x76, 0xEE, 0xC0,
  0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x1E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0x80, 0x04, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x0E, 0x00, 0x40, 0x00, 0x3F, 0x9F,
  0xF9, 0x87, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x08, 0x03, 0x80, 0x78,
  0x0E, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF0, 0x0F, 0x03, 0xC1, 0xC0, 0x0E,
  0x38, 0x00, 0x63, 0x07, 0x87, 0x70, 0xFE, 0x36, 0x1C, 0x63, 0x63, 0x8E,
  0x36, 0x30, 0xE3, 0xE3, 0x0E, 0x3E, 0x30, 0xE3, 0xE3, 0x0E, 0x3E, 0x30,
  0xE3, 0x63, 0x9E, 0x66, 0x1F, 0x7E, 0x70, 0xE3, 0xC3, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x10, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x0E, 0x70, 0x0E,
  0x30, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x3F, 0xFC, 0x3F,
  0xFC, 0x38, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xFF, 0xC7, 0xFF, 0x38, 0x7D, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x0E, 0xFF, 0xE7, 0xFC, 0x3F, 0xFD, 0xC0, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x7F, 0x0F, 0xBF, 0xFD, 0xFF, 0x80, 0x0F, 0xF0,
  0xFF, 0xCF, 0x8C, 0xF0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xF1, 0x87, 0xFC, 0x1F, 0xE0, 0xFF, 0x81, 0xFF, 0xC3, 0xFF,
  0xE7, 0x03, 0xCE, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xB8, 0x07, 0x70,
  0x1E, 0xE0, 0x79, 0xFF, 0xE3, 0xFF, 0x87, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xDF, 0xFB, 0xFF,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1F, 0xFB, 0xFF, 0x7F, 0xEE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x00, 0x07, 0xF8, 0x3F, 0xF8, 0xF8, 0x73, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC1, 0xFF,
  0x83, 0xFF, 0x07, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xB8, 0x07, 0x78,
  0x0E, 0x7C, 0x3C, 0x7F, 0xF8, 0x7F, 0xE0, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x73, 0xFF, 0xF0,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0xFE, 0xFC, 0xC0, 0xE0,
  0x3F, 0x81, 0xEE, 0x07, 0x38, 0x38, 0xE1, 0xC3, 0x8F, 0x0E, 0x38, 0x39,
  0xC0, 0xEE, 0x03, 0xFC, 0x0F, 0xF0, 0x3D, 0xE0, 0xE3, 0x83, 0x87, 0x0E,
  0x1E, 0x38, 0x38, 0xE0, 0x73, 0x81, 0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x37, 0xD8, 0x0E, 0xFB, 0x81, 0xDF, 0x70, 0x33, 0xE6, 0x0E, 0x7C,
  0xE1, 0xCF, 0x9C, 0x31, 0xF1, 0x8E, 0x3E, 0x39, 0xC7, 0xC7, 0x30, 0xF8,
  0x6E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0,
  0x70, 0x30, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7D,
  0xC0, 0xFB, 0xC1, 0xF3, 0x83, 0xE7, 0x87, 0xC7, 0x0F, 0x87, 0x1F, 0x0E,
  0x3E, 0x0E, 0x7C, 0x1C, 0xF8, 0x1D, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x80, 0x7F, 0x00, 0x70, 0x0F, 0xF0, 0x3F, 0xF8, 0x3C, 0x7C, 0x78, 0x1E,
  0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E,
  0x78, 0x1E, 0x3C, 0x7C, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0x8F, 0xFE, 0xFF,
  0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x1E, 0xFF,
  0xEF, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x0F, 0xF0, 0x3F, 0xF8, 0x3C, 0x7C, 0x78, 0x1E, 0xF0, 0x0E,
  0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E,
  0x3C, 0x7C, 0x1F, 0xF8, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x38, 0x1C, 0xE0,
  0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F,
  0xE0, 0xE3, 0xC3, 0x87, 0x0E, 0x0E, 0x38, 0x38, 0xE0, 0x73, 0x81, 0xCE,
  0x03, 0xB8, 0x0F, 0x1F, 0xF3, 0xFE, 0x7C, 0xE7, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x80, 0xFF, 0x3E, 0xFF, 0xC7, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07,
  0x70, 0x3D, 0xF1, 0xE3, 0xFF, 0x07, 0xF8, 0xE0, 0x0F, 0xE0, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x1C,
  0x38, 0x1C, 0x38, 0x1C, 0x70, 0x0C, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x06,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0,
  0x1C, 0x07, 0xE0, 0x3C, 0x07, 0x70, 0x3C, 0x0E, 0x70, 0x3C, 0x0E, 0x70,
  0x7E, 0x0E, 0x70, 0x7E, 0x0E, 0x38, 0x76, 0x0C, 0x38, 0x66, 0x1C, 0x38,
  0xE7, 0x1C, 0x38, 0xE7, 0x1C, 0x1C, 0xE3, 0x18, 0x1C, 0xC3, 0x38, 0x1D,
  0xC3, 0xB8, 0x1D, 0xC3, 0xB8, 0x0D, 0xC1, 0xB8, 0x0F, 0x81, 0xB0, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x00, 0xE0, 0x70,
  0x1E, 0xF0, 0x38, 0xE0, 0xE1, 0xE1, 0xC1, 0xC7, 0x01, 0xCE, 0x03, 0xB8,
  0x03, 0xF0, 0x07, 0xC0, 0x07, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xEE, 0x01,
  0xDC, 0x07, 0x1C, 0x0E, 0x3C, 0x38, 0x38, 0xF0, 0x79, 0xC0, 0x77, 0x80,
  0xF0, 0xE0, 0x1E, 0xE0, 0x39, 0xC0, 0xE1, 0xC1, 0xC3, 0x87, 0x03, 0x8E,
  0x07, 0x1C, 0x07, 0x70, 0x0E, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0x00, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38,
  0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38,
  0xE3, 0x8F, 0xFF, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03,
  0x80, 0x70, 0x1C, 0x03, 0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x7F, 0xFF, 0x06, 0x00,
  0x38, 0x03, 0xC0, 0x1F, 0x01, 0xD8, 0x0C, 0xE0, 0xE3, 0x06, 0x1C, 0x70,
  0x63, 0x03, 0x98, 0x0D, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0x83,
  0x3F, 0xC3, 0xFE, 0x30, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x1F, 0xF7, 0xFF,
  0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xF1, 0xF7, 0xF7, 0x3E, 0x70, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xBF, 0x1F, 0xFC,
  0xF8, 0xF7, 0x83, 0xB8, 0x1D, 0xC0, 0xEE, 0x03, 0x70, 0x1F, 0x81, 0xDC,
  0x0E, 0xE0, 0x77, 0x83, 0xBE, 0x3D, 0xFF, 0xCC, 0xFC, 0x00, 0x1F, 0xE7,
  0xF9, 0xE1, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x07, 0x84, 0x7F, 0x87, 0xF0, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x7E, 0xE7, 0xFF, 0x78, 0xFB, 0x83, 0xDC,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0x70, 0x3B, 0x83,
  0xDE, 0x3E, 0x7F, 0xF1, 0xFB, 0x80, 0x1F, 0xC3, 0xFE, 0x78, 0xE7, 0x07,
  0x70, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x33, 0xFF, 0x0F, 0xE0, 0x0F, 0xC7, 0xF1, 0xC0, 0x70, 0x1C, 0x07,
  0x07, 0xFB, 0xFE, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0x1F, 0xB9, 0xFF, 0xDE,
  0x3E, 0xE0, 0xF7, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xDC, 0x0E, 0xE0, 0xF7, 0x8F, 0x9F, 0xFC, 0x7E, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0x90, 0x1C, 0xFF, 0xE7, 0xFE, 0x0F, 0x80, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xEF, 0xCF, 0xFE, 0xF8, 0xFF, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x70, 0x7F, 0xA0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0C, 0x71, 0xC2, 0x00, 0x01, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xB8, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFE, 0x1C, 0xE3, 0xCE, 0x38,
  0xE7, 0x0E, 0xE0, 0xFE, 0x0F, 0xE0, 0xF7, 0x0E, 0x78, 0xE3, 0x8E, 0x1C,
  0xE1, 0xEE, 0x0E, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xCF, 0xCF, 0xCF, 0xFF, 0xFE, 0xF8, 0xF8, 0xFF, 0x0F, 0x07, 0xE0,
  0x70, 0x7E, 0x07, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E,
  0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0x60, 0x7E, 0x06, 0x07,
  0xE0, 0x60, 0x70, 0xCF, 0xCF, 0xFE, 0xF8, 0xFF, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x70, 0x1F, 0xC1, 0xFF, 0x1E, 0x3C, 0xE0, 0xF7, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xDC, 0x0E, 0xE0, 0xE3, 0x8F, 0x1F,
  0xF0, 0x3F, 0x00, 0xEF, 0xC7, 0xFF, 0x3E, 0x3D, 0xE0, 0xEE, 0x07, 0x70,
  0x3B, 0x80, 0xDC, 0x07, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xE0, 0xEF, 0x8E,
  0x7F, 0xF3, 0xBF, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x00, 0x1F, 0xB9, 0xFF, 0xDE, 0x3E, 0xE0, 0xF7, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xDC, 0x0E, 0xE0, 0xF7, 0x8F,
  0x9F, 0xFC, 0x7C, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0xCF, 0xEF, 0xFD, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x3F, 0xDF, 0xFE, 0x0B, 0x80, 0xE0,
  0x1E, 0x07, 0xE0, 0x7C, 0x07, 0x80, 0x70, 0x1C, 0x07, 0xC3, 0xFF, 0xEF,
  0xF0, 0x18, 0x0C, 0x06, 0x0F, 0xFF, 0xF9, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x1F, 0x87, 0xC0, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x0F, 0xF1, 0xF7, 0xFF, 0x3F, 0x70, 0xE0, 0x3B, 0x81,
  0xDC, 0x0C, 0xE0, 0xE3, 0x07, 0x1C, 0x30, 0xE3, 0x83, 0x1C, 0x1C, 0xC0,
  0xEE, 0x03, 0x70, 0x1B, 0x00, 0xF8, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x70,
  0x77, 0x0F, 0x07, 0x70, 0xF8, 0x77, 0x0D, 0x87, 0x70, 0xD8, 0xE3, 0x9D,
  0x8E, 0x39, 0xDC, 0xE3, 0x99, 0xCE, 0x39, 0x8C, 0xC1, 0xB8, 0xDC, 0x1F,
  0x0F, 0xC1, 0xF0, 0xF8, 0x1F, 0x07, 0x80, 0xF0, 0x78, 0x0E, 0x07, 0x80,
  0x70, 0x39, 0xC3, 0x8E, 0x38, 0x39, 0xC1, 0xDC, 0x07, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0x7E, 0x07, 0x78, 0x79, 0xC3, 0x87, 0x38, 0x3B, 0xC0,
  0xE0, 0xE0, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0xE3, 0x87, 0x1C, 0x30, 0xE3,
  0x83, 0x9C, 0x1C, 0xC0, 0xEE, 0x03, 0x70, 0x1F, 0x00, 0xF8, 0x03, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0xF8, 0x07, 0xC0, 0x38,
  0x00, 0xFF, 0xFF, 0xF0, 0x38, 0x0E, 0x07, 0x03, 0xC0, 0xE0, 0x70, 0x1C,
  0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0x0F, 0x1E, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0xF8, 0xF0, 0x78, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x1E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x01, 0xF0, 0x78, 0xF8, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC1, 0xC3, 0xE1, 0xE0, 0x38, 0x0F, 0xF8, 0xFF, 0xFF, 0x03,
  0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Medium28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 20, 7, 2, -20 },
  { 9, 8, 7, 12, 2, -20 },
  { 16, 15, 20, 16, 1, -20 },
  { 54, 12, 23, 15, 1, -21 },
  { 89, 20, 20, 22, 1, -20 },
  { 139, 17, 20, 18, 1, -20 },
  { 182, 3, 7, 6, 2, -20 },
  { 185, 7, 24, 9, 1, -20 },
  { 206, 6, 24, 9, 1, -20 },
  { 224, 12, 11, 14, 1, -21 },
  { 241, 12, 14, 15, 1, -17 },
  { 262, 4, 7, 7, 1, -3 },
  { 266, 7, 3, 9, 1, -9 },
  { 269, 3, 4, 7, 2, -4 },
  { 271, 10, 20, 11, 0, -20 },
  { 296, 12, 20, 15, 1, -20 },
  { 326, 8, 20, 15, 2, -20 },
  { 346, 12, 20, 15, 1, -20 },
  { 376, 12, 20, 15, 1, -20 },
  { 406, 13, 20, 15, 1, -20 },
  { 439, 11, 20, 15, 2, -20 },
  { 467, 13, 20, 15, 1, -20 },
  { 500, 13, 20, 15, 1, -20 },
  { 533, 13, 20, 15, 1, -20 },
  { 566, 12, 20, 15, 1, -20 },
  { 596, 3, 15, 7, 2, -15 },
  { 602, 4, 19, 7, 1, -15 },
  { 612, 13, 14, 15, 1, -17 },
  { 635, 12, 8, 15, 1, -14 },
  { 647, 13, 14, 15, 1, -17 },
  { 670, 11, 20, 11, 0, -20 },
  { 698, 20, 22, 23, 1, -20 },
  { 753, 16, 20, 16, 0, -20 },
  { 793, 13, 20, 17, 2, -20 },
  { 826, 13, 20, 16, 2, -20 },
  { 859, 15, 20, 18, 2, -20 },
  { 897, 11, 20, 14, 2, -20 },
  { 925, 11, 20, 13, 2, -20 },
  { 953, 15, 20, 19, 2, -20 },
  { 991, 14, 20, 19, 2, -20 },
  { 1026, 7, 20, 9, 1, -20 },
  { 1044, 7, 26, 8, -2, -20 },
  { 1067, 14, 20, 16, 2, -20 },
  { 1102, 11, 20, 13, 2, -20 },
  { 1130, 19, 20, 24, 2, -20 },
  { 1178, 15, 20, 20, 2, -20 },
  { 1216, 16, 20, 20, 2, -20 },
  { 1256, 12, 20, 16, 2, -20 },
  { 1286, 16, 25, 20, 2, -20 },
  { 1336, 14, 20, 16, 2, -20 },
  { 1371, 12, 20, 14, 1, -20 },
  { 1401, 14, 20, 14, 0, -20 },
  { 1436, 14, 20, 19, 2, -20 },
  { 1471, 16, 20, 16, 0, -20 },
  { 1511, 24, 20, 24, 0, -20 },
  { 1571, 15, 20, 15, 0, -20 },
  { 1609, 15, 20, 15, 0, -20 },
  { 1647, 12, 20, 14, 1, -20 },
  { 1677, 6, 24, 9, 2, -20 },
  { 1695, 10, 20, 11, 0, -20 },
  { 1720, 6, 24, 9, 1, -20 },
  { 1738, 13, 12, 15, 1, -20 },
  { 1758, 12, 2, 12, 0, 2 },
  { 1761, 6, 4, 8, 1, -21 },
  { 1764, 12, 15, 15, 1, -15 },
  { 1787, 13, 21, 16, 2, -21 },
  { 1822, 11, 15, 12, 1, -15 },
  { 1843, 13, 21, 16, 1, -21 },
  { 1878, 12, 15, 15, 1, -15 },
  { 1901, 10, 21, 9, 0, -21 },
  { 1928, 13, 22, 16, 1, -15 },
  { 1964, 12, 21, 16, 2, -21 },
  { 1996, 3, 21, 7, 2, -21 },
  { 2004, 6, 28, 7, -1, -21 },
  { 2025, 12, 21, 14, 2, -21 },
  { 2057, 3, 21, 7, 2, -21 },
  { 2065, 20, 15, 24, 2, -15 },
  { 2103, 12, 15, 16, 2, -15 },
  { 2126, 13, 15, 16, 1, -15 },
  { 2151, 13, 22, 16, 2, -15 },
  { 2187, 13, 22, 16, 1, -15 },
  { 2223, 8, 15, 11, 2, -15 },
  { 2238, 10, 15, 12, 1, -15 },
  { 2257, 9, 18, 10, 0, -18 },
  { 2278, 12, 15, 16, 2, -15 },
  { 2301, 13, 15, 13, 0, -15 },
  { 2326, 20, 15, 21, 0, -15 },
  { 2364, 13, 15, 14, 0, -15 },
  { 2389, 13, 22, 13, 0, -15 },
  { 2425, 10, 15, 12, 1, -15 },
  { 2444, 8, 24, 10, 1, -20 },
  { 2468, 2, 28, 14, 6, -21 },
  { 2475, 9, 24, 10, 1, -20 },
  { 2502, 13, 4, 15, 1, -12 },
};

const GFXfont NotoSans_SemiCondensed_Medium28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium28pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM28PT7B_H_
