#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM35PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM35PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium35pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xDE, 0xF7, 0xB9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x80, 0x02, 0x3F, 0xFF, 0x78, 0xF1, 0xFE, 0x3B, 0xC7, 0x78, 0xEF, 0x1C,
  0xE3, 0x98, 0x73, 0x0E, 0x61, 0xC0, 0x03, 0x87, 0x00, 0x70, 0xE0, 0x0E,
  0x1C, 0x01, 0xC3, 0x00, 0x38, 0x60, 0x06, 0x1C, 0x01, 0xC3, 0x83, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC, 0x1C, 0x30, 0x03, 0x0E, 0x00, 0xE1,
  0xC0, 0x1C, 0x38, 0x03, 0x87, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0xF8, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x60, 0x07, 0x1C,
  0x00, 0xC3, 0x80, 0x38, 0x70, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x3E, 0x03, 0xFF, 0xCF, 0xFF, 0xBF, 0xDE, 0x79, 0x82, 0xE3, 0x01, 0xC6,
  0x03, 0xCC, 0x07, 0xD8, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x01, 0xFC,
  0x03, 0xFC, 0x06, 0x78, 0x0C, 0x78, 0x18, 0xF0, 0x31, 0xF8, 0x67, 0xBF,
  0xFF, 0x7F, 0xFC, 0x7F, 0xE0, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x1F, 0x00, 0x70, 0x1F, 0xC0, 0x38, 0x1C, 0xF0, 0x38, 0x0E, 0x38,
  0x1C, 0x07, 0x1C, 0x1C, 0x03, 0x0E, 0x0E, 0x03, 0x83, 0x0E, 0x01, 0xC1,
  0x87, 0x00, 0xE1, 0xC7, 0x00, 0x30, 0xE3, 0x80, 0x1C, 0x73, 0x8F, 0x8E,
  0x39, 0xCF, 0xE7, 0xBD, 0xCE, 0x71, 0xFC, 0xE7, 0x1C, 0x7C, 0xE3, 0x0E,
  0x00, 0x73, 0x87, 0x00, 0x71, 0xC3, 0x80, 0x38, 0xE1, 0xC0, 0x38, 0x70,
  0xE0, 0x1C, 0x38, 0x70, 0x0E, 0x0C, 0x38, 0x0E, 0x07, 0x1C, 0x07, 0x03,
  0x9C, 0x07, 0x00, 0xFE, 0x07, 0x80, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0xC0, 0x07, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x70,
  0x01, 0xC1, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x78, 0xFF, 0x81, 0xC7, 0xCF,
  0x0F, 0x1E, 0x1E, 0x3C, 0x70, 0x3C, 0xE3, 0xC0, 0x7F, 0x8F, 0x01, 0xFC,
  0x3C, 0x03, 0xF0, 0x78, 0x0F, 0xC1, 0xF0, 0x7F, 0x87, 0xFF, 0xFF, 0x0F,
  0xFF, 0x3C, 0x0F, 0xF0, 0x7C, 0xFF, 0xFF, 0xF7, 0x66, 0x60, 0x07, 0x87,
  0x83, 0x83, 0xC1, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1C, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xE0,
  0x70, 0x3C, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0xF0, 0x70, 0x38,
  0x38, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0x1E, 0x1C, 0x3C,
  0x38, 0x78, 0x70, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x0E, 0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x0F, 0x80, 0x3B,
  0x80, 0xF3, 0x81, 0xC7, 0x87, 0x87, 0x02, 0x08, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x3C, 0xF3, 0x9E, 0x79, 0xC7,
  0x18, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x27, 0xFF, 0xF7, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E,
  0x00, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x3C, 0x3C, 0x38,
  0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0F, 0x70, 0x0F, 0x70,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x70,
  0x0F, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x1E, 0x38, 0x1E, 0x3C, 0x3C, 0x1F,
  0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0x03, 0x87, 0xC7, 0xE7, 0xF7, 0xBF, 0x9F,
  0x8E, 0x87, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x0F, 0xF0,
  0x3F, 0xF8, 0x7F, 0xFC, 0x78, 0x3C, 0x20, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0x70, 0x3E, 0x20, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0xC0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8,
  0x7F, 0xF0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0D, 0xE0, 0x0E, 0xF0, 0x0E, 0x78, 0x07, 0x3C, 0x07, 0x1E, 0x07,
  0x8F, 0x03, 0x87, 0x83, 0x83, 0xC1, 0xC1, 0xE1, 0xC0, 0xF1, 0xE0, 0x78,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x7F, 0xF8, 0xFF, 0xF1,
  0xFF, 0xE3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE6, 0x03, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0x80, 0x0F, 0x80, 0x0F,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xD8,
  0x0F, 0x3F, 0xFE, 0x7F, 0xF8, 0x7F, 0xC0, 0x03, 0xF8, 0x1F, 0xF0, 0x7F,
  0xE1, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC7, 0xC3, 0xBF, 0xC7, 0x7F, 0xCF, 0xC7, 0xDE, 0x07, 0xBC, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xF7, 0x01, 0xCF, 0x07,
  0x8F, 0xFE, 0x0F, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x1F, 0xFC,
  0x3F, 0xFC, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x1E,
  0x3C, 0x1C, 0x3E, 0x7C, 0x1F, 0xF8, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x3C, 0x3C, 0x78, 0x1E, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0x70, 0x0F, 0x78, 0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3C, 0x78, 0x1E, 0x70, 0x1E, 0x70, 0x0E,
  0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1F, 0x7C, 0x3F,
  0x3F, 0xFF, 0x1F, 0xEE, 0x07, 0x8E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x3F, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0,
  0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x9F, 0xFF, 0xDC,
  0x39, 0xF7, 0xDF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x39, 0xE7, 0x9C, 0x71, 0xCE, 0x38, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F,
  0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F,
  0xC0, 0x7F, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x3F, 0xE7, 0xFF,
  0x9F, 0xFE, 0xC0, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78,
  0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x40, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0, 0x01, 0xFC, 0xFE, 0x01,
  0xE0, 0x07, 0x81, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x1C,
  0xE0, 0x7F, 0x8E, 0x70, 0xFF, 0xC7, 0x30, 0x70, 0xE1, 0xF8, 0x70, 0x70,
  0xFC, 0x38, 0x38, 0x7E, 0x38, 0x1C, 0x3F, 0x1C, 0x0E, 0x1F, 0x8E, 0x07,
  0x0F, 0xC7, 0x07, 0x86, 0xE3, 0x83, 0xC7, 0x70, 0xE1, 0xE3, 0xB8, 0x79,
  0xBB, 0x9C, 0x1F, 0xDF, 0xC7, 0x07, 0xC7, 0x83, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x60, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1D, 0xC0, 0x01, 0xEE, 0x00, 0x0E, 0x70,
  0x00, 0x73, 0xC0, 0x07, 0x8E, 0x00, 0x3C, 0x70, 0x01, 0xC3, 0xC0, 0x1E,
  0x0E, 0x00, 0xF0, 0x70, 0x07, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0x00, 0x70, 0x78, 0x03, 0xC7, 0x80,
  0x1E, 0x3C, 0x00, 0x71, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF8,
  0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x0E,
  0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E, 0xFF, 0xFC, 0xFF, 0xF0,
  0xFF, 0xF8, 0xF1, 0xFE, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3E, 0xFF, 0xFE, 0xFF, 0xFC,
  0xFF, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xC3, 0xE0, 0x63, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF8,
  0x08, 0x7F, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xC1, 0xF8, 0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x00, 0x7B,
  0xC0, 0x1E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x1F, 0x3C, 0x1F, 0x8F, 0xFF, 0xC3,
  0xFF, 0xE0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0xFD, 0xFF,
  0xEF, 0xFF, 0x7F, 0xFB, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xFF, 0xEF, 0xFF, 0x7F, 0xFB, 0xFF, 0xDE, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0x80,
  0xE3, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xFF, 0xE0, 0x3F,
  0xFC, 0x07, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07,
  0xBE, 0x00, 0xF3, 0xC0, 0x1E, 0x7E, 0x03, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF,
  0x03, 0xFF, 0x80, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xC0,
  0xFF, 0xFF, 0xDF, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0xFD, 0xFF, 0xFF, 0x80, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC1,
  0xE9, 0xF7, 0xF3, 0xF9, 0xF0, 0xF0, 0x0F, 0xF8, 0x07, 0xBC, 0x07, 0x9E,
  0x07, 0x8F, 0x07, 0x87, 0x83, 0xC3, 0xC3, 0xC1, 0xE3, 0xC0, 0xF3, 0xC0,
  0x79, 0xE0, 0x3D, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xEF,
  0x81, 0xE3, 0xC0, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x1E, 0x07, 0x8F,
  0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x7D, 0xE0, 0x1E, 0xF0, 0x07, 0x80, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xEE, 0x00, 0x7F, 0xEE, 0x00,
  0xFF, 0xEF, 0x00, 0xEF, 0xE7, 0x00, 0xEF, 0xE7, 0x01, 0xCF, 0xE7, 0x81,
  0xCF, 0xE3, 0x81, 0xCF, 0xE3, 0x83, 0x8F, 0xE3, 0xC3, 0x8F, 0xE1, 0xC3,
  0x8F, 0xE1, 0xC7, 0x0F, 0xE1, 0xE7, 0x0F, 0xE0, 0xE7, 0x0F, 0xE0, 0xEE,
  0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x0F, 0xE0, 0x7C, 0x0F, 0xE0, 0x7C,
  0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0x38, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xDC, 0x03, 0xFB, 0xC0, 0x7F,
  0x3C, 0x0F, 0xE7, 0x81, 0xFC, 0x78, 0x3F, 0x8F, 0x07, 0xF0, 0xF0, 0xFE,
  0x1E, 0x1F, 0xC1, 0xE3, 0xF8, 0x3C, 0x7F, 0x03, 0xCF, 0xE0, 0x3D, 0xFC,
  0x07, 0xBF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xF8,
  0x07, 0xFF, 0xF0, 0x7C, 0x0F, 0x83, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xE0,
  0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xBC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xC3,
  0xC0, 0x1E, 0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xE0, 0x03, 0xFE,
  0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x87, 0xEF, 0x03, 0xDE, 0x03,
  0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0xF7, 0x83, 0xEF,
  0xFF, 0x9F, 0xFF, 0x3F, 0xF8, 0x7E, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xF0, 0x7C, 0x0F, 0x83, 0xC0,
  0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0E, 0xF0, 0x00, 0xF3, 0x80, 0x07, 0x9E,
  0x00, 0x3C, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x1F, 0x03, 0xE0, 0x7F, 0xFF,
  0x01, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xFF, 0xC0,
  0x7F, 0xF8, 0x3F, 0xFF, 0x1E, 0x0F, 0x8F, 0x03, 0xE7, 0x80, 0xF3, 0xC0,
  0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x1E, 0x0F, 0x8F,
  0xFF, 0x87, 0xFF, 0x03, 0xFF, 0x81, 0xE1, 0xC0, 0xF0, 0xF0, 0x78, 0x3C,
  0x3C, 0x1E, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x79, 0xE0,
  0x1E, 0xF0, 0x0F, 0x80, 0x1F, 0xF0, 0xFF, 0xF7, 0xFF, 0xBE, 0x06, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3F, 0x01, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0xFF, 0x80, 0x7B, 0xE0, 0x78, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0xF8, 0x00,
  0xF0, 0x00, 0xFF, 0x00, 0x1E, 0x70, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0x03,
  0xC3, 0x80, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x38, 0x1C, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x00, 0xE0, 0xF0, 0x0E, 0x0F, 0x00, 0xF0, 0xE0, 0x0F,
  0x1E, 0x00, 0x71, 0xE0, 0x07, 0x9C, 0x00, 0x79, 0xC0, 0x03, 0xBC, 0x00,
  0x3B, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0xF0, 0x07, 0x80, 0x3D, 0xC0, 0x1E, 0x00, 0xF7, 0x00,
  0x78, 0x03, 0x9E, 0x03, 0xF0, 0x1E, 0x78, 0x0F, 0xC0, 0x79, 0xE0, 0x3F,
  0x01, 0xE3, 0x80, 0xFC, 0x07, 0x0F, 0x07, 0xB8, 0x1C, 0x3C, 0x1C, 0xE0,
  0xF0, 0xF0, 0x73, 0x83, 0xC1, 0xC1, 0xCF, 0x0E, 0x07, 0x8F, 0x3C, 0x38,
  0x1E, 0x38, 0x71, 0xE0, 0x78, 0xE1, 0xC7, 0x80, 0xE3, 0x87, 0x9E, 0x03,
  0x9E, 0x0E, 0x70, 0x0F, 0x70, 0x3B, 0xC0, 0x3D, 0xC0, 0xEF, 0x00, 0x77,
  0x03, 0xBC, 0x01, 0xDC, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80,
  0x7E, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0xF8, 0x03, 0xC0, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x03, 0xC7, 0x00, 0x78, 0xF0, 0x1E, 0x0F, 0x03, 0x81, 0xE0,
  0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFE,
  0x00, 0x3D, 0xC0, 0x07, 0xBC, 0x01, 0xE3, 0xC0, 0x3C, 0x78, 0x0F, 0x07,
  0x81, 0xC0, 0xF0, 0x78, 0x0F, 0x0E, 0x01, 0xE3, 0xC0, 0x1E, 0xF0, 0x03,
  0xE0, 0xF0, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x78, 0xF0, 0x1E, 0x3C, 0x0F,
  0x07, 0x03, 0xC1, 0xE1, 0xE0, 0x38, 0x78, 0x0F, 0x1C, 0x03, 0xCF, 0x00,
  0x7B, 0x80, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xFF, 0xFE,
  0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0F, 0xFF, 0xFF, 0x80, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0xFF, 0xFF, 0xFF,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0x70, 0x1C, 0x38, 0x0E,
  0x0E, 0x0E, 0x07, 0x07, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x3B, 0x80, 0x1E,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x0F, 0xF0,
  0x7F, 0xF0, 0x7F, 0xF0, 0x81, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x0F, 0xFE, 0x7F, 0xFD, 0xF0, 0x7B, 0xC0, 0xFF, 0x01, 0xFE, 0x03,
  0xFC, 0x0F, 0xBC, 0x1F, 0x7F, 0xFE, 0x7F, 0x9C, 0x7E, 0x38, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE7, 0xE1, 0xDF, 0xF3, 0xFF, 0xE7, 0xC1, 0xEF, 0x03, 0xDE, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0x7C, 0x1E, 0xFF, 0xFD, 0xDF, 0xF3, 0x9F,
  0x80, 0x0F, 0xF8, 0xFF, 0x8F, 0xFC, 0xF8, 0x27, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x02, 0x7F, 0xF1, 0xFF, 0x83, 0xFC, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x0F,
  0xCE, 0x7F, 0xDD, 0xFF, 0xFB, 0xC1, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE,
  0x03, 0xFC, 0x07, 0xBC, 0x1F, 0x7F, 0xFE, 0x7F, 0xDC, 0x7F, 0x38, 0x0F,
  0xE0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x03, 0xDE, 0x03, 0xBC, 0x07,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x02, 0x3F, 0xFC, 0x3F, 0xF8, 0x3F, 0xE0, 0x01,
  0xE0, 0x3F, 0xC3, 0xFC, 0x1E, 0x21, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3F, 0xE7, 0xFF, 0x3F, 0xF8, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x0F, 0xCE, 0x7F, 0xDD, 0xFF,
  0xFB, 0xC1, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xBC,
  0x1F, 0x7F, 0xFE, 0x7F, 0xDC, 0x7F, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0xA0, 0x1E, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF, 0xC0, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE7, 0xF3, 0xBF, 0xEF, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xC0, 0x7F, 0xF7,
  0x00, 0x07, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x0E,
  0x3C, 0x78, 0x70, 0x00, 0x00, 0x07, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC7, 0xFF, 0xFD, 0xF0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x3D, 0xC0, 0xF3,
  0x83, 0xC7, 0x0F, 0x0E, 0x1E, 0x1C, 0x78, 0x39, 0xE0, 0x77, 0x80, 0xEF,
  0x01, 0xFF, 0x03, 0xFE, 0x07, 0x9E, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x3C,
  0x70, 0x78, 0xE0, 0x79, 0xC0, 0x7B, 0x80, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE7, 0xE0, 0xFC, 0xEF, 0xFB,
  0xFE, 0xFF, 0xFB, 0xFF, 0xF8, 0x7F, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x3C,
  0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C,
  0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C,
  0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C,
  0x07, 0xE0, 0x3C, 0x07, 0xE7, 0xF3, 0xBF, 0xEF, 0xFF, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xC0, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x3C, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xF0, 0x0E, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x3C, 0x3F, 0xFC,
  0x1F, 0xF8, 0x0F, 0xE0, 0xE7, 0xE1, 0xDF, 0xF3, 0xFF, 0xE7, 0xC1, 0xEF,
  0x03, 0xDE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0x7C, 0x1E, 0xFF, 0xFD,
  0xDF, 0xF3, 0x9F, 0xC7, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x0F, 0xCE, 0x7F, 0xDD, 0xFF,
  0xFB, 0xC1, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xBC,
  0x1F, 0x7F, 0xFE, 0x7F, 0xDC, 0x7F, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0xC3, 0xFB,
  0xFE, 0xFF, 0xF8, 0xF8, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x1F, 0xE1,
  0xFF, 0xDF, 0xFC, 0xE0, 0x2F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0xFF, 0x01, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE8, 0x0F,
  0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3F, 0xC7, 0xF0, 0xFC, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x01, 0xEE, 0x03,
  0xDC, 0x07, 0xBC, 0x1F, 0x7F, 0xFE, 0x7F, 0xDC, 0x7F, 0x38, 0xF0, 0x07,
  0xF8, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x80, 0xE1, 0xC0, 0xF0, 0xF0,
  0x78, 0x78, 0x38, 0x1C, 0x3C, 0x0F, 0x1E, 0x03, 0x8E, 0x01, 0xCF, 0x00,
  0xF7, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x03, 0xDC, 0x07, 0x80, 0xE7, 0x83, 0xF0,
  0x79, 0xE0, 0xFC, 0x1E, 0x78, 0x3F, 0x07, 0x0E, 0x0F, 0xC1, 0xC3, 0x87,
  0x38, 0xF0, 0xF1, 0xCE, 0x3C, 0x3C, 0x73, 0x8E, 0x07, 0x1C, 0xE3, 0x81,
  0xCE, 0x1C, 0xE0, 0x7B, 0x87, 0x78, 0x1E, 0xE1, 0xDC, 0x03, 0xB8, 0x77,
  0x00, 0xFC, 0x0D, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x1E, 0x07, 0x8F, 0x07, 0x83,
  0xC7, 0x81, 0xE3, 0xC0, 0x7B, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x78,
  0xF0, 0x38, 0x38, 0x3C, 0x1E, 0x3C, 0x07, 0xBE, 0x03, 0xE0, 0xF0, 0x07,
  0xB8, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE3, 0x80, 0xE1, 0xE0, 0xF0, 0xF0,
  0x78, 0x38, 0x38, 0x1E, 0x3C, 0x0F, 0x1E, 0x03, 0x8E, 0x01, 0xCF, 0x00,
  0xF7, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x9F,
  0xFC, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78,
  0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xE0, 0xFC, 0x1F, 0x87, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x7C, 0x3F, 0x07,
  0x80, 0xFC, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x3C, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0x08, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x1F, 0x83, 0xF8, 0x0F, 0x01, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x07, 0xE1,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x78, 0x1F, 0x0F, 0xC1, 0xF0, 0x20, 0x00, 0x1E, 0x01, 0x7F, 0x83, 0xFF,
  0xFF, 0xE3, 0xFF, 0x80, 0x7C,
};

const GFXglyph NotoSans_SemiCondensed_Medium35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 5, 25, 9, 2, -25 },
  { 17, 11, 9, 15, 2, -25 },
  { 30, 19, 25, 20, 1, -25 },
  { 90, 15, 29, 18, 2, -27 },
  { 145, 25, 25, 28, 1, -25 },
  { 224, 22, 25, 23, 1, -25 },
  { 293, 4, 9, 8, 2, -25 },
  { 298, 9, 31, 11, 1, -25 },
  { 333, 8, 31, 11, 1, -25 },
  { 364, 15, 15, 17, 1, -27 },
  { 393, 16, 17, 18, 1, -21 },
  { 427, 6, 9, 9, 1, -4 },
  { 434, 9, 3, 11, 1, -11 },
  { 438, 5, 5, 9, 2, -5 },
  { 442, 13, 25, 13, 0, -25 },
  { 483, 16, 25, 18, 1, -25 },
  { 533, 9, 25, 18, 3, -25 },
  { 562, 16, 25, 18, 1, -25 },
  { 612, 16, 25, 18, 1, -25 },
  { 662, 17, 25, 18, 1, -25 },
  { 716, 15, 25, 18, 2, -25 },
  { 763, 15, 25, 18, 2, -25 },
  { 810, 16, 25, 18, 1, -25 },
  { 860, 16, 25, 18, 1, -25 },
  { 910, 16, 25, 18, 1, -25 },
  { 960, 5, 19, 9, 2, -19 },
  { 972, 6, 24, 9, 1, -19 },
  { 990, 16, 17, 18, 1, -21 },
  { 1024, 15, 10, 18, 2, -17 },
  { 1043, 16, 17, 18, 1, -21 },
  { 1077, 13, 25, 14, 0, -25 },
  { 1118, 25, 28, 29, 2, -25 },
  { 1206, 21, 25, 21, 0, -25 },
  { 1272, 16, 25, 21, 3, -25 },
  { 1322, 17, 25, 20, 2, -25 },
  { 1376, 18, 25, 23, 3, -25 },
  { 1433, 13, 25, 18, 3, -25 },
  { 1474, 13, 25, 17, 3, -25 },
  { 1515, 19, 25, 23, 2, -25 },
  { 1575, 18, 25, 24, 3, -25 },
  { 1632, 9, 25, 12, 1, -25 },
  { 1661, 9, 32, 9, -2, -25 },
  { 1697, 17, 25, 20, 3, -25 },
  { 1751, 13, 25, 17, 3, -25 },
  { 1792, 24, 25, 30, 3, -25 },
  { 1867, 19, 25, 25, 3, -25 },
  { 1927, 21, 25, 25, 2, -25 },
  { 1993, 15, 25, 19, 3, -25 },
  { 2040, 21, 31, 25, 2, -25 },
  { 2122, 17, 25, 20, 3, -25 },
  { 2176, 14, 25, 18, 2, -25 },
  { 2220, 17, 25, 18, 0, -25 },
  { 2274, 17, 25, 23, 3, -25 },
  { 2328, 20, 25, 20, 0, -25 },
  { 2391, 30, 25, 30, 0, -25 },
  { 2485, 19, 25, 19, 0, -25 },
  { 2545, 18, 25, 18, 0, -25 },
  { 2602, 16, 25, 18, 1, -25 },
  { 2652, 7, 31, 11, 3, -25 },
  { 2680, 13, 25, 13, 0, -25 },
  { 2721, 8, 31, 11, 1, -25 },
  { 2752, 17, 15, 19, 1, -25 },
  { 2784, 15, 2, 15, 0, 3 },
  { 2788, 8, 6, 10, 1, -27 },
  { 2794, 15, 19, 18, 1, -19 },
  { 2830, 15, 27, 20, 3, -27 },
  { 2881, 13, 19, 16, 2, -19 },
  { 2912, 15, 27, 20, 2, -27 },
  { 2963, 15, 19, 18, 2, -19 },
  { 2999, 13, 27, 11, 0, -27 },
  { 3043, 15, 27, 20, 2, -19 },
  { 3094, 14, 27, 20, 3, -27 },
  { 3142, 4, 26, 9, 2, -26 },
  { 3155, 7, 34, 9, -1, -26 },
  { 3185, 15, 27, 18, 3, -27 },
  { 3236, 3, 27, 9, 3, -27 },
  { 3247, 24, 19, 30, 3, -19 },
  { 3304, 14, 19, 20, 3, -19 },
  { 3338, 16, 19, 19, 2, -19 },
  { 3376, 15, 27, 20, 3, -19 },
  { 3427, 15, 27, 20, 2, -19 },
  { 3478, 10, 19, 13, 3, -19 },
  { 3502, 13, 19, 15, 1, -19 },
  { 3533, 10, 23, 12, 1, -23 },
  { 3562, 15, 19, 20, 2, -19 },
  { 3598, 17, 19, 17, 0, -19 },
  { 3639, 26, 19, 26, 0, -19 },
  { 3701, 17, 19, 17, 0, -19 },
  { 3742, 17, 27, 17, 0, -19 },
  { 3800, 13, 19, 15, 1, -19 },
  { 3831, 11, 31, 13, 1, -25 },
  { 3874, 3, 35, 18, 7, -27 },
  { 3888, 11, 31, 13, 1, -25 },
  { 3931, 16, 5, 18, 1, -15 },
};

const GFXfont NotoSans_SemiCondensed_Medium35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium35pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM35PT7B_H_
