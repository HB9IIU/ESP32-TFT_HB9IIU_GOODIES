#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM70PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium70pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x9F, 0xE7, 0xF9, 0xFE, 0x7F,
  0x9F, 0xE7, 0xF9, 0xFE, 0x7F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3,
  0xF8, 0xFE, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xF9, 0xFE, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0x7F, 0x8F, 0xE1, 0xE0, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xF7, 0xF0, 0x3F, 0xBF, 0x01, 0xFD, 0xF8, 0x0F, 0xEF,
  0xC0, 0x7E, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07,
  0xE7, 0xE0, 0x3F, 0x3F, 0x01, 0xF9, 0xF8, 0x0F, 0xCF, 0xC0, 0x3E, 0x7E,
  0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0xF0, 0x3E, 0x7F, 0x87, 0x80, 0x23,
  0xF8, 0x3C, 0x00, 0x1F, 0xC1, 0xE0, 0x00, 0xFC, 0x0F, 0x00, 0x07, 0xE0,
  0x78, 0x00, 0x3F, 0x83, 0xC0, 0x01, 0xFC, 0x1E, 0x00, 0x0F, 0xE0, 0xF0,
  0x00, 0x7F, 0xC7, 0x80, 0x01, 0xFF, 0x3C, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0x3F, 0xF0, 0x00, 0x78, 0x7F,
  0xC0, 0x03, 0xC1, 0xFE, 0x00, 0x1E, 0x07, 0xF0, 0x00, 0xF0, 0x3F, 0x80,
  0x07, 0x80, 0xFC, 0x00, 0x3C, 0x0F, 0xE0, 0x01, 0xE0, 0x7F, 0x80, 0x0F,
  0x03, 0xFE, 0x00, 0x78, 0x3F, 0xFE, 0x03, 0xC3, 0xFD, 0xFF, 0x9F, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x3F, 0x07, 0xFC, 0x07, 0xC0, 0x7E, 0x1F, 0x83, 0xFF, 0xC1,
  0xF8, 0x1F, 0x87, 0xE1, 0xFF, 0xF0, 0x7E, 0x07, 0xE1, 0xF0, 0xFF, 0xFE,
  0x1F, 0x83, 0xF0, 0xFC, 0x3F, 0x9F, 0xC3, 0xF9, 0xFC, 0x3E, 0x1F, 0x83,
  0xF0, 0xFF, 0xFE, 0x1F, 0x87, 0xE0, 0x7E, 0x1F, 0xFF, 0x87, 0xE3, 0xF0,
  0x1F, 0x83, 0xFF, 0xC3, 0xF0, 0xFC, 0x07, 0xE0, 0x7F, 0xE0, 0xFC, 0x3F,
  0x01, 0xF8, 0x03, 0x80, 0x7E, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x83,
  0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x7E, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x81, 0xFF, 0xBF, 0xC0, 0x0F,
  0xF0, 0x7F, 0xC3, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0xC0, 0x3F, 0x83,
  0xFC, 0x07, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0xC1, 0xFC, 0x1F, 0xE0,
  0x07, 0xFC, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0xCF, 0xE0, 0x7F, 0x80, 0x07,
  0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0xFF, 0x81, 0xFC, 0x00, 0x07, 0xFF,
  0xE0, 0x3F, 0x80, 0x00, 0xFF, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x03, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFD,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x20, 0x07, 0xC0, 0x09, 0xF0, 0x1F, 0x01,
  0xE7, 0xFC, 0x7C, 0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF8, 0x3F, 0xC0, 0x3F, 0xC0, 0x7F,
  0x80, 0x3F, 0x01, 0xF8, 0x00, 0x38, 0x03, 0x80, 0x00, 0x60, 0x0C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xE3, 0xF8, 0x7F, 0x1F, 0xE3, 0xFC, 0x7F, 0x0F, 0xE1, 0xFC, 0x7F,
  0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1E, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xF9, 0xFE, 0x3F,
  0x07, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x7F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x3F, 0xC7, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0xFF, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x03,
  0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFE,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFE, 0x3F, 0xC0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F, 0x00, 0x0F, 0xF0, 0xFF, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0x81, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xF0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xF7, 0xF3,
  0xFE, 0xFF, 0x7F, 0xCF, 0xFF, 0xF8, 0xFF, 0x7F, 0x0F, 0xF3, 0xE0, 0xFF,
  0x1C, 0x0F, 0xF1, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x0F, 0xFC,
  0x3E, 0x00, 0x0F, 0xF0, 0x70, 0x00, 0x3F, 0xC0, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x1F, 0xC0, 0x07, 0xFC,
  0x3C, 0x00, 0x0F, 0xF0, 0x40, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xB0,
  0x00, 0x03, 0xFE, 0xF8, 0x00, 0x3F, 0xF3, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0,
  0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xC0, 0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF4, 0x00,
  0x00, 0xFF, 0xB0, 0x00, 0x0F, 0xF9, 0xF0, 0x00, 0xFF, 0xCF, 0xFE, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x38, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x0F, 0x80, 0x07, 0xF0, 0xFF, 0xF0, 0x0F, 0xC7, 0xFF, 0xF0,
  0x1F, 0x9F, 0xFF, 0xF0, 0x7F, 0x7F, 0xFF, 0xF0, 0xFE, 0xFF, 0xFF, 0xF1,
  0xFF, 0xF0, 0x3F, 0xF3, 0xFF, 0x80, 0x1F, 0xE7, 0xFE, 0x00, 0x1F, 0xEF,
  0xF8, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x7F, 0x7F,
  0x80, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0xFE, 0x3F, 0x80,
  0x01, 0xFC, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0xFF, 0x81, 0xFF, 0xDF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF0, 0x07, 0xF8,
  0x3F, 0xC0, 0x07, 0xF8, 0x7F, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0x7F,
  0x80, 0x0F, 0xE0, 0x7F, 0x80, 0x3F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0xC7, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xDF, 0xFC, 0x03, 0xFE, 0x0F,
  0xFC, 0x0F, 0xF8, 0x07, 0xFC, 0x1F, 0xE0, 0x07, 0xFC, 0x7F, 0x80, 0x07,
  0xF8, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFB,
  0xFC, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xFC, 0x00, 0x7F, 0x87,
  0xFE, 0x03, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F,
  0xF1, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0xFE,
  0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFF, 0x7F, 0x80, 0x07,
  0xFD, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x07, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFD, 0xFC, 0x3F, 0xFF, 0xE7, 0xF0, 0x7F, 0xFF, 0x1F, 0xC0,
  0x7F, 0xF8, 0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x70, 0x7F, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF7, 0xF9, 0xFE, 0x3F, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xF9, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0x7F, 0x8F, 0xE1, 0xE0, 0x0F, 0xC1, 0xFE, 0x1F, 0xE3,
  0xFF, 0x3F, 0xF3, 0xFF, 0x1F, 0xE1, 0xFE, 0x0F, 0xC0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC3, 0xF8, 0x3F, 0x83, 0xF8, 0x3F, 0x03, 0xF0, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xF8, 0x03, 0xFE, 0x30,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0xFF, 0xFE, 0x03, 0xF0, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0xFC, 0x3F, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0x8F, 0x80, 0x3F, 0xFF,
  0xFC, 0x07, 0xE7, 0xE0, 0x1F, 0xE0, 0x3F, 0x01, 0xF9, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x3E, 0x7C, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xBF, 0x00, 0xFC,
  0x00, 0xFC, 0x03, 0xEF, 0xC0, 0x7F, 0x00, 0x3F, 0x00, 0xFB, 0xF0, 0x1F,
  0x80, 0x0F, 0x80, 0x3F, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xFE, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x7C, 0x00, 0x7E, 0x00, 0xFF, 0xE0,
  0x3F, 0x00, 0x1F, 0x80, 0x3E, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xBE,
  0x03, 0xF0, 0x01, 0xF8, 0x03, 0xEF, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0xFB,
  0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x7E, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F,
  0xBE, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xCF, 0x80, 0x7E, 0x00, 0xFE, 0x03,
  0xF3, 0xF0, 0x1F, 0xC0, 0x7F, 0xC0, 0xFC, 0xFC, 0x03, 0xF8, 0x3F, 0xF0,
  0x7E, 0x3F, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0x0F, 0xC0, 0x1F, 0xFF, 0xCF,
  0xFF, 0xC1, 0xF8, 0x03, 0xFF, 0xE1, 0xFF, 0xE0, 0x7E, 0x00, 0x7F, 0xF0,
  0x3F, 0xF0, 0x1F, 0x80, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x3F, 0xFC, 0xFE, 0x00, 0x07,
  0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x1F, 0xFC, 0xFE, 0x00, 0x07,
  0xFC, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFE, 0xFE, 0x00, 0x07, 0xFE, 0xFE, 0x00, 0x3F,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0x7C, 0x07,
  0xFE, 0x00, 0x07, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x04, 0x07, 0xFF, 0x80, 0x0F,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0xFF,
  0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0xFE, 0x00, 0x03, 0xFF, 0x0F, 0xE0,
  0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x00, 0xFF, 0x8F, 0xE0, 0x00, 0x07, 0xFC,
  0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00,
  0x1F, 0xEF, 0xE0, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x00,
  0x7F, 0x8F, 0xE0, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x01, 0xFF, 0x0F, 0xE0,
  0x00, 0x7F, 0xF0, 0xFE, 0x00, 0x0F, 0xFE, 0x0F, 0xE0, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0x00, 0xE0,
  0x3F, 0xF0, 0x00, 0x00, 0x80, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x00, 0x3F, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x00, 0xFF, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0xFF, 0x80, 0x00, 0x3F, 0xC3, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xFF,
  0x80, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0xE0, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3F, 0xFE, 0x0F, 0xFF, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xEF, 0xE0,
  0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xFC, 0x3F,
  0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x03, 0xFC,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x7F,
  0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x0F,
  0xE7, 0xF8, 0x00, 0x03, 0xFB, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xC7, 0xF8, 0x00, 0x3F, 0xE1, 0xFF, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x03, 0xF8, 0x0F, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x7F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03,
  0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x03, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x1F, 0xF0, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x7F, 0xFB,
  0xF8, 0x00, 0x00, 0x7E, 0xFF, 0xF7, 0xF0, 0x00, 0x00, 0xFD, 0xFF, 0xF7,
  0xE0, 0x00, 0x03, 0xF3, 0xFF, 0xEF, 0xE0, 0x00, 0x07, 0xE7, 0xFF, 0xDF,
  0xC0, 0x00, 0x0F, 0xCF, 0xFF, 0x9F, 0x80, 0x00, 0x3F, 0x1F, 0xFF, 0x3F,
  0x80, 0x00, 0x7E, 0x7F, 0xFE, 0x7F, 0x00, 0x00, 0xFC, 0xFF, 0xFC, 0x7E,
  0x00, 0x03, 0xF1, 0xFF, 0xF8, 0xFE, 0x00, 0x07, 0xE3, 0xFF, 0xF1, 0xFC,
  0x00, 0x0F, 0xC7, 0xFF, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xFF, 0xC3, 0xF0,
  0x00, 0x7E, 0x1F, 0xFF, 0x87, 0xF0, 0x00, 0xFC, 0x3F, 0xFF, 0x07, 0xE0,
  0x03, 0xF0, 0x7F, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xFF, 0xFC, 0x1F, 0xC0,
  0x0F, 0xC1, 0xFF, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xFF, 0xF0, 0x3F, 0x00,
  0x7E, 0x07, 0xFF, 0xE0, 0x7F, 0x00, 0xFC, 0x0F, 0xFF, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x0F,
  0xC0, 0x7F, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0xFF, 0xFC, 0x03, 0xF0, 0x7E,
  0x01, 0xFF, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xE3, 0xF0,
  0x07, 0xFF, 0xE0, 0x0F, 0xC7, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xCF, 0xC0,
  0x1F, 0xFF, 0x80, 0x3F, 0xBF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x7E, 0x00,
  0x7F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x7F,
  0x80, 0x00, 0x7F, 0xFB, 0xFC, 0x00, 0x03, 0xFF, 0xCF, 0xF0, 0x00, 0x1F,
  0xFF, 0x7F, 0x80, 0x00, 0xFF, 0xF9, 0xFE, 0x00, 0x07, 0xFF, 0xC7, 0xF0,
  0x00, 0x3F, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0xF0, 0xFF, 0x00, 0x0F, 0xFF,
  0x87, 0xF8, 0x00, 0x7F, 0xFC, 0x1F, 0xE0, 0x03, 0xFF, 0xE0, 0xFF, 0x00,
  0x1F, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x1F, 0xE0, 0x07, 0xFF, 0xC0,
  0x7F, 0x80, 0x3F, 0xFE, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0xE0, 0x07,
  0xF8, 0x1F, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0x07, 0xFF,
  0xC0, 0x07, 0xF8, 0x3F, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0xF0, 0x00, 0xFF,
  0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x7F, 0xFC, 0x00, 0x0F, 0xF3, 0xFF, 0xE0,
  0x00, 0x7F, 0x9F, 0xFF, 0x00, 0x01, 0xFE, 0xFF, 0xF8, 0x00, 0x0F, 0xF7,
  0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x00, 0x1F, 0xE1, 0xFE,
  0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xDF, 0xC0,
  0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00,
  0x0F, 0xF3, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x0F, 0xF8,
  0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0x3F, 0x80, 0x0F,
  0xFC, 0xFE, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x7F,
  0xBF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFE, 0xFE, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x0F,
  0xFC, 0xFE, 0x01, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC3, 0xFC, 0x00, 0x00, 0x1F, 0xE1, 0xFE, 0x00,
  0x00, 0x0F, 0xF9, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x0F,
  0xF3, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x00,
  0x03, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x0F, 0xFF, 0x03, 0xF8, 0x00, 0x7F, 0xE0,
  0xFE, 0x00, 0x0F, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x03, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03, 0xFC, 0x0F,
  0xE0, 0x03, 0xFF, 0x03, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x1F,
  0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xF3, 0xF8, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x00, 0xFF, 0xBF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0x87, 0xFE, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0xE3, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFD, 0xE0,
  0x00, 0x3F, 0xEF, 0xE0, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00,
  0x07, 0xF7, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0x3F, 0xCF, 0xF8,
  0x00, 0x0F, 0xF0, 0xFF, 0x80, 0x03, 0xFE, 0x1F, 0xFC, 0x01, 0xFF, 0x81,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFD, 0xFC, 0x00, 0x00, 0x07, 0xF3, 0xFC, 0x00,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0xFF, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x3F,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xF9,
  0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xF0, 0x0F,
  0xF0, 0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x8F, 0xC0,
  0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x00,
  0x3F, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x7F, 0x07, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xE0,
  0x7E, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x7E, 0x07, 0xF0, 0x1F, 0xC0, 0x03,
  0xF8, 0x0F, 0xE0, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x03, 0xF0,
  0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0xFC, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x83, 0xF8,
  0x00, 0x1F, 0xE1, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x1F, 0x80,
  0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFC,
  0x7F, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0xFF, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x7F,
  0x80, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x00,
  0x7F, 0xBF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x7F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0xFF, 0x00, 0x00, 0x0F, 0xFB, 0xFC, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x03, 0xF9, 0xFE,
  0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x01,
  0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xE0, 0x7F, 0x07, 0xFE, 0x07, 0x80, 0x1F, 0xF0, 0x40, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xF8, 0x07, 0xF7, 0xFC,
  0x00, 0x7F, 0x7F, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03,
  0xFF, 0x7F, 0xC0, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0x3F, 0xFF, 0xF3, 0xF3,
  0xFF, 0xFE, 0x1F, 0x0F, 0xFF, 0xC1, 0xF0, 0x7F, 0xF8, 0x1F, 0x00, 0x78,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x03, 0xFF, 0x00, 0xFE, 0x1F, 0xFF, 0x01, 0xFC, 0x7F, 0xFF, 0x83,
  0xF9, 0xFF, 0xFF, 0x87, 0xF7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFE, 0x01, 0xFF, 0x3F, 0xF0, 0x01, 0xFE, 0x7F, 0xE0, 0x01, 0xFE, 0xFF,
  0x80, 0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xF7, 0xFC, 0x00, 0x1F, 0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xF8, 0x00, 0xFF,
  0x3F, 0xF8, 0x03, 0xFE, 0x7F, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFD, 0xFF, 0xFF, 0xC3, 0xF1, 0xFF, 0xFF, 0x07, 0xE1, 0xFF, 0xFC, 0x0F,
  0xC0, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xE1, 0xFF, 0x80, 0x70, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x04, 0x7F, 0xC0, 0x06, 0x0F, 0xFF, 0x3F, 0x83, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x3F, 0xF0, 0x7F, 0x01, 0xFF, 0xF8, 0xFE, 0x07, 0xFF, 0xF9,
  0xFC, 0x1F, 0xFF, 0xFB, 0xF8, 0x7F, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF, 0xFF,
  0xE3, 0xFE, 0x01, 0xFF, 0xCF, 0xF8, 0x01, 0xFF, 0x9F, 0xE0, 0x01, 0xFF,
  0x3F, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x1F, 0xE7, 0xFC, 0x00,
  0x7F, 0xC7, 0xFC, 0x01, 0xFF, 0x8F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0xFF,
  0x7E, 0x0F, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF, 0xF1, 0xF8, 0x0F, 0xFF, 0xC3,
  0xF0, 0x0F, 0xFF, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0x00, 0xFF, 0x07,
  0xF0, 0x01, 0xFE, 0x3F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7F, 0x7F, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x87, 0xFC, 0x00, 0x1E, 0x0F, 0xFE, 0x03,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xBE, 0x03, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x7E, 0x03, 0xFF,
  0xF0, 0xFC, 0x0F, 0xFF, 0xF1, 0xF8, 0x3F, 0xFF, 0xF3, 0xF0, 0xFF, 0xFF,
  0xF7, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFC, 0x03, 0xFF, 0x9F, 0xF0, 0x03,
  0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0x80, 0x03, 0xFD, 0xFE, 0x00, 0x07,
  0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFD, 0xFE,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x3F, 0xCF, 0xF8, 0x00, 0xFF, 0x8F, 0xF8, 0x03, 0xFF, 0x1F, 0xFC,
  0x3F, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFB, 0xF8, 0x1F, 0xFF,
  0xE7, 0xF0, 0x1F, 0xFF, 0x8F, 0xE0, 0x1F, 0xFE, 0x1F, 0xC0, 0x03, 0xE0,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x84, 0x00, 0x00, 0xFF, 0x0E, 0x00, 0x07, 0xFE,
  0x1F, 0xE0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x81, 0xFF, 0x80, 0xFE, 0x1F, 0xFF, 0x83, 0xF8, 0xFF, 0xFF, 0x0F,
  0xE7, 0xFF, 0xFE, 0x3F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xC0, 0x3F, 0xEF, 0xFE, 0x00, 0x7F, 0xBF, 0xF0, 0x00, 0xFE, 0xFF, 0x80,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFC, 0x7C,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0xFE, 0xFE, 0xFE, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFE, 0xC3, 0xFE, 0xFF, 0xFC, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0x3F, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x0F, 0xF0,
  0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F,
  0x80, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE0,
  0xFF, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF8, 0xFF,
  0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x3F, 0xBF, 0xE0, 0x00, 0xFE, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xEF, 0xF0, 0x03, 0xFF, 0x1F, 0xE0, 0x0F, 0xF8, 0x7F, 0x80, 0x3F,
  0xC0, 0xFF, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0,
  0x0F, 0xF0, 0x3F, 0x80, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0xFF, 0x0F, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0xFE, 0x00, 0x1F,
  0xE3, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x7F, 0xBF, 0x80, 0x01, 0xFE,
  0xFE, 0x00, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x3F, 0x07, 0xFF,
  0xC0, 0x3F, 0xFF, 0x0F, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFB, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFC, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFB, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFE, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x7F, 0xFE, 0x0F, 0xC3, 0xFF, 0xFC,
  0x3F, 0x9F, 0xFF, 0xF8, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0x00, 0xFF, 0xBF, 0xF0, 0x01, 0xFE, 0xFF, 0xC0, 0x03, 0xFB, 0xFE,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFE,
  0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F,
  0x7F, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFE, 0x3F, 0xC0, 0x01, 0xFE,
  0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xF8,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xFC, 0x07, 0xFE, 0x01, 0xF8, 0x3F, 0xFE, 0x03, 0xF0, 0xFF, 0xFF, 0x07,
  0xF3, 0xFF, 0xFF, 0x0F, 0xEF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFC, 0x03, 0xFE, 0x7F, 0xE0, 0x03, 0xFC, 0xFF, 0x80, 0x03, 0xFD, 0xFF,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xEF, 0xF8, 0x00, 0x3F, 0xDF, 0xF0, 0x00, 0x7F, 0xBF, 0xF0, 0x01, 0xFE,
  0x7F, 0xF0, 0x07, 0xFC, 0xFF, 0xFE, 0x7F, 0xF1, 0xFD, 0xFF, 0xFF, 0xE3,
  0xFB, 0xFF, 0xFF, 0x87, 0xF3, 0xFF, 0xFE, 0x0F, 0xE3, 0xFF, 0xF8, 0x1F,
  0xC1, 0xFF, 0xC0, 0x3F, 0x80, 0x7C, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x7E, 0x03, 0xFF, 0xF0, 0xFC, 0x0F, 0xFF, 0xF1, 0xF8, 0x3F, 0xFF,
  0xF3, 0xF0, 0xFF, 0xFF, 0xF7, 0xE3, 0xFF, 0xFF, 0xFF, 0xC7, 0xFC, 0x03,
  0xFF, 0x9F, 0xF0, 0x03, 0xFF, 0x3F, 0xC0, 0x03, 0xFE, 0x7F, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0xFE,
  0x00, 0x01, 0xFD, 0xFE, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x0F, 0xF7, 0xF8,
  0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x3F, 0xCF, 0xF8, 0x00, 0xFF, 0x8F, 0xF8,
  0x03, 0xFF, 0x1F, 0xFC, 0x3F, 0xFE, 0x1F, 0xFF, 0xFE, 0xFC, 0x1F, 0xFF,
  0xFB, 0xF8, 0x1F, 0xFF, 0xE7, 0xF0, 0x1F, 0xFF, 0x8F, 0xE0, 0x1F, 0xFC,
  0x1F, 0xC0, 0x03, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x07, 0xFF, 0xE0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x7F, 0xFB,
  0xFF, 0xFD, 0xDF, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0x07, 0xF3, 0xFC, 0x00, 0x71, 0xFC, 0x00,
  0x08, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFD, 0xE0, 0x01, 0xFE, 0xFF, 0x03, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x1C, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x78, 0x00,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xF7, 0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x0F, 0xFF,
  0x7F, 0xF1, 0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xF3, 0xFF, 0xFF, 0xDF, 0xC7,
  0xFF, 0xFE, 0x7F, 0x0F, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0x03, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7F,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x07,
  0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x3F,
  0x1F, 0xC0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFD, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x9F,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF8,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xFE, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xDF, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xF3, 0xF0, 0x07,
  0xF0, 0x7F, 0x00, 0xFC, 0xFC, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0x3F, 0x00,
  0xFE, 0x07, 0xF0, 0x0F, 0x8F, 0xC0, 0x3F, 0x81, 0xFC, 0x07, 0xE1, 0xF8,
  0x0F, 0xC0, 0x3F, 0x81, 0xF8, 0x7E, 0x07, 0xF0, 0x0F, 0xE0, 0x7E, 0x1F,
  0x81, 0xFC, 0x03, 0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x00, 0xFE, 0x0F, 0xC0,
  0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0xFC,
  0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x7F, 0x03, 0xF0, 0xFE, 0x00, 0x7F, 0x1F,
  0x80, 0xFE, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x1F, 0x9F, 0xC0, 0x03, 0xF9,
  0xF8, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x7E, 0x01, 0xF9, 0xFC, 0x00, 0x3F,
  0xBF, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x0F, 0xDF, 0x80, 0x01,
  0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xBE, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x7F, 0x80, 0x01, 0xFE, 0x3F, 0xC0,
  0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xE0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x0F, 0xE0, 0x07, 0xF8,
  0x1F, 0xE0, 0x03, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFE,
  0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0x03, 0xFC, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF8,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xE0,
  0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80,
  0x01, 0xFE, 0x7F, 0x80, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xF8, 0xFF,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xE0,
  0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x41, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF,
  0xF0, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x03,
  0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x02, 0x3F, 0xF8,
  0x00, 0x04, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0xC0, 0x01, 0xFF, 0xF9, 0x00, 0x00, 0x7F, 0xC0,
};

const GFXglyph NotoSans_SemiCondensed_Medium70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 10, 51, 18, 4, -50 },
  { 65, 21, 18, 29, 4, -50 },
  { 113, 37, 50, 41, 2, -50 },
  { 345, 29, 57, 37, 4, -53 },
  { 552, 50, 52, 56, 3, -51 },
  { 877, 43, 52, 46, 3, -51 },
  { 1157, 8, 18, 16, 4, -50 },
  { 1175, 17, 61, 21, 3, -50 },
  { 1305, 16, 61, 21, 2, -50 },
  { 1427, 30, 29, 35, 2, -53 },
  { 1536, 31, 34, 37, 3, -42 },
  { 1668, 11, 17, 18, 3, -8 },
  { 1692, 17, 6, 21, 2, -22 },
  { 1705, 10, 10, 18, 4, -9 },
  { 1718, 25, 50, 27, 1, -50 },
  { 1875, 31, 52, 37, 3, -51 },
  { 2077, 20, 50, 37, 5, -50 },
  { 2202, 30, 51, 37, 3, -51 },
  { 2394, 30, 52, 37, 3, -51 },
  { 2589, 34, 50, 37, 1, -50 },
  { 2802, 29, 51, 37, 4, -50 },
  { 2987, 31, 52, 37, 3, -51 },
  { 3189, 32, 50, 37, 2, -50 },
  { 3389, 31, 52, 37, 3, -51 },
  { 3591, 30, 52, 37, 3, -51 },
  { 3786, 10, 39, 18, 4, -38 },
  { 3835, 12, 47, 18, 2, -38 },
  { 3906, 31, 34, 37, 3, -42 },
  { 4038, 30, 20, 37, 3, -35 },
  { 4113, 31, 34, 37, 3, -42 },
  { 4245, 26, 52, 28, 1, -51 },
  { 4414, 50, 56, 57, 4, -50 },
  { 4764, 41, 50, 41, 0, -50 },
  { 5021, 32, 50, 42, 6, -50 },
  { 5221, 34, 52, 40, 4, -51 },
  { 5442, 36, 50, 46, 6, -50 },
  { 5667, 25, 50, 35, 6, -50 },
  { 5824, 25, 50, 34, 6, -50 },
  { 5981, 38, 52, 46, 4, -51 },
  { 6228, 35, 50, 47, 6, -50 },
  { 6447, 19, 50, 23, 2, -50 },
  { 6566, 18, 64, 19, -5, -50 },
  { 6710, 34, 50, 40, 6, -50 },
  { 6923, 26, 50, 33, 6, -50 },
  { 7086, 47, 50, 60, 6, -50 },
  { 7380, 37, 50, 49, 6, -50 },
  { 7612, 41, 52, 49, 4, -51 },
  { 7879, 30, 50, 39, 6, -50 },
  { 8067, 41, 63, 49, 4, -51 },
  { 8390, 34, 50, 40, 6, -50 },
  { 8603, 29, 52, 35, 3, -51 },
  { 8792, 33, 50, 35, 1, -50 },
  { 8999, 35, 51, 46, 6, -50 },
  { 9223, 39, 50, 39, 0, -50 },
  { 9467, 60, 50, 60, 0, -50 },
  { 9842, 38, 50, 38, 0, -50 },
  { 10080, 37, 50, 37, 0, -50 },
  { 10312, 31, 50, 35, 2, -50 },
  { 10506, 16, 61, 23, 5, -50 },
  { 10628, 25, 50, 27, 1, -50 },
  { 10785, 16, 61, 23, 2, -50 },
  { 10907, 33, 30, 37, 2, -50 },
  { 11031, 30, 5, 30, 0, 6 },
  { 11050, 15, 12, 21, 3, -54 },
  { 11073, 28, 39, 36, 3, -38 },
  { 11210, 31, 54, 40, 5, -53 },
  { 11420, 26, 39, 31, 3, -38 },
  { 11547, 31, 54, 40, 3, -53 },
  { 11757, 30, 39, 36, 3, -38 },
  { 11904, 24, 54, 23, 1, -54 },
  { 12066, 31, 55, 40, 3, -38 },
  { 12280, 30, 53, 40, 5, -53 },
  { 12479, 8, 52, 18, 5, -52 },
  { 12531, 16, 69, 18, -3, -52 },
  { 12669, 30, 53, 36, 5, -53 },
  { 12868, 7, 53, 18, 5, -53 },
  { 12915, 50, 38, 60, 5, -38 },
  { 13153, 30, 38, 40, 5, -38 },
  { 13296, 32, 39, 39, 3, -38 },
  { 13452, 31, 55, 40, 5, -38 },
  { 13666, 31, 55, 40, 3, -38 },
  { 13880, 21, 38, 27, 5, -38 },
  { 13980, 25, 39, 31, 3, -38 },
  { 14102, 22, 47, 24, 1, -46 },
  { 14232, 30, 39, 40, 5, -38 },
  { 14379, 33, 38, 33, 0, -38 },
  { 14536, 50, 38, 52, 1, -38 },
  { 14774, 32, 38, 34, 1, -38 },
  { 14926, 33, 55, 33, 0, -38 },
  { 15153, 25, 38, 29, 2, -38 },
  { 15272, 22, 61, 26, 2, -50 },
  { 15440, 6, 70, 35, 15, -53 },
  { 15493, 21, 61, 26, 3, -50 },
  { 15654, 31, 10, 37, 3, -30 },
};

const GFXfont NotoSans_SemiCondensed_Medium70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium70pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM70PT7B_H_
