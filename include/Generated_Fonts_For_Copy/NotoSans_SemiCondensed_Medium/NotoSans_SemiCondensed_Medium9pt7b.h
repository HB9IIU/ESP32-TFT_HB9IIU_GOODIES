#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM9PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x37, 0xD5, 0xF5, 0x28, 0x27, 0xA6, 0x3B, 0x62, 0x45,
  0x52, 0xA5, 0xA5, 0xA5, 0x49, 0x00, 0x21, 0x45, 0x09, 0x7A, 0x67, 0xC0,
  0xC0, 0x6A, 0x48, 0x98, 0xD5, 0x5C, 0x2F, 0x25, 0x2F, 0x22, 0x60, 0xC0,
  0x80, 0x25, 0x25, 0x00, 0x25, 0x99, 0x95, 0x70, 0xF5, 0x50, 0x2D, 0x11,
  0x24, 0xF0, 0x69, 0x16, 0x11, 0xF0, 0x31, 0x95, 0x2F, 0x88, 0x74, 0x71,
  0x1F, 0x34, 0x4F, 0x95, 0x70, 0xF1, 0x22, 0x24, 0x25, 0x56, 0x59, 0x70,
  0x25, 0x99, 0x71, 0x60, 0x88, 0x40, 0x60, 0x3C, 0x61, 0xFF, 0xC3, 0x2C,
  0x54, 0x94, 0x10, 0x3C, 0xB6, 0xAD, 0x5B, 0x48, 0x0E, 0x00, 0x22, 0x94,
  0xE8, 0xC4, 0xF9, 0xE9, 0x9E, 0x13, 0x51, 0x04, 0x21, 0xE0, 0xF9, 0x99,
  0x9E, 0xF3, 0xC9, 0xC0, 0xF3, 0xC9, 0x00, 0x13, 0x51, 0x24, 0xA5, 0xE0,
  0x99, 0xF9, 0x99, 0xE9, 0x25, 0xC0, 0x24, 0x92, 0x4E, 0xBA, 0xCA, 0xA9,
  0x92, 0x49, 0xC0, 0x8F, 0x3D, 0x75, 0xB6, 0x90, 0x8E, 0x6B, 0x59, 0xCC,
  0x31, 0x24, 0x61, 0x45, 0x37, 0x80, 0xE9, 0xAC, 0x88, 0x31, 0x24, 0x61,
  0x45, 0x37, 0x82, 0x0C, 0xE9, 0xAE, 0xA9, 0x25, 0x86, 0x11, 0xF0, 0xF2,
  0x22, 0x22, 0x99, 0x99, 0x9F, 0x8A, 0x94, 0xA5, 0x10, 0x99, 0x9A, 0x5A,
  0x6A, 0x66, 0x64, 0xDA, 0x88, 0xC5, 0x44, 0x9A, 0x98, 0x42, 0x10, 0xF2,
  0x24, 0x4F, 0xEA, 0xAC, 0x89, 0x22, 0x40, 0xD5, 0x5C, 0x22, 0xB6, 0xF0,
  0xD0, 0x71, 0x79, 0x70, 0x88, 0xE9, 0x99, 0xE0, 0x74, 0x84, 0x70, 0x11,
  0x75, 0x99, 0x70, 0x75, 0xF4, 0x70, 0x6B, 0xA4, 0x90, 0x75, 0x99, 0x71,
  0x70, 0x93, 0xDB, 0x68, 0xBE, 0x45, 0x55, 0x80, 0x88, 0xAC, 0xCA, 0xB0,
  0xFE, 0xFE, 0x9A, 0x69, 0xA4, 0xF6, 0xDA, 0x72, 0xA2, 0xA7, 0x00, 0xE9,
  0x99, 0xE8, 0x80, 0x75, 0x99, 0x71, 0x10, 0xEA, 0x80, 0x78, 0x61, 0xE0,
  0x5D, 0x24, 0xC0, 0xB6, 0xDE, 0x99, 0x56, 0x60, 0x93, 0x69, 0xB3, 0x64,
  0x80, 0x96, 0x26, 0x90, 0x99, 0x56, 0x22, 0xC0, 0xE2, 0x44, 0xF0, 0x69,
  0x44, 0x98, 0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xF0,
};

const GFXglyph NotoSans_SemiCondensed_Medium9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 2, 2, 4, 1, -6 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 4, 8, 5, 0, -7 },
  { 11, 7, 7, 7, 0, -7 },
  { 18, 6, 7, 6, 0, -7 },
  { 24, 1, 2, 2, 1, -6 },
  { 25, 3, 7, 3, 0, -6 },
  { 28, 2, 7, 3, 0, -6 },
  { 30, 4, 4, 4, 0, -7 },
  { 32, 4, 4, 5, 0, -5 },
  { 34, 2, 2, 2, 0, -1 },
  { 35, 2, 1, 3, 0, -3 },
  { 36, 1, 1, 2, 1, -1 },
  { 37, 3, 6, 3, 0, -6 },
  { 40, 4, 7, 5, 0, -7 },
  { 44, 2, 6, 5, 1, -6 },
  { 46, 4, 7, 5, 0, -7 },
  { 50, 4, 7, 5, 0, -7 },
  { 54, 5, 6, 5, 0, -6 },
  { 58, 4, 6, 5, 0, -6 },
  { 61, 4, 7, 5, 0, -7 },
  { 65, 4, 6, 5, 0, -6 },
  { 68, 4, 7, 5, 0, -7 },
  { 72, 4, 7, 5, 0, -7 },
  { 76, 1, 5, 2, 1, -5 },
  { 77, 2, 6, 2, 0, -5 },
  { 79, 4, 4, 5, 0, -5 },
  { 81, 4, 2, 5, 0, -4 },
  { 82, 4, 4, 5, 0, -5 },
  { 84, 3, 7, 4, 0, -7 },
  { 87, 7, 7, 7, 0, -6 },
  { 94, 5, 6, 5, 0, -6 },
  { 98, 4, 6, 5, 1, -6 },
  { 101, 5, 7, 5, 0, -7 },
  { 106, 4, 6, 6, 1, -6 },
  { 109, 3, 6, 5, 1, -6 },
  { 112, 3, 6, 4, 1, -6 },
  { 115, 5, 7, 6, 0, -7 },
  { 120, 4, 6, 6, 1, -6 },
  { 123, 3, 6, 3, 0, -6 },
  { 126, 3, 8, 2, -1, -6 },
  { 129, 4, 6, 5, 1, -6 },
  { 132, 3, 6, 4, 1, -6 },
  { 135, 6, 6, 8, 1, -6 },
  { 140, 5, 6, 6, 1, -6 },
  { 144, 6, 7, 6, 0, -7 },
  { 150, 4, 6, 5, 1, -6 },
  { 153, 6, 9, 6, 0, -7 },
  { 160, 4, 6, 5, 1, -6 },
  { 163, 4, 7, 5, 0, -7 },
  { 167, 4, 6, 5, 0, -6 },
  { 170, 4, 6, 6, 1, -6 },
  { 173, 5, 6, 5, 0, -6 },
  { 177, 8, 6, 8, 0, -6 },
  { 183, 5, 6, 5, 0, -6 },
  { 187, 5, 6, 5, 0, -6 },
  { 191, 4, 6, 5, 0, -6 },
  { 194, 2, 7, 3, 1, -6 },
  { 196, 3, 6, 3, 0, -6 },
  { 199, 2, 7, 3, 0, -6 },
  { 201, 5, 3, 5, 0, -6 },
  { 203, 4, 1, 4, 0, 1 },
  { 204, 2, 2, 3, 0, -7 },
  { 205, 4, 5, 5, 0, -5 },
  { 208, 4, 7, 5, 1, -7 },
  { 212, 4, 5, 4, 0, -5 },
  { 215, 4, 7, 5, 0, -7 },
  { 219, 4, 5, 5, 0, -5 },
  { 222, 3, 7, 3, 0, -7 },
  { 225, 4, 7, 5, 0, -5 },
  { 229, 3, 7, 5, 1, -7 },
  { 232, 1, 7, 2, 1, -7 },
  { 233, 2, 9, 2, 0, -7 },
  { 236, 4, 7, 5, 1, -7 },
  { 240, 1, 7, 2, 1, -7 },
  { 241, 6, 5, 8, 1, -5 },
  { 245, 3, 5, 5, 1, -5 },
  { 247, 5, 5, 5, 0, -5 },
  { 251, 4, 7, 5, 1, -5 },
  { 255, 4, 7, 5, 0, -5 },
  { 259, 2, 5, 3, 1, -5 },
  { 261, 4, 5, 4, 0, -5 },
  { 264, 3, 6, 3, 0, -6 },
  { 267, 3, 5, 5, 1, -5 },
  { 269, 4, 5, 4, 0, -5 },
  { 272, 7, 5, 7, 0, -5 },
  { 277, 4, 5, 4, 0, -5 },
  { 280, 4, 7, 4, 0, -5 },
  { 284, 4, 5, 4, 0, -5 },
  { 287, 3, 7, 3, 0, -6 },
  { 290, 1, 9, 5, 2, -7 },
  { 292, 3, 7, 3, 0, -6 },
  { 295, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_Medium9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium9pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM9PT7B_H_
