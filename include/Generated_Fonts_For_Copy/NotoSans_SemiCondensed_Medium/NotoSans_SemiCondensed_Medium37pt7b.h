#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM37PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium37pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xB9, 0xCE, 0x73,
  0x80, 0x00, 0x19, 0xFF, 0xFB, 0xC0, 0xF1, 0xFE, 0x3F, 0xC7, 0xB8, 0xF7,
  0x0E, 0xE1, 0xDC, 0x3B, 0x87, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x1C, 0x38,
  0x03, 0x83, 0x80, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x0E, 0x00, 0x70,
  0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x0C, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x1C, 0x18, 0x01,
  0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F, 0xF8, 0x3F, 0xFE, 0x7F, 0xFE,
  0xFD, 0x9C, 0xF1, 0x80, 0xF1, 0x80, 0xF1, 0x80, 0xF1, 0x80, 0xF9, 0x80,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x01, 0xBE,
  0x01, 0x8E, 0x01, 0x8F, 0x01, 0x8F, 0x81, 0x8E, 0xE1, 0xBE, 0xFF, 0xFC,
  0xFF, 0xF8, 0x7F, 0xE0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x1C, 0x00, 0x08, 0x1F, 0xC0, 0x1C, 0x07, 0xF8, 0x07, 0x03, 0xCE, 0x03,
  0x80, 0xE1, 0xC0, 0xE0, 0x38, 0x70, 0x70, 0x0E, 0x1C, 0x1C, 0x03, 0x87,
  0x0E, 0x00, 0xE1, 0xC3, 0x80, 0x38, 0x71, 0xC0, 0x0E, 0x1C, 0x70, 0x03,
  0x87, 0x38, 0xF8, 0xE1, 0xCE, 0x7F, 0x3C, 0xE7, 0x3D, 0xE7, 0xF9, 0xCE,
  0x38, 0xFC, 0xE3, 0x8F, 0x1C, 0x39, 0xC1, 0xC0, 0x1C, 0x70, 0x70, 0x07,
  0x1C, 0x1C, 0x03, 0x87, 0x07, 0x00, 0xE1, 0xC1, 0xC0, 0x78, 0x70, 0x70,
  0x1C, 0x0E, 0x3C, 0x0F, 0x03, 0x8E, 0x03, 0x80, 0xF7, 0x81, 0xE0, 0x1F,
  0xC0, 0x70, 0x03, 0xE0, 0x03, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80,
  0x0F, 0x9F, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0F,
  0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x07, 0x9F, 0x7C, 0x3C,
  0xF8, 0xF8, 0xF3, 0xC1, 0xF3, 0xCF, 0x03, 0xDE, 0x38, 0x07, 0xF8, 0xF0,
  0x0F, 0xC3, 0xC0, 0x3F, 0x0F, 0x00, 0xFC, 0x3E, 0x0F, 0xF8, 0x7F, 0xFF,
  0xF0, 0xFF, 0xE3, 0xE1, 0xFF, 0x07, 0xC0, 0xFF, 0xF7, 0x77, 0x77, 0x70,
  0x0F, 0x0E, 0x1C, 0x3C, 0x3C, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xF0, 0xF0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xF0, 0xF0, 0x70,
  0x78, 0x78, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x07, 0xF0, 0x3C, 0x0E, 0x07,
  0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xE0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1E, 0x0E,
  0x0F, 0x07, 0x83, 0x83, 0xC1, 0xC1, 0xC1, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x41, 0xC1, 0x79, 0x9F, 0x7F, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x07, 0xE0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x3C, 0x3C,
  0x0C, 0x30, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x3C, 0xF3, 0xDE, 0x79, 0xE7, 0x1C, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x73, 0xFF, 0xF7, 0x80, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8,
  0x3F, 0xFC, 0x78, 0x3C, 0x78, 0x1E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0xF0, 0x1E, 0xF0, 0x1E,
  0x70, 0x1E, 0x78, 0x3C, 0x7C, 0x3C, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0,
  0x03, 0xC1, 0xF1, 0xFC, 0xFF, 0x7F, 0xFE, 0xFE, 0x3D, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0x3F,
  0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0x70, 0x3C, 0x40, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x3F, 0xF0, 0xFF, 0xF8, 0xFD, 0xFC, 0x60,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0xF8, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0xC0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1D,
  0xC0, 0x0F, 0x70, 0x03, 0x9C, 0x01, 0xC7, 0x00, 0xF1, 0xC0, 0x38, 0x70,
  0x1E, 0x1C, 0x07, 0x07, 0x03, 0x81, 0xC1, 0xE0, 0x70, 0x70, 0x1C, 0x3C,
  0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x7F, 0xFC,
  0x7F, 0xFC, 0x7F, 0xFC, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC,
  0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x80, 0x3E, 0xC0, 0x7C, 0xFF, 0xFC, 0xFF, 0xF8,
  0x7F, 0xE0, 0x00, 0xFC, 0x07, 0xFC, 0x0F, 0xFC, 0x1F, 0xCC, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xE0,
  0xE7, 0xF8, 0xEF, 0xFC, 0xFE, 0x7E, 0xF8, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x78, 0x1E,
  0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC7,
  0xC3, 0xC0, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x38, 0x0F, 0x1E,
  0x0F, 0x0F, 0x8F, 0x83, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0xF0,
  0x7C, 0xFC, 0x3C, 0x1F, 0x3C, 0x07, 0x9C, 0x01, 0xEE, 0x00, 0xFF, 0x00,
  0x7B, 0x80, 0x3D, 0xE0, 0x1C, 0xF8, 0x1E, 0x3F, 0xFE, 0x0F, 0xFE, 0x03,
  0xFE, 0x00, 0x07, 0x80, 0x1F, 0xF0, 0x3F, 0xF8, 0x7E, 0xFC, 0xF8, 0x3C,
  0xF0, 0x1E, 0xF0, 0x1E, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x3F, 0x7F, 0xFF, 0x3F, 0xEE, 0x1F, 0xCE,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0xFF, 0xF7, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x7F, 0xFE, 0xF0, 0x3D, 0xF7, 0xDF,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xF3, 0x9E,
  0x79, 0xC7, 0x1C, 0xE0, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFE,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00,
  0x0F, 0x80, 0xFF, 0xCF, 0xFF, 0x9F, 0xFE, 0x60, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x81,
  0xF0, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0xE0,
  0x00, 0x0E, 0x78, 0x3F, 0xE3, 0xDC, 0x1F, 0xF8, 0x77, 0x0F, 0x0E, 0x1F,
  0x83, 0x83, 0x87, 0xE1, 0xC0, 0xE1, 0xF8, 0x70, 0x38, 0x7E, 0x1C, 0x0E,
  0x1F, 0x87, 0x03, 0x87, 0xE1, 0xC1, 0xE1, 0xF8, 0x70, 0x78, 0x7E, 0x1C,
  0x1E, 0x1F, 0x87, 0x8F, 0x8E, 0xE0, 0xFF, 0x7F, 0x9C, 0x3F, 0x9F, 0xC7,
  0x03, 0xC1, 0xC1, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x03, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0x78, 0x00, 0x3C, 0xE0, 0x00, 0xF3, 0xC0,
  0x03, 0x8F, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x0F,
  0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF1,
  0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xC0,
  0x01, 0xF0, 0xFF, 0xF8, 0x7F, 0xFF, 0x3F, 0xFF, 0xDE, 0x03, 0xEF, 0x00,
  0xF7, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xBC,
  0x1F, 0x9F, 0xFF, 0x0F, 0xFF, 0x87, 0xFF, 0xF3, 0xC0, 0x7D, 0xE0, 0x1F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x7F, 0xC0, 0xFD, 0xFF, 0xFC, 0xFF, 0xFC, 0x7F, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0xFF, 0xF0, 0xFF, 0xFC, 0x7F, 0xFE, 0x1F, 0x00, 0x8F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x06, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x78, 0x0F, 0xCF, 0x00, 0xF9, 0xE0,
  0x0F, 0xBC, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00,
  0x79, 0xE0, 0x1F, 0x3C, 0x1F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFE, 0xFF, 0xFB,
  0xFF, 0xEF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFB, 0xFF, 0xEF,
  0xFF, 0xBC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0x00, 0x63, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x7C,
  0x00, 0xF3, 0xC0, 0x0F, 0x3E, 0x00, 0xF1, 0xF8, 0x0F, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0x01, 0xFF, 0xC0, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3C, 0xFF, 0xFF, 0xF3, 0xF0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE1,
  0xFE, 0xFF, 0xFF, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0xF8, 0x7B, 0xFD, 0xFC, 0xFC, 0x00, 0xF0, 0x07, 0xFC, 0x03, 0xCF, 0x01,
  0xF3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x1E, 0x0F, 0x0F, 0x83, 0xC3, 0xC0,
  0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x7C, 0x03, 0xDE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x0F, 0xDE, 0x03, 0xE7, 0xC0, 0xF0, 0xF0, 0x3C, 0x1E, 0x0F, 0x07,
  0xC3, 0xC0, 0xF0, 0xF0, 0x3E, 0x3C, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x3E,
  0xF0, 0x07, 0xBC, 0x01, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xBF, 0xF8, 0x01, 0xDF, 0xFC, 0x01,
  0xEF, 0xEE, 0x00, 0xE7, 0xF7, 0x80, 0x73, 0xFB, 0xC0, 0x79, 0xFC, 0xE0,
  0x38, 0xFE, 0x78, 0x1C, 0x7F, 0x3C, 0x1E, 0x3F, 0x8E, 0x0E, 0x1F, 0xC7,
  0x87, 0x0F, 0xE3, 0xC7, 0x87, 0xF0, 0xE3, 0x83, 0xF8, 0x79, 0xC1, 0xFC,
  0x3D, 0xE0, 0xFE, 0x0E, 0xE0, 0x7F, 0x07, 0xF0, 0x3F, 0x83, 0xF8, 0x1F,
  0xC0, 0xF8, 0x0F, 0xE0, 0x7C, 0x07, 0xF0, 0x3E, 0x03, 0xF8, 0x0E, 0x01,
  0xC0, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF, 0x78, 0x0F, 0xF3, 0xC0, 0xFF,
  0x3C, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF0, 0xF0, 0xFF, 0x0F, 0x8F,
  0xF0, 0x78, 0xFF, 0x07, 0xCF, 0xF0, 0x3C, 0xFF, 0x01, 0xEF, 0xF0, 0x1E,
  0xFF, 0x00, 0xF7, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x01, 0xF0, 0xF0, 0x03, 0xC7, 0xC0,
  0x0F, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0x9E, 0x00,
  0x1E, 0x78, 0x00, 0x79, 0xF0, 0x03, 0xC3, 0xE0, 0x1F, 0x07, 0xE0, 0xF8,
  0x1F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF0, 0xFF,
  0xFC, 0xFF, 0xFE, 0xF0, 0x3E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x3E, 0xF0, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0x01, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0x78,
  0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xF0,
  0x03, 0xE3, 0xE0, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0xFF, 0xF0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xC0, 0xF8, 0xF0, 0x1F, 0x3C, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE3, 0xC0, 0xF8, 0xFF,
  0xFC, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0xC3, 0xC0, 0xF0, 0xF8, 0x3C, 0x1E,
  0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x00, 0xF3,
  0xC0, 0x3E, 0xF0, 0x07, 0xBC, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xFC, 0xFF,
  0xF3, 0xFF, 0xEF, 0x80, 0xDE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x0F, 0xF0, 0x3E, 0xFF, 0xF9, 0xFF, 0xE1, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xEF, 0x80, 0x3C, 0xF0,
  0x0F, 0x9F, 0x83, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0xFF, 0x80, 0xF0,
  0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xC3, 0x80, 0x1E,
  0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x78, 0x1E, 0x03, 0xC0, 0xF0,
  0x1E, 0x07, 0x81, 0xE0, 0x1C, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0x80,
  0x1C, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8E, 0x00, 0x1C, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x78, 0x03, 0xC0, 0x1E, 0x78, 0x07, 0xE0, 0x1E, 0x78, 0x07, 0xE0, 0x1E,
  0x78, 0x07, 0xE0, 0x1E, 0x38, 0x07, 0xE0, 0x3C, 0x3C, 0x0F, 0xF0, 0x3C,
  0x3C, 0x0E, 0xF0, 0x3C, 0x3C, 0x0E, 0x70, 0x3C, 0x1C, 0x0E, 0x70, 0x38,
  0x1E, 0x1E, 0x78, 0x78, 0x1E, 0x1C, 0x78, 0x78, 0x1E, 0x1C, 0x38, 0x78,
  0x0E, 0x3C, 0x38, 0x70, 0x0F, 0x3C, 0x3C, 0xF0, 0x0F, 0x38, 0x3C, 0xF0,
  0x0F, 0x38, 0x1C, 0xF0, 0x0F, 0x38, 0x1C, 0xE0, 0x07, 0x78, 0x1F, 0xE0,
  0x07, 0xF0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC1,
  0xE0, 0x78, 0x1F, 0x07, 0x80, 0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x79, 0xE0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x07, 0x9E, 0x00, 0x79,
  0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C,
  0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xEF,
  0x00, 0x79, 0xE0, 0x0F, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x1F, 0x07,
  0x83, 0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xDC,
  0x00, 0x77, 0x80, 0x38, 0xE0, 0x0E, 0x3C, 0x07, 0x87, 0x01, 0xC1, 0xE0,
  0xF0, 0x38, 0x38, 0x0F, 0x1E, 0x01, 0xC7, 0x00, 0x79, 0xC0, 0x0E, 0xE0,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x1E, 0x0E,
  0x07, 0x03, 0x0F, 0xF8, 0x3F, 0xFC, 0x1F, 0xFE, 0x18, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0x8F,
  0x7C, 0x0F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x1F, 0x78, 0x1F, 0x78, 0x3F,
  0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0xC7, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF3, 0xF0,
  0xEF, 0xFC, 0xEF, 0xFC, 0xFC, 0x3E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1E, 0xF8, 0x3E, 0xFF, 0xFC, 0xEF, 0xFC,
  0xE3, 0xF0, 0x0F, 0xF8, 0xFF, 0xCF, 0xFE, 0xF8, 0x27, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x09, 0xFF, 0xC7, 0xFE, 0x1F, 0xE0, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x0F, 0xCF, 0x3F, 0xF7, 0x3F, 0xF7, 0x7C, 0x3F, 0x78,
  0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1F, 0x7C,
  0x1F, 0x3F, 0xF7, 0x3F, 0xF7, 0x0F, 0xC7, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x78, 0x3C, 0x78, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x06, 0x3F, 0xFE, 0x1F, 0xFE, 0x0F, 0xFC, 0x07,
  0xF0, 0xFF, 0x1F, 0xF1, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7F,
  0xEF, 0xFE, 0xFF, 0xE1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0F, 0xC7, 0x3F, 0xF7, 0x3F, 0xF7, 0x7C,
  0x3F, 0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78,
  0x1F, 0x7C, 0x1F, 0x3F, 0xF7, 0x3F, 0xFF, 0x0F, 0xCF, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x40, 0x1E, 0x7C, 0x7E, 0x7F, 0xFC, 0x7F,
  0xF8, 0x1F, 0xE0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF3, 0xF9, 0xDF, 0xFB, 0xBF, 0xFF,
  0xE1, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x70, 0x4F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x02, 0x03,
  0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x4F,
  0xBF, 0xDF, 0xC7, 0x80, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0xF0, 0x3C,
  0xF0, 0x78, 0xF0, 0xF0, 0xF1, 0xF0, 0xF1, 0xE0, 0xF3, 0xC0, 0xE7, 0x80,
  0xEF, 0x00, 0xEF, 0x80, 0xFF, 0xC0, 0xFB, 0xC0, 0xF1, 0xE0, 0xF1, 0xF0,
  0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x3E, 0xF0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE3, 0xF0, 0x7E, 0x3B, 0xFE, 0x7F, 0xEE, 0xFF, 0xDF, 0xFB,
  0xF0, 0xFE, 0x1F, 0xF8, 0x3F, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01, 0xE0,
  0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF, 0x01,
  0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80, 0xFF,
  0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03, 0xFC, 0x07, 0x80,
  0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xE3, 0xF9, 0xDF, 0xFB, 0xBF,
  0xFF, 0xE1, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x70, 0x0F, 0xF0, 0x0F,
  0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xC7, 0x80, 0xF7, 0x80, 0x7B, 0xC0, 0x3D,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x7B, 0xC0, 0x3C, 0xF0, 0x1E, 0x7C, 0x1E, 0x1F, 0xFF, 0x07,
  0xFF, 0x01, 0xFE, 0x00, 0xE3, 0xF0, 0xEF, 0xFC, 0xEF, 0xFC, 0xFC, 0x3E,
  0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1E,
  0xFC, 0x3E, 0xEF, 0xFC, 0xEF, 0xFC, 0xF3, 0xF0, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x0F, 0xC7, 0x3F, 0xF7, 0x3F, 0xF7, 0x7C, 0x3F, 0x78, 0x1F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1F, 0x7C, 0x1F,
  0x3F, 0xF7, 0x3F, 0xFF, 0x0F, 0xCF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0xE3, 0xFC, 0xFF, 0xBF, 0x7F, 0x9F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x00, 0x3F, 0xE3, 0xFF, 0xBF, 0xFD, 0xE0, 0x4E, 0x00,
  0x70, 0x03, 0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xE0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF,
  0x80, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x07, 0xFF, 0xFF, 0xFF, 0xF9, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3F, 0xC7, 0xF8, 0x7F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xFC, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0xFF, 0xFD, 0xFF, 0xB9, 0xFE, 0x70,
  0xF0, 0x07, 0xDC, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1C, 0x38, 0x0F, 0x0F,
  0x03, 0xC3, 0xC0, 0xE0, 0x70, 0x78, 0x1E, 0x1E, 0x07, 0x87, 0x00, 0xE3,
  0xC0, 0x38, 0xF0, 0x0F, 0x38, 0x01, 0xCE, 0x00, 0x77, 0x80, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x80, 0xF0, 0x0F, 0x01,
  0xEF, 0x03, 0xE0, 0x3D, 0xE0, 0x7C, 0x07, 0x3C, 0x0F, 0xC1, 0xE3, 0x83,
  0xB8, 0x3C, 0x70, 0x77, 0x07, 0x8F, 0x0E, 0xE0, 0xE1, 0xE1, 0xCE, 0x3C,
  0x1C, 0x79, 0xC7, 0x83, 0x8E, 0x38, 0xF0, 0x79, 0xC7, 0x9C, 0x0F, 0x38,
  0x73, 0x80, 0xEF, 0x0E, 0xF0, 0x1D, 0xC1, 0xDE, 0x03, 0xB8, 0x3B, 0x80,
  0x7F, 0x07, 0x70, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x01,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x78, 0x07, 0x8F, 0x03, 0xC3, 0xC0, 0xF0,
  0x78, 0x78, 0x1F, 0x1E, 0x03, 0xCF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x78, 0x78, 0x1E, 0x1E, 0x0F, 0x03, 0xC7, 0xC0, 0xFB,
  0xE0, 0x1F, 0xF0, 0x07, 0xDE, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x38,
  0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x70, 0x78, 0x1E, 0x1E, 0x07, 0x87,
  0x80, 0xE3, 0xC0, 0x3C, 0xF0, 0x0F, 0x38, 0x01, 0xCE, 0x00, 0x7F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x27, 0xE0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xDF,
  0xFE, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x7F, 0x07, 0xF0, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xE0, 0xFE, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x7F, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x0F, 0xC0, 0xFE, 0x01,
  0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xE0, 0x3E, 0x0F, 0xE0, 0xFC, 0x0F, 0x00, 0x0C, 0x00, 0xBF, 0xC0, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFC, 0x0F, 0xF4, 0x00, 0x40,
};

const GFXglyph NotoSans_SemiCondensed_Medium37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 26, 10, 2, -26 },
  { 18, 11, 9, 15, 2, -26 },
  { 31, 20, 26, 22, 1, -26 },
  { 96, 16, 30, 19, 2, -28 },
  { 156, 26, 27, 29, 2, -27 },
  { 244, 22, 27, 24, 2, -27 },
  { 319, 4, 9, 8, 2, -26 },
  { 324, 8, 32, 11, 2, -26 },
  { 356, 9, 32, 11, 1, -26 },
  { 392, 16, 15, 18, 1, -28 },
  { 422, 16, 18, 19, 2, -22 },
  { 458, 6, 9, 10, 1, -4 },
  { 465, 9, 4, 11, 1, -12 },
  { 470, 5, 5, 10, 2, -5 },
  { 474, 14, 27, 14, 0, -27 },
  { 522, 16, 27, 19, 2, -27 },
  { 576, 10, 26, 19, 3, -26 },
  { 609, 16, 27, 19, 2, -27 },
  { 663, 16, 27, 19, 2, -27 },
  { 717, 18, 27, 19, 1, -27 },
  { 778, 16, 26, 19, 2, -26 },
  { 830, 16, 27, 19, 2, -27 },
  { 884, 17, 26, 19, 1, -26 },
  { 940, 17, 27, 19, 1, -27 },
  { 998, 16, 27, 19, 2, -27 },
  { 1052, 5, 20, 10, 2, -20 },
  { 1065, 6, 25, 10, 1, -20 },
  { 1084, 16, 18, 19, 2, -22 },
  { 1120, 16, 10, 19, 2, -18 },
  { 1140, 16, 18, 19, 2, -22 },
  { 1176, 14, 27, 15, 0, -27 },
  { 1224, 26, 30, 30, 2, -27 },
  { 1322, 22, 26, 22, 0, -26 },
  { 1394, 17, 26, 22, 3, -26 },
  { 1450, 18, 27, 21, 2, -27 },
  { 1511, 19, 26, 24, 3, -26 },
  { 1573, 14, 26, 19, 3, -26 },
  { 1619, 14, 26, 18, 3, -26 },
  { 1665, 20, 27, 25, 2, -27 },
  { 1733, 19, 26, 25, 3, -26 },
  { 1795, 10, 26, 12, 1, -26 },
  { 1828, 9, 33, 10, -2, -26 },
  { 1866, 18, 26, 21, 3, -26 },
  { 1925, 14, 26, 18, 3, -26 },
  { 1971, 25, 26, 31, 3, -26 },
  { 2053, 20, 26, 26, 3, -26 },
  { 2118, 22, 27, 26, 2, -27 },
  { 2193, 16, 26, 21, 3, -26 },
  { 2245, 22, 33, 26, 2, -27 },
  { 2336, 18, 26, 21, 3, -26 },
  { 2395, 15, 27, 19, 2, -27 },
  { 2446, 18, 26, 19, 0, -26 },
  { 2505, 19, 26, 25, 3, -26 },
  { 2567, 21, 26, 21, 0, -26 },
  { 2636, 32, 26, 32, 0, -26 },
  { 2740, 20, 26, 20, 0, -26 },
  { 2805, 19, 26, 19, 0, -26 },
  { 2867, 17, 26, 19, 1, -26 },
  { 2923, 8, 32, 12, 3, -26 },
  { 2955, 14, 27, 14, 0, -27 },
  { 3003, 8, 32, 12, 1, -26 },
  { 3035, 18, 17, 20, 1, -27 },
  { 3074, 16, 3, 16, 0, 3 },
  { 3080, 8, 6, 11, 1, -28 },
  { 3086, 16, 20, 19, 1, -20 },
  { 3126, 16, 28, 21, 3, -28 },
  { 3182, 13, 20, 16, 2, -20 },
  { 3215, 16, 28, 21, 2, -28 },
  { 3271, 16, 20, 19, 2, -20 },
  { 3311, 12, 28, 12, 1, -28 },
  { 3353, 16, 29, 21, 2, -20 },
  { 3411, 15, 28, 21, 3, -28 },
  { 3464, 4, 28, 9, 3, -28 },
  { 3478, 9, 37, 9, -2, -28 },
  { 3520, 16, 28, 19, 3, -28 },
  { 3576, 4, 28, 9, 3, -28 },
  { 3590, 26, 20, 32, 3, -20 },
  { 3655, 15, 20, 21, 3, -20 },
  { 3693, 17, 20, 21, 2, -20 },
  { 3736, 16, 29, 21, 3, -20 },
  { 3794, 16, 29, 21, 2, -20 },
  { 3852, 11, 20, 14, 3, -20 },
  { 3880, 13, 20, 16, 2, -20 },
  { 3913, 11, 24, 13, 1, -24 },
  { 3946, 15, 20, 21, 3, -20 },
  { 3984, 18, 20, 18, 0, -20 },
  { 4029, 27, 20, 27, 0, -20 },
  { 4097, 18, 20, 18, 0, -20 },
  { 4142, 18, 29, 18, 0, -20 },
  { 4208, 13, 20, 16, 1, -20 },
  { 4241, 12, 32, 14, 1, -26 },
  { 4289, 3, 37, 19, 8, -28 },
  { 4303, 12, 32, 14, 1, -26 },
  { 4351, 17, 6, 19, 1, -16 },
};

const GFXfont NotoSans_SemiCondensed_Medium37pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium37pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium37pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM37PT7B_H_
