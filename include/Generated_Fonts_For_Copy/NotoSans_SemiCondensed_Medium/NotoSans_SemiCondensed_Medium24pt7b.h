#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM24PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x6D, 0xB6, 0xDB, 0x60, 0x37, 0xE0, 0xE7, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0x8C, 0x18, 0xCF, 0xFF, 0xFF,
  0xF1, 0x98, 0x19, 0x81, 0x18, 0xFF, 0xFF, 0xFF, 0x31, 0x83, 0x30, 0x33,
  0x02, 0x30, 0x63, 0x00, 0x04, 0x01, 0x03, 0xFD, 0xFF, 0xE4, 0x79, 0x0E,
  0x41, 0xD0, 0x7C, 0x07, 0xE0, 0x7C, 0x17, 0x04, 0xC1, 0x3C, 0x5F, 0xFE,
  0x3E, 0x01, 0x00, 0x40, 0x7C, 0x1C, 0x36, 0x0C, 0x31, 0x8C, 0x18, 0xC6,
  0x0C, 0x66, 0x06, 0x33, 0x03, 0x1B, 0x11, 0x8D, 0xBE, 0x6D, 0xDB, 0xBE,
  0xD8, 0xC0, 0xEC, 0x60, 0x66, 0x30, 0x33, 0x18, 0x31, 0x8C, 0x18, 0x46,
  0x18, 0x3E, 0x1C, 0x0F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xC6, 0x03, 0x8C,
  0x03, 0x18, 0x06, 0x70, 0x0F, 0xC0, 0x0F, 0x00, 0x3E, 0x1C, 0xEE, 0x3B,
  0x8E, 0x67, 0x0F, 0xCE, 0x0F, 0x1C, 0x1E, 0x38, 0x7C, 0x3F, 0xFC, 0x3F,
  0x1E, 0xED, 0xB6, 0xC0, 0x1C, 0xE3, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x0C,
  0x30, 0xE3, 0x8E, 0x18, 0x61, 0xC3, 0x06, 0x1C, 0xC3, 0x1C, 0x63, 0x1C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0xE7, 0x33, 0x98, 0xCC, 0x00, 0x0C, 0x03,
  0x00, 0xC3, 0xB7, 0xFF, 0xC7, 0x01, 0xE0, 0xCC, 0x73, 0x84, 0x80, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC1, 0xFF, 0xFF, 0xF8, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x00, 0x76, 0x6E, 0xCC, 0xFF, 0xFF, 0xC0, 0xDF, 0x80, 0x03,
  0x81, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x06, 0x07,
  0x03, 0x01, 0x81, 0xC0, 0xC0, 0xE0, 0x00, 0x3F, 0x0F, 0xF1, 0xC7, 0x30,
  0xEE, 0x0D, 0xC1, 0xB8, 0x37, 0x06, 0xE0, 0xFC, 0x1B, 0x83, 0x70, 0x6E,
  0x0C, 0xC3, 0x9C, 0x71, 0xFC, 0x1F, 0x00, 0x0C, 0xF7, 0xFB, 0xCC, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0x3F, 0xE4, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x06, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x3F, 0xE4, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x38, 0xFC, 0x3F, 0x00, 0xF0, 0x1C, 0x03, 0x00, 0xC0, 0x78,
  0x1F, 0xFE, 0xFF, 0x00, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x6C, 0x06, 0xC0,
  0xCC, 0x1C, 0xC1, 0x8C, 0x30, 0xC3, 0x0C, 0x60, 0xCF, 0xFF, 0xFF, 0xF0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x7F, 0x9F, 0xE6, 0x01, 0x80, 0x60,
  0x18, 0x06, 0xE1, 0xFE, 0x77, 0xC0, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x78,
  0x1F, 0xFE, 0x7F, 0x00, 0x0F, 0x87, 0xF0, 0xE0, 0x38, 0x06, 0x01, 0xC0,
  0x3B, 0xC7, 0xFC, 0xF1, 0xDC, 0x1B, 0x83, 0x70, 0x7E, 0x0E, 0xC1, 0x9C,
  0x71, 0xFC, 0x1F, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xE0, 0x18, 0x03,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x38, 0x00, 0x3F, 0x0F, 0xF1, 0x87, 0x70, 0x66, 0x0C, 0xC3,
  0x9E, 0xE1, 0xF8, 0x3F, 0x0E, 0x73, 0x87, 0x70, 0x6C, 0x0F, 0x81, 0xB8,
  0x73, 0xFE, 0x3F, 0x00, 0x3F, 0x1F, 0xE6, 0x1F, 0x87, 0xC0, 0xF0, 0x3E,
  0x0F, 0x87, 0x73, 0xDF, 0xB1, 0xCC, 0x03, 0x01, 0xC0, 0x60, 0x39, 0xFC,
  0x7E, 0x00, 0xDF, 0x80, 0x00, 0x03, 0x7E, 0x67, 0x60, 0x00, 0x00, 0x00,
  0x76, 0x6E, 0xCC, 0x00, 0x60, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0xF0, 0xF8, 0x7C, 0x1E, 0x02, 0x00, 0x00, 0x7F, 0x7F, 0xD0, 0xE0,
  0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06, 0x03, 0x00, 0x00, 0x00,
  0x60, 0x78, 0x18, 0x00, 0x03, 0xF8, 0x07, 0xDE, 0x07, 0x01, 0x86, 0x00,
  0x67, 0x0E, 0x1B, 0x1F, 0xCD, 0x9C, 0x67, 0x8C, 0x33, 0xC6, 0x39, 0xE3,
  0x18, 0xF1, 0x8C, 0x78, 0xC6, 0x3C, 0x77, 0xB3, 0x1E, 0x79, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x08, 0x0F, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xF0, 0x0C, 0xC0, 0x33, 0x01, 0xCE, 0x07, 0x18, 0x18,
  0x60, 0xE1, 0xC3, 0xFF, 0x0F, 0xFC, 0x70, 0x39, 0xC0, 0xE6, 0x01, 0xB8,
  0x07, 0xE0, 0x1C, 0xFF, 0x1F, 0xFB, 0x87, 0x70, 0x7E, 0x0F, 0xC1, 0xB8,
  0x77, 0xFC, 0xFF, 0x9C, 0x3B, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x7F,
  0xFE, 0xFF, 0x00, 0x0F, 0xF1, 0xFF, 0x38, 0x27, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00,
  0x3C, 0x11, 0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xFC, 0xE1, 0xEE, 0x0E, 0xE0,
  0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x7E, 0x0E, 0xE3, 0xEF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xFE, 0xFF, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xFF, 0x7F, 0xB8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x00, 0x0F,
  0xF8, 0xFF, 0xCF, 0x04, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0xFF, 0x07, 0xF8, 0x06, 0xC0, 0x37, 0x01, 0xB8, 0x0C, 0xF0, 0x63,
  0xFF, 0x0F, 0xF8, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x30, 0xFF, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x3F, 0xFC, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x37, 0xEF,
  0x8E, 0x00, 0xE0, 0xFE, 0x0C, 0xE1, 0xCE, 0x38, 0xE7, 0x0E, 0x60, 0xEE,
  0x0F, 0xC0, 0xFE, 0x0F, 0xE0, 0xE7, 0x0E, 0x30, 0xE3, 0x8E, 0x1C, 0xE1,
  0xCE, 0x0E, 0xE0, 0x70, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0x80,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xD8, 0x0F, 0xD8, 0x1B, 0xD8, 0x1B,
  0xCC, 0x1B, 0xCC, 0x33, 0xCC, 0x33, 0xC6, 0x33, 0xC6, 0x63, 0xC6, 0x63,
  0xC3, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC1, 0xC3, 0xC1, 0x83, 0xE0, 0x1F,
  0x80, 0xFE, 0x07, 0xF0, 0x3D, 0xC1, 0xE6, 0x0F, 0x38, 0x78, 0xC3, 0xC7,
  0x1E, 0x18, 0xF0, 0xE7, 0x83, 0xBC, 0x1D, 0xE0, 0x7F, 0x03, 0xF8, 0x0F,
  0xC0, 0x38, 0x0F, 0xE0, 0x7F, 0xE0, 0xE0, 0xE3, 0x80, 0xE7, 0x01, 0xCC,
  0x01, 0xB8, 0x03, 0x70, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x33, 0x00,
  0x67, 0x01, 0xCE, 0x03, 0x8E, 0x0E, 0x0F, 0xF8, 0x0F, 0xE0, 0xFF, 0x3F,
  0xEE, 0x3F, 0x87, 0xE0, 0xF8, 0x3E, 0x1F, 0x87, 0xFF, 0xBF, 0xCF, 0x83,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0xE0,
  0xE0, 0xE3, 0x80, 0xE7, 0x01, 0xCC, 0x01, 0xB8, 0x03, 0x70, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x33, 0x00, 0x67, 0x01, 0xCE, 0x03, 0x8E, 0x0E,
  0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0xFF, 0x0F, 0xF8, 0xE1, 0xCE, 0x1C, 0xE0, 0xCE, 0x0C, 0xE1, 0xCE, 0x3C,
  0xFF, 0x8F, 0xE0, 0xE7, 0x0E, 0x30, 0xE3, 0x8E, 0x1C, 0xE1, 0xCE, 0x0E,
  0xE0, 0xF0, 0x3F, 0xDF, 0xE6, 0x0B, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xC0, 0x7C, 0x3F, 0xFE, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0x70,
  0xE7, 0xFE, 0x1F, 0x80, 0xE0, 0x1B, 0x01, 0xD8, 0x0E, 0xE0, 0x67, 0x07,
  0x18, 0x38, 0xE1, 0x87, 0x0C, 0x18, 0xE0, 0xC6, 0x07, 0x30, 0x1B, 0x80,
  0xD8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x70, 0x3B, 0x03,
  0x81, 0x98, 0x3C, 0x1C, 0xC1, 0xE0, 0xE7, 0x0D, 0x86, 0x38, 0x6C, 0x30,
  0xC7, 0x63, 0x86, 0x33, 0x1C, 0x39, 0x8C, 0xC1, 0xCC, 0x66, 0x06, 0xE3,
  0x30, 0x36, 0x1B, 0x81, 0xB0, 0x7C, 0x0F, 0x83, 0xC0, 0x3C, 0x1E, 0x01,
  0xC0, 0xF0, 0x0E, 0x03, 0x80, 0xF0, 0x7B, 0x83, 0x8E, 0x38, 0x31, 0xC1,
  0xDC, 0x06, 0xC0, 0x3E, 0x00, 0xE0, 0x07, 0x00, 0x7C, 0x03, 0x60, 0x3B,
  0x81, 0x8C, 0x1C, 0x71, 0xC1, 0xCE, 0x0E, 0xE0, 0x38, 0xE0, 0x3B, 0x03,
  0x9C, 0x18, 0x61, 0xC3, 0x8C, 0x0C, 0xE0, 0x76, 0x01, 0xF0, 0x0F, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x0C,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF,
  0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x1C, 0x06,
  0x03, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xFF, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFF, 0x80, 0x0C,
  0x01, 0xC0, 0x78, 0x0D, 0x83, 0x30, 0x63, 0x18, 0x63, 0x06, 0xE0, 0xD8,
  0x0C, 0xFF, 0xFF, 0xF0, 0xE3, 0x8E, 0x3F, 0x1F, 0xE2, 0x1C, 0x07, 0x01,
  0xC7, 0xF7, 0xFF, 0x87, 0xE1, 0xF0, 0x7E, 0x3F, 0xFB, 0x7C, 0xC0, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0xCF, 0xFB, 0x87, 0xE1, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x1F, 0x87, 0xFF, 0xB7, 0xC0, 0x1F, 0x9F,
  0xDC, 0x2C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x27, 0xF1,
  0xF8, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x7D, 0xDF, 0xFB, 0x8F,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3B, 0x8F, 0x7F,
  0xE7, 0xCC, 0x1F, 0x0F, 0xE7, 0x1D, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0x80,
  0xE0, 0x18, 0x07, 0x04, 0xFF, 0x1F, 0xC0, 0x1F, 0x8F, 0x8E, 0x07, 0x03,
  0x83, 0xFB, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x00, 0x1E, 0x6F, 0xED, 0xC7, 0xB0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1D, 0xC7, 0xBF, 0xF3, 0xEE, 0x01, 0xC0,
  0x38, 0x06, 0x63, 0xCF, 0xF0, 0xF8, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x37, 0xCF, 0xFB, 0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x70, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x18,
  0xC6, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0xDF, 0xFC, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x7C, 0x3B, 0x1C,
  0xCE, 0x37, 0x0D, 0x83, 0xF0, 0xEE, 0x31, 0x8C, 0x73, 0x0E, 0xC3, 0xB0,
  0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xDF, 0x1E, 0x7F, 0xDF, 0xB8, 0xF8,
  0xFC, 0x38, 0x7C, 0x1C, 0x3E, 0x0E, 0x1F, 0x07, 0x0F, 0x83, 0x87, 0xC1,
  0xC3, 0xE0, 0xE1, 0xF0, 0x70, 0xF8, 0x38, 0x7C, 0x1C, 0x38, 0xDF, 0x3F,
  0xEE, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xC0, 0x1F, 0x07, 0xF9, 0xC7, 0x30, 0x7E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0xEC, 0x1D, 0xC3, 0x1F, 0xE1, 0xF0, 0xDF, 0x3F, 0xEE,
  0x1F, 0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x7E, 0x1F, 0xFE,
  0xDF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1E, 0x6F, 0xED,
  0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1D, 0xC7,
  0xBF, 0xF3, 0xEE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0xCF, 0xBF, 0xC7, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x00,
  0x3F, 0x3F, 0xB8, 0x58, 0x0E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0x01, 0xE0,
  0xDF, 0xEF, 0xE0, 0x10, 0x30, 0x30, 0x7F, 0xFF, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x38, 0x3F, 0x1F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x3F, 0xFB, 0x7C, 0xC0,
  0xE0, 0x6C, 0x1D, 0x83, 0xB8, 0x63, 0x1C, 0x63, 0x8E, 0x60, 0xCC, 0x1B,
  0x83, 0x60, 0x3C, 0x07, 0x80, 0xE0, 0xE1, 0xC1, 0xD8, 0x78, 0x66, 0x1E,
  0x19, 0xC7, 0x8E, 0x73, 0x63, 0x0C, 0xCC, 0xC3, 0x33, 0x30, 0xCC, 0xDC,
  0x3E, 0x36, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x78, 0x78, 0x1C, 0x1C, 0x00,
  0xE0, 0xEE, 0x18, 0xE7, 0x0D, 0xC1, 0xF8, 0x1E, 0x03, 0x80, 0x78, 0x1F,
  0x87, 0x30, 0xC7, 0x38, 0x6E, 0x0E, 0xE0, 0x6C, 0x1D, 0x83, 0xB8, 0x63,
  0x1C, 0x63, 0x8E, 0x60, 0xCC, 0x1B, 0x83, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x1C, 0x1F, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0x07,
  0x0E, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0x0E, 0x3C,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x39, 0xE3, 0x83, 0x83, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0x70, 0xF0, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1,
  0xE0, 0xC1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x3C, 0x38, 0xE3, 0x87, 0x0E,
  0x1C, 0x38, 0x71, 0xC7, 0x8C, 0x00, 0x78, 0x3F, 0xFE, 0x1F, 0x00,
};

const GFXglyph NotoSans_SemiCondensed_Medium24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 17, 6, 2, -17 },
  { 8, 8, 6, 10, 1, -17 },
  { 14, 12, 17, 14, 1, -17 },
  { 40, 10, 19, 13, 1, -18 },
  { 64, 17, 17, 19, 1, -17 },
  { 101, 15, 17, 16, 1, -17 },
  { 133, 3, 6, 6, 1, -17 },
  { 136, 6, 21, 7, 1, -17 },
  { 152, 5, 21, 7, 1, -17 },
  { 166, 10, 10, 12, 1, -18 },
  { 179, 11, 11, 13, 1, -14 },
  { 195, 4, 6, 6, 1, -3 },
  { 198, 6, 3, 7, 1, -8 },
  { 201, 3, 3, 6, 2, -3 },
  { 203, 9, 17, 9, 0, -17 },
  { 223, 11, 17, 13, 1, -17 },
  { 247, 6, 17, 13, 2, -17 },
  { 260, 10, 17, 13, 1, -17 },
  { 282, 10, 17, 13, 1, -17 },
  { 304, 12, 17, 13, 0, -17 },
  { 330, 10, 17, 13, 1, -17 },
  { 352, 11, 17, 13, 1, -17 },
  { 376, 11, 17, 13, 1, -17 },
  { 400, 11, 17, 13, 1, -17 },
  { 424, 10, 17, 13, 1, -17 },
  { 446, 3, 13, 6, 2, -13 },
  { 451, 4, 16, 6, 1, -13 },
  { 459, 11, 11, 13, 1, -14 },
  { 475, 10, 7, 13, 1, -12 },
  { 484, 11, 11, 13, 1, -14 },
  { 500, 9, 17, 10, 0, -17 },
  { 520, 17, 19, 20, 1, -17 },
  { 561, 14, 17, 14, 0, -17 },
  { 591, 11, 17, 14, 2, -17 },
  { 615, 12, 17, 14, 1, -17 },
  { 641, 12, 17, 16, 2, -17 },
  { 667, 9, 17, 12, 2, -17 },
  { 687, 9, 17, 12, 2, -17 },
  { 707, 13, 17, 16, 1, -17 },
  { 735, 12, 17, 16, 2, -17 },
  { 761, 6, 17, 8, 1, -17 },
  { 774, 7, 22, 7, -2, -17 },
  { 794, 12, 17, 14, 2, -17 },
  { 820, 9, 17, 11, 2, -17 },
  { 840, 16, 17, 20, 2, -17 },
  { 874, 13, 17, 17, 2, -17 },
  { 902, 15, 17, 17, 1, -17 },
  { 934, 10, 17, 13, 2, -17 },
  { 956, 15, 21, 17, 1, -17 },
  { 996, 12, 17, 14, 2, -17 },
  { 1022, 10, 17, 12, 1, -17 },
  { 1044, 12, 17, 12, 0, -17 },
  { 1070, 12, 17, 16, 2, -17 },
  { 1096, 13, 17, 13, 0, -17 },
  { 1124, 21, 17, 21, 0, -17 },
  { 1169, 13, 17, 13, 0, -17 },
  { 1197, 13, 17, 13, 0, -17 },
  { 1225, 10, 17, 12, 1, -17 },
  { 1247, 5, 21, 8, 2, -17 },
  { 1261, 9, 17, 9, 0, -17 },
  { 1281, 5, 21, 8, 1, -17 },
  { 1295, 11, 10, 13, 1, -17 },
  { 1309, 10, 2, 10, 0, 2 },
  { 1312, 5, 3, 7, 1, -18 },
  { 1314, 10, 13, 12, 1, -13 },
  { 1331, 10, 18, 14, 2, -18 },
  { 1354, 9, 13, 11, 1, -13 },
  { 1369, 11, 18, 14, 1, -18 },
  { 1394, 10, 13, 13, 1, -13 },
  { 1411, 9, 18, 8, 0, -18 },
  { 1432, 11, 19, 14, 1, -13 },
  { 1459, 10, 18, 14, 2, -18 },
  { 1482, 2, 18, 6, 2, -18 },
  { 1487, 5, 24, 6, -1, -18 },
  { 1502, 10, 18, 12, 2, -18 },
  { 1525, 2, 18, 6, 2, -18 },
  { 1530, 17, 13, 21, 2, -13 },
  { 1558, 10, 13, 14, 2, -13 },
  { 1575, 11, 13, 13, 1, -13 },
  { 1593, 10, 19, 14, 2, -13 },
  { 1617, 11, 19, 14, 1, -13 },
  { 1644, 7, 13, 9, 2, -13 },
  { 1656, 9, 13, 10, 1, -13 },
  { 1671, 8, 16, 8, 0, -16 },
  { 1687, 10, 13, 14, 2, -13 },
  { 1704, 11, 13, 11, 0, -13 },
  { 1722, 18, 13, 18, 0, -13 },
  { 1752, 11, 13, 12, 0, -13 },
  { 1770, 11, 19, 11, 0, -13 },
  { 1797, 8, 13, 10, 1, -13 },
  { 1810, 7, 21, 9, 1, -17 },
  { 1829, 2, 24, 12, 5, -18 },
  { 1835, 7, 21, 9, 1, -17 },
  { 1854, 11, 3, 13, 1, -10 },
};

const GFXfont NotoSans_SemiCondensed_Medium24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium24pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM24PT7B_H_
