#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM10PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xF4, 0x28, 0xA7, 0xD4, 0xF9, 0x45, 0x00, 0x4F, 0xCC, 0x65,
  0xF4, 0x40, 0x64, 0xA8, 0xA8, 0x76, 0x15, 0x25, 0x26, 0x70, 0xA1, 0x43,
  0x2D, 0x59, 0x1D, 0x80, 0xC0, 0x69, 0x48, 0x92, 0x20, 0xC9, 0x12, 0x52,
  0x80, 0x21, 0x3E, 0xA5, 0x00, 0x21, 0x3E, 0x42, 0x00, 0x70, 0xE0, 0x80,
  0x12, 0x24, 0x44, 0x80, 0x72, 0x73, 0x1C, 0xA5, 0xC0, 0x7D, 0xB6, 0xD8,
  0xF0, 0x44, 0x22, 0x23, 0xE0, 0xF0, 0x44, 0xE0, 0x87, 0xC0, 0x11, 0x94,
  0xA9, 0x3C, 0x40, 0xE8, 0x8E, 0x11, 0xE0, 0x72, 0x19, 0xBC, 0xA5, 0xC0,
  0xF8, 0x84, 0x22, 0x11, 0x00, 0x72, 0x54, 0xE4, 0xC5, 0xC0, 0x76, 0x62,
  0xF0, 0x89, 0xC0, 0x88, 0x40, 0x60, 0x09, 0xB0, 0x60, 0x80, 0xF8, 0x3E,
  0xC1, 0x06, 0xC8, 0x00, 0xF1, 0x32, 0x40, 0x40, 0x79, 0x0A, 0xEE, 0x5C,
  0xB7, 0xA0, 0x3C, 0x30, 0xC5, 0x12, 0x7B, 0x28, 0x40, 0xF9, 0x9F, 0x99,
  0xF0, 0x78, 0x88, 0x88, 0x70, 0xF4, 0xE3, 0x18, 0xCF, 0xC0, 0xF2, 0x79,
  0x38, 0xF2, 0x79, 0x20, 0x7C, 0x21, 0x38, 0xC5, 0xE0, 0x8C, 0x63, 0xF8,
  0xC6, 0x20, 0xE9, 0x24, 0xB8, 0x24, 0x92, 0x49, 0xC0, 0x9D, 0x29, 0xCA,
  0x4A, 0x60, 0x88, 0x88, 0x88, 0xF0, 0xC7, 0x8F, 0x2D, 0x5A, 0xB6, 0x64,
  0x80, 0x8E, 0x7B, 0x59, 0xCE, 0x20, 0xFC, 0x63, 0x18, 0xC5, 0xC0, 0xF9,
  0x9F, 0x88, 0x80, 0xFC, 0x63, 0x18, 0xC5, 0xC2, 0x08, 0xF4, 0xA5, 0xCA,
  0x4A, 0x60, 0x72, 0x10, 0x61, 0x8F, 0xC0, 0xF9, 0x08, 0x42, 0x10, 0x80,
  0x8C, 0x63, 0x18, 0xC5, 0xC0, 0x8D, 0x24, 0x94, 0x50, 0xC3, 0x00, 0x89,
  0xCC, 0x95, 0x4A, 0xA5, 0x63, 0x30, 0x88, 0xCA, 0x8C, 0x47, 0x2E, 0x20,
  0x8A, 0x94, 0x42, 0x10, 0x80, 0xF8, 0x8C, 0x44, 0x23, 0xE0, 0xEA, 0xAA,
  0xC0, 0x84, 0x44, 0x22, 0x10, 0xE4, 0x92, 0x49, 0xE0, 0x22, 0x95, 0x90,
  0xF0, 0xCC, 0x71, 0x79, 0x70, 0x88, 0x8F, 0x99, 0x9F, 0x74, 0xC4, 0x70,
  0x08, 0x4A, 0xB4, 0xE5, 0x2F, 0x72, 0x7E, 0x87, 0x80, 0x34, 0x4E, 0x44,
  0x44, 0x7A, 0x72, 0x97, 0x85, 0xE0, 0x88, 0x8F, 0x99, 0x99, 0xBE, 0x45,
  0x55, 0xC0, 0x88, 0x9A, 0xCC, 0xA9, 0xFF, 0xFF, 0x26, 0x4C, 0x99, 0x20,
  0xF9, 0x99, 0x90, 0x7A, 0x72, 0x97, 0x00, 0xF9, 0x99, 0xF8, 0x80, 0x7A,
  0x72, 0x97, 0x84, 0x20, 0xF2, 0x48, 0xF4, 0x31, 0xF0, 0x4B, 0xA4, 0x98,
  0x99, 0x99, 0xF0, 0x9A, 0x94, 0xC2, 0x00, 0x9A, 0xB5, 0xAB, 0x66, 0x40,
  0xDB, 0x88, 0xAD, 0x80, 0x9A, 0x94, 0xC2, 0x13, 0x00, 0xF2, 0x64, 0xF0,
  0x29, 0x2C, 0x93, 0x20, 0xFF, 0xC0, 0xC9, 0x22, 0x92, 0x80, 0xF8,
};

const GFXglyph NotoSans_SemiCondensed_Medium10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 3, 1, -7 },
  { 2, 3, 2, 4, 1, -7 },
  { 3, 6, 7, 6, 0, -7 },
  { 9, 4, 9, 5, 1, -8 },
  { 14, 8, 7, 8, 0, -7 },
  { 21, 7, 7, 7, 0, -7 },
  { 28, 1, 2, 2, 1, -7 },
  { 29, 3, 9, 3, 0, -7 },
  { 33, 3, 9, 3, 0, -7 },
  { 37, 5, 5, 5, 0, -8 },
  { 41, 5, 5, 5, 0, -6 },
  { 45, 2, 2, 3, 0, -1 },
  { 46, 3, 1, 3, 0, -3 },
  { 47, 1, 1, 3, 1, -1 },
  { 48, 4, 7, 4, 0, -7 },
  { 52, 5, 7, 5, 0, -7 },
  { 57, 3, 7, 5, 1, -7 },
  { 60, 5, 7, 5, 0, -7 },
  { 65, 5, 7, 5, 0, -7 },
  { 70, 5, 7, 5, 0, -7 },
  { 75, 4, 7, 5, 1, -7 },
  { 79, 5, 7, 5, 0, -7 },
  { 84, 5, 7, 5, 0, -7 },
  { 89, 5, 7, 5, 0, -7 },
  { 94, 5, 7, 5, 0, -7 },
  { 99, 1, 5, 3, 1, -5 },
  { 100, 2, 6, 3, 0, -5 },
  { 102, 5, 5, 5, 0, -6 },
  { 106, 5, 3, 5, 0, -5 },
  { 108, 5, 5, 5, 0, -6 },
  { 112, 4, 7, 4, 0, -7 },
  { 116, 7, 8, 8, 1, -7 },
  { 123, 6, 7, 6, 0, -7 },
  { 129, 4, 7, 6, 1, -7 },
  { 133, 4, 7, 6, 1, -7 },
  { 137, 5, 7, 7, 1, -7 },
  { 142, 3, 7, 5, 1, -7 },
  { 145, 3, 7, 5, 1, -7 },
  { 148, 5, 7, 7, 1, -7 },
  { 153, 5, 7, 7, 1, -7 },
  { 158, 3, 7, 3, 0, -7 },
  { 161, 3, 9, 3, -1, -7 },
  { 165, 5, 7, 6, 1, -7 },
  { 170, 4, 7, 5, 1, -7 },
  { 174, 7, 7, 9, 1, -7 },
  { 181, 5, 7, 7, 1, -7 },
  { 186, 5, 7, 7, 1, -7 },
  { 191, 4, 7, 6, 1, -7 },
  { 195, 5, 9, 7, 1, -7 },
  { 201, 5, 7, 6, 1, -7 },
  { 206, 5, 7, 5, 0, -7 },
  { 211, 5, 7, 5, 0, -7 },
  { 216, 5, 7, 7, 1, -7 },
  { 221, 6, 7, 6, 0, -7 },
  { 227, 9, 7, 9, 0, -7 },
  { 235, 5, 7, 5, 0, -7 },
  { 240, 5, 7, 5, 0, -7 },
  { 245, 5, 7, 5, 0, -7 },
  { 250, 2, 9, 3, 1, -7 },
  { 253, 4, 7, 4, 0, -7 },
  { 257, 3, 9, 3, 0, -7 },
  { 261, 5, 4, 5, 0, -7 },
  { 264, 4, 1, 4, 0, 1 },
  { 265, 3, 2, 3, 0, -8 },
  { 266, 4, 5, 5, 0, -5 },
  { 269, 4, 8, 6, 1, -8 },
  { 273, 4, 5, 4, 0, -5 },
  { 276, 5, 8, 6, 0, -8 },
  { 281, 5, 5, 5, 0, -5 },
  { 285, 4, 8, 3, 0, -8 },
  { 289, 5, 7, 6, 0, -5 },
  { 294, 4, 8, 6, 1, -8 },
  { 298, 1, 7, 3, 1, -7 },
  { 299, 2, 9, 3, 0, -7 },
  { 302, 4, 8, 5, 1, -8 },
  { 306, 1, 8, 3, 1, -8 },
  { 307, 7, 5, 9, 1, -5 },
  { 312, 4, 5, 6, 1, -5 },
  { 315, 5, 5, 6, 0, -5 },
  { 319, 4, 7, 6, 1, -5 },
  { 323, 5, 7, 6, 0, -5 },
  { 328, 3, 5, 4, 1, -5 },
  { 330, 4, 5, 4, 0, -5 },
  { 333, 3, 7, 3, 0, -7 },
  { 336, 4, 5, 6, 1, -5 },
  { 339, 5, 5, 5, 0, -5 },
  { 343, 7, 5, 7, 0, -5 },
  { 348, 5, 5, 5, 0, -5 },
  { 352, 5, 7, 5, 0, -5 },
  { 357, 4, 5, 4, 0, -5 },
  { 360, 3, 9, 4, 0, -7 },
  { 364, 1, 10, 5, 2, -8 },
  { 366, 3, 9, 4, 0, -7 },
  { 370, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_SemiCondensed_Medium10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium10pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM10PT7B_H_
