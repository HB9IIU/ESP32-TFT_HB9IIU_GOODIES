#ifndef _NOTOSANS_SEMICONDENSED_MEDIUM26PT7B_H_
#define _NOTOSANS_SEMICONDENSED_MEDIUM26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_SemiCondensed-Medium.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_SemiCondensed_Medium26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xED, 0x80, 0xFF, 0x80, 0xCF, 0x8F, 0x1E,
  0x3C, 0x78, 0xF1, 0x80, 0x06, 0x30, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x0C,
  0x60, 0x31, 0x8F, 0xFF, 0xFF, 0xFF, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x06,
  0x30, 0xFF, 0xFB, 0xFF, 0xE3, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03,
  0x38, 0x00, 0x06, 0x00, 0xC0, 0x3C, 0x1F, 0xF7, 0xFF, 0xCC, 0x79, 0x87,
  0x30, 0x76, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x7E, 0x0C, 0xC1, 0x9C, 0x37,
  0xFF, 0xFF, 0xF8, 0xFC, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x38, 0x06, 0x0F,
  0x81, 0x81, 0x98, 0x30, 0x63, 0x0C, 0x0C, 0x61, 0x81, 0x8E, 0x60, 0x31,
  0xCC, 0x06, 0x33, 0x00, 0xC6, 0x67, 0x8C, 0xDD, 0xF9, 0xF3, 0x73, 0x1C,
  0xEC, 0x60, 0x19, 0x8E, 0x07, 0x31, 0xC0, 0xC6, 0x38, 0x38, 0xC6, 0x06,
  0x0C, 0xC1, 0xC1, 0xF8, 0x30, 0x1E, 0x00, 0x0F, 0x00, 0x1F, 0x80, 0x39,
  0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x39, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7F, 0x0E, 0x73, 0x8E, 0xE1, 0xDC, 0xE0, 0xFC, 0xE0,
  0x78, 0xE0, 0x78, 0xF0, 0xFC, 0x7F, 0xDE, 0x3F, 0x8F, 0xFF, 0xFC, 0x0C,
  0x73, 0x8C, 0x71, 0xC6, 0x18, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x61,
  0xC7, 0x0C, 0x38, 0x61, 0xC0, 0xC3, 0x87, 0x0C, 0x30, 0xE1, 0x86, 0x1C,
  0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x18, 0xE3, 0x8C, 0x71, 0x8E, 0x00, 0x0E,
  0x01, 0xC0, 0x38, 0x46, 0x1F, 0x5F, 0xFF, 0xC3, 0x80, 0xD8, 0x3B, 0x8E,
  0x38, 0xC4, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF,
  0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x77, 0x66, 0xEC,
  0xFF, 0xF0, 0xFF, 0x80, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0x03, 0x01, 0xC0,
  0x60, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0,
  0x70, 0x18, 0x0E, 0x00, 0x0F, 0x07, 0xF1, 0xFF, 0x38, 0x76, 0x0F, 0xC1,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC1, 0xD8,
  0x3B, 0x87, 0x71, 0xC7, 0xF8, 0x7E, 0x00, 0x06, 0x1C, 0xFB, 0xBE, 0xE9,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x1F, 0x0F, 0xF3, 0xFF, 0x20, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01,
  0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0x0F, 0xFB, 0xEF, 0x20, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x0E, 0x1F, 0x83, 0xE0, 0x7F, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0xC1, 0xFF, 0xFB, 0xFE, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0xC0, 0x3E, 0x03, 0x70, 0x3B, 0x81, 0x9C, 0x18, 0xE0, 0xC7, 0x0C, 0x38,
  0xE1, 0xC6, 0x0E, 0x7F, 0xFF, 0xFF, 0xE0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x7F, 0xCF, 0xF9, 0xFF, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x20,
  0x7F, 0x8F, 0xF8, 0x07, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x38, 0x07, 0xC1,
  0xDF, 0xF9, 0xFC, 0x00, 0x03, 0xC1, 0xFC, 0x3E, 0x43, 0x80, 0x70, 0x06,
  0x00, 0x60, 0x0E, 0x70, 0xFF, 0xCF, 0xDE, 0xF0, 0xEE, 0x06, 0xE0, 0x7E,
  0x07, 0x60, 0x67, 0x0E, 0x78, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x00, 0x0F, 0x03, 0xFC, 0x79, 0xE6, 0x0E, 0x60, 0xE6, 0x0E, 0x70,
  0xE3, 0x9C, 0x3F, 0x81, 0xF0, 0x3B, 0xC7, 0x1E, 0xE0, 0xEE, 0x06, 0xE0,
  0x7E, 0x06, 0xF0, 0xE7, 0xFC, 0x3F, 0x80, 0x0E, 0x07, 0xF1, 0xEF, 0x30,
  0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xEE, 0x3D, 0xFD, 0x9F, 0x30,
  0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x8F, 0xF1, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x77, 0x70, 0x00, 0x00, 0x00, 0x07, 0x76, 0xEE,
  0xC0, 0x00, 0x10, 0x07, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x10, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x1F, 0x07, 0xC1, 0xE0, 0xF8,
  0x0E, 0x00, 0x80, 0x00, 0x1E, 0x3F, 0xE7, 0xF9, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x06, 0x00, 0x00, 0x00,
  0x1C, 0x07, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x3C, 0x3C, 0x0E,
  0x01, 0xC3, 0x80, 0x1C, 0x60, 0xE1, 0x98, 0x7F, 0x33, 0x1C, 0x63, 0x63,
  0x1C, 0x7C, 0xE3, 0x8F, 0x18, 0x71, 0xE3, 0x0E, 0x3C, 0x61, 0xCF, 0xCE,
  0x39, 0x98, 0xFF, 0xF3, 0x0F, 0x3C, 0x70, 0x00, 0x06, 0x00, 0x00, 0x70,
  0x08, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x00,
  0x36, 0x00, 0x6C, 0x01, 0xDC, 0x03, 0x98, 0x06, 0x30, 0x1C, 0x70, 0x38,
  0xE0, 0x60, 0xC1, 0xFF, 0xC3, 0xFF, 0x87, 0xFF, 0x1C, 0x07, 0x38, 0x0E,
  0x70, 0x0D, 0xC0, 0x1F, 0x80, 0x38, 0xFE, 0x0F, 0xFC, 0xFF, 0xEE, 0x0F,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0E, 0xFF, 0xCF, 0xF8, 0xE3, 0xEE, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFF, 0xFE, 0xFF, 0x80, 0x03,
  0xE0, 0x7F, 0xC7, 0xFE, 0x78, 0x17, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x3E, 0x10, 0xFF, 0x81, 0xFC, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x38,
  0x3C, 0xE0, 0x7B, 0x80, 0xEE, 0x03, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x1C, 0xE3, 0xE3,
  0xFF, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xFF, 0xBF, 0xEF, 0xFB, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3F, 0xEF, 0xFB, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x00, 0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0xCF, 0x01, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x83, 0xFE, 0x0F, 0xD8,
  0x03, 0x70, 0x0D, 0xC0, 0x37, 0x00, 0xCE, 0x03, 0x3E, 0x0C, 0x7F, 0xF0,
  0x7F, 0xC0, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x06, 0xFF, 0xFD, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x39,
  0xFF, 0xF8, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xF3, 0xBF, 0x7C, 0xE0,
  0x3F, 0x03, 0xB8, 0x39, 0xC3, 0x8E, 0x1C, 0x71, 0xC3, 0x9C, 0x1D, 0xC0,
  0xEE, 0x07, 0xF0, 0x3F, 0xC1, 0xEE, 0x0E, 0x38, 0x71, 0xE3, 0x87, 0x1C,
  0x1C, 0xE0, 0xE7, 0x03, 0xB8, 0x1E, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFC, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80,
  0x7F, 0xE0, 0x1F, 0xF8, 0x07, 0xFF, 0x03, 0xFE, 0xC0, 0xDF, 0xB0, 0x37,
  0xEE, 0x1D, 0xF9, 0x86, 0x7E, 0x61, 0x9F, 0x9C, 0xE7, 0xE3, 0x31, 0xF8,
  0xCC, 0x7E, 0x3F, 0x1F, 0x87, 0x87, 0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x0C,
  0x1C, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3E,
  0xE0, 0xFB, 0x83, 0xE7, 0x0F, 0x8E, 0x3E, 0x38, 0xF8, 0x73, 0xE1, 0xCF,
  0x83, 0xBE, 0x0E, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xC0, 0x03,
  0xE0, 0x0F, 0xF8, 0x3F, 0xFC, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x70,
  0x07, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1E, 0x3C, 0x3C, 0x1F, 0xF8, 0x07,
  0xF0, 0xF8, 0x1F, 0xF3, 0xFF, 0x70, 0xFE, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0xFC, 0xFB, 0xFE, 0x7F, 0x8E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0xF8, 0x3F, 0xFC, 0x38, 0x1C,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0x60, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1E,
  0x3C, 0x3C, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0xFC, 0x07, 0xFC, 0x3F, 0xF1, 0xC1, 0xCE, 0x0E, 0x70, 0x33,
  0x83, 0x9C, 0x1C, 0xE1, 0xE7, 0xFE, 0x3F, 0xC1, 0xC6, 0x0E, 0x38, 0x70,
  0xE3, 0x87, 0x1C, 0x1C, 0xE0, 0xE7, 0x03, 0xB8, 0x1E, 0x0F, 0x87, 0xFD,
  0xFF, 0x38, 0x2E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x7C, 0x03, 0xE0, 0x3F,
  0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xC1, 0xDF, 0xF9, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0x78, 0xF1, 0xFF,
  0x87, 0xF0, 0xE0, 0x0F, 0xC0, 0x39, 0x80, 0x73, 0x80, 0xE7, 0x03, 0x86,
  0x07, 0x0E, 0x0E, 0x1C, 0x18, 0x18, 0x70, 0x30, 0xE0, 0x71, 0x80, 0xE7,
  0x00, 0xCE, 0x01, 0xD8, 0x03, 0xB0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x0E, 0x00, 0xE0, 0x38, 0x0F, 0x80, 0xE0, 0x76, 0x07, 0x81, 0xDC, 0x1E,
  0x07, 0x70, 0x7C, 0x19, 0xC1, 0xF0, 0xE3, 0x0E, 0xC3, 0x8E, 0x33, 0x0E,
  0x38, 0xCE, 0x30, 0xE3, 0x39, 0xC1, 0x9C, 0x67, 0x06, 0x61, 0x9C, 0x1D,
  0x87, 0x60, 0x76, 0x1D, 0x80, 0xF8, 0x3E, 0x03, 0xC0, 0xF8, 0x0F, 0x03,
  0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x1C, 0x00, 0x70, 0x1D, 0xC0, 0xE3, 0x83,
  0x0E, 0x1C, 0x1C, 0x60, 0x73, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0xF0, 0x0C, 0xC0, 0x73, 0x81, 0x86, 0x0E, 0x1C, 0x70,
  0x39, 0xC0, 0xEE, 0x01, 0xC0, 0xE0, 0x1F, 0x80, 0xE7, 0x03, 0x9C, 0x1C,
  0x38, 0x70, 0xE3, 0x81, 0xCE, 0x07, 0x70, 0x0F, 0xC0, 0x3E, 0x00, 0x78,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x60, 0x1C, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0,
  0xE0, 0x18, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03,
  0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18,
  0xFF, 0xF1, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xC0, 0x06, 0x00, 0xE0, 0x0F, 0x00, 0xF0,
  0x1B, 0x81, 0x98, 0x31, 0xC3, 0x0C, 0x60, 0xE6, 0x06, 0xE0, 0x7C, 0x03,
  0xFF, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x3F, 0x8F, 0xF8, 0x87, 0x00, 0x70,
  0x0E, 0x03, 0xCF, 0xFB, 0xC7, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xF7, 0xFE,
  0xFC, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3B, 0xE7,
  0xFE, 0xF1, 0xFC, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07,
  0xE0, 0xFE, 0x3F, 0x7F, 0x67, 0xC0, 0x1F, 0xCF, 0xE7, 0x89, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xE1, 0x3F, 0xC7, 0xE0,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x1F, 0x73, 0xFF,
  0x70, 0xF7, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0x70, 0x77, 0x0F, 0x3F, 0xF1, 0xF3, 0x1F, 0x87, 0xF9, 0xC3, 0xB8, 0x7E,
  0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x13, 0xFE,
  0x3F, 0x80, 0x07, 0x8F, 0xC7, 0x23, 0x03, 0x81, 0xC1, 0xFD, 0xFE, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x00, 0x1F, 0x73, 0xFF, 0x70, 0xF7, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0x70, 0x77, 0x0F, 0x3F, 0xF1, 0xF7, 0x00, 0x70,
  0x07, 0x00, 0x74, 0x0E, 0x7F, 0xC7, 0xF8, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x3B, 0xE6, 0xFE, 0xF1, 0xFC, 0x1F, 0x83, 0xF0, 0x7E,
  0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x70, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x71, 0x80, 0x00, 0x71,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xBE, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x7F,
  0x0E, 0xE3, 0x9C, 0xE3, 0xB8, 0x7E, 0x0D, 0xC1, 0xFC, 0x39, 0xC7, 0x38,
  0xE3, 0x9C, 0x3B, 0x87, 0x70, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xCF, 0x9F, 0xB7, 0xFF, 0xFF, 0x1F, 0x1F, 0x83, 0x83, 0xE0,
  0xE0, 0xF8, 0x38, 0x3E, 0x0E, 0x0F, 0x83, 0x83, 0xE0, 0xE0, 0xF8, 0x38,
  0x3E, 0x0E, 0x0F, 0x83, 0x83, 0xE0, 0xE0, 0xF8, 0x38, 0x30, 0xCF, 0x9B,
  0xFB, 0xC7, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xC0, 0x1F, 0x83, 0xFC, 0x70, 0xE7, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x07, 0x70, 0x77, 0x0E,
  0x3F, 0xC1, 0xF8, 0xCF, 0x9B, 0xFB, 0xC7, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF8, 0xFD, 0xFD, 0xDF, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x1F, 0x73, 0xFF, 0x70, 0xF7,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x70, 0x77,
  0x0F, 0x3F, 0xF1, 0xF7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0xCF, 0xDE, 0xF8, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x3F, 0xBF, 0xF8, 0x3C, 0x0E, 0x03, 0xC0, 0xF8, 0x3E,
  0x07, 0x80, 0xC0, 0x70, 0x7F, 0xFF, 0xF0, 0x18, 0x18, 0x38, 0x7F, 0xFF,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1F, 0x1F,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0xF7, 0xFE, 0x7C, 0xC0, 0xE0, 0x76, 0x07, 0x70,
  0x77, 0x0E, 0x30, 0xE3, 0x0E, 0x38, 0xC1, 0x9C, 0x19, 0xC1, 0xD8, 0x0F,
  0x80, 0xF8, 0x0F, 0x00, 0x70, 0xE0, 0xE0, 0xEC, 0x1E, 0x1D, 0xC7, 0xC3,
  0x38, 0xD8, 0x67, 0x1B, 0x1C, 0x63, 0x73, 0x8E, 0xE6, 0x61, 0xD8, 0xCC,
  0x3B, 0x1B, 0x83, 0x63, 0x70, 0x6C, 0x7C, 0x0F, 0x07, 0x81, 0xE0, 0xF0,
  0x1C, 0x1E, 0x00, 0x70, 0x77, 0x0E, 0x38, 0xE1, 0xDC, 0x1D, 0x80, 0xF8,
  0x0F, 0x00, 0xF0, 0x0F, 0x81, 0xDC, 0x39, 0xC3, 0x8E, 0x70, 0x6F, 0x07,
  0xE0, 0x76, 0x07, 0x70, 0x77, 0x06, 0x30, 0xE3, 0x8E, 0x38, 0xC1, 0x9C,
  0x1D, 0xC1, 0xD8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xC0, 0xE0, 0xE0, 0xE0,
  0x70, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x1C, 0x0F, 0xFF, 0xFC, 0x03, 0x0F,
  0x1F, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x78, 0xE0, 0xF0, 0x38,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0xF0, 0xF8, 0x38, 0x38,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x1E, 0x07, 0x0F, 0x1C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x38, 0x38, 0xF0, 0xE0, 0x78, 0x1F, 0xFF, 0xC7, 0xE8, 0x18,
};

const GFXglyph NotoSans_SemiCondensed_Medium26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 19, 7, 2, -19 },
  { 9, 7, 7, 11, 2, -19 },
  { 16, 14, 19, 15, 1, -19 },
  { 50, 11, 22, 14, 1, -20 },
  { 81, 19, 19, 21, 1, -19 },
  { 127, 16, 19, 17, 1, -19 },
  { 165, 2, 7, 6, 2, -19 },
  { 167, 6, 23, 8, 1, -19 },
  { 185, 6, 23, 8, 1, -19 },
  { 203, 11, 11, 13, 1, -20 },
  { 219, 12, 12, 14, 1, -15 },
  { 237, 4, 6, 7, 1, -3 },
  { 240, 6, 2, 8, 1, -8 },
  { 242, 3, 3, 7, 2, -3 },
  { 244, 10, 19, 10, 0, -19 },
  { 268, 11, 19, 14, 1, -19 },
  { 295, 7, 19, 14, 2, -19 },
  { 312, 11, 19, 14, 1, -19 },
  { 339, 11, 19, 14, 1, -19 },
  { 366, 13, 19, 14, 0, -19 },
  { 397, 11, 19, 14, 1, -19 },
  { 424, 12, 19, 14, 1, -19 },
  { 453, 12, 19, 14, 1, -19 },
  { 482, 12, 19, 14, 1, -19 },
  { 511, 11, 19, 14, 1, -19 },
  { 538, 3, 14, 7, 2, -14 },
  { 544, 4, 17, 7, 1, -14 },
  { 553, 12, 13, 14, 1, -16 },
  { 573, 11, 8, 14, 1, -13 },
  { 584, 12, 13, 14, 1, -16 },
  { 604, 10, 19, 11, 0, -19 },
  { 628, 19, 21, 21, 1, -19 },
  { 678, 15, 19, 15, 0, -19 },
  { 714, 12, 19, 15, 2, -19 },
  { 743, 13, 19, 15, 1, -19 },
  { 774, 14, 19, 17, 2, -19 },
  { 808, 10, 19, 13, 2, -19 },
  { 832, 10, 19, 12, 2, -19 },
  { 856, 14, 19, 17, 1, -19 },
  { 890, 13, 19, 18, 2, -19 },
  { 921, 7, 19, 9, 1, -19 },
  { 938, 7, 24, 7, -2, -19 },
  { 959, 13, 19, 15, 2, -19 },
  { 990, 10, 19, 12, 2, -19 },
  { 1014, 18, 19, 22, 2, -19 },
  { 1057, 14, 19, 18, 2, -19 },
  { 1091, 16, 19, 18, 1, -19 },
  { 1129, 11, 19, 14, 2, -19 },
  { 1156, 16, 23, 18, 1, -19 },
  { 1202, 13, 19, 15, 2, -19 },
  { 1233, 11, 19, 13, 1, -19 },
  { 1260, 13, 19, 13, 0, -19 },
  { 1291, 13, 19, 17, 2, -19 },
  { 1322, 15, 19, 15, 0, -19 },
  { 1358, 22, 19, 22, 0, -19 },
  { 1411, 14, 19, 14, 0, -19 },
  { 1445, 14, 19, 14, 0, -19 },
  { 1479, 11, 19, 13, 1, -19 },
  { 1506, 6, 23, 8, 2, -19 },
  { 1524, 10, 19, 10, 0, -19 },
  { 1548, 6, 23, 8, 1, -19 },
  { 1566, 12, 12, 14, 1, -19 },
  { 1584, 11, 2, 11, 0, 2 },
  { 1587, 6, 4, 8, 1, -20 },
  { 1590, 11, 14, 14, 1, -14 },
  { 1610, 11, 20, 15, 2, -20 },
  { 1638, 10, 14, 12, 1, -14 },
  { 1656, 12, 20, 15, 1, -20 },
  { 1686, 11, 14, 14, 1, -14 },
  { 1706, 9, 20, 8, 0, -20 },
  { 1729, 12, 20, 15, 1, -14 },
  { 1759, 11, 20, 15, 2, -20 },
  { 1787, 3, 19, 7, 2, -19 },
  { 1795, 6, 25, 7, -1, -19 },
  { 1814, 11, 20, 13, 2, -20 },
  { 1842, 3, 20, 7, 2, -20 },
  { 1850, 18, 14, 22, 2, -14 },
  { 1882, 11, 14, 15, 2, -14 },
  { 1902, 12, 14, 14, 1, -14 },
  { 1923, 11, 20, 15, 2, -14 },
  { 1951, 12, 20, 15, 1, -14 },
  { 1981, 8, 14, 10, 2, -14 },
  { 1995, 9, 14, 11, 1, -14 },
  { 2011, 8, 17, 9, 0, -17 },
  { 2028, 11, 14, 15, 2, -14 },
  { 2048, 12, 14, 12, 0, -14 },
  { 2069, 19, 14, 19, 0, -14 },
  { 2103, 12, 14, 13, 0, -14 },
  { 2124, 12, 20, 12, 0, -14 },
  { 2154, 9, 14, 11, 1, -14 },
  { 2170, 8, 23, 10, 1, -19 },
  { 2193, 3, 26, 13, 5, -20 },
  { 2203, 8, 23, 10, 1, -19 },
  { 2226, 12, 4, 14, 1, -11 },
};

const GFXfont NotoSans_SemiCondensed_Medium26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_SemiCondensed_Medium26pt7bBitmaps,
  (GFXglyph *)NotoSans_SemiCondensed_Medium26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_SEMICONDENSED_MEDIUM26PT7B_H_
